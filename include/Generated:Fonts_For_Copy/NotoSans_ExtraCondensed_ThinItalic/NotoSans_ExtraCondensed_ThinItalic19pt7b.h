#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x40, 0x08, 0x76, 0xDA, 0x0A, 0x14,
  0x48, 0x97, 0xE4, 0x89, 0x14, 0x49, 0xF9, 0x42, 0x89, 0x14, 0x00, 0x08,
  0x3C, 0xA2, 0x45, 0x06, 0x04, 0x08, 0x18, 0x48, 0x91, 0x4B, 0x8C, 0x10,
  0x00, 0x31, 0x52, 0x92, 0x94, 0x94, 0x98, 0xAF, 0xB5, 0xD9, 0x29, 0x29,
  0x49, 0x4A, 0x8E, 0x18, 0x92, 0x4A, 0x28, 0xC2, 0x08, 0x56, 0x59, 0xA2,
  0x9B, 0xA0, 0xF8, 0x0C, 0x41, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x81, 0x04, 0x10, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x21,
  0x10, 0x27, 0x4D, 0xA1, 0x00, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20,
  0x29, 0x40, 0xF0, 0x80, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x0C, 0x52, 0x49, 0x45, 0x14, 0x51,
  0x86, 0x18, 0xA2, 0x91, 0xC0, 0x2E, 0x92, 0x52, 0x4A, 0x49, 0x00, 0x1C,
  0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0xF8, 0x1C, 0x44, 0x08, 0x10, 0x20, 0x8E, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x9E, 0x00, 0x02, 0x08, 0x30, 0x61, 0x44, 0x89, 0x24, 0x49, 0x13, 0xF0,
  0x81, 0x02, 0x00, 0x0F, 0x10, 0x10, 0x10, 0x20, 0x20, 0x38, 0x04, 0x02,
  0x02, 0x02, 0x04, 0x04, 0xF8, 0x0E, 0x20, 0x81, 0x04, 0x0A, 0x1A, 0x22,
  0x85, 0x0A, 0x14, 0x28, 0x8E, 0x00, 0x7C, 0x10, 0x42, 0x08, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x82, 0x00, 0x1C, 0x44, 0x8A, 0x12, 0x24, 0x86, 0x18,
  0x49, 0x0A, 0x14, 0x28, 0x9E, 0x00, 0x18, 0x94, 0x51, 0x45, 0x14, 0x53,
  0x34, 0x10, 0x82, 0x13, 0x80, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x00, 0x24, 0x48, 0x04, 0x23, 0x30, 0x81, 0x81, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x81, 0x03, 0x02, 0x0C, 0x46, 0x20, 0x30, 0x42, 0x10, 0x88, 0x44,
  0x42, 0x10, 0x00, 0x40, 0x07, 0x04, 0x44, 0x24, 0x12, 0x6A, 0x55, 0x4A,
  0xA5, 0x94, 0xCA, 0x65, 0x53, 0x48, 0x04, 0x01, 0x00, 0x70, 0x04, 0x10,
  0xC3, 0x14, 0x51, 0x49, 0x3D, 0x14, 0x61, 0x86, 0x10, 0x1C, 0x44, 0x89,
  0x12, 0x24, 0x5F, 0x22, 0x44, 0x89, 0x14, 0x28, 0x9E, 0x00, 0x0E, 0x60,
  0x82, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x0E, 0x00, 0x1C,
  0x44, 0x89, 0x12, 0x24, 0x50, 0xA1, 0x42, 0x85, 0x14, 0x28, 0x9E, 0x00,
  0x1E, 0x40, 0x81, 0x02, 0x04, 0x1F, 0x20, 0x40, 0x81, 0x04, 0x08, 0x1E,
  0x00, 0x1E, 0x40, 0x81, 0x02, 0x04, 0x10, 0x3E, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x00, 0x0F, 0x30, 0x20, 0x40, 0x80, 0x80, 0x80, 0x8E, 0x82, 0x82,
  0x84, 0x84, 0x84, 0x7C, 0x10, 0x90, 0x48, 0x44, 0x22, 0x11, 0x09, 0xF4,
  0x84, 0x42, 0x21, 0x10, 0x90, 0x48, 0x44, 0x20, 0x18, 0x84, 0x21, 0x08,
  0x84, 0x21, 0x10, 0x84, 0x70, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x84, 0x10, 0x41, 0x08, 0xE0, 0x11, 0x22, 0x22, 0x24, 0x28, 0x30,
  0x50, 0x70, 0x50, 0x50, 0x48, 0x88, 0x88, 0x88, 0x12, 0x22, 0x22, 0x44,
  0x44, 0x48, 0x8F, 0x10, 0x22, 0x04, 0xC0, 0x98, 0x33, 0x0A, 0x61, 0x54,
  0x52, 0x8A, 0x51, 0x4A, 0x49, 0x49, 0x4A, 0x48, 0x89, 0x11, 0x00, 0x10,
  0x88, 0x4C, 0x26, 0x12, 0x91, 0x49, 0x24, 0x92, 0x49, 0x25, 0x11, 0x90,
  0xC8, 0x44, 0x20, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A,
  0x14, 0x28, 0x9E, 0x00, 0x1C, 0x44, 0x89, 0x12, 0x24, 0x51, 0x3C, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0A, 0x14, 0x28, 0x9A, 0x08, 0x08, 0x10, 0x1C, 0x44, 0x89, 0x12,
  0x24, 0x51, 0x3C, 0x50, 0xA1, 0x24, 0x48, 0x91, 0x00, 0x0F, 0x10, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0xF8, 0x7C,
  0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x22, 0x85,
  0x0A, 0x14, 0x28, 0x61, 0x42, 0x85, 0x0A, 0x24, 0x48, 0x9E, 0x00, 0x86,
  0x18, 0xA2, 0x8A, 0x49, 0x28, 0xA3, 0x0C, 0x20, 0x82, 0x00, 0x82, 0x18,
  0x41, 0x84, 0x28, 0xA2, 0x8A, 0x48, 0xA4, 0x92, 0x49, 0x48, 0x94, 0x8A,
  0x50, 0xA5, 0x0C, 0x50, 0xC2, 0x08, 0x20, 0x11, 0x11, 0x12, 0x12, 0x14,
  0x08, 0x08, 0x08, 0x18, 0x28, 0x28, 0x48, 0x48, 0x88, 0x86, 0x18, 0x92,
  0x51, 0x46, 0x10, 0x41, 0x04, 0x20, 0x82, 0x00, 0x1F, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0xF8, 0x1C, 0x41,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0xE0, 0xAA,
  0xA5, 0x55, 0x50, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0xE0, 0x08, 0x30, 0x61, 0x24, 0x48, 0x60,
  0x80, 0xF0, 0xAC, 0x3D, 0x18, 0x61, 0x8A, 0x28, 0xA2, 0x93, 0xC0, 0x10,
  0x40, 0x81, 0x03, 0xC4, 0x48, 0xA1, 0x42, 0x89, 0x14, 0x28, 0x9E, 0x00,
  0x3A, 0x21, 0x08, 0x42, 0x10, 0x87, 0x00, 0x02, 0x04, 0x08, 0x23, 0xC8,
  0xA1, 0x44, 0x89, 0x12, 0x24, 0x49, 0x1E, 0x00, 0x3A, 0x63, 0x2E, 0x42,
  0x10, 0x87, 0x80, 0x03, 0x04, 0x04, 0x08, 0x08, 0x1C, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1E,
  0x45, 0x0A, 0x24, 0x50, 0xA1, 0x42, 0x88, 0xF0, 0x20, 0x41, 0x02, 0x38,
  0x00, 0x10, 0x42, 0x08, 0x3C, 0x92, 0x51, 0x45, 0x14, 0x62, 0x8A, 0x20,
  0x11, 0x00, 0x22, 0x44, 0x44, 0x48, 0x88, 0x02, 0x04, 0x00, 0x00, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x43, 0x00,
  0x10, 0x82, 0x08, 0x24, 0xA4, 0x94, 0x71, 0x45, 0x24, 0x92, 0x20, 0x11,
  0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x3F, 0xC9, 0x14, 0x45, 0x11, 0x44,
  0x91, 0x24, 0x8A, 0x22, 0x88, 0xA2, 0x40, 0x3C, 0x92, 0x51, 0x45, 0x14,
  0xA2, 0x8A, 0x20, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0x97, 0x00, 0x1E, 0x11,
  0x11, 0x21, 0x21, 0x22, 0x22, 0x42, 0x44, 0x78, 0x40, 0x40, 0x80, 0x80,
  0x3D, 0x18, 0x61, 0x8A, 0x28, 0xA2, 0x93, 0xC1, 0x04, 0x10, 0x80, 0x39,
  0x08, 0x84, 0x21, 0x10, 0x84, 0x00, 0x3A, 0x10, 0x82, 0x10, 0x42, 0x17,
  0x00, 0x22, 0x72, 0x44, 0x44, 0x88, 0x8C, 0x22, 0x45, 0x12, 0x24, 0x48,
  0x92, 0x44, 0x88, 0xF0, 0x8C, 0x65, 0x2A, 0x53, 0x18, 0x84, 0x00, 0x88,
  0xC4, 0xA6, 0x53, 0x4A, 0xA5, 0x53, 0x31, 0x98, 0x88, 0x44, 0x00, 0x22,
  0x28, 0x50, 0xC1, 0x02, 0x0A, 0x14, 0x49, 0x10, 0x10, 0x88, 0x84, 0x42,
  0x41, 0x20, 0xA0, 0x50, 0x30, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x03,
  0x00, 0x1C, 0x10, 0x84, 0x10, 0x82, 0x10, 0x43, 0xC0, 0x0C, 0x41, 0x08,
  0x20, 0x82, 0x10, 0x81, 0x04, 0x10, 0x82, 0x08, 0x20, 0x60, 0xFF, 0xFF,
  0xE0, 0x18, 0x10, 0x41, 0x08, 0x20, 0x82, 0x04, 0x21, 0x04, 0x10, 0x82,
  0x08, 0xC0, 0x42, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 3, 5, 5, 2, -14 },
  { 10, 7, 14, 7, 0, -14 },
  { 23, 7, 15, 6, 0, -14 },
  { 37, 8, 14, 10, 1, -14 },
  { 51, 6, 14, 6, 0, -14 },
  { 62, 1, 5, 3, 2, -14 },
  { 63, 6, 16, 5, 0, -13 },
  { 75, 5, 16, 5, -1, -13 },
  { 85, 5, 5, 6, 2, -14 },
  { 89, 6, 9, 8, 1, -11 },
  { 96, 3, 4, 3, -1, -2 },
  { 98, 4, 1, 5, 0, -6 },
  { 99, 1, 1, 3, 0, -1 },
  { 100, 8, 14, 6, -1, -14 },
  { 114, 6, 14, 7, 0, -14 },
  { 125, 3, 14, 7, 2, -14 },
  { 131, 8, 14, 7, -1, -14 },
  { 145, 7, 14, 7, 0, -14 },
  { 158, 7, 14, 7, 0, -14 },
  { 171, 8, 14, 7, -1, -14 },
  { 185, 7, 14, 7, 0, -14 },
  { 198, 6, 14, 7, 1, -14 },
  { 209, 7, 14, 7, 0, -14 },
  { 222, 6, 14, 7, 0, -14 },
  { 233, 3, 10, 3, 0, -10 },
  { 237, 4, 12, 3, -1, -10 },
  { 243, 6, 8, 8, 1, -11 },
  { 249, 6, 5, 8, 1, -9 },
  { 253, 6, 8, 8, 1, -11 },
  { 259, 5, 14, 5, 0, -14 },
  { 268, 9, 16, 10, 0, -14 },
  { 286, 6, 14, 6, -1, -14 },
  { 297, 7, 14, 7, 0, -14 },
  { 310, 7, 14, 6, 1, -14 },
  { 323, 7, 14, 8, 0, -14 },
  { 336, 7, 14, 6, 0, -14 },
  { 349, 7, 14, 6, 0, -14 },
  { 362, 8, 14, 9, 1, -14 },
  { 376, 9, 14, 8, 0, -14 },
  { 392, 5, 14, 3, -1, -14 },
  { 401, 6, 17, 3, -3, -14 },
  { 414, 8, 14, 7, 0, -14 },
  { 428, 4, 14, 6, 0, -14 },
  { 435, 11, 14, 11, 0, -14 },
  { 455, 9, 14, 9, 0, -14 },
  { 471, 7, 14, 8, 1, -14 },
  { 484, 7, 14, 7, 0, -14 },
  { 497, 7, 17, 8, 1, -14 },
  { 512, 7, 14, 7, 0, -14 },
  { 525, 8, 14, 6, -1, -14 },
  { 539, 6, 14, 6, 1, -14 },
  { 550, 7, 14, 8, 1, -14 },
  { 563, 6, 14, 7, 2, -14 },
  { 574, 12, 14, 11, 1, -14 },
  { 595, 8, 14, 6, -1, -14 },
  { 609, 6, 14, 5, 1, -14 },
  { 620, 8, 14, 6, -1, -14 },
  { 634, 6, 17, 5, 0, -14 },
  { 647, 2, 14, 6, 2, -14 },
  { 651, 7, 17, 5, -1, -14 },
  { 666, 7, 7, 7, 0, -14 },
  { 673, 4, 1, 5, -1, 1 },
  { 674, 2, 3, 4, 3, -15 },
  { 675, 6, 10, 7, 1, -10 },
  { 683, 7, 14, 7, 0, -14 },
  { 696, 5, 10, 5, 1, -10 },
  { 703, 7, 14, 7, 1, -14 },
  { 716, 5, 10, 6, 1, -10 },
  { 723, 8, 20, 4, -2, -15 },
  { 743, 7, 15, 7, 0, -10 },
  { 757, 6, 14, 7, 0, -14 },
  { 768, 4, 14, 3, 0, -14 },
  { 775, 7, 19, 3, -3, -14 },
  { 792, 6, 14, 6, 0, -14 },
  { 803, 4, 14, 3, 0, -14 },
  { 810, 10, 10, 10, 0, -10 },
  { 823, 6, 10, 7, 0, -10 },
  { 831, 5, 10, 7, 1, -10 },
  { 838, 8, 14, 7, -1, -10 },
  { 852, 6, 14, 7, 1, -10 },
  { 863, 5, 10, 4, 0, -10 },
  { 870, 5, 10, 5, 0, -10 },
  { 877, 4, 12, 3, 0, -12 },
  { 883, 7, 10, 7, 0, -10 },
  { 892, 5, 10, 5, 1, -10 },
  { 899, 9, 10, 9, 1, -10 },
  { 911, 7, 10, 5, -1, -10 },
  { 920, 9, 15, 6, -2, -10 },
  { 937, 6, 10, 4, -1, -10 },
  { 945, 6, 17, 6, 1, -14 },
  { 958, 1, 19, 7, 3, -14 },
  { 961, 6, 17, 6, -1, -14 },
  { 974, 6, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC19PT7B_H_
