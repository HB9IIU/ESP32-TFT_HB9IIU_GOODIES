#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x08, 0x41, 0x00, 0x00, 0x00, 0x08, 0x20, 0x22, 0x49, 0x12, 0x24, 0x48,
  0xA2, 0x44, 0x88, 0x01, 0x08, 0x08, 0x80, 0x44, 0x04, 0x20, 0x21, 0x01,
  0x10, 0x10, 0x83, 0xFF, 0x04, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00, 0x88,
  0x08, 0x40, 0x44, 0x1F, 0xFC, 0x21, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04,
  0x20, 0x22, 0x02, 0x10, 0x10, 0x80, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3E,
  0x0C, 0x91, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x00, 0xA0,
  0x0A, 0x00, 0x60, 0x02, 0x00, 0x50, 0x04, 0x80, 0x48, 0x04, 0x40, 0x84,
  0x08, 0x80, 0x88, 0x08, 0x88, 0xB0, 0x3C, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x58, 0x22, 0x20, 0x90, 0x84, 0x42, 0x11, 0x08, 0x88, 0x22,
  0x20, 0x90, 0x84, 0x42, 0x12, 0x08, 0x49, 0xA2, 0x49, 0x89, 0x46, 0x29,
  0x19, 0x28, 0x59, 0x21, 0x04, 0x84, 0x24, 0x10, 0x90, 0x44, 0x42, 0x11,
  0x08, 0x84, 0x22, 0x11, 0x10, 0x44, 0x40, 0xE0, 0x01, 0x01, 0xA0, 0x44,
  0x21, 0x08, 0x42, 0x10, 0x88, 0x22, 0x09, 0x02, 0x40, 0xA0, 0x30, 0x0C,
  0x05, 0x02, 0x41, 0x09, 0x42, 0x60, 0x98, 0x2A, 0x06, 0x81, 0x20, 0x48,
  0x32, 0x12, 0x78, 0x80, 0x25, 0x24, 0xA4, 0x80, 0x00, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x06, 0x00, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x08, 0x00, 0x08, 0x08, 0x88, 0x48, 0x37, 0x18, 0x28, 0xC4, 0x06, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x12,
  0x24, 0x44, 0x80, 0xFE, 0xC0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x01,
  0x00, 0xD8, 0x21, 0x04, 0x21, 0x02, 0x20, 0x48, 0x09, 0x01, 0x40, 0x48,
  0x09, 0x01, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x80, 0x90, 0x12,
  0x04, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x20, 0x78, 0x00, 0x0C, 0xE6,
  0xA2, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x00, 0xC0, 0x31, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x71,
  0x81, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x01, 0x80, 0x70, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x48,
  0x02, 0x40, 0x24, 0x01, 0x20, 0x11, 0x01, 0x08, 0x08, 0x40, 0x84, 0x0C,
  0x20, 0x41, 0x04, 0x08, 0x20, 0x82, 0x04, 0x3F, 0xF8, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x03, 0xF8, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x07,
  0xE0, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x42, 0x04, 0x1F, 0xC0, 0x00, 0xE0,
  0x64, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x38, 0x28, 0x8A, 0x09, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x11, 0x02, 0x20, 0x44, 0x10, 0x7C, 0x00, 0x3F, 0xF0, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x01, 0x80, 0x66,
  0x08, 0x31, 0x01, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x20, 0x84,
  0x08, 0xC0, 0x50, 0x06, 0x01, 0x90, 0x21, 0x04, 0x08, 0x80, 0x88, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x01,
  0x80, 0xC8, 0x20, 0x8C, 0x11, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x24,
  0x04, 0x80, 0x90, 0x12, 0x06, 0x41, 0x46, 0xD0, 0x22, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0xF8, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x10, 0x20, 0x81, 0x04, 0x18, 0x00, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x08, 0x00,
  0x06, 0x06, 0x60, 0x08, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x02, 0x06,
  0x04, 0x02, 0x08, 0x02, 0x08, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0xF1,
  0x21, 0x11, 0x42, 0x21, 0x44, 0x22, 0x44, 0x22, 0x44, 0x42, 0x88, 0x42,
  0x88, 0x42, 0x88, 0x44, 0x88, 0xC4, 0x88, 0x88, 0x89, 0x48, 0x86, 0x70,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x61, 0x00,
  0x1F, 0x00, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x48,
  0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x82, 0x1F, 0xC2, 0x08, 0x81,
  0x10, 0x24, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x07,
  0xE0, 0x20, 0x81, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x02,
  0x10, 0x10, 0x81, 0x04, 0x30, 0x3F, 0x02, 0x04, 0x10, 0x10, 0x80, 0x84,
  0x04, 0x20, 0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x42, 0x04,
  0x1F, 0xC0, 0x00, 0x60, 0x0C, 0x41, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x20, 0x81, 0x02,
  0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x02, 0x20, 0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x02, 0x20, 0x12, 0x01,
  0x10, 0x08, 0x80, 0x84, 0x08, 0x20, 0xC2, 0x08, 0x1F, 0x80, 0x07, 0xF8,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x3F, 0x82, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0xFC, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x00, 0x38, 0x03, 0x0C, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x1F, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x08, 0x04, 0x10, 0x08, 0x10,
  0x10, 0x1F, 0xC0, 0x04, 0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80,
  0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x20,
  0xFF, 0xC2, 0x00, 0x84, 0x01, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80,
  0x21, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x20, 0x08, 0x40, 0x20,
  0x07, 0xC0, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x03, 0xE0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x81, 0xC0, 0x00,
  0x04, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x88,
  0x02, 0x40, 0x11, 0x00, 0x48, 0x01, 0x40, 0x06, 0x80, 0x2A, 0x00, 0xC8,
  0x02, 0x20, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x40,
  0x81, 0x02, 0x08, 0x08, 0x20, 0x20, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0xFF, 0x06, 0x00, 0x10, 0x60, 0x03, 0x06,
  0x00, 0x30, 0xA0, 0x05, 0x0A, 0x00, 0x60, 0xA0, 0x0A, 0x0A, 0x00, 0xA0,
  0xA0, 0x12, 0x12, 0x01, 0x21, 0x20, 0x24, 0x12, 0x02, 0x41, 0x20, 0x44,
  0x22, 0x04, 0x42, 0x20, 0x84, 0x22, 0x08, 0x82, 0x21, 0x08, 0x22, 0x10,
  0x84, 0x12, 0x08, 0x41, 0x21, 0x04, 0x16, 0x10, 0x41, 0x41, 0x04, 0x14,
  0x10, 0x81, 0x81, 0x08, 0x18, 0x20, 0x06, 0x01, 0x06, 0x01, 0x06, 0x01,
  0x0A, 0x02, 0x0A, 0x02, 0x0A, 0x02, 0x09, 0x02, 0x09, 0x02, 0x11, 0x04,
  0x11, 0x04, 0x11, 0x04, 0x10, 0x84, 0x20, 0x88, 0x20, 0x88, 0x20, 0x88,
  0x20, 0x88, 0x20, 0x88, 0x40, 0x50, 0x40, 0x50, 0x40, 0x50, 0x40, 0x50,
  0x40, 0x50, 0x80, 0x20, 0x80, 0x20, 0x00, 0xC0, 0x19, 0x81, 0x02, 0x10,
  0x10, 0x80, 0x88, 0x04, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x50, 0x02,
  0x80, 0x14, 0x00, 0xA0, 0x06, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0,
  0x09, 0x00, 0x48, 0x04, 0x40, 0x21, 0x02, 0x08, 0x20, 0x3E, 0x00, 0x07,
  0xE0, 0x43, 0x04, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10,
  0x11, 0x02, 0x10, 0x21, 0x04, 0x21, 0x83, 0xE0, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x00,
  0xC0, 0x19, 0x81, 0x02, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x06, 0x00, 0x50,
  0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x04, 0x40, 0x21, 0x02,
  0x08, 0x20, 0x3E, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x07, 0xE0, 0x43, 0x04, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08,
  0x10, 0x81, 0x10, 0x11, 0x02, 0x10, 0x21, 0x04, 0x1F, 0x82, 0x20, 0x22,
  0x02, 0x10, 0x21, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x08, 0x80,
  0x88, 0x08, 0x00, 0x40, 0x18, 0xC1, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x10, 0x30, 0xFE, 0x00, 0x7F, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x08, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x10,
  0x08, 0x40, 0x21, 0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x40, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x04, 0x10, 0x0F, 0x80, 0x80, 0x30,
  0x06, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x42,
  0x08, 0x42, 0x08, 0x41, 0x08, 0x22, 0x04, 0x40, 0x90, 0x12, 0x02, 0x80,
  0x50, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x40, 0x38, 0x04, 0x02,
  0x80, 0xC0, 0x28, 0x0C, 0x04, 0x81, 0x40, 0x48, 0x14, 0x08, 0x81, 0x40,
  0x88, 0x24, 0x08, 0x82, 0x41, 0x08, 0x24, 0x10, 0x84, 0x42, 0x08, 0x44,
  0x20, 0x88, 0x42, 0x08, 0x84, 0x40, 0x88, 0x44, 0x09, 0x04, 0x80, 0x90,
  0x48, 0x0A, 0x04, 0x80, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0xC0, 0x60, 0x0C,
  0x06, 0x00, 0x80, 0x60, 0x08, 0x04, 0x00, 0x02, 0x06, 0x04, 0x08, 0x08,
  0x20, 0x10, 0x40, 0x21, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x28, 0x00, 0x50, 0x01, 0x20, 0x02,
  0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x20, 0x40, 0x68, 0x09, 0x02, 0x20, 0x44, 0x10, 0x82,
  0x10, 0x82, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x07, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFC, 0x00,
  0xC2, 0x10, 0x84, 0x21, 0x04, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84,
  0x21, 0x04, 0x21, 0x03, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFC, 0x00, 0x06,
  0x00, 0x60, 0x09, 0x00, 0x90, 0x10, 0x81, 0x08, 0x20, 0x42, 0x04, 0x40,
  0x24, 0x02, 0x80, 0x10, 0xFF, 0x80, 0x91, 0x22, 0x07, 0x90, 0x86, 0x10,
  0x62, 0x06, 0x20, 0x64, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x88, 0x08, 0x80, 0x88, 0x18, 0x81, 0x88, 0x30, 0x43, 0x07, 0xD0, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0B,
  0xC0, 0xC2, 0x18, 0x11, 0x81, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20,
  0x22, 0x02, 0x20, 0x22, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44, 0x08, 0xA1,
  0x09, 0xE0, 0x07, 0x84, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x3E, 0x00, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x07, 0x90, 0x43, 0x04, 0x18, 0x40, 0xC2, 0x06, 0x20, 0x21, 0x01, 0x08,
  0x08, 0x80, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0xC2, 0x06,
  0x10, 0x60, 0x43, 0x03, 0xE8, 0x00, 0x07, 0x82, 0x21, 0x04, 0x82, 0x20,
  0x90, 0x24, 0x11, 0x08, 0x9C, 0x38, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x03, 0xE0, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x03, 0x80, 0x00, 0x01, 0xE4, 0x08, 0x60, 0x41, 0x82, 0x06,
  0x08, 0x18, 0x40, 0x41, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02,
  0x08, 0x08, 0x20, 0x20, 0x81, 0x82, 0x06, 0x08, 0x30, 0x10, 0xC0, 0x7D,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x82,
  0x01, 0xF0, 0x00, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x0B, 0xC1, 0x84, 0x20, 0x8C, 0x11, 0x02, 0x20, 0x44, 0x09,
  0x02, 0x20, 0x44, 0x08, 0x81, 0x10, 0x24, 0x08, 0x81, 0x10, 0x22, 0x04,
  0x81, 0x10, 0x20, 0x04, 0x10, 0x00, 0x00, 0x00, 0x82, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x21, 0x08, 0x42,
  0x08, 0x41, 0x10, 0x24, 0x05, 0x01, 0x20, 0x2C, 0x06, 0x40, 0x88, 0x11,
  0x04, 0x20, 0x84, 0x10, 0x82, 0x08, 0x81, 0x10, 0x20, 0x02, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x00, 0x0B, 0xCF, 0x83, 0x0C,
  0x21, 0x83, 0x04, 0x60, 0x82, 0x10, 0x20, 0x84, 0x08, 0x21, 0x04, 0x08,
  0x81, 0x02, 0x20, 0x41, 0x08, 0x10, 0x42, 0x08, 0x10, 0x82, 0x04, 0x40,
  0x81, 0x10, 0x20, 0x84, 0x08, 0x21, 0x04, 0x08, 0x81, 0x02, 0x20, 0x40,
  0x80, 0x0B, 0xC1, 0x84, 0x60, 0x8C, 0x11, 0x02, 0x20, 0x44, 0x09, 0x02,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x44, 0x08, 0x81, 0x10, 0x22, 0x04, 0x81,
  0x10, 0x20, 0x07, 0x86, 0x11, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0xC2, 0x1F,
  0x00, 0x05, 0xE0, 0x30, 0x82, 0x82, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20,
  0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x22, 0x02, 0x10, 0x10,
  0x80, 0x84, 0x08, 0x50, 0x82, 0x78, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x07, 0x90, 0x86, 0x10,
  0x62, 0x06, 0x20, 0x64, 0x04, 0x40, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80,
  0x88, 0x08, 0x80, 0x88, 0x18, 0x81, 0x88, 0x30, 0x43, 0x07, 0xD0, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0B,
  0x86, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x00, 0x07, 0xC1, 0x04, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x1F, 0x80, 0x08, 0x41, 0x04,
  0x7C, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x83, 0x80, 0x10, 0x22, 0x04, 0x81, 0x10, 0x22, 0x04, 0x40, 0x88, 0x12,
  0x04, 0x40, 0x88, 0x11, 0x02, 0x40, 0x88, 0x11, 0x02, 0x20, 0xC4, 0x18,
  0x86, 0x0F, 0x40, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x12, 0x11, 0x08,
  0x88, 0x44, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xC0, 0x40, 0x00,
  0x81, 0x03, 0x02, 0x06, 0x0C, 0x14, 0x18, 0x28, 0x30, 0x50, 0xA1, 0x21,
  0x42, 0x44, 0x88, 0x89, 0x11, 0x12, 0x22, 0x44, 0x84, 0x89, 0x0A, 0x14,
  0x14, 0x28, 0x30, 0x50, 0x60, 0xC0, 0xC1, 0x81, 0x02, 0x00, 0x08, 0x10,
  0x82, 0x08, 0x40, 0x84, 0x08, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0A, 0x00, 0xA0, 0x12, 0x02, 0x20, 0x21, 0x04, 0x10, 0x81, 0x08,
  0x10, 0x01, 0x01, 0x01, 0x02, 0x01, 0x02, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x3F, 0x00, 0x00, 0xF0, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x18, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x0F, 0x00, 0x7C, 0x18, 0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 7, 9, 9, 3, -24 },
  { 27, 13, 24, 12, 0, -24 },
  { 66, 12, 28, 12, 0, -26 },
  { 108, 14, 25, 18, 2, -25 },
  { 152, 10, 25, 11, 0, -25 },
  { 184, 3, 9, 5, 3, -24 },
  { 188, 9, 29, 8, 1, -24 },
  { 221, 9, 29, 8, -2, -24 },
  { 254, 8, 9, 11, 4, -26 },
  { 263, 12, 16, 14, 1, -20 },
  { 287, 4, 7, 5, -1, -3 },
  { 291, 7, 1, 9, 1, -10 },
  { 292, 1, 2, 5, 1, -2 },
  { 293, 14, 24, 10, -2, -24 },
  { 335, 11, 25, 12, 1, -25 },
  { 370, 6, 24, 12, 4, -24 },
  { 388, 13, 25, 12, -1, -25 },
  { 429, 13, 25, 12, -1, -25 },
  { 470, 13, 25, 12, -1, -25 },
  { 511, 13, 24, 12, -1, -24 },
  { 550, 11, 25, 12, 1, -25 },
  { 585, 12, 24, 12, 1, -24 },
  { 621, 12, 25, 12, 0, -25 },
  { 659, 11, 25, 12, 0, -25 },
  { 694, 5, 18, 5, 0, -18 },
  { 706, 7, 22, 5, -2, -18 },
  { 726, 12, 14, 14, 1, -19 },
  { 747, 12, 8, 14, 1, -16 },
  { 759, 12, 14, 14, 1, -19 },
  { 780, 10, 25, 8, 0, -25 },
  { 812, 16, 27, 17, 1, -24 },
  { 866, 11, 24, 11, -2, -24 },
  { 899, 13, 24, 13, 0, -24 },
  { 938, 13, 25, 11, 1, -25 },
  { 979, 13, 24, 14, 0, -24 },
  { 1018, 13, 24, 11, 0, -24 },
  { 1057, 13, 24, 11, 0, -24 },
  { 1096, 15, 25, 15, 1, -25 },
  { 1143, 15, 24, 15, 0, -24 },
  { 1188, 10, 24, 6, -2, -24 },
  { 1218, 11, 30, 5, -5, -24 },
  { 1260, 14, 24, 12, 0, -24 },
  { 1302, 8, 24, 10, 0, -24 },
  { 1326, 20, 24, 20, 0, -24 },
  { 1386, 16, 24, 16, 0, -24 },
  { 1434, 13, 25, 15, 1, -25 },
  { 1475, 12, 24, 12, 0, -24 },
  { 1511, 13, 31, 15, 1, -25 },
  { 1562, 12, 24, 12, 0, -24 },
  { 1598, 13, 25, 12, -1, -25 },
  { 1639, 11, 24, 10, 2, -24 },
  { 1672, 14, 24, 14, 1, -24 },
  { 1714, 11, 24, 12, 3, -24 },
  { 1747, 20, 24, 20, 3, -24 },
  { 1807, 15, 24, 10, -2, -24 },
  { 1852, 11, 24, 10, 2, -24 },
  { 1885, 13, 24, 10, -1, -24 },
  { 1924, 12, 29, 9, -1, -24 },
  { 1968, 5, 24, 11, 3, -24 },
  { 1983, 12, 29, 9, -2, -24 },
  { 2027, 12, 11, 13, 1, -24 },
  { 2044, 9, 1, 9, -3, 3 },
  { 2046, 3, 5, 7, 5, -26 },
  { 2048, 12, 18, 13, 1, -18 },
  { 2075, 12, 26, 13, 0, -26 },
  { 2114, 9, 18, 9, 1, -18 },
  { 2135, 13, 26, 13, 1, -26 },
  { 2178, 10, 18, 11, 1, -18 },
  { 2201, 14, 34, 6, -4, -26 },
  { 2261, 14, 26, 13, -1, -18 },
  { 2307, 11, 26, 12, 0, -26 },
  { 2343, 6, 24, 5, 0, -24 },
  { 2361, 12, 32, 5, -5, -24 },
  { 2409, 11, 26, 10, 0, -26 },
  { 2445, 7, 26, 5, 0, -26 },
  { 2468, 18, 18, 19, 0, -18 },
  { 2509, 11, 18, 12, 0, -18 },
  { 2534, 10, 18, 12, 1, -18 },
  { 2557, 13, 26, 13, -1, -18 },
  { 2600, 12, 26, 13, 1, -18 },
  { 2639, 9, 18, 8, 0, -18 },
  { 2660, 11, 18, 9, -1, -18 },
  { 2685, 6, 22, 6, 1, -22 },
  { 2702, 11, 18, 12, 1, -18 },
  { 2727, 9, 18, 9, 2, -18 },
  { 2748, 15, 18, 16, 2, -18 },
  { 2782, 12, 18, 10, -1, -18 },
  { 2809, 16, 26, 10, -4, -18 },
  { 2861, 10, 18, 8, -1, -18 },
  { 2884, 12, 29, 11, 1, -24 },
  { 2928, 1, 34, 12, 5, -26 },
  { 2933, 11, 29, 10, -2, -24 },
  { 2973, 12, 2, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC34PT7B_H_
