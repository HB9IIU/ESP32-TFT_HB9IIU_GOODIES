#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0xA0, 0x80, 0xB7, 0x00, 0x29, 0x5E, 0xA5, 0x3A, 0x94,
  0xA0, 0x11, 0xD8, 0xC6, 0x10, 0x8A, 0x57, 0x10, 0xED, 0xAD, 0xDF, 0xB5,
  0xB5, 0xB8, 0x75, 0x52, 0x4B, 0xBA, 0xE0, 0xE0, 0x12, 0x44, 0x88, 0x88,
  0x88, 0x40, 0x21, 0x11, 0x11, 0x12, 0x24, 0x80, 0x5E, 0x20, 0x21, 0x09,
  0xF2, 0x10, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x20, 0x84, 0x10, 0x80,
  0x35, 0x59, 0x99, 0x9A, 0xE0, 0x75, 0x24, 0x94, 0x80, 0x71, 0x11, 0x12,
  0x48, 0xE0, 0x78, 0x42, 0x26, 0x08, 0x42, 0xE0, 0x18, 0x8C, 0xA5, 0x4B,
  0xC4, 0x20, 0x7A, 0x11, 0xC1, 0x08, 0x42, 0xE0, 0x3A, 0x11, 0xC9, 0x4A,
  0x52, 0xE0, 0x78, 0x44, 0x22, 0x11, 0x08, 0x80, 0x7A, 0x52, 0xA6, 0x4A,
  0x52, 0xE0, 0x75, 0x99, 0x53, 0x12, 0xE0, 0x40, 0x08, 0x20, 0x00, 0x12,
  0x80, 0x1B, 0x30, 0x41, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0x71,
  0x12, 0x44, 0x80, 0x80, 0x3D, 0x15, 0xDB, 0xAE, 0xDB, 0x6A, 0x81, 0x80,
  0x11, 0x33, 0x35, 0x59, 0x90, 0x3A, 0x52, 0xA7, 0x4A, 0x52, 0xE0, 0x3A,
  0x10, 0x88, 0x42, 0x10, 0x60, 0x3A, 0x52, 0x94, 0xC6, 0x32, 0xE0, 0x3A,
  0x10, 0x87, 0x42, 0x10, 0xE0, 0x3A, 0x10, 0x87, 0x42, 0x10, 0x80, 0x3D,
  0x04, 0x20, 0x8A, 0x28, 0xA2, 0x78, 0x45, 0x14, 0x52, 0x7A, 0x28, 0xA2,
  0x90, 0x32, 0x22, 0x24, 0x44, 0xC0, 0x11, 0x11, 0x12, 0x22, 0x22, 0xC0,
  0x4A, 0x94, 0xC6, 0x52, 0x92, 0x90, 0x49, 0x25, 0x24, 0xE0, 0x21, 0x22,
  0x62, 0x66, 0x66, 0xAA, 0xAA, 0xB4, 0xA4, 0x24, 0x96, 0x59, 0x5A, 0x69,
  0xA2, 0x90, 0x3D, 0x14, 0x51, 0x86, 0x28, 0xA2, 0x70, 0x3A, 0x52, 0x97,
  0x42, 0x10, 0x80, 0x3D, 0x14, 0x51, 0x86, 0x28, 0xA2, 0x50, 0x82, 0x00,
  0x3A, 0x52, 0x97, 0x52, 0x94, 0x90, 0x7A, 0x10, 0x82, 0x08, 0x42, 0xE0,
  0xF4, 0x44, 0x88, 0x88, 0x80, 0x45, 0x14, 0x92, 0x4A, 0x28, 0xA4, 0xF0,
  0x9C, 0xA5, 0x4A, 0x63, 0x10, 0x80, 0x91, 0x92, 0xB2, 0xB4, 0xB4, 0xD4,
  0x98, 0x88, 0x90, 0x24, 0xA2, 0x84, 0x10, 0xC5, 0x14, 0x90, 0x9A, 0xAC,
  0x88, 0x88, 0x80, 0x1C, 0x20, 0x84, 0x10, 0x84, 0x10, 0xF0, 0x34, 0x44,
  0x44, 0x88, 0x88, 0xC0, 0xA9, 0x55, 0x40, 0x18, 0x42, 0x21, 0x08, 0x44,
  0x21, 0x38, 0x22, 0x93, 0x10, 0xE0, 0xC0, 0x3A, 0x63, 0x29, 0x4B, 0x80,
  0x21, 0x10, 0xE4, 0xA6, 0x32, 0x97, 0x00, 0x34, 0x88, 0x88, 0xE0, 0x08,
  0x42, 0x74, 0xC6, 0x52, 0x97, 0x00, 0x35, 0x9E, 0x88, 0xE0, 0x0C, 0x21,
  0x06, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0xC0, 0x3A, 0x63, 0x29, 0x4B,
  0x82, 0x27, 0x00, 0x22, 0x47, 0x55, 0x99, 0x99, 0x45, 0x6A, 0x80, 0x08,
  0x04, 0x21, 0x08, 0x84, 0x21, 0x11, 0x80, 0x22, 0x45, 0x56, 0x4A, 0xAA,
  0x25, 0x24, 0xA4, 0x90, 0x7E, 0x95, 0x4C, 0x99, 0x52, 0xA9, 0x00, 0x75,
  0x59, 0x99, 0x90, 0x35, 0x99, 0x99, 0xE0, 0x38, 0x92, 0x51, 0x49, 0x27,
  0x10, 0x82, 0x00, 0x3A, 0x53, 0x29, 0x4B, 0x82, 0x21, 0x00, 0x74, 0x48,
  0x88, 0x80, 0x78, 0x44, 0x22, 0xE0, 0x49, 0xA5, 0x24, 0x80, 0x4A, 0x55,
  0x29, 0x4B, 0x80, 0xB7, 0x69, 0x20, 0xA6, 0xAE, 0xBA, 0xB2, 0x8A, 0x00,
  0x29, 0x4C, 0x42, 0x2A, 0x40, 0x14, 0x51, 0x46, 0x18, 0x41, 0x04, 0x23,
  0x80, 0x64, 0xA9, 0x30, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x10, 0xFF,
  0xF8, 0x30, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 3, 1, -9 },
  { 7, 5, 9, 5, 0, -9 },
  { 13, 5, 11, 4, 0, -10 },
  { 20, 5, 9, 7, 1, -9 },
  { 26, 4, 9, 4, 0, -9 },
  { 31, 1, 3, 2, 1, -9 },
  { 32, 4, 11, 3, 0, -9 },
  { 38, 4, 11, 3, -1, -9 },
  { 44, 3, 4, 4, 2, -10 },
  { 46, 5, 6, 5, 0, -8 },
  { 50, 2, 3, 2, -1, -1 },
  { 51, 3, 1, 3, 0, -4 },
  { 52, 1, 1, 2, 0, -1 },
  { 53, 6, 9, 4, -1, -9 },
  { 60, 4, 9, 4, 0, -9 },
  { 65, 3, 9, 4, 1, -9 },
  { 69, 4, 9, 4, 0, -9 },
  { 74, 5, 9, 4, 0, -9 },
  { 80, 5, 9, 4, 0, -9 },
  { 86, 5, 9, 4, 0, -9 },
  { 92, 5, 9, 4, 0, -9 },
  { 98, 5, 9, 4, 0, -9 },
  { 104, 5, 9, 4, 0, -9 },
  { 110, 4, 9, 4, 0, -9 },
  { 115, 2, 7, 2, 0, -7 },
  { 117, 3, 9, 2, -1, -7 },
  { 121, 5, 5, 5, 0, -7 },
  { 125, 5, 3, 5, 0, -6 },
  { 127, 5, 5, 5, 0, -7 },
  { 131, 4, 9, 3, 0, -9 },
  { 136, 6, 10, 7, 0, -9 },
  { 144, 4, 9, 4, -1, -9 },
  { 149, 5, 9, 5, 0, -9 },
  { 155, 5, 9, 4, 0, -9 },
  { 161, 5, 9, 5, 0, -9 },
  { 167, 5, 9, 4, 0, -9 },
  { 173, 5, 9, 4, 0, -9 },
  { 179, 6, 9, 6, 0, -9 },
  { 186, 6, 9, 6, 0, -9 },
  { 193, 4, 9, 2, -1, -9 },
  { 198, 4, 11, 2, -2, -9 },
  { 204, 5, 9, 5, 0, -9 },
  { 210, 3, 9, 4, 0, -9 },
  { 214, 8, 9, 8, 0, -9 },
  { 223, 6, 9, 6, 0, -9 },
  { 230, 6, 9, 6, 0, -9 },
  { 237, 5, 9, 5, 0, -9 },
  { 243, 6, 11, 6, 0, -9 },
  { 252, 5, 9, 5, 0, -9 },
  { 258, 5, 9, 4, 0, -9 },
  { 264, 4, 9, 4, 1, -9 },
  { 269, 6, 9, 6, 0, -9 },
  { 276, 5, 9, 4, 1, -9 },
  { 282, 8, 9, 8, 1, -9 },
  { 291, 6, 9, 4, -1, -9 },
  { 298, 4, 9, 4, 1, -9 },
  { 303, 6, 9, 4, -1, -9 },
  { 310, 4, 11, 4, 0, -9 },
  { 316, 2, 9, 4, 1, -9 },
  { 319, 5, 11, 4, -1, -9 },
  { 326, 5, 4, 5, 0, -9 },
  { 329, 3, 1, 3, -1, 1 },
  { 330, 1, 2, 3, 2, -10 },
  { 331, 5, 7, 5, 0, -7 },
  { 336, 5, 10, 5, 0, -10 },
  { 343, 4, 7, 4, 0, -7 },
  { 347, 5, 10, 5, 0, -10 },
  { 354, 4, 7, 4, 0, -7 },
  { 358, 6, 13, 2, -2, -10 },
  { 368, 5, 10, 5, 0, -7 },
  { 375, 4, 10, 5, 0, -10 },
  { 380, 2, 9, 2, 0, -9 },
  { 383, 5, 12, 2, -2, -9 },
  { 391, 4, 10, 4, 0, -10 },
  { 396, 3, 10, 2, 0, -10 },
  { 400, 7, 7, 7, 0, -7 },
  { 407, 4, 7, 5, 0, -7 },
  { 411, 4, 7, 5, 0, -7 },
  { 415, 6, 10, 5, -1, -7 },
  { 423, 5, 10, 5, 0, -7 },
  { 430, 4, 7, 3, 0, -7 },
  { 434, 4, 7, 4, 0, -7 },
  { 438, 3, 9, 2, 0, -9 },
  { 442, 5, 7, 5, 0, -7 },
  { 447, 3, 7, 4, 1, -7 },
  { 450, 6, 7, 6, 1, -7 },
  { 456, 5, 7, 4, -1, -7 },
  { 461, 6, 10, 4, -2, -7 },
  { 469, 3, 7, 3, 0, -7 },
  { 472, 5, 11, 4, 0, -9 },
  { 479, 1, 13, 4, 2, -10 },
  { 481, 5, 11, 4, -1, -9 },
  { 488, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC13PT7B_H_
