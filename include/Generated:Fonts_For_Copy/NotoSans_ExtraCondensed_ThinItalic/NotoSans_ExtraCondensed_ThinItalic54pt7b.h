#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x10, 0x62, 0x08, 0xC1, 0x18, 0x62, 0x0C, 0x41, 0x08, 0x23,
  0x04, 0x61, 0x88, 0x21, 0x04, 0x20, 0x8C, 0x11, 0x06, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x40, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x01, 0x02, 0x00,
  0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x60, 0x40, 0x03, 0x06,
  0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x80, 0x02,
  0x04, 0x00, 0x30, 0x60, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80,
  0x06, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81,
  0x00, 0x04, 0x08, 0x07, 0xFF, 0xFC, 0x02, 0x04, 0x00, 0x10, 0x20, 0x01,
  0x83, 0x00, 0x08, 0x18, 0x00, 0x40, 0x80, 0x06, 0x04, 0x00, 0x30, 0x60,
  0x01, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x20,
  0x40, 0x03, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x03, 0x18, 0xE0,
  0x30, 0x80, 0x03, 0x04, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x03,
  0x10, 0x00, 0x08, 0x80, 0x00, 0x64, 0x00, 0x01, 0xA0, 0x00, 0x07, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x2C, 0x00, 0x03,
  0x30, 0x00, 0x10, 0x80, 0x00, 0x86, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80,
  0x03, 0x04, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x04, 0x18, 0x00, 0x60,
  0x80, 0x02, 0x0C, 0x08, 0x10, 0xC0, 0x7C, 0xBC, 0x00, 0x7F, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xC0, 0x08, 0x1C, 0x80, 0x10, 0x21, 0x80, 0x40, 0xC1, 0x00,
  0x83, 0x02, 0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x18, 0x30, 0x10, 0x20,
  0x40, 0x60, 0xC0, 0x80, 0xC1, 0x03, 0x01, 0x86, 0x06, 0x02, 0x08, 0x0C,
  0x04, 0x30, 0x10, 0x08, 0x40, 0x20, 0x31, 0x80, 0x40, 0x62, 0x08, 0x80,
  0x8C, 0x7D, 0x03, 0x11, 0x8A, 0x04, 0x66, 0x1C, 0x18, 0x88, 0x38, 0x23,
  0x30, 0x30, 0xC4, 0x40, 0xF3, 0x19, 0x81, 0xBC, 0x22, 0x03, 0x00, 0xC4,
  0x06, 0x01, 0x18, 0x0C, 0x06, 0x30, 0x10, 0x08, 0x40, 0x20, 0x30, 0x80,
  0xC0, 0x41, 0x01, 0x81, 0x82, 0x02, 0x02, 0x0C, 0x04, 0x0C, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x60, 0x60, 0x40, 0x80, 0xC1, 0x83, 0x00, 0x86, 0x04,
  0x01, 0x08, 0x18, 0x03, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x19,
  0x80, 0x18, 0x40, 0x18, 0x20, 0x0C, 0x18, 0x04, 0x08, 0x06, 0x04, 0x03,
  0x02, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x18, 0x60,
  0x0C, 0x60, 0x02, 0x20, 0x01, 0x30, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x34, 0x00, 0x33, 0x00, 0x31, 0x80, 0x30, 0x41, 0x10,
  0x20, 0x98, 0x18, 0xC8, 0x04, 0x4C, 0x02, 0x24, 0x01, 0x32, 0x00, 0xD1,
  0x00, 0x39, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x08, 0x06,
  0x86, 0x02, 0x43, 0x86, 0x30, 0xFE, 0x08, 0x0C, 0x00, 0x11, 0x33, 0x22,
  0x26, 0x64, 0x44, 0xC8, 0x00, 0x06, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0xE1, 0x00, 0xC4,
  0x00, 0xD3, 0xC0, 0xF0, 0x07, 0x00, 0x34, 0x01, 0x08, 0x08, 0x30, 0x40,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x04,
  0x30, 0xC2, 0x18, 0x41, 0x08, 0x21, 0x04, 0x20, 0xFF, 0xF0, 0x7F, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x31, 0x80, 0x30, 0x40, 0x30, 0x30,
  0x30, 0x08, 0x10, 0x04, 0x18, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x86, 0x00,
  0x42, 0x00, 0x23, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0xC0, 0x06, 0x60,
  0x03, 0x20, 0x01, 0x90, 0x00, 0x98, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x32,
  0x00, 0x19, 0x00, 0x0C, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01,
  0x18, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x42, 0x00, 0x21, 0x00, 0x30, 0xC0,
  0x10, 0x60, 0x18, 0x30, 0x08, 0x08, 0x0C, 0x04, 0x0C, 0x03, 0x0C, 0x00,
  0xFC, 0x00, 0x10, 0x00, 0x00, 0x81, 0xC1, 0xE1, 0xB1, 0x93, 0x8B, 0x04,
  0x86, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0x8E, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x1C,
  0x01, 0x80, 0x40, 0x10, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x38, 0x08, 0x06, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x1A, 0x00, 0x01, 0x60,
  0x00, 0x36, 0x00, 0x02, 0x40, 0x00, 0x64, 0x00, 0x0C, 0x40, 0x00, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x08, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0x41,
  0x80, 0x0C, 0x18, 0x00, 0x81, 0x00, 0x18, 0x10, 0x03, 0x03, 0x00, 0x20,
  0x30, 0x06, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x06, 0x03, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0F,
  0xFF, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0D, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x38, 0x08, 0x06, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0x08, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x33, 0xF8, 0x04, 0xC1, 0x80,
  0xA0, 0x18, 0x3C, 0x03, 0x07, 0x00, 0x20, 0xC0, 0x04, 0x18, 0x00, 0xC2,
  0x00, 0x18, 0x40, 0x02, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x01, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x20, 0xC0, 0x0C, 0x18,
  0x01, 0x01, 0x00, 0x60, 0x20, 0x08, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x07,
  0xF0, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0x1C, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x01,
  0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x30,
  0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x02, 0x03, 0x00, 0x60, 0x30, 0x04,
  0x01, 0x00, 0x80, 0x18, 0x18, 0x00, 0xC6, 0x00, 0x04, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0x98, 0x00, 0x60, 0xC0, 0x0C, 0x04, 0x01, 0x80,
  0x60, 0x30, 0x02, 0x02, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x0C,
  0x00, 0x30, 0x40, 0x02, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x81, 0x80,
  0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x3E, 0x00, 0x38, 0xC0, 0x18, 0x18,
  0x0C, 0x02, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x04, 0x30, 0x01, 0x0C,
  0x00, 0x42, 0x00, 0x11, 0x80, 0x04, 0x60, 0x01, 0x18, 0x00, 0x44, 0x00,
  0x31, 0x00, 0x0C, 0x40, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x0E, 0x08, 0x07, 0x83, 0x03, 0x60, 0x77, 0x90, 0x0F, 0x84, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x20, 0xE0, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x02,
  0x03, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0xE0, 0xE0, 0xC0, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xE0, 0x38, 0xE0, 0x80, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x08, 0x04, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x30, 0x07, 0x03, 0x0C,
  0x07, 0xE0, 0xC2, 0x03, 0x08, 0x31, 0x81, 0x86, 0x08, 0x40, 0xC1, 0x82,
  0x10, 0x20, 0x40, 0x8C, 0x18, 0x10, 0x22, 0x04, 0x0C, 0x18, 0x83, 0x02,
  0x06, 0x20, 0xC0, 0x81, 0x98, 0x20, 0x60, 0x46, 0x08, 0x18, 0x11, 0x06,
  0x04, 0x0C, 0x41, 0x81, 0x02, 0x10, 0x60, 0xC0, 0x84, 0x18, 0x30, 0x61,
  0x04, 0x0C, 0x10, 0xC1, 0x07, 0x0C, 0x30, 0x61, 0xC2, 0x0C, 0x18, 0x91,
  0x83, 0x03, 0x67, 0xC0, 0xC0, 0x70, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00,
  0x19, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x18,
  0x40, 0x04, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x18, 0x10,
  0x04, 0x04, 0x03, 0x03, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x18, 0x03, 0x04, 0x00,
  0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x33,
  0x00, 0x0C, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x80, 0xE0, 0x08, 0x03, 0x01, 0x80, 0x30,
  0x18, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x01,
  0x03, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x02, 0x06, 0x00,
  0x60, 0x60, 0x0C, 0x04, 0x01, 0x80, 0x40, 0x70, 0x07, 0xFC, 0x00, 0xC3,
  0xC0, 0x0C, 0x07, 0x00, 0x80, 0x10, 0x08, 0x01, 0x81, 0x80, 0x08, 0x18,
  0x00, 0x81, 0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x30, 0x00, 0x83,
  0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x10, 0x20, 0x01, 0x06, 0x00, 0x30,
  0x60, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x18, 0x04, 0x1F, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xC3, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x81, 0x00,
  0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x20,
  0x30, 0x01, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x60,
  0x20, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00,
  0x10, 0x20, 0x00, 0x81, 0x00, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x03, 0x04,
  0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01,
  0x04, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x20, 0x80,
  0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x40,
  0x80, 0x06, 0x04, 0x00, 0x20, 0x20, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03,
  0x00, 0x80, 0x30, 0x04, 0x07, 0x00, 0x61, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x1C, 0x1E, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x07, 0xF0,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x20,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80,
  0x40, 0x00, 0x80, 0x60, 0x01, 0x80, 0x20, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x1C, 0x03, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x80, 0x20, 0x00, 0x40, 0x10, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x08, 0x02, 0x00, 0x04, 0x01, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x40, 0x00, 0x80, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x04,
  0x00, 0x08, 0x02, 0x00, 0x0C, 0x03, 0xFF, 0xFE, 0x01, 0x80, 0x02, 0x00,
  0x80, 0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x20, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x02, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0x40, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x10, 0x00, 0x20, 0x08, 0x00,
  0x10, 0x04, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x08, 0x60, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x40,
  0x30, 0x00, 0x80, 0x40, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x10, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x10, 0x00, 0x04, 0x60, 0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x6B, 0x00, 0x00, 0xA6, 0x00, 0x01, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x0C,
  0x10, 0x00, 0x18, 0x30, 0x00, 0x20, 0x60, 0x00, 0x40, 0x40, 0x00, 0x80,
  0x80, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x08, 0x02, 0x00, 0x10, 0x04,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0A, 0x01, 0x60, 0x00,
  0x1A, 0x01, 0x60, 0x00, 0x12, 0x01, 0x60, 0x00, 0x36, 0x03, 0x20, 0x00,
  0x26, 0x03, 0x20, 0x00, 0x64, 0x02, 0x20, 0x00, 0x44, 0x02, 0x20, 0x00,
  0xCC, 0x02, 0x20, 0x00, 0x8C, 0x06, 0x20, 0x01, 0x88, 0x06, 0x20, 0x01,
  0x88, 0x04, 0x20, 0x03, 0x08, 0x04, 0x20, 0x03, 0x18, 0x0C, 0x20, 0x02,
  0x18, 0x0C, 0x20, 0x06, 0x10, 0x08, 0x20, 0x04, 0x10, 0x08, 0x30, 0x0C,
  0x10, 0x08, 0x30, 0x08, 0x30, 0x18, 0x30, 0x18, 0x30, 0x18, 0x30, 0x10,
  0x20, 0x10, 0x30, 0x30, 0x20, 0x10, 0x30, 0x20, 0x60, 0x10, 0x30, 0x60,
  0x60, 0x30, 0x30, 0x40, 0x40, 0x30, 0x10, 0xC0, 0x40, 0x20, 0x10, 0x80,
  0x40, 0x20, 0x11, 0x80, 0xC0, 0x60, 0x11, 0x00, 0xC0, 0x60, 0x13, 0x00,
  0x80, 0x40, 0x12, 0x00, 0x80, 0x40, 0x16, 0x00, 0x80, 0x40, 0x14, 0x01,
  0x80, 0xC0, 0x1C, 0x01, 0x80, 0xC0, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x03, 0x80, 0x02, 0x01, 0xE0,
  0x01, 0x80, 0x68, 0x00, 0x60, 0x12, 0x00, 0x10, 0x04, 0x80, 0x04, 0x01,
  0x30, 0x03, 0x00, 0xCC, 0x00, 0xC0, 0x31, 0x00, 0x30, 0x08, 0x40, 0x08,
  0x02, 0x10, 0x02, 0x00, 0x86, 0x01, 0x80, 0x61, 0x80, 0x60, 0x18, 0x60,
  0x10, 0x04, 0x08, 0x04, 0x01, 0x02, 0x01, 0x00, 0xC0, 0x80, 0xC0, 0x30,
  0x30, 0x30, 0x0C, 0x0C, 0x08, 0x02, 0x01, 0x02, 0x00, 0x80, 0x41, 0x80,
  0x60, 0x10, 0x60, 0x18, 0x06, 0x18, 0x04, 0x01, 0x84, 0x01, 0x00, 0x61,
  0x00, 0x40, 0x08, 0xC0, 0x30, 0x02, 0x30, 0x0C, 0x00, 0x88, 0x02, 0x00,
  0x32, 0x00, 0x80, 0x0C, 0x80, 0x60, 0x01, 0x60, 0x18, 0x00, 0x58, 0x06,
  0x00, 0x14, 0x01, 0x00, 0x07, 0x00, 0x40, 0x01, 0xC0, 0x30, 0x00, 0x70,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xC7, 0x00, 0x30, 0x08,
  0x03, 0x00, 0x60, 0x30, 0x01, 0x01, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x64, 0x00, 0x03, 0x60, 0x00,
  0x13, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x64, 0x00, 0x03,
  0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00,
  0x06, 0x10, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x80,
  0x80, 0x18, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00, 0x7F, 0x80, 0x00, 0x60,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x81, 0xC0, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x01, 0x00, 0x30, 0x10, 0x03, 0x01, 0x00, 0x30,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x02,
  0x06, 0x00, 0x60, 0x60, 0x04, 0x04, 0x00, 0xC0, 0x40, 0x08, 0x0C, 0x01,
  0x80, 0xC0, 0x30, 0x08, 0x0C, 0x00, 0xFF, 0x80, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xC7, 0x00, 0x30, 0x08, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x01, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x64, 0x00, 0x03, 0x60, 0x00, 0x13,
  0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x64, 0x00, 0x03, 0x20,
  0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x06,
  0x10, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x80, 0x80,
  0x18, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x50, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x81, 0xC0, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02,
  0x01, 0x80, 0x30, 0x10, 0x03, 0x01, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x04, 0x04, 0x00, 0xC0, 0x40, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0F,
  0xFC, 0x00, 0xFE, 0x00, 0x08, 0x20, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x03, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x30, 0x10, 0x03, 0x01, 0x80,
  0x20, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x80, 0x60, 0x0C,
  0x04, 0x00, 0xC0, 0x40, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x04, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xE0, 0xF0, 0x06, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x07, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x08, 0x00,
  0x30, 0x20, 0x00, 0x81, 0x80, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x60,
  0x40, 0x01, 0x81, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x40, 0x80,
  0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81, 0x80, 0x06,
  0x04, 0x00, 0x18, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x08,
  0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00,
  0x60, 0x40, 0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0x40,
  0xC0, 0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80,
  0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x40, 0x18,
  0x01, 0xC1, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x28, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x20,
  0x80, 0x18, 0x20, 0x04, 0x08, 0x03, 0x02, 0x00, 0x80, 0x80, 0x60, 0x20,
  0x18, 0x08, 0x04, 0x02, 0x03, 0x00, 0x80, 0x80, 0x20, 0x60, 0x08, 0x10,
  0x02, 0x04, 0x00, 0x83, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00,
  0x8C, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x60, 0x00, 0x90, 0x00, 0x2C,
  0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x02, 0xC0, 0x01, 0x80, 0x06, 0xC0, 0x02, 0x80, 0x06, 0xC0, 0x02, 0x80,
  0x04, 0xC0, 0x06, 0x80, 0x0C, 0xC0, 0x04, 0x80, 0x08, 0xC0, 0x04, 0x80,
  0x18, 0xC0, 0x0C, 0x80, 0x18, 0xC0, 0x08, 0x80, 0x10, 0xC0, 0x19, 0x80,
  0x30, 0xC0, 0x11, 0x80, 0x20, 0xC0, 0x11, 0x80, 0x60, 0xC0, 0x31, 0x80,
  0x60, 0xC0, 0x21, 0x80, 0x40, 0xC0, 0x61, 0x80, 0xC0, 0xC0, 0x41, 0x80,
  0x80, 0xC0, 0x41, 0x81, 0x80, 0xC0, 0xC1, 0x81, 0x80, 0xC0, 0x81, 0x81,
  0x00, 0xC1, 0x81, 0x03, 0x00, 0xC1, 0x81, 0x02, 0x00, 0xC1, 0x01, 0x06,
  0x00, 0xC3, 0x01, 0x04, 0x00, 0xC2, 0x01, 0x04, 0x00, 0xC6, 0x01, 0x0C,
  0x00, 0xC6, 0x01, 0x08, 0x00, 0xC4, 0x01, 0x18, 0x00, 0x8C, 0x01, 0x10,
  0x00, 0x88, 0x01, 0x10, 0x00, 0x98, 0x01, 0x30, 0x00, 0x98, 0x01, 0x20,
  0x00, 0x90, 0x01, 0x60, 0x00, 0xB0, 0x01, 0x40, 0x00, 0xA0, 0x01, 0x40,
  0x00, 0xA0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x60, 0x02, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x10,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00, 0x43, 0x00, 0x00, 0x84, 0x00,
  0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x05, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x26, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x20, 0x00, 0x20, 0x40,
  0x00, 0xC0, 0x80, 0x01, 0x01, 0x00, 0x06, 0x02, 0x00, 0x08, 0x04, 0x00,
  0x20, 0x08, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x08,
  0x00, 0xC0, 0x30, 0x00, 0x80, 0x00, 0x60, 0x00, 0x90, 0x00, 0xC8, 0x00,
  0x44, 0x00, 0x62, 0x00, 0x61, 0x00, 0x30, 0x80, 0x30, 0x40, 0x18, 0x30,
  0x18, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x04, 0x01, 0x06, 0x00, 0x82, 0x00,
  0x43, 0x00, 0x21, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x40,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x81,
  0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x03, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0,
  0x81, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x80, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x50, 0x00,
  0x0D, 0x80, 0x00, 0x98, 0x00, 0x18, 0x80, 0x01, 0x0C, 0x00, 0x30, 0x40,
  0x02, 0x06, 0x00, 0x60, 0x20, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x08, 0x01,
  0x81, 0x80, 0x08, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00,
  0x06, 0xC0, 0x00, 0x30, 0xFF, 0xFC, 0x86, 0x10, 0xC2, 0x18, 0x41, 0x00,
  0x78, 0x00, 0x77, 0x10, 0x30, 0x6C, 0x18, 0x0A, 0x0C, 0x03, 0x86, 0x00,
  0xE1, 0x80, 0x18, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x18, 0x80,
  0x06, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03,
  0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x28, 0x30, 0x1E, 0x0C, 0x05, 0x01,
  0x86, 0x40, 0x3F, 0x10, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x31, 0xF0, 0x06, 0x77, 0x00, 0x90, 0x30, 0x14, 0x06, 0x07, 0x00, 0x40,
  0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x03, 0x08,
  0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x30,
  0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01, 0x07, 0x00, 0x60, 0xA0,
  0x18, 0x16, 0x06, 0x02, 0x41, 0x80, 0xCF, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0xFC, 0x07, 0x30, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x20,
  0x3F, 0x80, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x07, 0x8C, 0x00, 0xEE, 0x60, 0x0C, 0x1B, 0x00, 0xC0, 0x50, 0x0C, 0x03,
  0x80, 0xC0, 0x1C, 0x06, 0x00, 0x60, 0x60, 0x02, 0x03, 0x00, 0x30, 0x10,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x10,
  0x30, 0x00, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0x40, 0x02, 0x02, 0x00,
  0x10, 0x10, 0x01, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20, 0x06, 0x01,
  0x00, 0x30, 0x08, 0x02, 0x80, 0x60, 0x3C, 0x03, 0x01, 0x40, 0x0C, 0x32,
  0x00, 0x3F, 0x10, 0x00, 0x40, 0x00, 0x00, 0x00, 0x78, 0x00, 0xEE, 0x03,
  0x02, 0x02, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x02, 0x10,
  0x06, 0x30, 0x06, 0x30, 0x0C, 0x20, 0x18, 0x60, 0x30, 0x61, 0xE0, 0x7F,
  0x80, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x20, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xC4, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x0B, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xDC,
  0x40, 0x18, 0x36, 0x01, 0x80, 0xA0, 0x18, 0x07, 0x01, 0x80, 0x38, 0x0C,
  0x00, 0xC0, 0xC0, 0x04, 0x06, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00,
  0x18, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x03, 0x01,
  0x00, 0x18, 0x08, 0x01, 0xC0, 0x40, 0x0C, 0x02, 0x00, 0x60, 0x10, 0x05,
  0x00, 0xC0, 0x78, 0x06, 0x02, 0x80, 0x18, 0x64, 0x00, 0x7E, 0x20, 0x00,
  0x83, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x10, 0x0C, 0x00, 0xF3, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x1F, 0x00, 0xDE, 0xE0, 0x2C, 0x08, 0x0A, 0x03, 0x03, 0x00,
  0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x04, 0x00, 0x83, 0x00, 0x20,
  0xC0, 0x18, 0x30, 0x06, 0x08, 0x01, 0x02, 0x00, 0x41, 0x80, 0x10, 0x60,
  0x0C, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x06,
  0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x03, 0x04,
  0x00, 0x81, 0x00, 0x20, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x5C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x40, 0xC0, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x06, 0x01, 0x81,
  0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x30, 0x03, 0x08, 0x00, 0xC4, 0x00,
  0x23, 0x00, 0x09, 0xC0, 0x02, 0x50, 0x01, 0xA4, 0x00, 0x71, 0x00, 0x1C,
  0x40, 0x06, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x80, 0x20, 0x20, 0x08, 0x08,
  0x02, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x0C, 0x04, 0x01, 0x01,
  0x00, 0x40, 0xC0, 0x10, 0x00, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x1E, 0x07,
  0x80, 0x27, 0x71, 0xCE, 0x02, 0xC1, 0xB0, 0x20, 0x38, 0x0E, 0x03, 0x07,
  0x00, 0xC0, 0x30, 0x60, 0x0C, 0x03, 0x06, 0x00, 0x80, 0x30, 0x60, 0x08,
  0x02, 0x04, 0x01, 0x80, 0x20, 0xC0, 0x18, 0x02, 0x0C, 0x01, 0x00, 0x60,
  0x80, 0x10, 0x06, 0x08, 0x03, 0x00, 0x40, 0x80, 0x30, 0x04, 0x18, 0x02,
  0x00, 0x41, 0x80, 0x20, 0x0C, 0x10, 0x02, 0x00, 0xC1, 0x00, 0x60, 0x08,
  0x10, 0x06, 0x00, 0x83, 0x00, 0x40, 0x18, 0x30, 0x04, 0x01, 0x82, 0x00,
  0x40, 0x18, 0x20, 0x0C, 0x01, 0x06, 0x00, 0xC0, 0x10, 0x60, 0x08, 0x03,
  0x04, 0x00, 0x80, 0x30, 0x40, 0x18, 0x02, 0x04, 0x01, 0x80, 0x20, 0xC0,
  0x10, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x9E, 0xE0, 0x2C, 0x08, 0x0E, 0x03,
  0x07, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x08, 0x18, 0x02, 0x04, 0x00, 0x83,
  0x00, 0x20, 0xC0, 0x18, 0x20, 0x06, 0x08, 0x01, 0x02, 0x00, 0x41, 0x80,
  0x30, 0x60, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x18,
  0x30, 0x06, 0x08, 0x01, 0x02, 0x00, 0x41, 0x80, 0x10, 0x60, 0x0C, 0x10,
  0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x18, 0x00, 0x00, 0xF8, 0x03,
  0xDC, 0x06, 0x06, 0x0C, 0x02, 0x0C, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x30, 0xC0,
  0x20, 0xC0, 0x60, 0x60, 0xC0, 0x3F, 0x80, 0x04, 0x00, 0x00, 0x47, 0xC0,
  0x04, 0x77, 0x00, 0x24, 0x0C, 0x01, 0x40, 0x60, 0x0E, 0x01, 0x00, 0xE0,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x08, 0x18, 0x00,
  0x40, 0xC0, 0x06, 0x04, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x08, 0x18,
  0x00, 0xC0, 0xC0, 0x04, 0x06, 0x00, 0x20, 0x30, 0x03, 0x01, 0x80, 0x10,
  0x1C, 0x01, 0x80, 0xE0, 0x18, 0x05, 0x01, 0x80, 0x24, 0x18, 0x03, 0x3F,
  0x80, 0x18, 0x20, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x77, 0x10, 0x20, 0x6C, 0x10, 0x0A, 0x0C, 0x03, 0x86, 0x00, 0xE1, 0x00,
  0x18, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C,
  0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x18, 0x80, 0x06, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x01,
  0x82, 0x00, 0x60, 0x80, 0x28, 0x30, 0x1E, 0x0C, 0x05, 0x01, 0x86, 0x40,
  0x3F, 0x10, 0x02, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x1E, 0x04, 0xF4,
  0x0B, 0x00, 0x14, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xDF, 0x02, 0x01, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0xC0, 0xC0, 0xFF,
  0x80, 0x04, 0x00, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40,
  0xFF, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0F, 0x80, 0x40,
  0x06, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x30, 0x06, 0x0C, 0x01, 0x82,
  0x00, 0x60, 0x80, 0x10, 0x20, 0x04, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00,
  0x20, 0x40, 0x08, 0x10, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x80, 0x10,
  0x20, 0x04, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x08, 0x10,
  0x06, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x38, 0x10, 0x14, 0x06, 0x0D,
  0x00, 0xFC, 0x40, 0x08, 0x00, 0x00, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0,
  0x06, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x20, 0x18, 0x80, 0x42, 0x03, 0x08,
  0x0C, 0x20, 0x20, 0x81, 0x82, 0x04, 0x0C, 0x30, 0x30, 0x80, 0xC6, 0x03,
  0x10, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x01, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x02, 0xC0, 0x38, 0x06, 0xC0, 0x28, 0x04, 0xC0, 0x28,
  0x04, 0xC0, 0x68, 0x0C, 0xC0, 0x48, 0x08, 0xC0, 0xC8, 0x18, 0xC0, 0x88,
  0x10, 0xC0, 0x88, 0x10, 0xC1, 0x08, 0x30, 0xC1, 0x08, 0x20, 0xC3, 0x08,
  0x60, 0xC2, 0x08, 0x40, 0xC6, 0x08, 0x40, 0xC4, 0x08, 0xC0, 0xC4, 0x08,
  0x80, 0xCC, 0x08, 0x80, 0xC8, 0x09, 0x00, 0xD8, 0x09, 0x00, 0xD0, 0x0B,
  0x00, 0xD0, 0x0A, 0x00, 0xB0, 0x0A, 0x00, 0xA0, 0x0C, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x60, 0x20, 0x18,
  0x04, 0x02, 0x00, 0x80, 0xC0, 0x18, 0x10, 0x03, 0x04, 0x00, 0x21, 0x80,
  0x04, 0x20, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x03, 0x40, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0x20, 0x00,
  0x64, 0x00, 0x08, 0x80, 0x02, 0x18, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x06,
  0x04, 0x01, 0x80, 0x80, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x20, 0x60,
  0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x10, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C,
  0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x04,
  0x40, 0x00, 0x02, 0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x20, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x03, 0xF0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0E, 0x00, 0x01, 0xF0, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00,
  0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x70, 0x18, 0x07, 0x1A, 0x00, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 39, 11, 1, -39 },
  { 50, 11, 14, 14, 5, -39 },
  { 70, 21, 39, 20, 0, -39 },
  { 173, 21, 44, 18, -1, -41 },
  { 289, 23, 40, 28, 3, -39 },
  { 404, 17, 40, 17, -1, -39 },
  { 489, 4, 14, 8, 5, -39 },
  { 496, 15, 47, 13, 1, -38 },
  { 585, 15, 47, 13, -4, -38 },
  { 674, 14, 15, 17, 6, -41 },
  { 701, 18, 24, 22, 2, -31 },
  { 755, 6, 12, 8, -2, -5 },
  { 764, 12, 1, 14, 1, -15 },
  { 766, 2, 4, 8, 1, -4 },
  { 767, 21, 38, 16, -2, -38 },
  { 867, 17, 40, 19, 1, -39 },
  { 952, 9, 39, 19, 6, -39 },
  { 996, 21, 39, 19, -2, -39 },
  { 1099, 20, 40, 19, -1, -39 },
  { 1199, 20, 39, 19, -1, -39 },
  { 1297, 20, 40, 19, -1, -39 },
  { 1397, 19, 40, 19, 1, -39 },
  { 1492, 19, 39, 19, 2, -39 },
  { 1585, 20, 40, 19, -1, -39 },
  { 1685, 18, 40, 19, 0, -39 },
  { 1775, 8, 29, 8, 0, -29 },
  { 1804, 10, 36, 8, -2, -29 },
  { 1849, 18, 22, 22, 2, -30 },
  { 1899, 18, 13, 22, 2, -26 },
  { 1929, 18, 22, 22, 2, -30 },
  { 1979, 14, 39, 13, 1, -39 },
  { 2048, 26, 44, 27, 1, -39 },
  { 2191, 18, 39, 18, -4, -39 },
  { 2279, 20, 39, 20, 0, -39 },
  { 2377, 20, 40, 18, 2, -39 },
  { 2477, 21, 39, 22, 0, -39 },
  { 2580, 20, 39, 18, 0, -39 },
  { 2678, 21, 39, 17, 0, -39 },
  { 2781, 24, 40, 24, 2, -39 },
  { 2901, 25, 39, 24, 0, -39 },
  { 3023, 16, 39, 9, -3, -39 },
  { 3101, 18, 48, 8, -8, -39 },
  { 3209, 23, 39, 19, 0, -39 },
  { 3322, 12, 39, 16, 0, -39 },
  { 3381, 32, 39, 32, 0, -39 },
  { 3537, 26, 39, 25, 0, -39 },
  { 3664, 21, 40, 24, 2, -39 },
  { 3769, 20, 39, 19, 0, -39 },
  { 3867, 21, 48, 24, 2, -39 },
  { 3993, 20, 39, 19, 0, -39 },
  { 4091, 22, 40, 18, -2, -39 },
  { 4201, 16, 39, 16, 4, -39 },
  { 4279, 22, 40, 23, 2, -39 },
  { 4389, 18, 39, 19, 5, -39 },
  { 4477, 32, 39, 32, 4, -39 },
  { 4633, 23, 39, 16, -3, -39 },
  { 4746, 17, 39, 16, 3, -39 },
  { 4829, 22, 39, 16, -2, -39 },
  { 4937, 19, 48, 15, -1, -39 },
  { 5051, 7, 39, 17, 6, -39 },
  { 5086, 19, 48, 15, -3, -39 },
  { 5200, 20, 19, 21, 1, -39 },
  { 5248, 14, 1, 14, -4, 5 },
  { 5250, 5, 8, 11, 8, -41 },
  { 5255, 18, 30, 20, 2, -29 },
  { 5323, 19, 42, 20, 0, -41 },
  { 5423, 14, 30, 15, 2, -29 },
  { 5476, 21, 42, 20, 2, -41 },
  { 5587, 16, 30, 18, 1, -29 },
  { 5647, 23, 54, 10, -7, -41 },
  { 5803, 21, 42, 20, -1, -29 },
  { 5914, 18, 41, 19, 0, -41 },
  { 6007, 10, 38, 8, 0, -38 },
  { 6055, 17, 51, 9, -7, -38 },
  { 6164, 18, 41, 16, 0, -41 },
  { 6257, 10, 41, 8, 0, -41 },
  { 6309, 28, 29, 29, 0, -29 },
  { 6411, 18, 29, 19, 0, -29 },
  { 6477, 16, 30, 19, 2, -29 },
  { 6537, 21, 41, 20, -2, -29 },
  { 6645, 18, 42, 21, 2, -29 },
  { 6740, 15, 29, 13, 0, -29 },
  { 6795, 16, 30, 15, -1, -29 },
  { 6855, 10, 36, 10, 1, -35 },
  { 6900, 18, 29, 19, 1, -28 },
  { 6966, 14, 28, 15, 3, -28 },
  { 7015, 24, 28, 25, 3, -28 },
  { 7099, 19, 28, 15, -2, -28 },
  { 7166, 25, 41, 16, -6, -28 },
  { 7295, 16, 28, 12, -2, -28 },
  { 7351, 18, 48, 17, 2, -39 },
  { 7459, 2, 54, 19, 8, -41 },
  { 7473, 19, 48, 17, -4, -39 },
  { 7587, 18, 4, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC54PT7B_H_
