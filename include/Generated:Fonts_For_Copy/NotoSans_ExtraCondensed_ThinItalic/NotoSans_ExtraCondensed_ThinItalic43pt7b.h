#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x80, 0x21, 0x21, 0x21, 0x21,
  0x62, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x00, 0x61, 0x00, 0x41, 0x00,
  0x41, 0x00, 0x42, 0x00, 0x82, 0x00, 0x82, 0x00, 0x84, 0x01, 0x04, 0x01,
  0x04, 0x1F, 0xFF, 0x03, 0x08, 0x02, 0x08, 0x02, 0x18, 0x06, 0x10, 0x04,
  0x10, 0x04, 0x10, 0x04, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x40, 0xFF,
  0xF8, 0x10, 0x40, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x21, 0x80, 0x61,
  0x00, 0x41, 0x00, 0x41, 0x00, 0x42, 0x00, 0x82, 0x00, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x01, 0xFC, 0x02, 0x23, 0x04, 0x20, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80, 0x08,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x40, 0x01, 0x20, 0x02, 0x20, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x84, 0xC0, 0xFF, 0x80, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x07, 0x00, 0x81,
  0x10, 0x10, 0x42, 0x04, 0x18, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10,
  0x21, 0x02, 0x04, 0x20, 0x40, 0x88, 0x18, 0x31, 0x03, 0x04, 0x40, 0x40,
  0x88, 0x08, 0x13, 0x19, 0x06, 0x4C, 0xA0, 0x99, 0x14, 0x12, 0x43, 0x84,
  0xC8, 0x79, 0x92, 0x0D, 0xE6, 0x41, 0x80, 0x98, 0x20, 0x32, 0x04, 0x04,
  0x40, 0x81, 0x88, 0x10, 0x21, 0x06, 0x0C, 0x20, 0x81, 0x0C, 0x10, 0x61,
  0x82, 0x08, 0x30, 0x83, 0x06, 0x10, 0x40, 0x44, 0x18, 0x0F, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x02, 0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20,
  0x20, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x88, 0x03, 0x40,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x05, 0x80, 0x22, 0x01, 0x08, 0x4C, 0x21,
  0x20, 0xC9, 0x81, 0x24, 0x04, 0x90, 0x14, 0x40, 0x73, 0x00, 0x8C, 0x02,
  0x10, 0x18, 0x40, 0xB1, 0x86, 0x43, 0xF1, 0x00, 0x24, 0x96, 0x92, 0x52,
  0x00, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x04, 0x00, 0x40, 0x10, 0x42,
  0x06, 0x40, 0x2B, 0xC3, 0x80, 0x60, 0x32, 0x08, 0x42, 0x04, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x46, 0x21, 0x10, 0x88, 0xC0, 0xFF, 0x80, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x0C, 0x60, 0x20, 0x81, 0x02,
  0x0C, 0x0C, 0x20, 0x31, 0x80, 0xC4, 0x03, 0x10, 0x0C, 0xC0, 0x22, 0x00,
  0x88, 0x02, 0x60, 0x09, 0x00, 0x24, 0x00, 0x90, 0x06, 0x40, 0x13, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x18, 0x80,
  0x42, 0x01, 0x08, 0x08, 0x20, 0x60, 0xC1, 0x01, 0x08, 0x03, 0xC0, 0x00,
  0x02, 0x1C, 0x69, 0xA4, 0x50, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41, 0x82,
  0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF8,
  0x07, 0x06, 0x02, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x80, 0xC0, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x05, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x1A, 0x00, 0x12,
  0x00, 0x26, 0x00, 0x24, 0x00, 0x44, 0x00, 0xC4, 0x00, 0x84, 0x01, 0x0C,
  0x01, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x08, 0x08, 0x10, 0x08, 0x10,
  0x10, 0x10, 0x30, 0x10, 0x20, 0x30, 0x40, 0x20, 0x40, 0x20, 0xFF, 0xFC,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x01, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x08, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60,
  0x80, 0xC0, 0xFF, 0x00, 0x00, 0x7E, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x18, 0x0D, 0xDC, 0x14, 0x08, 0x30, 0x08, 0x60, 0x11,
  0x80, 0x23, 0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x18, 0x80, 0x21, 0x00, 0x42, 0x01, 0x84, 0x02, 0x04, 0x08, 0x08, 0x30,
  0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0x86, 0x02, 0x03, 0x06, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x04, 0x01, 0x04, 0x01, 0x04, 0x02, 0x04, 0x02, 0x02, 0x04, 0x02, 0x08,
  0x01, 0x30, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x08, 0x20, 0x10, 0x10,
  0x20, 0x18, 0x60, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08,
  0xC0, 0x08, 0x40, 0x08, 0x40, 0x10, 0x60, 0x10, 0x30, 0x60, 0x1F, 0xC0,
  0x01, 0xF0, 0x0C, 0x20, 0x60, 0xC1, 0x01, 0x08, 0x04, 0x20, 0x11, 0x80,
  0x44, 0x01, 0x10, 0x04, 0x40, 0x13, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x33, 0x00, 0xC4, 0x07, 0x10, 0x38, 0x21, 0xA0, 0x78, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x0F, 0xC0, 0x00, 0x04, 0x30, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x0C,
  0x00, 0x01, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x04, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x0F, 0x82, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x01, 0x80, 0x20, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x0C,
  0x00, 0xC0, 0x60, 0x10, 0x02, 0x02, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x11, 0x01, 0xE1, 0x10, 0x62, 0x13, 0x04,
  0x21, 0x20, 0x84, 0x12, 0x18, 0x41, 0x61, 0x04, 0x14, 0x10, 0x43, 0x42,
  0x08, 0x24, 0x20, 0x82, 0x42, 0x08, 0x2C, 0x21, 0x86, 0xC6, 0x18, 0x48,
  0x61, 0x04, 0x86, 0x30, 0x88, 0x63, 0x08, 0x82, 0x59, 0x08, 0x38, 0xE0,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x84, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40,
  0x09, 0x00, 0x44, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x00, 0x84, 0x04, 0x10,
  0x10, 0x40, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x7F, 0xC1, 0x01, 0x0C, 0x04,
  0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x58, 0x01,
  0x40, 0x05, 0x00, 0x1C, 0x00, 0x40, 0x01, 0xF8, 0x03, 0x1C, 0x02, 0x02,
  0x02, 0x01, 0x02, 0x01, 0x02, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x04, 0x03, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x18, 0x0F, 0xF0,
  0x18, 0xE0, 0x10, 0x18, 0x10, 0x08, 0x10, 0x0C, 0x10, 0x04, 0x30, 0x04,
  0x20, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x20, 0x08, 0x40, 0x08, 0x40, 0x18,
  0x40, 0x10, 0x40, 0x60, 0xC0, 0xC0, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xC1,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x01, 0x9E, 0x00, 0x81, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x10,
  0x06, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x18, 0x40, 0x0C, 0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x84, 0x00, 0xC2, 0x00, 0x42, 0x00, 0x21, 0x00, 0x30, 0x80, 0x10, 0x40,
  0x18, 0x60, 0x08, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x04, 0x04, 0x0C, 0x06,
  0x1C, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x08, 0x1F, 0xF0, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x30,
  0x30, 0x30, 0x04, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x04, 0x80, 0x3E, 0x20, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x81, 0x00, 0x20, 0x60,
  0x08, 0x0C, 0x06, 0x01, 0xFF, 0x00, 0x01, 0x00, 0x30, 0x20, 0x02, 0x02,
  0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x04, 0x04, 0x00, 0x40,
  0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x0C, 0x0C, 0x00, 0x80, 0x80, 0x08,
  0x08, 0x00, 0x80, 0x80, 0x08, 0x0F, 0xFF, 0x81, 0x80, 0x10, 0x10, 0x01,
  0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00,
  0x20, 0x20, 0x02, 0x02, 0x00, 0x60, 0x60, 0x04, 0x04, 0x00, 0x40, 0x40,
  0x04, 0x04, 0x00, 0x40, 0x40, 0x0C, 0x0C, 0x00, 0x80, 0x80, 0x08, 0x00,
  0x01, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x03, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x03, 0xE0, 0x00, 0x01, 0x00,
  0xC0, 0x80, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x02, 0x06, 0x00, 0x81, 0x00,
  0x40, 0x80, 0x10, 0x60, 0x04, 0x10, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x23,
  0x00, 0x08, 0x80, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x7C, 0x00, 0x15, 0x80,
  0x06, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0xC0, 0x08, 0x10, 0x02,
  0x04, 0x00, 0x81, 0x00, 0x60, 0x40, 0x10, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x0C, 0x08, 0x01, 0x00, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x1F, 0xF8, 0x01,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E,
  0x03, 0x00, 0x02, 0x80, 0xE0, 0x00, 0xA0, 0x48, 0x00, 0x58, 0x12, 0x00,
  0x14, 0x04, 0x80, 0x09, 0x01, 0x20, 0x02, 0x40, 0xC8, 0x01, 0x10, 0x22,
  0x00, 0x48, 0x08, 0x80, 0x22, 0x02, 0x20, 0x08, 0x80, 0x88, 0x04, 0x20,
  0x62, 0x01, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x18,
  0x40, 0x42, 0x04, 0x10, 0x20, 0x83, 0x0C, 0x08, 0x20, 0x82, 0x02, 0x08,
  0x60, 0x80, 0x83, 0x10, 0x20, 0x60, 0xCC, 0x08, 0x10, 0x32, 0x04, 0x04,
  0x05, 0x81, 0x01, 0x01, 0x40, 0x40, 0x40, 0x70, 0x10, 0x30, 0x18, 0x0C,
  0x08, 0x06, 0x02, 0x00, 0x01, 0x00, 0x10, 0x30, 0x01, 0x03, 0x00, 0x10,
  0x28, 0x01, 0x02, 0x80, 0x30, 0x28, 0x02, 0x04, 0x80, 0x20, 0x48, 0x02,
  0x04, 0xC0, 0x20, 0x44, 0x04, 0x0C, 0x40, 0x40, 0x84, 0x04, 0x08, 0x40,
  0x40, 0x84, 0x0C, 0x08, 0x20, 0x81, 0x82, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x08, 0x10, 0x21, 0x81, 0x03, 0x10, 0x20, 0x11, 0x02, 0x01, 0x10, 0x20,
  0x11, 0x02, 0x01, 0x20, 0x60, 0x1A, 0x04, 0x00, 0xA0, 0x40, 0x0A, 0x04,
  0x00, 0xA0, 0x40, 0x0C, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x00, 0x00, 0x7C,
  0x00, 0x61, 0x80, 0x40, 0x40, 0x40, 0x30, 0x40, 0x08, 0x20, 0x04, 0x20,
  0x02, 0x10, 0x01, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x05, 0x80, 0x06, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x64, 0x00, 0x26, 0x00, 0x13, 0x00, 0x19, 0x80,
  0x08, 0x40, 0x04, 0x20, 0x04, 0x10, 0x06, 0x08, 0x02, 0x06, 0x02, 0x01,
  0x82, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x03, 0x3C, 0x02, 0x06, 0x02, 0x02,
  0x02, 0x03, 0x02, 0x03, 0x04, 0x01, 0x04, 0x03, 0x04, 0x03, 0x04, 0x02,
  0x0C, 0x02, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x08, 0x08, 0x18, 0x10,
  0x10, 0xE0, 0x1F, 0x80, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x61, 0x80, 0x40,
  0x40, 0x40, 0x30, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02, 0x10, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05,
  0x80, 0x06, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x64, 0x00, 0x26, 0x00, 0x13, 0x00, 0x19, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x04, 0x10, 0x06, 0x08, 0x02, 0x06, 0x02, 0x01, 0x82, 0x00, 0x7E, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0xF0, 0x03, 0x3C, 0x02, 0x06, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x03, 0x04, 0x03, 0x04, 0x03, 0x04, 0x03, 0x04, 0x02, 0x0C,
  0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x08, 0x08, 0x18, 0x30, 0x1F,
  0xE0, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0xC0, 0x20, 0x40, 0x20,
  0x40, 0x20, 0x40, 0x60, 0x40, 0x40, 0x40, 0x40, 0x60, 0x40, 0x20, 0x40,
  0x20, 0xC0, 0x20, 0x80, 0x20, 0x00, 0x7E, 0x00, 0xC0, 0xC0, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x04, 0x02, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x04,
  0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00,
  0x41, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x83, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x06, 0x08, 0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x40,
  0x0C, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08, 0x30, 0x04,
  0x0C, 0x01, 0x03, 0x00, 0xC0, 0x40, 0x20, 0x18, 0x10, 0x03, 0xF8, 0x00,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x03,
  0x20, 0x08, 0x80, 0x62, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x82, 0x06,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x8C,
  0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x00, 0x40, 0x04, 0x00, 0xD0, 0x03,
  0x00, 0x24, 0x00, 0xC0, 0x09, 0x00, 0x50, 0x06, 0x40, 0x14, 0x01, 0x10,
  0x05, 0x00, 0xC4, 0x02, 0x40, 0x23, 0x00, 0x90, 0x08, 0xC0, 0x64, 0x06,
  0x30, 0x11, 0x01, 0x0C, 0x04, 0xC0, 0xC3, 0x02, 0x30, 0x20, 0xC0, 0x88,
  0x08, 0x30, 0x62, 0x06, 0x0C, 0x10, 0x81, 0x03, 0x04, 0x20, 0xC0, 0x82,
  0x08, 0x20, 0x20, 0x82, 0x08, 0x08, 0x20, 0x84, 0x02, 0x10, 0x21, 0x00,
  0x84, 0x08, 0x40, 0x23, 0x02, 0x20, 0x08, 0x80, 0x88, 0x02, 0x20, 0x24,
  0x00, 0x90, 0x09, 0x00, 0x24, 0x02, 0x40, 0x0B, 0x00, 0xA0, 0x02, 0x80,
  0x28, 0x00, 0xA0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x60, 0x40, 0x04, 0x08,
  0x00, 0x82, 0x00, 0x10, 0xC0, 0x02, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80,
  0x01, 0x30, 0x00, 0x24, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00,
  0x33, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00, 0x20, 0x80, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x40, 0x40, 0x18, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x30,
  0x06, 0x00, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21,
  0x01, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x44, 0x02, 0x20, 0x12,
  0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x1F, 0xE0, 0x00, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08,
  0x20, 0x83, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08, 0x20, 0x83,
  0x04, 0x10, 0x40, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03,
  0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x18,
  0x10, 0x10, 0x08, 0x30, 0x08, 0x20, 0x04, 0x60, 0x04, 0x40, 0x06, 0xC0,
  0x03, 0xFF, 0xE0, 0x84, 0x42, 0x21, 0x10, 0x01, 0xE2, 0x04, 0x24, 0x10,
  0x30, 0x40, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x08,
  0x80, 0x11, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x18, 0x02, 0x30, 0x04, 0x40,
  0x18, 0x80, 0x21, 0x00, 0x42, 0x01, 0x86, 0x03, 0x04, 0x0A, 0x0C, 0x28,
  0x0F, 0x90, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x13, 0xE0,
  0x2C, 0x60, 0x70, 0x41, 0x40, 0xC3, 0x00, 0x86, 0x01, 0x08, 0x02, 0x10,
  0x04, 0x60, 0x08, 0x80, 0x31, 0x00, 0x62, 0x00, 0x8C, 0x01, 0x10, 0x02,
  0x20, 0x0C, 0x40, 0x10, 0x80, 0x23, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x18,
  0x08, 0x28, 0x20, 0x9F, 0x80, 0x01, 0xF0, 0x61, 0x0C, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x78, 0x80, 0x42, 0xC0, 0x40, 0xC0, 0x40, 0x60, 0x60, 0x30,
  0x20, 0x18, 0x30, 0x0C, 0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00,
  0x82, 0x00, 0xC1, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x18, 0x20,
  0x08, 0x10, 0x04, 0x08, 0x06, 0x06, 0x03, 0x01, 0x02, 0x80, 0xC2, 0x80,
  0x3E, 0x40, 0x00, 0x01, 0xE0, 0x63, 0x0C, 0x10, 0x81, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x02, 0x60, 0x64, 0x0C, 0x43, 0x87, 0xE0, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x08,
  0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x64, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x80,
  0x42, 0x40, 0x40, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x20, 0x18, 0x30, 0x0C,
  0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC1, 0x00,
  0x41, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x18, 0x20, 0x08, 0x10, 0x04, 0x08,
  0x06, 0x06, 0x03, 0x01, 0x02, 0x80, 0xC2, 0x80, 0x3E, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x01, 0x03, 0x00, 0x7F, 0x00, 0x00, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x4F, 0x81, 0x63, 0x06, 0x04, 0x28, 0x10, 0xC0, 0x43, 0x01,
  0x08, 0x04, 0x20, 0x31, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01,
  0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x03, 0x18, 0x08, 0x40, 0x21, 0x00,
  0x84, 0x02, 0x10, 0x18, 0xC0, 0x40, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0xF0,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x41, 0x02, 0x04, 0x18,
  0x20, 0x40, 0x82, 0x02, 0x10, 0x08, 0xC0, 0x22, 0x01, 0x10, 0x04, 0xC0,
  0x17, 0x00, 0x54, 0x03, 0x90, 0x0C, 0x40, 0x21, 0x80, 0x82, 0x02, 0x08,
  0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x10, 0x10, 0x80, 0x40, 0x01,
  0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x04, 0xF0, 0xF8, 0x14,
  0x24, 0x30, 0x60, 0x60, 0x43, 0x01, 0x81, 0x0C, 0x04, 0x04, 0x20, 0x30,
  0x10, 0x80, 0x80, 0x42, 0x02, 0x03, 0x18, 0x08, 0x08, 0x40, 0x20, 0x21,
  0x01, 0x80, 0x84, 0x04, 0x02, 0x30, 0x10, 0x10, 0x80, 0x40, 0x42, 0x01,
  0x01, 0x08, 0x08, 0x04, 0x20, 0x20, 0x31, 0x80, 0x80, 0x84, 0x02, 0x02,
  0x10, 0x18, 0x08, 0x40, 0x40, 0x21, 0x01, 0x01, 0x8C, 0x04, 0x04, 0x00,
  0x04, 0xF8, 0x14, 0x30, 0x60, 0x43, 0x01, 0x0C, 0x04, 0x20, 0x10, 0x80,
  0x42, 0x02, 0x18, 0x08, 0x40, 0x21, 0x00, 0x84, 0x02, 0x30, 0x10, 0x80,
  0x42, 0x01, 0x08, 0x04, 0x20, 0x31, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40,
  0x21, 0x01, 0x8C, 0x04, 0x00, 0x01, 0xE0, 0x31, 0x83, 0x06, 0x10, 0x11,
  0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x60, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x01, 0xE0, 0x0B, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x19,
  0x80, 0x84, 0x0C, 0x30, 0xC0, 0xFC, 0x00, 0x01, 0x1E, 0x00, 0xB1, 0x80,
  0x70, 0x40, 0x50, 0x30, 0x30, 0x08, 0x18, 0x04, 0x08, 0x02, 0x04, 0x01,
  0x06, 0x00, 0x82, 0x00, 0x41, 0x00, 0x60, 0x80, 0x20, 0x40, 0x10, 0x40,
  0x08, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x03,
  0x01, 0x81, 0x81, 0x80, 0xA1, 0x80, 0xDF, 0x80, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE2, 0x0C, 0x24, 0x30, 0x30,
  0x40, 0x61, 0x00, 0xC2, 0x01, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x08, 0xC0,
  0x11, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08, 0x02, 0x30, 0x04, 0x40, 0x18,
  0x80, 0x21, 0x00, 0x42, 0x01, 0x86, 0x03, 0x04, 0x0A, 0x0C, 0x28, 0x0F,
  0x90, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0xF0, 0x50, 0x06,
  0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x30, 0xC3, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x40, 0xC3, 0xFC, 0x00, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x3F, 0x58, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xF0, 0x08, 0x04, 0x20, 0x10, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21,
  0x01, 0x8C, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x0C, 0x60, 0x21,
  0x00, 0x84, 0x02, 0x10, 0x18, 0x40, 0x62, 0x01, 0x08, 0x0C, 0x20, 0x30,
  0x81, 0x43, 0x0E, 0x07, 0xE8, 0x00, 0xC0, 0x1C, 0x02, 0xC0, 0x2C, 0x04,
  0xC0, 0x4C, 0x0C, 0xC0, 0x8C, 0x18, 0x41, 0x04, 0x10, 0x42, 0x04, 0x20,
  0x44, 0x04, 0x40, 0x4C, 0x04, 0x80, 0x58, 0x05, 0x00, 0x50, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0A, 0x03, 0x01,
  0x40, 0x60, 0x68, 0x14, 0x09, 0x02, 0x81, 0x20, 0xD0, 0x44, 0x12, 0x08,
  0x82, 0x43, 0x10, 0x88, 0x42, 0x11, 0x08, 0x44, 0x22, 0x08, 0x84, 0x41,
  0x10, 0x88, 0x24, 0x12, 0x04, 0x82, 0x40, 0xA0, 0x50, 0x14, 0x0A, 0x03,
  0x81, 0x40, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x00,
  0x06, 0x03, 0x02, 0x02, 0x02, 0x04, 0x02, 0x0C, 0x02, 0x08, 0x02, 0x10,
  0x01, 0x10, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x10, 0x40, 0x30, 0x40, 0x20, 0x60, 0x40, 0x20, 0xC0, 0x20, 0x00, 0xC0,
  0x10, 0x0C, 0x02, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04,
  0x0C, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00,
  0x42, 0x00, 0x04, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00,
  0x04, 0x80, 0x00, 0x58, 0x00, 0x05, 0x00, 0x00, 0x50, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x78,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x70, 0x00, 0xF0, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x3C, 0x02, 0xC6, 0x06, 0x03, 0xF0, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 8, 11, 11, 4, -31 },
  { 43, 16, 31, 16, 0, -31 },
  { 105, 16, 36, 15, 0, -33 },
  { 177, 19, 32, 22, 2, -31 },
  { 253, 14, 31, 14, -1, -31 },
  { 308, 3, 11, 6, 4, -31 },
  { 313, 12, 38, 10, 1, -31 },
  { 370, 12, 38, 10, -3, -31 },
  { 427, 11, 12, 14, 5, -33 },
  { 444, 15, 20, 17, 1, -25 },
  { 482, 5, 9, 7, -2, -4 },
  { 488, 9, 1, 11, 1, -12 },
  { 490, 2, 3, 7, 1, -3 },
  { 491, 17, 31, 13, -2, -31 },
  { 557, 14, 31, 15, 1, -31 },
  { 612, 7, 31, 15, 5, -31 },
  { 640, 17, 31, 15, -2, -31 },
  { 706, 16, 31, 15, -1, -31 },
  { 768, 16, 31, 15, -1, -31 },
  { 830, 16, 31, 15, -1, -31 },
  { 892, 15, 31, 15, 1, -31 },
  { 951, 14, 31, 15, 2, -31 },
  { 1006, 16, 31, 15, -1, -31 },
  { 1068, 14, 31, 15, 0, -31 },
  { 1123, 6, 23, 7, 0, -23 },
  { 1141, 9, 28, 7, -2, -23 },
  { 1173, 15, 18, 17, 1, -24 },
  { 1207, 15, 10, 17, 1, -20 },
  { 1226, 15, 18, 17, 1, -24 },
  { 1260, 11, 31, 10, 1, -31 },
  { 1303, 20, 35, 22, 1, -31 },
  { 1391, 14, 31, 14, -3, -31 },
  { 1446, 16, 31, 16, 0, -31 },
  { 1508, 16, 31, 14, 2, -31 },
  { 1570, 17, 31, 18, 0, -31 },
  { 1636, 16, 31, 15, 0, -31 },
  { 1698, 16, 31, 13, 0, -31 },
  { 1760, 18, 31, 19, 2, -31 },
  { 1830, 20, 31, 19, 0, -31 },
  { 1908, 13, 31, 7, -3, -31 },
  { 1959, 14, 38, 7, -6, -31 },
  { 2026, 18, 31, 15, 0, -31 },
  { 2096, 10, 31, 13, 0, -31 },
  { 2135, 26, 31, 25, 0, -31 },
  { 2236, 20, 31, 20, 0, -31 },
  { 2314, 17, 31, 19, 1, -31 },
  { 2380, 16, 31, 15, 0, -31 },
  { 2442, 17, 38, 19, 1, -31 },
  { 2523, 16, 31, 15, 0, -31 },
  { 2585, 17, 31, 15, -1, -31 },
  { 2651, 13, 31, 13, 3, -31 },
  { 2702, 18, 31, 18, 1, -31 },
  { 2772, 14, 31, 15, 4, -31 },
  { 2827, 26, 31, 26, 3, -31 },
  { 2928, 19, 31, 13, -3, -31 },
  { 3002, 13, 31, 12, 3, -31 },
  { 3053, 18, 31, 13, -2, -31 },
  { 3123, 15, 38, 12, -1, -31 },
  { 3195, 6, 31, 14, 4, -31 },
  { 3219, 16, 38, 12, -3, -31 },
  { 3295, 16, 15, 17, 1, -31 },
  { 3325, 11, 1, 11, -3, 4 },
  { 3327, 4, 7, 9, 6, -33 },
  { 3331, 15, 23, 16, 1, -23 },
  { 3375, 15, 33, 16, 0, -33 },
  { 3437, 12, 23, 12, 1, -23 },
  { 3472, 17, 33, 16, 1, -33 },
  { 3543, 12, 23, 14, 1, -23 },
  { 3578, 19, 43, 8, -6, -33 },
  { 3681, 17, 33, 16, -1, -23 },
  { 3752, 14, 33, 15, 0, -33 },
  { 3810, 8, 31, 7, 0, -31 },
  { 3841, 14, 41, 7, -6, -31 },
  { 3913, 14, 33, 13, 0, -33 },
  { 3971, 8, 33, 6, 0, -33 },
  { 4004, 22, 23, 23, 0, -23 },
  { 4068, 14, 23, 15, 0, -23 },
  { 4109, 13, 23, 15, 1, -23 },
  { 4147, 17, 33, 16, -2, -23 },
  { 4218, 15, 33, 16, 1, -23 },
  { 4280, 12, 23, 10, 0, -23 },
  { 4315, 13, 23, 12, -1, -23 },
  { 4353, 8, 28, 8, 1, -28 },
  { 4381, 14, 23, 15, 1, -23 },
  { 4422, 12, 23, 12, 2, -23 },
  { 4457, 19, 23, 20, 3, -23 },
  { 4512, 16, 23, 12, -2, -23 },
  { 4558, 20, 33, 13, -5, -23 },
  { 4641, 12, 23, 10, -1, -23 },
  { 4676, 15, 38, 13, 1, -31 },
  { 4748, 1, 43, 15, 7, -33 },
  { 4754, 15, 38, 13, -3, -31 },
  { 4826, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC43PT7B_H_
