#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoMono_Medium6pt7b, 6, "RobotoMono_Medium6pt7b" },
  { &RobotoMono_Medium7pt7b, 7, "RobotoMono_Medium7pt7b" },
  { &RobotoMono_Medium8pt7b, 8, "RobotoMono_Medium8pt7b" },
  { &RobotoMono_Medium9pt7b, 9, "RobotoMono_Medium9pt7b" },
  { &RobotoMono_Medium10pt7b, 10, "RobotoMono_Medium10pt7b" },
  { &RobotoMono_Medium11pt7b, 11, "RobotoMono_Medium11pt7b" },
  { &RobotoMono_Medium12pt7b, 12, "RobotoMono_Medium12pt7b" },
  { &RobotoMono_Medium13pt7b, 13, "RobotoMono_Medium13pt7b" },
  { &RobotoMono_Medium14pt7b, 14, "RobotoMono_Medium14pt7b" },
  { &RobotoMono_Medium15pt7b, 15, "RobotoMono_Medium15pt7b" },
  { &RobotoMono_Medium16pt7b, 16, "RobotoMono_Medium16pt7b" },
  { &RobotoMono_Medium17pt7b, 17, "RobotoMono_Medium17pt7b" },
  { &RobotoMono_Medium18pt7b, 18, "RobotoMono_Medium18pt7b" },
  { &RobotoMono_Medium19pt7b, 19, "RobotoMono_Medium19pt7b" },
  { &RobotoMono_Medium20pt7b, 20, "RobotoMono_Medium20pt7b" },
  { &RobotoMono_Medium21pt7b, 21, "RobotoMono_Medium21pt7b" },
  { &RobotoMono_Medium22pt7b, 22, "RobotoMono_Medium22pt7b" },
  { &RobotoMono_Medium23pt7b, 23, "RobotoMono_Medium23pt7b" },
  { &RobotoMono_Medium24pt7b, 24, "RobotoMono_Medium24pt7b" },
  { &RobotoMono_Medium25pt7b, 25, "RobotoMono_Medium25pt7b" },
  { &RobotoMono_Medium26pt7b, 26, "RobotoMono_Medium26pt7b" },
  { &RobotoMono_Medium27pt7b, 27, "RobotoMono_Medium27pt7b" },
  { &RobotoMono_Medium28pt7b, 28, "RobotoMono_Medium28pt7b" },
  { &RobotoMono_Medium29pt7b, 29, "RobotoMono_Medium29pt7b" },
  { &RobotoMono_Medium30pt7b, 30, "RobotoMono_Medium30pt7b" },
  { &RobotoMono_Medium31pt7b, 31, "RobotoMono_Medium31pt7b" },
  { &RobotoMono_Medium32pt7b, 32, "RobotoMono_Medium32pt7b" },
  { &RobotoMono_Medium33pt7b, 33, "RobotoMono_Medium33pt7b" },
  { &RobotoMono_Medium34pt7b, 34, "RobotoMono_Medium34pt7b" },
  { &RobotoMono_Medium35pt7b, 35, "RobotoMono_Medium35pt7b" },
  { &RobotoMono_Medium36pt7b, 36, "RobotoMono_Medium36pt7b" },
  { &RobotoMono_Medium37pt7b, 37, "RobotoMono_Medium37pt7b" },
  { &RobotoMono_Medium38pt7b, 38, "RobotoMono_Medium38pt7b" },
  { &RobotoMono_Medium39pt7b, 39, "RobotoMono_Medium39pt7b" },
  { &RobotoMono_Medium40pt7b, 40, "RobotoMono_Medium40pt7b" },
  { &RobotoMono_Medium41pt7b, 41, "RobotoMono_Medium41pt7b" },
  { &RobotoMono_Medium42pt7b, 42, "RobotoMono_Medium42pt7b" },
  { &RobotoMono_Medium43pt7b, 43, "RobotoMono_Medium43pt7b" },
  { &RobotoMono_Medium44pt7b, 44, "RobotoMono_Medium44pt7b" },
  { &RobotoMono_Medium45pt7b, 45, "RobotoMono_Medium45pt7b" },
  { &RobotoMono_Medium46pt7b, 46, "RobotoMono_Medium46pt7b" },
  { &RobotoMono_Medium47pt7b, 47, "RobotoMono_Medium47pt7b" },
  { &RobotoMono_Medium48pt7b, 48, "RobotoMono_Medium48pt7b" },
  { &RobotoMono_Medium49pt7b, 49, "RobotoMono_Medium49pt7b" },
  { &RobotoMono_Medium50pt7b, 50, "RobotoMono_Medium50pt7b" },
  { &RobotoMono_Medium51pt7b, 51, "RobotoMono_Medium51pt7b" },
  { &RobotoMono_Medium52pt7b, 52, "RobotoMono_Medium52pt7b" },
  { &RobotoMono_Medium53pt7b, 53, "RobotoMono_Medium53pt7b" },
  { &RobotoMono_Medium54pt7b, 54, "RobotoMono_Medium54pt7b" },
  { &RobotoMono_Medium55pt7b, 55, "RobotoMono_Medium55pt7b" },
  { &RobotoMono_Medium56pt7b, 56, "RobotoMono_Medium56pt7b" },
  { &RobotoMono_Medium57pt7b, 57, "RobotoMono_Medium57pt7b" },
  { &RobotoMono_Medium58pt7b, 58, "RobotoMono_Medium58pt7b" },
  { &RobotoMono_Medium59pt7b, 59, "RobotoMono_Medium59pt7b" },
  { &RobotoMono_Medium60pt7b, 60, "RobotoMono_Medium60pt7b" },
  { &RobotoMono_Medium61pt7b, 61, "RobotoMono_Medium61pt7b" },
  { &RobotoMono_Medium62pt7b, 62, "RobotoMono_Medium62pt7b" },
  { &RobotoMono_Medium63pt7b, 63, "RobotoMono_Medium63pt7b" },
  { &RobotoMono_Medium64pt7b, 64, "RobotoMono_Medium64pt7b" },
  { &RobotoMono_Medium65pt7b, 65, "RobotoMono_Medium65pt7b" },
  { &RobotoMono_Medium66pt7b, 66, "RobotoMono_Medium66pt7b" },
  { &RobotoMono_Medium67pt7b, 67, "RobotoMono_Medium67pt7b" },
  { &RobotoMono_Medium68pt7b, 68, "RobotoMono_Medium68pt7b" },
  { &RobotoMono_Medium69pt7b, 69, "RobotoMono_Medium69pt7b" },
  { &RobotoMono_Medium70pt7b, 70, "RobotoMono_Medium70pt7b" },
  { &RobotoMono_Medium71pt7b, 71, "RobotoMono_Medium71pt7b" },
  { &RobotoMono_Medium72pt7b, 72, "RobotoMono_Medium72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
