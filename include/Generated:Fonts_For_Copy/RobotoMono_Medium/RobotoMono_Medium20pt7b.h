#ifndef _ROBOTOMONO_MEDIUM20PT7B_H_
#define _ROBOTOMONO_MEDIUM20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC2, 0xF0, 0xCF, 0x3C, 0xF2, 0xC8, 0x04, 0xC1, 0x98,
  0x33, 0x06, 0x47, 0xFE, 0x13, 0x06, 0x60, 0xCC, 0xFF, 0xFF, 0xFC, 0x4C,
  0x19, 0x83, 0x30, 0x66, 0x00, 0x04, 0x01, 0x00, 0x40, 0xFC, 0x7F, 0x98,
  0x76, 0x0D, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0x01, 0xF8, 0x36, 0x1D,
  0xFE, 0x3F, 0x01, 0x00, 0x40, 0x78, 0x0C, 0xC8, 0xCC, 0x8C, 0xD8, 0x79,
  0x03, 0x30, 0x06, 0x00, 0x60, 0x0D, 0xE0, 0xB6, 0x1B, 0x31, 0x33, 0x03,
  0x20, 0x1E, 0x3E, 0x0F, 0xE1, 0x8C, 0x31, 0x87, 0x60, 0x78, 0x0E, 0x03,
  0xE7, 0xEE, 0xD8, 0xDB, 0x0F, 0x71, 0xCF, 0xFC, 0xFD, 0xC0, 0xF8, 0x08,
  0x71, 0x8C, 0x31, 0x86, 0x18, 0x63, 0x8E, 0x38, 0x61, 0x86, 0x18, 0x30,
  0xC1, 0x83, 0x04, 0x86, 0x18, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x31, 0x99, 0x88, 0x00, 0x18, 0x04, 0x22, 0x3D, 0x7F, 0xF8, 0xE0,
  0xD0, 0xCC, 0x63, 0x11, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x77, 0x76, 0xE4, 0xFF, 0xFF,
  0x6F, 0x70, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x60, 0x60, 0xE0, 0x3F, 0x1F, 0xE6, 0x19, 0x86, 0xE1, 0xF8,
  0xFE, 0xFF, 0xE7, 0xF1, 0xF8, 0x76, 0x19, 0x86, 0x7F, 0x8F, 0xC0, 0x0D,
  0xFF, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x3F, 0x1F,
  0xCC, 0x3B, 0x06, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0x3B, 0xF8, 0x60, 0x30, 0x18, 0x1C, 0x78,
  0x3E, 0x01, 0x80, 0xF0, 0x7C, 0x37, 0xF9, 0xF0, 0x07, 0x01, 0xC0, 0xF0,
  0x7C, 0x1B, 0x0C, 0xC7, 0x31, 0x8C, 0xC3, 0x3F, 0xFF, 0xFC, 0x0C, 0x03,
  0x00, 0xC0, 0x3F, 0x9F, 0xE7, 0x01, 0x80, 0x60, 0x1F, 0xC7, 0xF8, 0x06,
  0x01, 0xC0, 0x7E, 0x1D, 0x86, 0x7F, 0x8F, 0xC0, 0x0E, 0x0F, 0x87, 0x01,
  0x80, 0x60, 0x3F, 0xCF, 0xFB, 0x86, 0xE1, 0xF8, 0x7E, 0x19, 0x86, 0x7F,
  0x87, 0xC0, 0xFF, 0xFF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x00, 0x3F, 0x1F, 0xE6, 0x19,
  0x86, 0x61, 0x9C, 0xE3, 0xF1, 0xFE, 0x61, 0xB8, 0x7E, 0x1D, 0x86, 0x7F,
  0x8F, 0xC0, 0x3F, 0x3F, 0x98, 0xFC, 0x3C, 0x1F, 0x0F, 0x86, 0xFF, 0x3F,
  0x80, 0xC0, 0xE0, 0xE3, 0xE1, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x77,
  0x70, 0x00, 0x00, 0x07, 0x77, 0x6E, 0x40, 0x01, 0x07, 0x1F, 0xFC, 0xE0,
  0xF0, 0x7E, 0x0F, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80,
  0xE0, 0xF8, 0x3E, 0x07, 0x0F, 0x7E, 0xF0, 0xC0, 0x7E, 0x7F, 0xB0, 0xC0,
  0x70, 0x30, 0x38, 0x38, 0x38, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0xC0,
  0x0F, 0x83, 0x18, 0xC1, 0xB3, 0xD4, 0xDA, 0x92, 0x56, 0x4A, 0xC9, 0x59,
  0x2B, 0xED, 0x37, 0x30, 0x03, 0x90, 0x3F, 0x00, 0x06, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0D, 0x81, 0x98, 0x19, 0x81, 0x9C, 0x38, 0xC3, 0xFC, 0x3F,
  0xE7, 0x06, 0x60, 0x6E, 0x07, 0xFF, 0x3F, 0xEE, 0x1F, 0x83, 0xE1, 0xF8,
  0xEF, 0xF3, 0xFE, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xFF, 0xBF, 0xC0, 0x3F,
  0x1F, 0xE6, 0x1F, 0x83, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E,
  0x0D, 0x87, 0x7F, 0x8F, 0xC0, 0xFE, 0x3F, 0xCE, 0x3B, 0x87, 0xE1, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x8E, 0xFF, 0x3F, 0x80, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x3F, 0x1F, 0xE6, 0x1F, 0x83,
  0xC0, 0x30, 0x0C, 0x03, 0x1F, 0xC7, 0xF0, 0x3E, 0x0D, 0x83, 0x7F, 0xC7,
  0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x1B, 0x86,
  0x7F, 0x8F, 0x80, 0xE1, 0xFC, 0x33, 0x8E, 0x73, 0x8E, 0xE1, 0xD8, 0x3F,
  0x07, 0xF0, 0xF6, 0x1C, 0xE3, 0x8E, 0x70, 0xCE, 0x1D, 0xC1, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0F, 0xFF, 0xFC, 0xE1, 0xFC, 0xFF, 0x3F, 0x4F, 0xDE, 0xF7, 0xBD, 0xEF,
  0x33, 0xEC, 0xFB, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x30, 0xE1, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF9, 0xFE, 0x7E, 0xDF, 0xB7, 0xE7, 0xF9, 0xFE, 0x3F, 0x8F,
  0xE1, 0xF8, 0x70, 0x3F, 0x1F, 0xE6, 0x1B, 0x87, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0x86, 0x7F, 0x8F, 0xC0, 0xFE, 0x7F, 0xB0,
  0xF8, 0x3C, 0x1E, 0x0F, 0x1F, 0xFE, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x3F, 0x0F, 0xF1, 0x86, 0x70, 0xEC, 0x0D, 0x81, 0xB0, 0x36, 0x06,
  0xC0, 0xD8, 0x1B, 0x87, 0x30, 0xC7, 0xF8, 0x7F, 0x00, 0x70, 0x07, 0xFF,
  0x3F, 0xEE, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x3B, 0xFC, 0xE7, 0x38, 0xCE,
  0x3B, 0x86, 0xE1, 0xF8, 0x30, 0x3F, 0x1F, 0xE6, 0x1F, 0x83, 0x60, 0x1E,
  0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x3C, 0x0F, 0x87, 0x7F, 0x8F, 0xC0, 0xFF,
  0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x7F,
  0x8F, 0xC0, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x0C, 0x30, 0xC3, 0x9C, 0x19,
  0x81, 0x98, 0x19, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0xE6,
  0x76, 0x66, 0x66, 0x66, 0x76, 0x6F, 0x66, 0xF6, 0x6F, 0x66, 0xD6, 0x39,
  0x63, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0x8C, 0xE1, 0xEC, 0x39, 0xCE,
  0x19, 0x83, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0x60, 0xCE, 0x38,
  0xCE, 0x1D, 0xC1, 0xC0, 0xE0, 0x77, 0x0E, 0x30, 0xC3, 0x9C, 0x19, 0x81,
  0xD8, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xF0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x0C, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18,
  0x18, 0x1C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0xF3, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x18, 0x1C, 0x3C, 0x34, 0x66, 0x66,
  0xC3, 0xFF, 0xFF, 0xC0, 0xE3, 0x1E, 0x1F, 0xC6, 0x38, 0x06, 0x01, 0x8F,
  0xE6, 0x1B, 0x86, 0xE1, 0x9F, 0xE3, 0xDC, 0xC0, 0x60, 0x30, 0x18, 0x0D,
  0xC7, 0xFB, 0x9D, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x37, 0xFB, 0xF8,
  0x1E, 0x0F, 0xC7, 0x39, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0x61, 0x9F,
  0xE3, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x31, 0xD9, 0xFD, 0xCF, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x36, 0x1B, 0xFC, 0xFE, 0x0E, 0x0F, 0xC7, 0x19, 0x87,
  0xE0, 0xFF, 0xFE, 0x03, 0x80, 0x70, 0x9F, 0xF1, 0xF0, 0x07, 0xC3, 0xF1,
  0xC0, 0x70, 0xFF, 0xBF, 0xE1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x1D, 0xCF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0x61, 0xDF, 0xF3, 0xFC, 0x06, 0x41, 0x9F, 0xE3, 0xE0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0xE7, 0xFB, 0x9D, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0E, 0x08, 0x0E, 0x06, 0x00, 0x0F, 0xC7, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x04, 0x1C, 0x30,
  0x07, 0xCF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0D,
  0xFB, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x3E, 0x3B, 0x39, 0xB8, 0xF8,
  0x7C, 0x3F, 0x19, 0xCC, 0x66, 0x3B, 0x0E, 0xFC, 0x7E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE,
  0xD9, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3,
  0x3C, 0xCC, 0xCE, 0x7F, 0xB8, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xE0, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE1, 0xF0, 0x3C, 0x0F,
  0x87, 0x61, 0x9F, 0xE3, 0xF0, 0xDC, 0x7F, 0xB9, 0xD8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0x7F, 0xBF, 0x98, 0x0C, 0x06, 0x03, 0x00, 0x1D, 0x9F,
  0xDC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x61, 0xBF, 0xCF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0xCF, 0xDF, 0xFE, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x1E, 0x0F, 0xE6, 0x19, 0x87, 0x70, 0x0F, 0xC0, 0xF8, 0x07,
  0xE1, 0xDF, 0xE3, 0xF0, 0x18, 0x06, 0x0F, 0xFB, 0xFE, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7E, 0x0F, 0xC0, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xDE, 0xE0, 0xC0, 0xF8,
  0x76, 0x19, 0x86, 0x73, 0x8C, 0xC3, 0x30, 0x78, 0x1E, 0x07, 0x80, 0xC0,
  0xC6, 0x76, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x66, 0xF6, 0x29, 0x43, 0x9C,
  0x39, 0xC3, 0x9C, 0x31, 0xC0, 0xE0, 0xD8, 0x73, 0x38, 0xEC, 0x1E, 0x03,
  0x81, 0xE0, 0xFC, 0x33, 0x9C, 0x6E, 0x1C, 0xC0, 0xFC, 0x1B, 0x87, 0x30,
  0xC7, 0x18, 0x66, 0x0E, 0xC0, 0xF8, 0x1E, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x06, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0x04, 0x1C, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x31, 0xC3, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x38, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x81, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x38, 0x3C, 0x79, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xE3, 0x84, 0x00, 0x38,
  0x0F, 0xCF, 0x1F, 0xA1, 0xE0,
};

const GFXglyph RobotoMono_Medium20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 14, 12, 5, -14 },
  { 5, 6, 5, 12, 3, -15 },
  { 9, 11, 14, 12, 0, -14 },
  { 29, 10, 19, 12, 1, -17 },
  { 53, 12, 14, 12, 0, -14 },
  { 74, 11, 14, 12, 1, -14 },
  { 94, 1, 5, 12, 5, -15 },
  { 95, 6, 21, 12, 3, -16 },
  { 111, 5, 21, 12, 3, -16 },
  { 125, 9, 10, 12, 2, -14 },
  { 137, 10, 11, 12, 1, -12 },
  { 151, 4, 6, 12, 3, -2 },
  { 154, 8, 2, 12, 2, -7 },
  { 156, 4, 3, 12, 4, -3 },
  { 158, 8, 15, 12, 2, -14 },
  { 173, 10, 14, 12, 1, -14 },
  { 191, 6, 14, 12, 2, -14 },
  { 202, 10, 14, 12, 1, -14 },
  { 220, 9, 14, 12, 1, -14 },
  { 236, 10, 14, 12, 1, -14 },
  { 254, 10, 14, 12, 1, -14 },
  { 272, 10, 14, 12, 1, -14 },
  { 290, 10, 14, 12, 1, -14 },
  { 308, 10, 14, 12, 1, -14 },
  { 326, 9, 14, 12, 1, -14 },
  { 342, 3, 11, 12, 5, -11 },
  { 347, 4, 15, 12, 4, -11 },
  { 355, 8, 9, 12, 2, -11 },
  { 364, 9, 6, 12, 2, -9 },
  { 371, 8, 9, 12, 2, -11 },
  { 380, 9, 14, 12, 2, -14 },
  { 396, 11, 14, 12, 0, -14 },
  { 416, 12, 14, 12, 0, -14 },
  { 437, 10, 14, 12, 1, -14 },
  { 455, 10, 14, 12, 1, -14 },
  { 473, 10, 14, 12, 1, -14 },
  { 491, 9, 14, 12, 2, -14 },
  { 507, 9, 14, 12, 2, -14 },
  { 523, 10, 14, 12, 1, -14 },
  { 541, 10, 14, 12, 1, -14 },
  { 559, 8, 14, 12, 2, -14 },
  { 573, 10, 14, 12, 1, -14 },
  { 591, 11, 14, 12, 1, -14 },
  { 611, 9, 14, 12, 2, -14 },
  { 627, 10, 14, 12, 1, -14 },
  { 645, 10, 14, 12, 1, -14 },
  { 663, 10, 14, 12, 1, -14 },
  { 681, 9, 14, 12, 2, -14 },
  { 697, 11, 16, 12, 1, -14 },
  { 719, 10, 14, 12, 1, -14 },
  { 737, 10, 14, 12, 1, -14 },
  { 755, 12, 14, 12, 0, -14 },
  { 776, 10, 14, 12, 1, -14 },
  { 794, 12, 14, 12, 0, -14 },
  { 815, 12, 14, 12, 0, -14 },
  { 836, 11, 14, 12, 1, -14 },
  { 856, 12, 14, 12, 0, -14 },
  { 877, 10, 14, 12, 1, -14 },
  { 895, 4, 19, 12, 4, -16 },
  { 905, 8, 15, 12, 2, -14 },
  { 920, 4, 19, 12, 4, -16 },
  { 930, 8, 7, 12, 2, -14 },
  { 937, 9, 2, 12, 1, 0 },
  { 940, 4, 2, 12, 4, -14 },
  { 941, 10, 11, 12, 1, -11 },
  { 955, 9, 15, 12, 2, -15 },
  { 972, 10, 11, 12, 1, -11 },
  { 986, 9, 15, 12, 1, -15 },
  { 1003, 10, 11, 12, 1, -11 },
  { 1017, 10, 15, 12, 1, -15 },
  { 1036, 10, 15, 12, 1, -11 },
  { 1055, 9, 15, 12, 2, -15 },
  { 1072, 9, 15, 12, 2, -15 },
  { 1089, 7, 19, 12, 2, -15 },
  { 1106, 9, 15, 12, 2, -15 },
  { 1123, 9, 15, 12, 2, -15 },
  { 1140, 10, 11, 12, 1, -11 },
  { 1154, 9, 11, 12, 2, -11 },
  { 1167, 10, 11, 12, 1, -11 },
  { 1181, 9, 15, 12, 2, -11 },
  { 1198, 9, 15, 12, 1, -11 },
  { 1215, 8, 11, 12, 3, -11 },
  { 1226, 10, 11, 12, 1, -11 },
  { 1240, 10, 13, 12, 1, -13 },
  { 1257, 9, 11, 12, 2, -11 },
  { 1270, 10, 11, 12, 1, -11 },
  { 1284, 12, 11, 12, 0, -11 },
  { 1301, 10, 11, 12, 1, -11 },
  { 1315, 11, 15, 12, 1, -11 },
  { 1336, 10, 11, 12, 1, -11 },
  { 1350, 7, 20, 12, 3, -16 },
  { 1368, 2, 18, 12, 5, -14 },
  { 1373, 7, 20, 12, 3, -16 },
  { 1391, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_Medium20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium20pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_MEDIUM20PT7B_H_
