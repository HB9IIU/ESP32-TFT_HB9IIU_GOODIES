#ifndef _ROBOTOMONO_MEDIUM25PT7B_H_
#define _ROBOTOMONO_MEDIUM25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xC0, 0x06, 0x30, 0x33, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x3F, 0xFD,
  0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x31, 0xFF, 0xEF, 0xFF, 0x18,
  0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x98, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x01, 0xF8, 0x3F, 0xC7, 0xBE, 0x70, 0xEE, 0x07, 0xE0, 0x77, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x07, 0xE0, 0x7E, 0x0F, 0xF1,
  0xE7, 0xFE, 0x3F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x00, 0xFC, 0x01,
  0x98, 0x87, 0x31, 0x8E, 0x66, 0x0C, 0xCC, 0x1F, 0xB0, 0x1C, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0xC0, 0x33, 0xE0, 0x6C, 0xC1, 0x99, 0x87, 0x33,
  0x84, 0x66, 0x00, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0x7E, 0x03, 0xDC, 0x0E,
  0x30, 0x30, 0xC0, 0xE7, 0x03, 0xB8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0xF1, 0xBC, 0xE6, 0xE3, 0xFB, 0x87, 0xEE, 0x0F, 0x3C, 0x7C, 0x7F, 0xF8,
  0xFE, 0xF0, 0xFF, 0xFC, 0x02, 0x1C, 0x30, 0xC3, 0x86, 0x1C, 0x38, 0x60,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0xC3, 0x83, 0x07, 0x06,
  0x06, 0x06, 0x04, 0x81, 0x81, 0x83, 0x83, 0x83, 0x06, 0x0E, 0x1C, 0x18,
  0x30, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC3, 0x86, 0x1C, 0x70,
  0xC1, 0x00, 0x06, 0x00, 0x60, 0x06, 0x08, 0x60, 0xE6, 0x7F, 0xFF, 0x1F,
  0xC0, 0xF0, 0x1F, 0x01, 0x98, 0x71, 0xC3, 0x0E, 0x00, 0x80, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x77, 0x77, 0x77, 0xE4, 0xFF, 0xFF,
  0xF0, 0x6F, 0xFE, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0x1F, 0x07, 0xF1, 0xEF, 0x70, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x1F, 0xE7, 0xFD, 0xDF, 0xE3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3B, 0x8E, 0x7F, 0xC3, 0xF0, 0x01, 0x0F, 0x7F, 0xFF, 0xE7, 0x87, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F,
  0x83, 0xFC, 0x7B, 0xEE, 0x0E, 0xE0, 0x6E, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0F, 0xE0, 0x70, 0x07, 0x00,
  0xE0, 0x1E, 0x0F, 0xC0, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x7E, 0x07, 0xE0,
  0x77, 0x0E, 0x7F, 0xE1, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x80,
  0x6C, 0x07, 0x60, 0x73, 0x03, 0x18, 0x38, 0xC1, 0x86, 0x1C, 0x31, 0xC1,
  0x8F, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0xB8, 0x07, 0x00, 0xC0, 0x19, 0x83, 0xFC, 0xFF, 0xC4,
  0x3C, 0x03, 0x80, 0x70, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0,
  0x03, 0xC0, 0xFC, 0x1F, 0xC3, 0xC0, 0x38, 0x07, 0x00, 0x73, 0x06, 0xFC,
  0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x07, 0x70, 0x73, 0x8E,
  0x3F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x1F, 0x0F, 0xF9, 0xEF, 0x70, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3B, 0x8E, 0x3F, 0x8F, 0xFB, 0xC7, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0x0F, 0x83, 0xFC, 0x7D, 0xE7,
  0x0E, 0x70, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0x77, 0x8F, 0x3F, 0xF1,
  0xF7, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0xFC, 0x1F, 0x81, 0xE0, 0x6F, 0xFF,
  0x00, 0x00, 0x00, 0x6F, 0xFF, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x77,
  0x6E, 0xEC, 0x40, 0x00, 0xE0, 0x7C, 0x3F, 0xBF, 0x8F, 0x81, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3E, 0x03, 0xC3, 0xF9, 0xF8, 0xFC, 0x1E, 0x02, 0x00, 0x00, 0x1F, 0x8F,
  0xF9, 0xEF, 0xF0, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x39, 0xE7, 0xEF, 0x33, 0x79, 0x19,
  0xD8, 0xCC, 0xC4, 0xE6, 0x27, 0xB3, 0x3D, 0xFF, 0x67, 0x73, 0x80, 0x0C,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x37, 0x01, 0xDC, 0x07, 0x30, 0x18, 0xE0, 0xE3, 0x83, 0x8E,
  0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80,
  0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0xEE,
  0x1E, 0xFF, 0x8F, 0xFE, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x3E, 0xFF, 0xEF, 0xF8, 0x0F, 0x81, 0xFF, 0x0F, 0x7C, 0xE0, 0xE7, 0x03,
  0xF0, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x1D, 0xC1, 0xCF, 0x1E, 0x3F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F,
  0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x7C, 0xFF, 0x8F,
  0xE0, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xCF, 0xFC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0x7C,
  0xE0, 0xE7, 0x03, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7E, 0x03, 0xB8, 0x1D, 0xC0, 0xE7, 0x0F, 0x3F, 0xF0, 0x7E,
  0x00, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x07,
  0x70, 0x77, 0x8E, 0x3F, 0xE1, 0xF8, 0xE0, 0x7F, 0x07, 0xB8, 0x79, 0xC3,
  0x8E, 0x38, 0x73, 0xC3, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1,
  0xEF, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0x77, 0x03, 0xC0,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF9, 0xFD, 0xBF,
  0xDB, 0x7D, 0xB7, 0xDF, 0x7C, 0xE7, 0xCE, 0x7C, 0xE7, 0xC4, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFF, 0x3F, 0xE7, 0xEC, 0xFD, 0xDF, 0x9B, 0xF3, 0xFE, 0x3F,
  0xC7, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1C, 0x0F, 0x81, 0xFE, 0x0F, 0x78,
  0xE0, 0xE7, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x39, 0xC1, 0xCF, 0x1C, 0x3F, 0xE0, 0xFC,
  0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xEF, 0xFE, 0xFF, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0xFF, 0x83, 0xDE, 0x1C, 0x1C, 0x70,
  0x73, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8,
  0x0E, 0xE0, 0x39, 0xC0, 0xE7, 0x07, 0x1E, 0x3C, 0x3F, 0xE0, 0x3F, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x10, 0xFE, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8E, 0x38, 0xE3,
  0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0x0F, 0xC1, 0xFF, 0x1F,
  0x3C, 0xE0, 0xF7, 0x03, 0xB8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xF0, 0x1D, 0xC0, 0xEF, 0x0F, 0x3F, 0xF0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0xE0, 0x3F, 0x01,
  0xF8, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x38, 0xE3, 0x87, 0x1C, 0x38, 0xE1,
  0xC7, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x00, 0x38, 0x00, 0xC7, 0x1F, 0x1C, 0x6E, 0x71, 0xB9, 0xC6, 0xE7, 0x3B,
  0x9E, 0xEE, 0xFB, 0xBB, 0x6E, 0x6D, 0xB9, 0xB6, 0xC6, 0xDB, 0x1F, 0x7C,
  0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x3C, 0x38, 0xE0, 0xE3, 0x80, 0xE0,
  0x3D, 0xC1, 0xE7, 0x07, 0x0E, 0x3C, 0x38, 0xE0, 0x77, 0x01, 0xDC, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xF0, 0x1D, 0xC0, 0xE3, 0x83,
  0x8F, 0x1C, 0x1C, 0x70, 0x7B, 0x80, 0xF0, 0xE0, 0x3F, 0x80, 0xE7, 0x07,
  0x1C, 0x1C, 0x38, 0xE0, 0xE3, 0x81, 0xCC, 0x07, 0x70, 0x0D, 0xC0, 0x3E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F,
  0xF8, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x07, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF8, 0x1C, 0x07, 0x01, 0xE0, 0xF8, 0x36,
  0x1D, 0xC6, 0x31, 0x8E, 0xE1, 0xB0, 0x70, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3,
  0xC0, 0x3F, 0x8F, 0xFB, 0x87, 0xF0, 0x70, 0x0E, 0x7F, 0xDF, 0xFF, 0x07,
  0xE0, 0xFC, 0x1F, 0x8F, 0xFF, 0xF7, 0xEE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x8F, 0xFC, 0xF1, 0xEE, 0x0E, 0xE0, 0xEE,
  0x06, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0xF1, 0xEF, 0xFC, 0xEF, 0x80,
  0x3F, 0x8F, 0xFB, 0xC7, 0xF0, 0x7E, 0x0F, 0xC0, 0x30, 0x07, 0x00, 0xE0,
  0x1C, 0x1D, 0xC7, 0xBF, 0xE1, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x1F, 0xF3, 0xFF, 0x78, 0xF7, 0x07, 0x70, 0x76, 0x07,
  0xE0, 0x76, 0x07, 0x70, 0x77, 0x07, 0x78, 0xF3, 0xFF, 0x1F, 0x70, 0x1F,
  0xC1, 0xFF, 0x1E, 0x1C, 0xE0, 0xE7, 0x03, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x70, 0x03, 0x81, 0x0F, 0x1C, 0x7F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0x3F, 0xEF, 0xFF, 0xC7, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xBF, 0xF3, 0xEE, 0x01, 0xD0, 0x3B, 0x0E,
  0xFF, 0xC7, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B,
  0xF7, 0xFF, 0xF1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x80, 0x0C, 0x07, 0x80, 0x80, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0x0E, 0x0F, 0x06, 0x00, 0x00, 0x7E, 0x7E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0xFC, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE1, 0xEE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F,
  0x70, 0xE7, 0x8E, 0x3C, 0xE1, 0xCE, 0x0E, 0xE0, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFE, 0xF7, 0xFF, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F,
  0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0x80,
  0xEF, 0xDF, 0xFF, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0,
  0xE6, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0x70, 0x73, 0x83, 0x9E, 0x3C,
  0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0x9F, 0xFB, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xFF, 0xEE, 0xF9, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x3F, 0xEF, 0xFF, 0xC7, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xBF, 0xF3, 0xEE, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0xEF, 0xFF, 0xFF, 0x7E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3F, 0x8F, 0xFF,
  0x83, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC3,
  0xBF, 0xF3, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0xFF, 0xFE, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x43, 0xF8,
  0x3F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0xC7, 0xBF, 0xF3, 0xEE, 0xE0, 0x3B, 0x83, 0x9C, 0x1C,
  0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0x63, 0x03, 0xB8, 0x1D, 0xC0, 0x6C, 0x03,
  0xE0, 0x0E, 0x00, 0x70, 0x00, 0xE3, 0x8D, 0x8E, 0x36, 0x39, 0xDC, 0xE7,
  0x76, 0x9C, 0xDB, 0x63, 0x6D, 0x8D, 0xB6, 0x34, 0xD8, 0xF1, 0xE3, 0xC7,
  0x07, 0x1C, 0x1C, 0x70, 0xF0, 0x79, 0xC3, 0x8E, 0x38, 0x3B, 0x80, 0xFC,
  0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0xC0, 0xEF, 0x0E, 0x38, 0xF0, 0xEF,
  0x03, 0x80, 0xE0, 0x3F, 0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0xE3,
  0x81, 0xCE, 0x07, 0x70, 0x0D, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xEF,
  0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0x07, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0xF8, 0xE0, 0xF8, 0x38, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0xE0, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x1F,
  0x07, 0x1F, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0,
  0x3C, 0x01, 0xFC, 0x37, 0xF9, 0xF8, 0xFE, 0x20, 0xF8,
};

const GFXglyph RobotoMono_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 7, 6, 15, 4, -19 },
  { 14, 13, 18, 15, 1, -18 },
  { 44, 12, 24, 15, 2, -21 },
  { 80, 15, 18, 15, 0, -18 },
  { 114, 14, 18, 15, 1, -18 },
  { 146, 2, 7, 15, 6, -19 },
  { 148, 7, 26, 15, 4, -20 },
  { 171, 7, 26, 15, 4, -20 },
  { 194, 12, 13, 15, 2, -18 },
  { 214, 12, 13, 15, 1, -15 },
  { 234, 4, 8, 15, 4, -3 },
  { 238, 10, 2, 15, 3, -9 },
  { 241, 4, 4, 15, 6, -4 },
  { 243, 10, 20, 15, 3, -18 },
  { 268, 11, 18, 15, 2, -18 },
  { 293, 8, 18, 15, 2, -18 },
  { 311, 12, 18, 15, 1, -18 },
  { 338, 12, 18, 15, 1, -18 },
  { 365, 13, 18, 15, 1, -18 },
  { 395, 11, 18, 15, 2, -18 },
  { 420, 12, 18, 15, 1, -18 },
  { 447, 12, 18, 15, 1, -18 },
  { 474, 11, 18, 15, 2, -18 },
  { 499, 12, 18, 15, 1, -18 },
  { 526, 4, 14, 15, 6, -14 },
  { 533, 4, 19, 15, 6, -14 },
  { 543, 11, 11, 15, 2, -13 },
  { 559, 11, 8, 15, 2, -12 },
  { 570, 11, 11, 15, 2, -13 },
  { 586, 11, 18, 15, 2, -18 },
  { 611, 13, 18, 15, 1, -18 },
  { 641, 14, 18, 15, 1, -18 },
  { 673, 12, 18, 15, 2, -18 },
  { 700, 13, 18, 15, 1, -18 },
  { 730, 12, 18, 15, 2, -18 },
  { 757, 12, 18, 15, 2, -18 },
  { 784, 12, 18, 15, 2, -18 },
  { 811, 13, 18, 15, 1, -18 },
  { 841, 11, 18, 15, 2, -18 },
  { 866, 11, 18, 15, 2, -18 },
  { 891, 12, 18, 15, 1, -18 },
  { 918, 13, 18, 15, 2, -18 },
  { 948, 12, 18, 15, 2, -18 },
  { 975, 12, 18, 15, 2, -18 },
  { 1002, 11, 18, 15, 2, -18 },
  { 1027, 13, 18, 15, 1, -18 },
  { 1057, 12, 18, 15, 2, -18 },
  { 1084, 14, 21, 15, 1, -18 },
  { 1121, 12, 18, 15, 2, -18 },
  { 1148, 13, 18, 15, 1, -18 },
  { 1178, 13, 18, 15, 1, -18 },
  { 1208, 11, 18, 15, 2, -18 },
  { 1233, 13, 18, 15, 1, -18 },
  { 1263, 14, 18, 15, 1, -18 },
  { 1295, 14, 18, 15, 1, -18 },
  { 1327, 14, 18, 15, 1, -18 },
  { 1359, 13, 18, 15, 1, -18 },
  { 1389, 5, 25, 15, 5, -21 },
  { 1405, 10, 20, 15, 3, -18 },
  { 1430, 5, 25, 15, 5, -21 },
  { 1446, 10, 10, 15, 3, -18 },
  { 1459, 11, 2, 15, 2, 0 },
  { 1462, 6, 3, 15, 5, -18 },
  { 1465, 11, 13, 15, 2, -13 },
  { 1483, 12, 19, 15, 2, -19 },
  { 1512, 11, 13, 15, 2, -13 },
  { 1530, 12, 19, 15, 1, -19 },
  { 1559, 13, 13, 15, 1, -13 },
  { 1581, 12, 19, 15, 2, -19 },
  { 1610, 11, 18, 15, 2, -13 },
  { 1635, 11, 19, 15, 2, -19 },
  { 1662, 10, 18, 15, 3, -18 },
  { 1685, 8, 23, 15, 3, -18 },
  { 1708, 12, 19, 15, 2, -19 },
  { 1737, 12, 19, 15, 2, -19 },
  { 1766, 13, 13, 15, 1, -13 },
  { 1788, 11, 13, 15, 2, -13 },
  { 1806, 13, 13, 15, 1, -13 },
  { 1828, 11, 18, 15, 2, -13 },
  { 1853, 11, 18, 15, 2, -13 },
  { 1878, 9, 13, 15, 4, -13 },
  { 1893, 11, 13, 15, 2, -13 },
  { 1911, 11, 16, 15, 2, -16 },
  { 1933, 11, 13, 15, 2, -13 },
  { 1951, 13, 13, 15, 1, -13 },
  { 1973, 14, 13, 15, 0, -13 },
  { 1996, 13, 13, 15, 1, -13 },
  { 2018, 14, 18, 15, 1, -13 },
  { 2050, 12, 13, 15, 2, -13 },
  { 2070, 8, 24, 15, 4, -20 },
  { 2094, 2, 23, 15, 7, -18 },
  { 2100, 8, 24, 15, 4, -20 },
  { 2124, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_Medium25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium25pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_MEDIUM25PT7B_H_
