#ifndef _ROBOTOMONO_MEDIUM35PT7B_H_
#define _ROBOTOMONO_MEDIUM35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0,
  0x00, 0x00, 0x7B, 0xFF, 0x70, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x06, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0x83, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x0C, 0x38,
  0x03, 0x87, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x38, 0xE0,
  0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0C, 0x00, 0xE3, 0x80,
  0x18, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x7C, 0x3E, 0x3C, 0x0F, 0xBE, 0x03,
  0xDE, 0x01, 0xEF, 0x80, 0xF3, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBF, 0x0F, 0xCF, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0x9E, 0x00, 0x71, 0xC3, 0x0E,
  0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x07, 0x1C, 0xE0, 0xFF, 0x38, 0x0F,
  0xE7, 0x00, 0x61, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x80, 0x0C, 0xFE, 0x03, 0x9F, 0xE0, 0xE7, 0x1C, 0x1C, 0xE3, 0x87,
  0x1C, 0x70, 0xE3, 0x8E, 0x08, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xF3, 0xC0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x7C,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFE,
  0x0E, 0x3F, 0xF0, 0xE7, 0xCF, 0x1E, 0x78, 0x79, 0xE7, 0x87, 0xDE, 0xF8,
  0x3F, 0xC7, 0x81, 0xFC, 0x78, 0x0F, 0x87, 0xC1, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x81, 0xC1,
  0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x10, 0x40, 0x18, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x3C, 0x06, 0x01, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07, 0x0E, 0x1B,
  0xE6, 0x3D, 0xFF, 0xFF, 0x3F, 0xFE, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xE7, 0x00, 0xF3, 0xC0, 0xF0, 0xF0, 0x70, 0x3C, 0x18, 0x18, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0xF3, 0xCF, 0x3D, 0xE7, 0x9E, 0xF1,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xF8,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0x9E, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0xC0, 0xF1, 0xF0, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFB, 0xF8, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xC7, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x0F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x03, 0x9E, 0x01, 0xE7, 0x80,
  0xF1, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xE1, 0xE0,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1D, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xC3, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xFE, 0x01, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF3, 0xF8,
  0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x3E, 0x3E,
  0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xC7,
  0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x0F,
  0x0F, 0xDF, 0x83, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xF0, 0xF0, 0x78, 0xF0,
  0x1E, 0x78, 0x0F, 0x78, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0x80, 0xF3,
  0xE0, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7F,
  0x7F, 0x3F, 0xFF, 0x1F, 0xEF, 0x07, 0x8F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x7B,
  0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF,
  0xF7, 0x80, 0x7C, 0xF9, 0xFB, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xE0,
  0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0xFF, 0xC7, 0xFC, 0x3F,
  0xE0, 0x7E, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x3E, 0x03, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x3C, 0x00, 0x40, 0x00, 0x0F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xF3, 0xE1, 0xFF, 0x81, 0xFE, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x41, 0x9C,
  0x3F, 0x33, 0x8F, 0xE7, 0x63, 0x8C, 0xFC, 0x61, 0x8F, 0x9C, 0x71, 0xF3,
  0x8E, 0x3C, 0x61, 0xC7, 0x8C, 0x39, 0xF1, 0x86, 0x36, 0x38, 0xC6, 0xE7,
  0x38, 0xDC, 0xFF, 0xF3, 0x8F, 0xBE, 0x38, 0x43, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC7, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x3B, 0xC0, 0x07, 0x9C, 0x00, 0x79, 0xE0, 0x07, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0x78, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xC0, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xF0,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x01, 0xF7, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x3F, 0x9F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0x83, 0xFB, 0xFF,
  0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xF7, 0x80, 0xFB, 0xE0, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x3F, 0xCF, 0x83, 0xE7, 0xC0,
  0xFB, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xEF, 0x83, 0xF7, 0xC7, 0xF3, 0xFF,
  0xF1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0xC0, 0xFB, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0x79, 0xF0, 0x7C, 0xFF, 0xFE, 0x3F,
  0xFC, 0x07, 0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0,
  0x0F, 0xFC, 0x07, 0xEF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x3E,
  0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDE, 0x03, 0xE7, 0xC0, 0xF0,
  0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07,
  0xCF, 0x01, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x7F, 0xF7, 0x77, 0xFB, 0xBB, 0xFD, 0xDD, 0xFE, 0x7C, 0xFF,
  0x3E, 0x7F, 0x9F, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xF7, 0x0F, 0xFB,
  0xC7, 0xFC, 0xE3, 0xFE, 0x79, 0xFF, 0x1C, 0xFF, 0x8F, 0x7F, 0xC3, 0xBF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC7, 0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x01, 0xE7, 0x80, 0xF3, 0xF1, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9E, 0x1F,
  0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0xFC, 0x7C, 0x0F, 0x3E, 0x03, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xE0, 0x3E, 0x78, 0x0F, 0x1F, 0x8F, 0xC3,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x1F,
  0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x07, 0xDE, 0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1,
  0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1F, 0x1E, 0x07, 0x8F, 0x03,
  0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7C, 0x78, 0x0F, 0x9E, 0x01, 0xEF,
  0x80, 0x7D, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0x9F, 0x03, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xEF,
  0x01, 0xE7, 0x80, 0xF3, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x0F, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0xF0, 0xE0, 0xFE, 0x1C, 0x3F, 0xC3, 0xC7, 0xF8, 0xF8, 0xFF, 0x1F,
  0x1F, 0xE3, 0xE3, 0xDC, 0x7C, 0x7B, 0x8F, 0x8E, 0x79, 0xF9, 0xCF, 0x37,
  0x39, 0xEE, 0xEF, 0x3D, 0xDD, 0xE7, 0xBB, 0xBC, 0x77, 0x77, 0x8E, 0xE6,
  0xF1, 0xD8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F,
  0x00, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x1F, 0x03, 0xC1, 0xE0,
  0xF8, 0x3E, 0x1E, 0x03, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0xBE, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xBE, 0x01, 0xF3, 0xC0, 0x3C, 0x7C, 0x0F, 0x87,
  0x81, 0xE0, 0xF8, 0x7C, 0x0F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0,
  0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF,
  0xFF, 0xF8, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x1E,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDE, 0x0F, 0x38, 0x38,
  0xF1, 0xE1, 0xC7, 0x07, 0x1C, 0x1E, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0x3C, 0x1C, 0x0F, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x8F, 0xCF, 0xC7, 0x81, 0xF3, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x0F,
  0xFF, 0x1F, 0xFF, 0x9F, 0x83, 0xCF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B,
  0xE0, 0x7D, 0xF0, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xF3, 0xE0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF3, 0xE0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xFC, 0x3E, 0xFF, 0xFC, 0xFF,
  0xF8, 0xE7, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C,
  0x1F, 0x78, 0x0F, 0x78, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x78, 0x0F, 0x3E, 0x1F, 0x3F,
  0xFE, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x8F, 0x1F, 0xEF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xEF, 0x03, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x08, 0x7C, 0x1F, 0x3F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE2, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0xF7, 0x3F, 0xFF, 0x3F, 0xFF, 0x7C,
  0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7E, 0x1F, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xEF, 0x00, 0x0F, 0x00, 0x0F, 0x10, 0x1F, 0x38,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0xF7,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x01,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0xBF, 0xF7, 0xFC, 0xFE, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x02, 0xF0, 0x3E, 0x78, 0x3E, 0x3C, 0x3E, 0x1E, 0x3E, 0x0F,
  0x3E, 0x07, 0xBE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3E, 0xF8, 0x1E, 0x3E, 0x0F, 0x0F, 0x87, 0x83, 0xE3, 0xC1, 0xF1, 0xE0,
  0x7C, 0xF0, 0x1F, 0x78, 0x07, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC7,
  0x1E, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x1E, 0x1D, 0xE1, 0xC3,
  0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87,
  0xF8, 0x70, 0xFF, 0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F,
  0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0x80, 0x01, 0xF0, 0xE7, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xE0,
  0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x7D, 0xE0, 0x3C, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xF7, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xEF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0xFB, 0xCF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0x0B, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x3D, 0xE0, 0x1E, 0xF8, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x20, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xBF, 0xF7, 0x3F, 0xEE, 0x3F,
  0x1C, 0xF8, 0x03, 0xEF, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x70, 0x70, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x1C, 0x70, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xE0, 0xE1, 0xFE, 0x1C,
  0x3F, 0xC7, 0x87, 0xF8, 0xF8, 0xE7, 0x1F, 0x1C, 0xE3, 0xE3, 0x9C, 0x6C,
  0x73, 0xDD, 0xDE, 0x7B, 0xBB, 0xC7, 0x77, 0x70, 0xEC, 0x6E, 0x1D, 0x8D,
  0xC3, 0xF1, 0xB8, 0x7E, 0x3F, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF8, 0x0F, 0xDF, 0x03, 0xC3, 0xC1, 0xF0, 0x78, 0xF8,
  0x1F, 0x3C, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0x7C, 0x07, 0x8F, 0x83, 0xE1,
  0xE1, 0xF0, 0x3C, 0x78, 0x0F, 0xBE, 0x01, 0xF0, 0xF8, 0x01, 0xEF, 0x00,
  0x7D, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83,
  0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x1F, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xF8,
  0x0F, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3F, 0x01,
  0xE0, 0xFC, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x00, 0x1E,
  0x00, 0x0F, 0xF0, 0x1D, 0xFF, 0x03, 0xFF, 0xF8, 0xEE, 0x0F, 0xFD, 0x80,
  0xFF, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoMono_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 25, 21, 8, -25 },
  { 17, 10, 8, 21, 5, -26 },
  { 27, 19, 25, 21, 1, -25 },
  { 87, 17, 33, 21, 2, -29 },
  { 158, 19, 25, 21, 1, -25 },
  { 218, 20, 25, 21, 1, -25 },
  { 281, 3, 9, 21, 8, -26 },
  { 285, 9, 36, 21, 6, -28 },
  { 326, 10, 36, 21, 5, -28 },
  { 371, 17, 17, 21, 3, -25 },
  { 408, 17, 19, 21, 2, -21 },
  { 449, 6, 10, 21, 6, -4 },
  { 457, 14, 4, 21, 4, -13 },
  { 464, 6, 5, 21, 8, -5 },
  { 468, 14, 27, 21, 4, -25 },
  { 516, 17, 25, 21, 2, -25 },
  { 570, 11, 25, 21, 3, -25 },
  { 605, 17, 25, 21, 1, -25 },
  { 659, 16, 25, 21, 2, -25 },
  { 709, 18, 25, 21, 1, -25 },
  { 766, 17, 25, 21, 2, -25 },
  { 820, 16, 25, 21, 2, -25 },
  { 870, 18, 25, 21, 1, -25 },
  { 927, 17, 25, 21, 2, -25 },
  { 981, 16, 25, 21, 2, -25 },
  { 1031, 6, 19, 21, 8, -19 },
  { 1046, 7, 25, 21, 8, -19 },
  { 1068, 15, 16, 21, 3, -19 },
  { 1098, 16, 11, 21, 3, -16 },
  { 1120, 15, 16, 21, 3, -19 },
  { 1150, 15, 25, 21, 3, -25 },
  { 1197, 19, 25, 21, 1, -25 },
  { 1257, 20, 25, 21, 1, -25 },
  { 1320, 17, 25, 21, 3, -25 },
  { 1374, 17, 25, 21, 2, -25 },
  { 1428, 17, 25, 21, 2, -25 },
  { 1482, 16, 25, 21, 3, -25 },
  { 1532, 16, 25, 21, 3, -25 },
  { 1582, 17, 25, 21, 2, -25 },
  { 1636, 17, 25, 21, 2, -25 },
  { 1690, 15, 25, 21, 3, -25 },
  { 1737, 16, 25, 21, 2, -25 },
  { 1787, 18, 25, 21, 3, -25 },
  { 1844, 16, 25, 21, 3, -25 },
  { 1894, 17, 25, 21, 2, -25 },
  { 1948, 17, 25, 21, 2, -25 },
  { 2002, 17, 25, 21, 2, -25 },
  { 2056, 17, 25, 21, 3, -25 },
  { 2110, 18, 29, 21, 2, -25 },
  { 2176, 17, 25, 21, 3, -25 },
  { 2230, 18, 25, 21, 2, -25 },
  { 2287, 19, 25, 21, 1, -25 },
  { 2347, 17, 25, 21, 2, -25 },
  { 2401, 19, 25, 21, 1, -25 },
  { 2461, 19, 25, 21, 1, -25 },
  { 2521, 19, 25, 21, 1, -25 },
  { 2581, 19, 25, 21, 1, -25 },
  { 2641, 17, 25, 21, 2, -25 },
  { 2695, 7, 35, 21, 7, -29 },
  { 2726, 14, 27, 21, 4, -25 },
  { 2774, 7, 35, 21, 7, -29 },
  { 2805, 14, 13, 21, 4, -25 },
  { 2828, 15, 3, 21, 3, 0 },
  { 2834, 8, 4, 21, 7, -25 },
  { 2838, 17, 19, 21, 2, -19 },
  { 2879, 16, 26, 21, 3, -26 },
  { 2931, 16, 19, 21, 2, -19 },
  { 2969, 16, 26, 21, 2, -26 },
  { 3021, 17, 19, 21, 2, -19 },
  { 3062, 18, 27, 21, 2, -27 },
  { 3123, 16, 26, 21, 2, -19 },
  { 3175, 16, 26, 21, 3, -26 },
  { 3227, 15, 26, 21, 4, -26 },
  { 3276, 11, 33, 21, 4, -26 },
  { 3322, 17, 26, 21, 3, -26 },
  { 3378, 16, 26, 21, 3, -26 },
  { 3430, 19, 19, 21, 1, -19 },
  { 3476, 16, 19, 21, 3, -19 },
  { 3514, 17, 19, 21, 2, -19 },
  { 3555, 16, 26, 21, 3, -19 },
  { 3607, 16, 26, 21, 2, -19 },
  { 3659, 14, 19, 21, 5, -19 },
  { 3693, 17, 19, 21, 2, -19 },
  { 3734, 17, 23, 21, 2, -23 },
  { 3783, 15, 18, 21, 3, -18 },
  { 3817, 19, 18, 21, 1, -18 },
  { 3860, 19, 18, 21, 1, -18 },
  { 3903, 18, 18, 21, 2, -18 },
  { 3944, 19, 25, 21, 1, -18 },
  { 4004, 17, 18, 21, 2, -18 },
  { 4043, 12, 33, 21, 5, -27 },
  { 4093, 3, 32, 21, 9, -25 },
  { 4105, 11, 33, 21, 6, -27 },
  { 4151, 19, 7, 21, 1, -14 },
};

const GFXfont RobotoMono_Medium35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium35pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_MEDIUM35PT7B_H_
