#ifndef _ROBOTOMONO_MEDIUM27PT7B_H_
#define _ROBOTOMONO_MEDIUM27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0xFF, 0xF0, 0xE7,
  0xE7, 0xC7, 0xC6, 0xC6, 0xC6, 0x06, 0x38, 0x18, 0xC0, 0x63, 0x01, 0x8C,
  0x0E, 0x31, 0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x0C, 0x60, 0x71, 0x81, 0x8E,
  0x06, 0x30, 0xFF, 0xFB, 0xFF, 0xE1, 0x8C, 0x0E, 0x30, 0x31, 0x80, 0xC6,
  0x03, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0x83, 0xFE, 0x3C,
  0x79, 0xC1, 0xCE, 0x0F, 0x70, 0x3B, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x1E, 0xF1, 0xE7,
  0xFE, 0x0F, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0x18, 0x86, 0x33, 0x8C, 0x66, 0x19, 0xD8, 0x3F, 0x30, 0x3C, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x33, 0xC0, 0xEF, 0xC1, 0xB9, 0xC6, 0x73,
  0x8C, 0xE7, 0x01, 0xCE, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0,
  0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0F, 0x70, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x3B, 0x9C, 0x6F, 0x3D, 0xDC, 0x3F, 0xB8, 0x3F,
  0x78, 0x3C, 0x79, 0xF8, 0xFF, 0xF8, 0x7E, 0x78, 0xFF, 0xFF, 0xB0, 0x04,
  0x1C, 0x71, 0xC3, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30,
  0x70, 0xE1, 0xC3, 0x83, 0x07, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x10, 0xC1,
  0xC1, 0xC1, 0xC1, 0x83, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x8E, 0x1C, 0x71, 0xC1, 0x00, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x86, 0x1F, 0x33, 0xFF, 0xFC, 0x7F, 0x80, 0xE0,
  0x0D, 0x80, 0xEE, 0x0E, 0x38, 0x71, 0xE1, 0x04, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x77, 0x77,
  0x7E, 0xE4, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x77, 0xBF, 0xE0, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x00, 0x1F, 0xC3, 0xFE, 0x78, 0xEF, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x1F, 0xE3, 0xFE, 0xF7, 0xFC, 0x7F, 0x87, 0xF0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0x79, 0xE3, 0xFE, 0x1F, 0x80, 0x03, 0x87, 0xDF, 0xFF,
  0xFE, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1F, 0xC1, 0xFF, 0x1E, 0x3D, 0xE0,
  0xEE, 0x07, 0xF0, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xC1, 0xFF, 0x9E, 0x3C, 0xE0, 0xFF, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x1E, 0x0F, 0xE0, 0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0x80, 0x1F,
  0x80, 0xFE, 0x0F, 0x78, 0xF1, 0xFF, 0x07, 0xF0, 0x00, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xEE, 0x07, 0x38, 0x18, 0xE0,
  0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0x00,
  0x70, 0x07, 0x00, 0x72, 0x07, 0xFC, 0x7F, 0xE7, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0xE0, 0x7F, 0x07, 0x79, 0xF3, 0xFE, 0x1F, 0xC0, 0x07,
  0x81, 0xF8, 0x3F, 0x87, 0x80, 0x70, 0x0E, 0x00, 0xE7, 0x0F, 0xFC, 0xFF,
  0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x79,
  0xE3, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x3F,
  0xC7, 0xFE, 0x78, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0x70, 0xF7, 0x8E, 0x3F,
  0xC3, 0xFC, 0x7F, 0xEF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF9,
  0xF7, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xFC, 0xF1, 0xEE, 0x0E, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xF3, 0xFF, 0x0E, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x3F, 0xC3, 0xF0, 0x3C, 0x00, 0x77, 0xFE, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xEF, 0xFD, 0xC0, 0x7B, 0xDE, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x39, 0xCE, 0x73, 0xB8, 0x80, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7F, 0x3F, 0x8F, 0xC0, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0x70, 0x3F, 0x0F, 0xE7, 0xF0, 0xFC, 0x0E, 0x00, 0x80, 0x00,
  0x3F, 0xC7, 0xFE, 0x78, 0xFF, 0x07, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x8C, 0x06,
  0x63, 0xCD, 0x9F, 0xBC, 0xE6, 0xF3, 0x11, 0xCC, 0x47, 0x73, 0x1D, 0x8C,
  0xF7, 0x33, 0xCC, 0xCF, 0x3F, 0xEC, 0x67, 0x18, 0x00, 0x70, 0x20, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1,
  0xC3, 0x83, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x38, 0x0E, 0xF0, 0x1D, 0xC0,
  0x3B, 0x80, 0x78, 0xFF, 0xC7, 0xFF, 0x38, 0x7D, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0x81, 0xDC, 0x1E, 0xFF, 0xE7, 0xFF, 0x38, 0x3D, 0xC0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0xF7, 0xFF, 0x3F, 0xF0, 0x0F, 0xE0,
  0xFF, 0xC3, 0xC7, 0x9C, 0x0E, 0x70, 0x3F, 0xC0, 0x7E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x77, 0x03,
  0xDE, 0x0E, 0x3C, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x39,
  0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3B, 0x81, 0xDC, 0x1E, 0xFF, 0xE7,
  0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xFF, 0xE7, 0xFF, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0xC7, 0x9E, 0x0E,
  0x70, 0x3F, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xDE, 0x07, 0x3E, 0x7C, 0x7F,
  0xE0, 0xFE, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xF8, 0x1F,
  0xC0, 0xEE, 0x0F, 0x7C, 0xF1, 0xFF, 0x07, 0xF0, 0xE0, 0x7F, 0x81, 0xEE,
  0x0F, 0x38, 0x78, 0xE3, 0xC3, 0x8E, 0x0E, 0x78, 0x3B, 0xC0, 0xFE, 0x03,
  0xFC, 0x0F, 0xF8, 0x3C, 0xE0, 0xF3, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C,
  0xE0, 0x7B, 0x81, 0xEE, 0x03, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0x9F, 0xFC, 0xDF, 0xF6,
  0xFD, 0xF7, 0xEF, 0x3F, 0x79, 0xFB, 0xCF, 0xCC, 0x7E, 0x63, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE, 0x7E, 0x77, 0xE7,
  0x7E, 0x37, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x70, 0x0F, 0xE0, 0xFF, 0xC3, 0xCF, 0x1E, 0x0E, 0x70, 0x3B, 0xC0, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3E, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0xFF,
  0xC7, 0xFF, 0x38, 0x7D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0xFF, 0xBF, 0xF9, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0xF3, 0xE3,
  0xC1, 0xC7, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x3B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDE, 0x03, 0x9C, 0x0F, 0x3C, 0x1C,
  0x3E, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0x80,
  0xFF, 0xC7, 0xFF, 0x38, 0x7D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x8E, 0x1C, 0x70, 0xF3, 0x83,
  0x9C, 0x1E, 0xE0, 0x77, 0x03, 0xF8, 0x0E, 0x0F, 0xE0, 0xFF, 0xE3, 0xC7,
  0x9C, 0x0F, 0x70, 0x1D, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0x01, 0xDC, 0x0F, 0x7C,
  0x78, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x79, 0xE3, 0xFE, 0x1F, 0x80, 0xE0, 0x1F,
  0xE0, 0x3B, 0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x8F, 0x07, 0x0E, 0x1C, 0x1C,
  0x38, 0x3C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x00, 0xEE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xE3, 0x0F,
  0xC7, 0x1F, 0x8E, 0x37, 0x3C, 0xEE, 0x79, 0xDC, 0xF3, 0xB9, 0xE7, 0x33,
  0xEE, 0x76, 0xDC, 0xFD, 0xB1, 0xFB, 0x63, 0xE6, 0xC7, 0xCF, 0x8F, 0x9F,
  0x0F, 0x3E, 0x1E, 0x3C, 0x3C, 0x78, 0x70, 0xE0, 0xE1, 0xC0, 0xF0, 0x1E,
  0xE0, 0x79, 0xE0, 0xE1, 0xC3, 0xC1, 0xC7, 0x03, 0xDC, 0x03, 0xF8, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xEE, 0x03, 0x9E,
  0x0F, 0x1C, 0x1C, 0x3C, 0x78, 0x38, 0xE0, 0x7B, 0xC0, 0x78, 0xE0, 0x1F,
  0xE0, 0x79, 0xC0, 0xE3, 0xC1, 0xC3, 0x87, 0x07, 0x8E, 0x07, 0x38, 0x0E,
  0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xFF, 0xF0, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0xFF, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0xFF, 0xF0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xB0,
  0x67, 0x1C, 0x63, 0x8E, 0x61, 0xDC, 0x1C, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3,
  0x87, 0x06, 0x03, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0x70, 0x07, 0x07, 0xF7,
  0xFF, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xF7, 0xFF, 0x3F, 0x70,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x71, 0x83, 0xBF, 0x1F,
  0xFC, 0xF8, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xDC, 0x0E, 0xF0, 0x77, 0xCF, 0xBF, 0xF9, 0xDF, 0x80, 0x02, 0x01, 0xFC,
  0x7F, 0xE7, 0x8F, 0xF0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x7F, 0x07, 0x78, 0xF3, 0xFE, 0x1F, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x47, 0x3F, 0x77, 0xFF, 0x70, 0xFF, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x9F, 0x7F,
  0xF1, 0xF7, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xEF, 0x07, 0x70, 0x3B,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xE0, 0x47, 0xCF, 0x1F,
  0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x1F, 0xFE, 0xFF, 0xF0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0x04, 0x03, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x79, 0xF7, 0xFF, 0x1F,
  0x70, 0x07, 0x40, 0x76, 0x0F, 0xFF, 0xE3, 0xFC, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x10, 0xEF, 0xEF, 0xFF, 0xF8, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x04, 0x00, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x07,
  0x07, 0x02, 0x00, 0x00, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFE, 0xFE, 0xF0,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x83, 0xDC,
  0x3C, 0xE3, 0xC7, 0x3C, 0x3B, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xDE,
  0x1C, 0x78, 0xE1, 0xE7, 0x07, 0xB8, 0x3D, 0xC0, 0xF0, 0xFE, 0x0F, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x04, 0x23, 0xFD, 0xEF, 0xFF, 0xF9, 0xE7, 0xE3, 0x9F,
  0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7,
  0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xC0, 0x01, 0x0E, 0xFE, 0xFF, 0xFF, 0x8F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x0E, 0x1E,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x03,
  0x9E, 0x0E, 0x3C, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x02, 0x07, 0x7E, 0x3F,
  0xF9, 0xE1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x03,
  0xB8, 0x1D, 0xC1, 0xEF, 0x9F, 0x7F, 0xF3, 0xBF, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x04, 0x03, 0xF7, 0x7F, 0xFF, 0x8F, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x79,
  0xF7, 0xFF, 0x3F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x01,
  0xBC, 0xFB, 0xBF, 0x7F, 0xEF, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x03, 0xFC, 0x7F,
  0xE7, 0x0F, 0xE0, 0x7F, 0x00, 0x7C, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0x00,
  0x7E, 0x07, 0xF0, 0xF7, 0xFE, 0x1F, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xF1, 0x0F, 0xF0, 0x7F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x77, 0x9F, 0x7F, 0xF3, 0xF7, 0xF0, 0x1D, 0xC0, 0xE7, 0x03,
  0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC1, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x3B,
  0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xE1, 0x87, 0x71, 0x86,
  0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x33, 0xCE, 0x33, 0xEC, 0x3E, 0x6C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0xF0, 0x3C, 0xE1, 0xE3, 0xC7, 0x07, 0xBC, 0x0F, 0xE0, 0x1F, 0x00, 0x78,
  0x01, 0xF0, 0x0F, 0xC0, 0x7B, 0x81, 0xCF, 0x0F, 0x1E, 0x78, 0x3B, 0xC0,
  0x70, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xC3, 0x87, 0x87, 0x8E,
  0x07, 0x1C, 0x0E, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x83, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0E, 0x07, 0x07, 0x0F, 0x07, 0xC0, 0xF0, 0x38, 0x0C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x60, 0x78, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x01, 0xE0, 0x78, 0x3C, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0xE0, 0x70, 0xF0, 0x20, 0x00, 0x1C, 0x00, 0x7E, 0x0D,
  0xFE, 0x1B, 0x1F, 0xFE, 0x0F, 0xC0, 0x0F, 0x00,
};

const GFXglyph RobotoMono_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 8, 6, 16, 4, -20 },
  { 17, 14, 19, 16, 1, -19 },
  { 51, 13, 25, 16, 2, -22 },
  { 92, 15, 19, 16, 1, -19 },
  { 128, 15, 19, 16, 1, -19 },
  { 164, 3, 7, 16, 6, -20 },
  { 167, 7, 27, 16, 5, -21 },
  { 191, 7, 27, 16, 4, -21 },
  { 215, 13, 13, 16, 2, -19 },
  { 237, 14, 14, 16, 1, -16 },
  { 262, 4, 8, 16, 5, -3 },
  { 266, 11, 3, 16, 3, -10 },
  { 271, 5, 4, 16, 6, -4 },
  { 274, 11, 21, 16, 3, -19 },
  { 303, 12, 19, 16, 2, -19 },
  { 332, 9, 19, 16, 2, -19 },
  { 354, 13, 19, 16, 1, -19 },
  { 385, 13, 19, 16, 1, -19 },
  { 416, 14, 19, 16, 1, -19 },
  { 450, 12, 19, 16, 2, -19 },
  { 479, 12, 19, 16, 2, -19 },
  { 508, 13, 19, 16, 1, -19 },
  { 539, 12, 19, 16, 2, -19 },
  { 568, 12, 19, 16, 2, -19 },
  { 597, 5, 15, 16, 6, -15 },
  { 607, 5, 20, 16, 6, -15 },
  { 620, 12, 13, 16, 2, -15 },
  { 640, 12, 8, 16, 2, -12 },
  { 652, 12, 13, 16, 2, -15 },
  { 672, 12, 19, 16, 2, -19 },
  { 701, 14, 19, 16, 1, -19 },
  { 735, 15, 19, 16, 1, -19 },
  { 771, 13, 19, 16, 2, -19 },
  { 802, 14, 19, 16, 1, -19 },
  { 836, 13, 19, 16, 2, -19 },
  { 867, 13, 19, 16, 2, -19 },
  { 898, 13, 19, 16, 2, -19 },
  { 929, 14, 19, 16, 1, -19 },
  { 963, 12, 19, 16, 2, -19 },
  { 992, 12, 19, 16, 2, -19 },
  { 1021, 13, 19, 16, 1, -19 },
  { 1052, 14, 19, 16, 2, -19 },
  { 1086, 13, 19, 16, 2, -19 },
  { 1117, 13, 19, 16, 2, -19 },
  { 1148, 12, 19, 16, 2, -19 },
  { 1177, 14, 19, 16, 1, -19 },
  { 1211, 13, 19, 16, 2, -19 },
  { 1242, 15, 22, 16, 1, -19 },
  { 1284, 13, 19, 16, 2, -19 },
  { 1315, 14, 19, 16, 1, -19 },
  { 1349, 15, 19, 16, 1, -19 },
  { 1385, 12, 19, 16, 2, -19 },
  { 1414, 15, 19, 16, 1, -19 },
  { 1450, 15, 19, 16, 1, -19 },
  { 1486, 15, 19, 16, 1, -19 },
  { 1522, 15, 19, 16, 1, -19 },
  { 1558, 14, 19, 16, 1, -19 },
  { 1592, 6, 26, 16, 5, -22 },
  { 1612, 11, 21, 16, 3, -19 },
  { 1641, 6, 26, 16, 5, -22 },
  { 1661, 11, 10, 16, 3, -19 },
  { 1675, 12, 2, 16, 2, 0 },
  { 1678, 6, 4, 16, 5, -20 },
  { 1681, 12, 15, 16, 2, -15 },
  { 1704, 13, 20, 16, 2, -20 },
  { 1737, 12, 15, 16, 2, -15 },
  { 1760, 12, 20, 16, 2, -20 },
  { 1790, 13, 15, 16, 2, -15 },
  { 1815, 13, 21, 16, 2, -21 },
  { 1850, 12, 21, 16, 2, -15 },
  { 1882, 12, 20, 16, 2, -20 },
  { 1912, 12, 20, 16, 3, -20 },
  { 1942, 8, 26, 16, 3, -20 },
  { 1968, 13, 20, 16, 2, -20 },
  { 2001, 12, 20, 16, 3, -20 },
  { 2031, 14, 15, 16, 1, -15 },
  { 2058, 12, 15, 16, 2, -15 },
  { 2081, 14, 15, 16, 1, -15 },
  { 2108, 13, 20, 16, 2, -15 },
  { 2141, 12, 20, 16, 2, -15 },
  { 2171, 11, 15, 16, 4, -15 },
  { 2192, 12, 15, 16, 2, -15 },
  { 2215, 12, 18, 16, 2, -18 },
  { 2242, 12, 14, 16, 2, -14 },
  { 2263, 14, 14, 16, 1, -14 },
  { 2288, 16, 14, 16, 0, -14 },
  { 2316, 14, 14, 16, 1, -14 },
  { 2341, 15, 20, 16, 1, -14 },
  { 2379, 13, 14, 16, 2, -14 },
  { 2402, 9, 26, 16, 4, -21 },
  { 2432, 2, 24, 16, 7, -19 },
  { 2438, 9, 26, 16, 4, -21 },
  { 2468, 15, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_Medium27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium27pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_MEDIUM27PT7B_H_
