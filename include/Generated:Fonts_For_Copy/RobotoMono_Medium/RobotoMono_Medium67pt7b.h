#ifndef _ROBOTOMONO_MEDIUM67PT7B_H_
#define _ROBOTOMONO_MEDIUM67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8,
  0xFC, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x03, 0x00, 0x3F, 0x01, 0xF0, 0x0F,
  0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0xC1, 0xF0,
  0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x3E, 0x00, 0x1F, 0xC7,
  0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xC0, 0x00, 0xFF, 0xFC, 0x3F, 0x00,
  0x01, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xC0, 0x00, 0x00, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0x87, 0xFF, 0x80, 0x00, 0x7C,
  0x3F, 0xFF, 0x00, 0x01, 0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0x87, 0xFF, 0xF8,
  0x00, 0x3E, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0x0F, 0xC3,
  0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x3E, 0x03, 0xF0,
  0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x00, 0x38, 0x0F,
  0x80, 0xFC, 0x00, 0x20, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0x83, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0xFF, 0xF0,
  0x0F, 0xE3, 0xFE, 0x7F, 0xC0, 0x7E, 0x1F, 0xE1, 0xFF, 0x07, 0xF1, 0xFE,
  0x0F, 0xF8, 0x3F, 0x8F, 0xF0, 0x3F, 0xE1, 0xFC, 0xFF, 0x00, 0xFF, 0x9F,
  0xE7, 0xF8, 0x03, 0xFE, 0xFE, 0x3F, 0xC0, 0x1F, 0xF7, 0xF1, 0xFE, 0x00,
  0x7F, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0xF8, 0x7F, 0x80, 0x07, 0xFF, 0xC3,
  0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xDF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x06, 0x20, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x10, 0x01, 0xF0, 0x01, 0x0E, 0x00, 0xF8, 0x03, 0x8F, 0xE0, 0x7C,
  0x07, 0xC7, 0xFC, 0x3E, 0x1F, 0xF3, 0xFF, 0x9F, 0x3F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x00, 0x40, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F,
  0x87, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x0F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xF8,
  0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0x87,
  0xF8, 0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0x80, 0x1F, 0xF8, 0x06, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x00, 0xFE,
  0x0F, 0xFC, 0x01, 0xFC, 0x7F, 0xFE, 0x03, 0xFB, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC,
  0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF,
  0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xBF, 0x80, 0x7F, 0xFE, 0x7F, 0x00, 0x3F, 0xF0, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0x03, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC,
  0x7F, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE7, 0xFE, 0x3F, 0xF0, 0xFF, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0xFF, 0x83,
  0xE1, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x03, 0xFF, 0xE1, 0xE3, 0xE0, 0x7F,
  0xFE, 0x1F, 0x3C, 0x0F, 0xE3, 0xE1, 0xF7, 0xC1, 0xF8, 0x3E, 0x1F, 0x7C,
  0x1F, 0x03, 0xE0, 0xF7, 0xC1, 0xF0, 0x3C, 0x0F, 0xF8, 0x3E, 0x03, 0xC0,
  0xFF, 0x83, 0xE0, 0x3C, 0x0F, 0xF8, 0x3E, 0x03, 0xC0, 0xFF, 0x87, 0xC0,
  0x3C, 0x0F, 0xF8, 0x7C, 0x03, 0xC0, 0xFF, 0x87, 0xC0, 0x7C, 0x0F, 0xF8,
  0x7C, 0x07, 0xC0, 0xFF, 0x87, 0xC0, 0x7C, 0x1F, 0xF8, 0x7C, 0x07, 0xC1,
  0xEF, 0x87, 0xC0, 0x7C, 0x1E, 0xF8, 0x7C, 0x07, 0xC1, 0xEF, 0x87, 0xC0,
  0x78, 0x3E, 0xF8, 0x7E, 0x0F, 0x83, 0xCF, 0x87, 0xF1, 0xFC, 0x7C, 0xF8,
  0x3F, 0xFF, 0xFF, 0x8F, 0x83, 0xFF, 0xBF, 0xF8, 0x7C, 0x1F, 0xFB, 0xFF,
  0x07, 0xC0, 0xFE, 0x1F, 0xE0, 0x7E, 0x03, 0x80, 0x78, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x9F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0x00,
  0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC0, 0x1F, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x00,
  0x07, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x01,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xF0,
  0xFE, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFE,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xF8,
  0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x7F, 0xF0, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01,
  0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0x80,
  0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF8, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE,
  0xFC, 0x3F, 0x7F, 0xFE, 0x7E, 0x3F, 0x7F, 0xFF, 0x7E, 0x7F, 0x7F, 0xFF,
  0x7E, 0x7E, 0x7F, 0xFF, 0x3E, 0x7E, 0x7F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFC, 0x7F, 0xFF, 0x3F, 0xFC, 0x7F, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF,
  0x1F, 0xF8, 0x7F, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F, 0xFF,
  0x07, 0xE0, 0x7F, 0xFF, 0x07, 0xE0, 0x7F, 0xFF, 0x07, 0xE0, 0x7F, 0xFF,
  0x03, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0x00, 0xFF, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0xFF,
  0x1F, 0xC0, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF,
  0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xFF,
  0x01, 0xFC, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF,
  0x00, 0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF3, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xF8, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F,
  0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x9F,
  0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xE0,
  0x1F, 0xDF, 0xC0, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0x03, 0xFD, 0xFC,
  0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x3F, 0x9F, 0xE0, 0x7F, 0x80,
  0xFE, 0x3F, 0x81, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x07,
  0xF8, 0xFE, 0x0F, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFF, 0xE1, 0xFC, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xFE, 0x1F,
  0xC1, 0xFC, 0x7E, 0xF8, 0x7F, 0x07, 0xF1, 0xFB, 0xE1, 0xFC, 0x1F, 0xC7,
  0xEF, 0xC7, 0xE0, 0x7F, 0x1F, 0x3F, 0x3F, 0x81, 0xFC, 0x7C, 0xFC, 0xFE,
  0x03, 0xF1, 0xF3, 0xF3, 0xF8, 0x0F, 0xEF, 0xC7, 0xCF, 0xE0, 0x3F, 0xBF,
  0x1F, 0x3F, 0x80, 0xFE, 0xFC, 0x7C, 0xFE, 0x03, 0xFB, 0xE1, 0xFB, 0xF8,
  0x0F, 0xEF, 0x87, 0xEF, 0xC0, 0x3F, 0xBE, 0x1F, 0xBF, 0x00, 0xFF, 0xF8,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xF9, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xDF, 0xC0,
  0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x03,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x0F,
  0xFC, 0x7F, 0xC0, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xF1,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0x80, 0xFF,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0x80, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x81, 0xFC, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFF, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xF8, 0xFF, 0x03, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xE7, 0xFF,
  0xE7, 0xFE, 0x01, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xF8,
  0xFE, 0x00, 0xFF, 0xE1, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x3F, 0xE0, 0x00,
  0x38, 0x3F, 0xF0, 0x00, 0x7C, 0x1F, 0xFC, 0x01, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xF3, 0xF8,
  0x3F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0x9F, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0x8F, 0xF0, 0x00, 0x78, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x82, 0x00, 0x00, 0xFF, 0x06,
  0x00, 0x03, 0xFC, 0x1E, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x7F, 0x87, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF, 0xC3,
  0xFD, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x40, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xFC, 0x3F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8,
  0x0F, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFC, 0x07, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01,
  0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xE3, 0xFC, 0x00, 0x1F, 0xF9, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x3F, 0x9F, 0xF0, 0xFF, 0x8F, 0xEF, 0xFE,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE7, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFE,
  0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF,
  0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF,
  0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81,
  0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0x07, 0xF3, 0xFF,
  0xFF, 0x8F, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF,
  0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xFE, 0x03, 0xF9,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE,
  0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xF0, 0x0F, 0xF0,
  0x0E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xE1,
  0xFC, 0x0F, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x9F, 0xF8, 0x03, 0xFF,
  0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0x01,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0x8F,
  0xF0, 0x00, 0x70, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0x81,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x00,
  0xBF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F,
  0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF,
  0x9F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x06,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x03,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xC7, 0xF0,
  0x1F, 0xFC, 0x1F, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F,
  0x80, 0xFC, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xFF,
  0x07, 0xE0, 0x7E, 0x1F, 0x7E, 0x1F, 0x81, 0xFC, 0x7C, 0xF8, 0x7E, 0x07,
  0xF1, 0xF3, 0xE3, 0xF8, 0x1F, 0xC7, 0xCF, 0x8F, 0xE0, 0x3F, 0x1F, 0x3E,
  0x3F, 0x00, 0xFC, 0xF8, 0x7C, 0xFC, 0x03, 0xF3, 0xE1, 0xF3, 0xF0, 0x0F,
  0xCF, 0x87, 0xCF, 0xC0, 0x3F, 0xBE, 0x1F, 0x7F, 0x00, 0x7E, 0xF0, 0x7D,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7C, 0x3F, 0xFF, 0xC0, 0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x1F, 0x9F, 0xFF,
  0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0xF8, 0x0F, 0xCF, 0xE0, 0xFF, 0xF1, 0xFE,
  0xFE, 0x01, 0xFF, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xFF, 0x3F, 0x00, 0x0F,
  0xFF, 0xF1, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00,
};

const GFXglyph RobotoMono_Medium67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 10, 48, 40, 15, -48 },
  { 61, 19, 16, 40, 10, -50 },
  { 99, 36, 48, 40, 2, -48 },
  { 315, 32, 62, 40, 5, -55 },
  { 563, 38, 49, 40, 1, -48 },
  { 796, 37, 49, 40, 3, -48 },
  { 1023, 7, 17, 40, 15, -50 },
  { 1038, 18, 68, 40, 11, -53 },
  { 1191, 18, 68, 40, 10, -53 },
  { 1344, 33, 33, 40, 5, -48 },
  { 1481, 33, 34, 40, 3, -39 },
  { 1622, 10, 20, 40, 12, -8 },
  { 1647, 27, 6, 40, 8, -24 },
  { 1668, 11, 11, 40, 15, -10 },
  { 1684, 26, 52, 40, 8, -48 },
  { 1853, 31, 49, 40, 5, -48 },
  { 2043, 20, 48, 40, 6, -48 },
  { 2163, 33, 48, 40, 2, -48 },
  { 2361, 32, 49, 40, 3, -48 },
  { 2557, 35, 48, 40, 2, -48 },
  { 2767, 31, 49, 40, 5, -48 },
  { 2957, 31, 49, 40, 4, -48 },
  { 3147, 33, 48, 40, 3, -48 },
  { 3345, 31, 49, 40, 5, -48 },
  { 3535, 31, 48, 40, 4, -48 },
  { 3721, 11, 39, 40, 16, -38 },
  { 3775, 13, 50, 40, 15, -38 },
  { 3857, 29, 31, 40, 5, -36 },
  { 3970, 31, 21, 40, 5, -31 },
  { 4052, 30, 31, 40, 5, -36 },
  { 4169, 29, 48, 40, 6, -48 },
  { 4343, 36, 47, 40, 2, -47 },
  { 4555, 37, 48, 40, 2, -48 },
  { 4777, 33, 48, 40, 5, -48 },
  { 4975, 34, 49, 40, 3, -48 },
  { 5184, 32, 48, 40, 5, -48 },
  { 5376, 31, 48, 40, 5, -48 },
  { 5562, 31, 48, 40, 5, -48 },
  { 5748, 34, 49, 40, 3, -48 },
  { 5957, 32, 48, 40, 4, -48 },
  { 6149, 28, 48, 40, 6, -48 },
  { 6317, 32, 49, 40, 3, -48 },
  { 6513, 35, 48, 40, 5, -48 },
  { 6723, 30, 48, 40, 6, -48 },
  { 6903, 32, 48, 40, 4, -48 },
  { 7095, 32, 48, 40, 4, -48 },
  { 7287, 34, 49, 40, 3, -48 },
  { 7496, 33, 48, 40, 5, -48 },
  { 7694, 36, 56, 40, 3, -48 },
  { 7946, 33, 48, 40, 5, -48 },
  { 8144, 35, 49, 40, 3, -48 },
  { 8359, 37, 48, 40, 2, -48 },
  { 8581, 32, 49, 40, 4, -48 },
  { 8777, 37, 48, 40, 2, -48 },
  { 8999, 38, 48, 40, 1, -48 },
  { 9227, 37, 48, 40, 2, -48 },
  { 9449, 38, 48, 40, 1, -48 },
  { 9677, 34, 48, 40, 3, -48 },
  { 9881, 14, 66, 40, 13, -55 },
  { 9997, 26, 52, 40, 8, -48 },
  { 10166, 14, 66, 40, 13, -55 },
  { 10282, 27, 26, 40, 7, -48 },
  { 10370, 30, 6, 40, 5, 0 },
  { 10393, 14, 9, 40, 14, -48 },
  { 10409, 32, 37, 40, 4, -36 },
  { 10557, 31, 51, 40, 5, -50 },
  { 10755, 31, 37, 40, 4, -36 },
  { 10899, 31, 51, 40, 4, -50 },
  { 11097, 32, 37, 40, 4, -36 },
  { 11245, 33, 52, 40, 4, -52 },
  { 11460, 31, 50, 40, 4, -36 },
  { 11654, 31, 50, 40, 5, -50 },
  { 11848, 29, 49, 40, 7, -49 },
  { 12026, 22, 63, 40, 7, -49 },
  { 12200, 33, 50, 40, 5, -50 },
  { 12407, 29, 50, 40, 7, -50 },
  { 12589, 34, 36, 40, 3, -36 },
  { 12742, 31, 36, 40, 5, -36 },
  { 12882, 33, 37, 40, 4, -36 },
  { 13035, 31, 50, 40, 5, -36 },
  { 13229, 31, 50, 40, 4, -36 },
  { 13423, 26, 36, 40, 10, -36 },
  { 13540, 31, 37, 40, 5, -36 },
  { 13684, 32, 45, 40, 4, -44 },
  { 13864, 30, 36, 40, 5, -35 },
  { 13999, 34, 35, 40, 3, -35 },
  { 14148, 38, 35, 40, 1, -35 },
  { 14315, 35, 35, 40, 3, -35 },
  { 14469, 37, 49, 40, 2, -35 },
  { 14696, 32, 35, 40, 4, -35 },
  { 14836, 22, 64, 40, 10, -52 },
  { 15012, 5, 61, 40, 18, -48 },
  { 15051, 22, 64, 40, 11, -52 },
  { 15227, 37, 14, 40, 1, -27 },
};

const GFXfont RobotoMono_Medium67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium67pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_MEDIUM67PT7B_H_
