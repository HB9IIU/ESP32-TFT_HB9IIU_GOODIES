#ifndef _ROBOTOMONO_MEDIUM29PT7B_H_
#define _ROBOTOMONO_MEDIUM29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x04, 0xEF, 0xE0,
  0xE3, 0xF1, 0xF8, 0xDC, 0x6E, 0x37, 0x1B, 0x8C, 0x03, 0x1C, 0x03, 0x18,
  0x07, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0xFF, 0xFC,
  0xFF, 0xFC, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0xC0,
  0x31, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xF0, 0x1F, 0xF0, 0xFF,
  0xE7, 0x87, 0x9C, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x80, 0x1F, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x3D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x38, 0x00, 0xFE, 0x00, 0xEE, 0x00, 0xC6, 0x18, 0xC6, 0x30,
  0xC6, 0x70, 0xC6, 0x60, 0xFE, 0xE0, 0x7C, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x18, 0x06, 0x7E, 0x06, 0xE7, 0x0C, 0xC7, 0x1C, 0xC7,
  0x18, 0xC7, 0x00, 0xE7, 0x00, 0xFE, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x3C, 0x70, 0x1D, 0xE0,
  0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x87, 0x7B, 0xC7, 0x71, 0xCE,
  0xF1, 0xEE, 0xF0, 0xFE, 0xF0, 0x7C, 0xF0, 0x3C, 0x7D, 0xFC, 0x3F, 0xFE,
  0x1F, 0xCF, 0xFF, 0xFF, 0x02, 0x07, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x70,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x0C, 0x0F, 0x06, 0x02, 0x40, 0xE0,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0C, 0x1C, 0x38,
  0x38, 0xF0, 0x60, 0x40, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x43,
  0x05, 0xCC, 0x7F, 0xFF, 0xC7, 0xFE, 0x07, 0x80, 0x1F, 0x00, 0xEE, 0x07,
  0x38, 0x38, 0x78, 0x61, 0xC0, 0x82, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x7B, 0xDE,
  0xF7, 0x3B, 0x9C, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0xF0, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x81, 0xFF, 0x0F,
  0xFC, 0xF0, 0xE7, 0x07, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF9, 0xEF, 0xDC, 0x7F, 0xC3, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3B,
  0x83, 0xDF, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0x01, 0x07, 0x3F, 0xFF, 0xFF,
  0xC7, 0x87, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0xF0,
  0x3B, 0xC0, 0xFE, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E,
  0x70, 0x3D, 0xC0, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x1F, 0xC0, 0x7E,
  0x01, 0xFE, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x3D, 0xE0,
  0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x38,
  0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x1C, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3F, 0xF8,
  0xFF, 0xE3, 0xFF, 0x9E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x40,
  0x7F, 0xE1, 0xFF, 0xC7, 0x8F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xF8, 0x0E, 0xF0, 0x39, 0xC1, 0xE7, 0xFF, 0x0F, 0xFC, 0x1F, 0xC0, 0x01,
  0xC0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x70,
  0xEF, 0xE7, 0xFF, 0xBE, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x3B, 0x83, 0xDF, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xF0, 0xF7, 0x07, 0xF8, 0x1F, 0xC0, 0xEE, 0x0F,
  0x78, 0xF1, 0xFF, 0x07, 0xF0, 0x7F, 0xE7, 0x87, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x3F, 0x83, 0xDF, 0x7E, 0x7F, 0xE1, 0xFC, 0x00, 0x0F, 0x81,
  0xFE, 0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x1E, 0xFB, 0xF7, 0xFF, 0x8F, 0xDC, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x0F, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0xF7, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x7F, 0xFE, 0x3D, 0xF7, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0xE0, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x0F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x1F, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x3E, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xE0, 0x1F,
  0x07, 0xF8, 0xFE, 0x3F, 0xC1, 0xF8, 0x0E, 0x00, 0x40, 0x00, 0x0F, 0xC1,
  0xFF, 0x9F, 0xFC, 0xF0, 0xF7, 0x03, 0xF8, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x80, 0x07,
  0xF0, 0x1F, 0xF8, 0x38, 0x0C, 0x30, 0x0E, 0x63, 0xE6, 0x67, 0xF6, 0xC6,
  0x66, 0xCE, 0x62, 0xCC, 0x63, 0xCC, 0x62, 0xCC, 0x66, 0xCC, 0x66, 0xCC,
  0x66, 0xCF, 0xEC, 0xC7, 0xFC, 0xE2, 0x10, 0x70, 0x00, 0x38, 0x20, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C,
  0x78, 0x1C, 0x38, 0x3C, 0x38, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x78,
  0x1E, 0x70, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF,
  0x8F, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0xFE, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x81, 0xEE, 0x03, 0xDC, 0x03, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x0F, 0x78, 0x1E, 0xF0, 0x38, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x38, 0x7C, 0xE0, 0x7B, 0x80,
  0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0x83, 0xCF, 0xFF, 0x3F,
  0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xE1,
  0xE7, 0x81, 0xEE, 0x03, 0xDC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x87, 0xFF, 0x0F, 0xFE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x78,
  0x0E, 0x78, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xDC, 0x07, 0x70, 0x3D, 0xE0, 0xF7,
  0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xF0, 0x1F, 0xE0, 0x7B, 0xC1, 0xE7, 0x83,
  0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0x81, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xBC, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0,
  0xF9, 0xE0, 0xF3, 0xC0, 0xF7, 0x81, 0xEF, 0x01, 0xE0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7F,
  0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xF3, 0xFF, 0xCD, 0xFB, 0x77,
  0xED, 0xDF, 0xBE, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x1F, 0x9C, 0x7E, 0x31,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFD, 0xC7,
  0xEE, 0x3F, 0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B, 0xF1, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0x80, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCE, 0x03, 0xDC, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xB8, 0x0F, 0x78, 0x1C, 0x70, 0x78, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xCF, 0xFF, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x3C, 0x78,
  0x1C, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x78,
  0x1C, 0x78, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0x83,
  0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3,
  0xFF, 0xE7, 0xFF, 0x0F, 0xFC, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0xF0,
  0x71, 0xE0, 0xF3, 0xC0, 0xE7, 0x81, 0xEF, 0x01, 0xE0, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xE1, 0xE7, 0x81, 0xEE, 0x01, 0xDE, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xF8, 0x07, 0x70, 0x0E, 0xF0, 0x3C, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0E, 0xF0,
  0x3B, 0xC1, 0xE7, 0xFF, 0x0F, 0xFC, 0x1F, 0xC0, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x38, 0x3C, 0x38, 0x38,
  0x3C, 0x38, 0x3C, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0xF0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0xCF, 0xE3, 0xCE,
  0xE3, 0xCE, 0xF7, 0xCE, 0x77, 0xCE, 0x77, 0xCE, 0x76, 0xEE, 0x76, 0xEE,
  0x76, 0xEC, 0x76, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C,
  0x3C, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x38, 0xF0, 0x0F, 0x70, 0x1E,
  0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C,
  0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xFC, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0xFF, 0xFF, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x81, 0xB8, 0x39, 0xC3, 0x1C, 0x70, 0xC7, 0x0E, 0xE0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xE3, 0x87, 0x02, 0x01, 0xFF, 0x1F,
  0xFC, 0xE1, 0xEF, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xFF, 0x7F, 0xFF, 0x83,
  0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xFD, 0xFD, 0xFF, 0xE7, 0xE7, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x10, 0x3F, 0xF8,
  0xFF, 0xF3, 0xE3, 0xEF, 0x07, 0xBC, 0x0E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBF, 0xFE, 0xEF, 0xF3, 0x9F,
  0x80, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xF1, 0xFF, 0x03, 0xF8, 0x1F, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x77, 0x07, 0xBF, 0xFC,
  0xFF, 0xC3, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x10, 0xE7, 0xF7, 0x7F, 0xFB, 0xC7, 0xFC, 0x1F, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1E, 0xFF, 0xF3,
  0xFF, 0x8F, 0xDC, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B,
  0xC0, 0xEE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x19, 0xFB, 0xF3, 0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x7C,
  0xC3, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x06, 0x00,
  0xFD, 0xDF, 0xFE, 0xF9, 0xFF, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xBF, 0xFC, 0xFF, 0xE3, 0xF7,
  0x00, 0x39, 0x03, 0xD8, 0x1E, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC6, 0x1E, 0xFE, 0xFF,
  0xF7, 0xC7, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1C, 0x07, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x83, 0xC0,
  0xE0, 0x20, 0x00, 0x01, 0xFE, 0xFF, 0x7F, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0xFF, 0x7F, 0xBF, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x01, 0x78, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF,
  0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7D, 0xE0, 0xF3, 0xC1,
  0xE3, 0xC3, 0xC3, 0xC7, 0x83, 0xCF, 0x07, 0x9E, 0x07, 0xC0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x11,
  0xDF, 0xFB, 0xFF, 0xFF, 0x9E, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1,
  0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71,
  0xF8, 0xE3, 0xF1, 0xC7, 0x01, 0x87, 0x3F, 0xBB, 0xFD, 0xF0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x07, 0x00, 0x7F, 0x83, 0xFF, 0x1E,
  0x3E, 0xF0, 0x7B, 0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x0E, 0xF0, 0x79, 0xF7, 0xC3, 0xFF, 0x07, 0xF0, 0x03, 0x83,
  0xBF, 0x8F, 0xFF, 0x3E, 0x3E, 0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xF7, 0xCF, 0xFF,
  0x3D, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x06, 0x01, 0xFD, 0xDF, 0xFE, 0xF1, 0xFF, 0x07, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xBF, 0xFC,
  0xFF, 0xE3, 0xF7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xCF, 0x7F, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x03, 0x00, 0x7F, 0x87, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0x07,
  0x80, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xB8, 0x0F, 0xF0, 0x39,
  0xE1, 0xE3, 0xFF, 0x07, 0xF8, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFC, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0xF7, 0xFF, 0x9F, 0xFC, 0x7C,
  0xE0, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0x71, 0xC1, 0xE3, 0x83, 0x87, 0x87,
  0x07, 0x1E, 0x0E, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x3B, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE3, 0x87, 0xE3, 0x8E, 0xE3, 0x8E,
  0xE3, 0xCE, 0xE7, 0xCE, 0x66, 0xCE, 0x76, 0xCC, 0x76, 0xCC, 0x76, 0xFC,
  0x7E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x1E, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78,
  0x3C, 0x3C, 0x78, 0x1C, 0xF8, 0x1F, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x1E,
  0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0xF0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x3E, 0x0F, 0x83, 0xF0, 0x1E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0,
  0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x70, 0x3C,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xE0,
  0x7C, 0x1E, 0x1F, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x3C, 0x1C, 0x00, 0x08, 0x00, 0x3F, 0x03, 0x7F, 0x83, 0x73,
  0xE7, 0x60, 0xFF, 0xE0, 0x7E, 0x00, 0x08,
};

const GFXglyph RobotoMono_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 21, 17, 7, -21 },
  { 12, 9, 7, 17, 4, -22 },
  { 20, 16, 21, 17, 1, -21 },
  { 62, 14, 27, 17, 2, -24 },
  { 110, 16, 21, 17, 1, -21 },
  { 152, 16, 21, 17, 1, -21 },
  { 194, 2, 8, 17, 7, -22 },
  { 196, 8, 30, 17, 5, -23 },
  { 226, 8, 30, 17, 4, -23 },
  { 256, 14, 15, 17, 2, -21 },
  { 283, 14, 15, 17, 2, -17 },
  { 310, 5, 8, 17, 5, -3 },
  { 315, 11, 2, 17, 4, -10 },
  { 318, 5, 4, 17, 6, -4 },
  { 321, 12, 23, 17, 3, -21 },
  { 356, 13, 21, 17, 2, -21 },
  { 391, 8, 21, 17, 3, -21 },
  { 412, 14, 21, 17, 1, -21 },
  { 449, 14, 21, 17, 1, -21 },
  { 486, 15, 21, 17, 1, -21 },
  { 526, 14, 21, 17, 2, -21 },
  { 563, 13, 21, 17, 2, -21 },
  { 598, 14, 21, 17, 1, -21 },
  { 635, 13, 21, 17, 2, -21 },
  { 670, 13, 21, 17, 2, -21 },
  { 705, 5, 16, 17, 7, -16 },
  { 715, 6, 21, 17, 6, -16 },
  { 731, 13, 14, 17, 2, -16 },
  { 754, 13, 8, 17, 2, -13 },
  { 767, 13, 14, 17, 2, -16 },
  { 790, 13, 21, 17, 2, -21 },
  { 825, 16, 21, 17, 1, -21 },
  { 867, 16, 21, 17, 1, -21 },
  { 909, 14, 21, 17, 2, -21 },
  { 946, 15, 21, 17, 1, -21 },
  { 986, 14, 21, 17, 2, -21 },
  { 1023, 14, 21, 17, 2, -21 },
  { 1060, 14, 21, 17, 2, -21 },
  { 1097, 15, 21, 17, 1, -21 },
  { 1137, 13, 21, 17, 2, -21 },
  { 1172, 12, 21, 17, 3, -21 },
  { 1204, 14, 21, 17, 1, -21 },
  { 1241, 15, 21, 17, 2, -21 },
  { 1281, 14, 21, 17, 2, -21 },
  { 1318, 14, 21, 17, 2, -21 },
  { 1355, 13, 21, 17, 2, -21 },
  { 1390, 15, 21, 17, 1, -21 },
  { 1430, 14, 21, 17, 2, -21 },
  { 1467, 16, 25, 17, 1, -21 },
  { 1517, 15, 21, 17, 2, -21 },
  { 1557, 15, 21, 17, 1, -21 },
  { 1597, 16, 21, 17, 1, -21 },
  { 1639, 14, 21, 17, 2, -21 },
  { 1676, 16, 21, 17, 1, -21 },
  { 1718, 16, 21, 17, 1, -21 },
  { 1760, 16, 21, 17, 1, -21 },
  { 1802, 16, 21, 17, 1, -21 },
  { 1844, 15, 21, 17, 1, -21 },
  { 1884, 6, 29, 17, 6, -24 },
  { 1906, 12, 23, 17, 3, -21 },
  { 1941, 6, 29, 17, 6, -24 },
  { 1963, 12, 11, 17, 3, -21 },
  { 1980, 13, 3, 17, 2, 0 },
  { 1985, 6, 4, 17, 6, -21 },
  { 1988, 13, 16, 17, 2, -16 },
  { 2014, 14, 22, 17, 2, -22 },
  { 2053, 13, 16, 17, 2, -16 },
  { 2079, 13, 22, 17, 2, -22 },
  { 2115, 14, 16, 17, 2, -16 },
  { 2143, 14, 22, 17, 2, -22 },
  { 2182, 13, 22, 17, 2, -16 },
  { 2218, 13, 22, 17, 2, -22 },
  { 2254, 13, 21, 17, 3, -21 },
  { 2289, 9, 27, 17, 3, -21 },
  { 2320, 15, 22, 17, 2, -22 },
  { 2362, 13, 22, 17, 3, -22 },
  { 2398, 15, 16, 17, 1, -16 },
  { 2428, 13, 16, 17, 2, -16 },
  { 2454, 14, 16, 17, 2, -16 },
  { 2482, 14, 22, 17, 2, -16 },
  { 2521, 13, 22, 17, 2, -16 },
  { 2557, 12, 16, 17, 4, -16 },
  { 2581, 14, 16, 17, 2, -16 },
  { 2609, 13, 19, 17, 2, -19 },
  { 2640, 13, 15, 17, 2, -15 },
  { 2665, 15, 15, 17, 1, -15 },
  { 2694, 16, 15, 17, 1, -15 },
  { 2724, 16, 15, 17, 1, -15 },
  { 2754, 16, 21, 17, 1, -15 },
  { 2796, 14, 15, 17, 2, -15 },
  { 2823, 10, 28, 17, 4, -23 },
  { 2858, 2, 27, 17, 8, -21 },
  { 2865, 9, 28, 17, 5, -23 },
  { 2897, 16, 7, 17, 0, -12 },
};

const GFXfont RobotoMono_Medium29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium29pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_MEDIUM29PT7B_H_
