#ifndef _ROBOTOMONO_MEDIUM49PT7B_H_
#define _ROBOTOMONO_MEDIUM49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x9F, 0xFF, 0xFF, 0xFD, 0xF0, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xF7, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x3F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x07, 0x81, 0x01,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x78,
  0x78, 0x1E, 0x0F, 0x1E, 0x03, 0xE1, 0xE3, 0xC0, 0x3F, 0xFC, 0xF0, 0x07,
  0xFF, 0x1E, 0x00, 0x7F, 0xC7, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0xFF, 0x00, 0x1E, 0x3F,
  0xF0, 0x03, 0xCF, 0xFF, 0x00, 0xF3, 0xE1, 0xE0, 0x1C, 0x78, 0x3C, 0x07,
  0x8F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x3C, 0x3C, 0x1E, 0x03, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x1F, 0x0F, 0xFF,
  0x03, 0xE3, 0xFF, 0xF0, 0x7C, 0xFE, 0x7F, 0x0F, 0x9F, 0x87, 0xE1, 0xF7,
  0xE0, 0x7E, 0x7E, 0xFC, 0x07, 0xEF, 0x9F, 0x80, 0xFF, 0xF3, 0xF0, 0x0F,
  0xFE, 0x7E, 0x00, 0xFF, 0x8F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x1F,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFB,
  0xF8, 0x1F, 0xFC, 0x3F, 0x80, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBD, 0xEF, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x38, 0x00, 0x80, 0x40, 0x07, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C,
  0x0C, 0x7C, 0x38, 0x3E, 0xFF, 0x38, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEF,
  0x00, 0x03, 0xEF, 0x80, 0x03, 0xC7, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x83,
  0xE0, 0x1F, 0x83, 0xF0, 0x3F, 0x01, 0xF8, 0x0E, 0x00, 0xE0, 0x02, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x7E,
  0xF9, 0xF7, 0xEF, 0x9E, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0x87, 0xE0,
  0x3F, 0x0F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x7F, 0xF8, 0xFC, 0xFF,
  0xF3, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xF0,
  0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xEF,
  0xF8, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xCF, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0xCF, 0xF0, 0xFF,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE3, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7E, 0x07, 0xF8, 0x18, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xEF, 0xE0, 0x1F, 0x8F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x1F, 0x9F, 0xF8, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFB, 0xF8,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xF1, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x87,
  0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC,
  0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x07, 0xF1, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0xC3, 0xF0, 0x1F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0x8F,
  0xE0, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0x03, 0xFC, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03,
  0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0x7E, 0x00, 0xFE, 0xFC, 0x03, 0xF9, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0x81, 0xFF, 0x1F, 0x00, 0x20, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x3F, 0x3F,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFC, 0x07, 0xEF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x0F, 0xE1,
  0xC7, 0x83, 0xFE, 0x38, 0xE0, 0xFF, 0xC7, 0x1C, 0x3E, 0x38, 0xF7, 0x87,
  0x87, 0x0E, 0xE1, 0xE1, 0xE1, 0xDC, 0x3C, 0x3C, 0x3B, 0x87, 0x07, 0x87,
  0xF1, 0xE0, 0xF0, 0xFE, 0x3C, 0x1C, 0x1F, 0xC7, 0x83, 0x83, 0xF8, 0xF0,
  0x70, 0xEF, 0x1E, 0x0E, 0x1D, 0xE3, 0xC1, 0xC3, 0xBC, 0x78, 0x78, 0x77,
  0x8F, 0x9F, 0x1C, 0x70, 0xFF, 0xFF, 0x8F, 0x1F, 0xFF, 0xE1, 0xE1, 0xF9,
  0xF8, 0x1C, 0x08, 0x08, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x04, 0x00, 0x7F, 0x07, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8,
  0x03, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8,
  0x01, 0xFC, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xF8, 0x07, 0xFC, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xF8,
  0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFC, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xFC, 0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFC, 0x0F, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0xC3, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0xF1, 0xFE, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0x8F, 0x80, 0x3F,
  0x87, 0xC0, 0x1F, 0xC3, 0xE0, 0x1F, 0xC1, 0xF0, 0x1F, 0xC0, 0xF8, 0x1F,
  0xC0, 0x7C, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x0F, 0x8F,
  0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xF0, 0x01, 0xF7, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x80,
  0xF8, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0x7F,
  0x0F, 0x80, 0x3F, 0x87, 0xC0, 0x0F, 0xE3, 0xE0, 0x03, 0xF9, 0xF0, 0x01,
  0xFC, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC3, 0xDF, 0xFB, 0xC7, 0xFF, 0xFB, 0xC7, 0xFF, 0xFB, 0xE7, 0xBF,
  0xF9, 0xE7, 0xBF, 0xF9, 0xEF, 0xBF, 0xF9, 0xFF, 0x3F, 0xF8, 0xFF, 0x3F,
  0xFC, 0xFF, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x38, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xBE,
  0x0F, 0xFF, 0x3E, 0x1F, 0xFE, 0x7C, 0x3F, 0xFC, 0x7C, 0x7F, 0xF8, 0xF8,
  0xFF, 0xF1, 0xF9, 0xFF, 0xE1, 0xF3, 0xFF, 0xC3, 0xF7, 0xFF, 0x83, 0xEF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x9F,
  0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x80,
  0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9,
  0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83,
  0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8,
  0x03, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0xF8, 0x07, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xF1, 0xFC, 0x03, 0xF8,
  0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xF9,
  0xFC, 0x01, 0xFC, 0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xF1, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3,
  0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x0F,
  0x03, 0xFF, 0xC1, 0xF0, 0x3E, 0xFC, 0x1F, 0x03, 0xE7, 0xC1, 0xF8, 0x3E,
  0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC3,
  0xF8, 0x7E, 0x7C, 0x3F, 0x87, 0xE7, 0xE3, 0xFC, 0x7C, 0x7E, 0x3F, 0xC7,
  0xC3, 0xE3, 0xFC, 0x7C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE7, 0xFC, 0x7C, 0x3E,
  0x7B, 0xC7, 0xC3, 0xE7, 0xBC, 0x7C, 0x3E, 0x79, 0xEF, 0x83, 0xE7, 0x9E,
  0xF8, 0x3F, 0x79, 0xEF, 0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0xF1, 0xEF, 0x81,
  0xFF, 0x1E, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7B, 0xE0,
  0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F,
  0x83, 0xE0, 0x78, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xC0, 0x3F, 0x9F, 0x80, 0x3F, 0x3E,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0x3F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBE,
  0x1F, 0xFE, 0x7E, 0x0F, 0xF8, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x3F, 0xC0, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xF3, 0xFE, 0xFE, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFE, 0xFF, 0x87,
  0xFB, 0xFF, 0xFF, 0xCF, 0xBF, 0xFE, 0x3E, 0x7F, 0xF0, 0xF8, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x7F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3F, 0x7C,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xF0, 0x0F,
  0xC7, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0xE3, 0xF0, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xE3, 0xFF, 0x7F, 0x01, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF,
  0x80, 0xFF, 0x3F, 0xC7, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFB, 0xF0, 0x3F, 0xC7, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0x80, 0xFC, 0x7F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x18, 0x3F, 0x80, 0x3C, 0x3F, 0xE0, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0x01, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x3E, 0x0F, 0xFE, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0xEF, 0xE0, 0x3F, 0xDF, 0x80,
  0x3F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xF0, 0x0F, 0xE7, 0xF8, 0x7F, 0xC7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x0F, 0xFF, 0x7E, 0x07, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x80, 0x0F, 0xC3, 0x00, 0x1F, 0x87, 0x00, 0x7F, 0x3F, 0xC7,
  0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0xE0, 0xF8, 0xFF,
  0xE3, 0xEF, 0xFF, 0xCF, 0xBF, 0xFF, 0xBF, 0xF3, 0xFE, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x83, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC,
  0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9,
  0xF8, 0xFE, 0x7D, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xF9, 0xFF, 0xE1, 0xF8, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F,
  0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1,
  0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C,
  0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07,
  0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0,
  0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7F, 0x83,
  0xE7, 0xFF, 0x8F, 0xBF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xCF, 0xFB, 0xF8,
  0x07, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF8,
  0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFC,
  0x3F, 0x83, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xF8, 0xFF, 0x03, 0xEF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x8F, 0xFB, 0xF8, 0x0F, 0xEF, 0xC0,
  0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7E, 0xFE, 0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFB, 0xFF, 0xC3, 0xE3, 0xFE, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x7E,
  0x1F, 0xFE, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x7F, 0xEF,
  0xE0, 0x3F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xF8, 0x7F,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0x7E, 0x07, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xF0, 0x1F, 0xCF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x60, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0x7E, 0x01, 0xFD, 0xFC, 0x3F,
  0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0x1F, 0xFC, 0x7C, 0x3F, 0xE1, 0xF0,
  0x08, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xBE,
  0x0F, 0x81, 0xF7, 0xC1, 0xF0, 0x3E, 0xF8, 0x3F, 0x0F, 0x9F, 0x0F, 0xE1,
  0xF3, 0xE1, 0xFC, 0x3E, 0x7C, 0x3F, 0x87, 0xC7, 0x87, 0x78, 0xF8, 0xF8,
  0xEF, 0x1E, 0x1F, 0x3D, 0xE3, 0xC3, 0xE7, 0xBC, 0xF8, 0x7C, 0xF3, 0x9F,
  0x07, 0x9C, 0x7B, 0xE0, 0xF7, 0x8F, 0x78, 0x1F, 0xF1, 0xEF, 0x03, 0xFE,
  0x1D, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xC0,
  0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFD, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xBF,
  0xFE, 0x01, 0xF7, 0xFF, 0xF0, 0x3D, 0xFC, 0xFF, 0x0F, 0xBE, 0x07, 0xFF,
  0xF7, 0x80, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xE0, 0x00,
};

const GFXglyph RobotoMono_Medium49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 35, 29, 11, -35 },
  { 32, 14, 12, 29, 7, -37 },
  { 53, 27, 35, 29, 1, -35 },
  { 172, 24, 45, 29, 3, -40 },
  { 307, 27, 35, 29, 1, -35 },
  { 426, 27, 36, 29, 2, -35 },
  { 548, 5, 13, 29, 11, -37 },
  { 557, 13, 50, 29, 8, -39 },
  { 639, 13, 50, 29, 8, -39 },
  { 721, 24, 24, 29, 4, -35 },
  { 793, 23, 26, 29, 3, -29 },
  { 868, 7, 15, 29, 9, -6 },
  { 882, 19, 5, 29, 6, -18 },
  { 894, 8, 7, 29, 11, -7 },
  { 901, 19, 38, 29, 6, -35 },
  { 992, 23, 36, 29, 3, -35 },
  { 1096, 15, 35, 29, 4, -35 },
  { 1162, 24, 35, 29, 2, -35 },
  { 1267, 23, 35, 29, 2, -35 },
  { 1368, 25, 35, 29, 2, -35 },
  { 1478, 23, 35, 29, 3, -35 },
  { 1579, 23, 35, 29, 3, -35 },
  { 1680, 24, 35, 29, 2, -35 },
  { 1785, 23, 35, 29, 3, -35 },
  { 1886, 23, 35, 29, 3, -35 },
  { 1987, 8, 27, 29, 12, -27 },
  { 2014, 9, 36, 29, 11, -27 },
  { 2055, 21, 22, 29, 4, -26 },
  { 2113, 22, 15, 29, 4, -23 },
  { 2155, 21, 22, 29, 4, -26 },
  { 2213, 22, 35, 29, 4, -35 },
  { 2310, 27, 35, 29, 1, -35 },
  { 2429, 28, 35, 29, 1, -35 },
  { 2552, 24, 35, 29, 4, -35 },
  { 2657, 25, 36, 29, 2, -35 },
  { 2770, 24, 35, 29, 3, -35 },
  { 2875, 22, 35, 29, 4, -35 },
  { 2972, 23, 35, 29, 4, -35 },
  { 3073, 25, 35, 29, 2, -35 },
  { 3183, 23, 35, 29, 3, -35 },
  { 3284, 21, 35, 29, 4, -35 },
  { 3376, 23, 35, 29, 3, -35 },
  { 3477, 25, 35, 29, 4, -35 },
  { 3587, 22, 35, 29, 4, -35 },
  { 3684, 24, 35, 29, 3, -35 },
  { 3789, 23, 35, 29, 3, -35 },
  { 3890, 25, 35, 29, 2, -35 },
  { 4000, 24, 35, 29, 4, -35 },
  { 4105, 27, 41, 29, 2, -35 },
  { 4244, 24, 35, 29, 4, -35 },
  { 4349, 25, 35, 29, 2, -35 },
  { 4459, 27, 35, 29, 1, -35 },
  { 4578, 23, 35, 29, 3, -35 },
  { 4679, 27, 35, 29, 1, -35 },
  { 4798, 28, 35, 29, 1, -35 },
  { 4921, 28, 35, 29, 1, -35 },
  { 5044, 28, 35, 29, 1, -35 },
  { 5167, 25, 35, 29, 2, -35 },
  { 5277, 10, 48, 29, 10, -40 },
  { 5337, 19, 38, 29, 6, -35 },
  { 5428, 10, 48, 29, 10, -40 },
  { 5488, 20, 19, 29, 5, -35 },
  { 5536, 21, 5, 29, 4, 0 },
  { 5550, 11, 6, 29, 10, -35 },
  { 5559, 23, 26, 29, 3, -26 },
  { 5634, 22, 37, 29, 4, -37 },
  { 5736, 23, 27, 29, 3, -26 },
  { 5814, 23, 37, 29, 3, -37 },
  { 5921, 24, 26, 29, 3, -26 },
  { 5999, 24, 38, 29, 3, -38 },
  { 6113, 23, 36, 29, 3, -26 },
  { 6217, 22, 37, 29, 4, -37 },
  { 6319, 21, 36, 29, 5, -36 },
  { 6414, 16, 46, 29, 5, -36 },
  { 6506, 24, 37, 29, 4, -37 },
  { 6617, 22, 37, 29, 5, -37 },
  { 6719, 25, 26, 29, 2, -26 },
  { 6801, 22, 26, 29, 4, -26 },
  { 6873, 24, 27, 29, 3, -26 },
  { 6954, 22, 36, 29, 4, -26 },
  { 7053, 23, 36, 29, 3, -26 },
  { 7157, 19, 26, 29, 7, -26 },
  { 7219, 23, 27, 29, 3, -26 },
  { 7297, 23, 33, 29, 3, -32 },
  { 7392, 22, 27, 29, 4, -26 },
  { 7467, 25, 26, 29, 2, -26 },
  { 7549, 27, 26, 29, 1, -26 },
  { 7637, 26, 26, 29, 2, -26 },
  { 7722, 28, 36, 29, 1, -26 },
  { 7848, 24, 26, 29, 3, -26 },
  { 7926, 16, 47, 29, 8, -38 },
  { 8020, 4, 45, 29, 13, -35 },
  { 8043, 16, 47, 29, 8, -38 },
  { 8137, 27, 11, 29, 1, -20 },
};

const GFXfont RobotoMono_Medium49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium49pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_MEDIUM49PT7B_H_
