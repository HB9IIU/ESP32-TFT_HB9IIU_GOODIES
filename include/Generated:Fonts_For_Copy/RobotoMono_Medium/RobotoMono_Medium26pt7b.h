#ifndef _ROBOTOMONO_MEDIUM26PT7B_H_
#define _ROBOTOMONO_MEDIUM26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium26pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x0E, 0xFE, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0x80, 0x06, 0x30, 0x18, 0xC0, 0xE7, 0x03, 0x18,
  0x0C, 0x61, 0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x18, 0xC0, 0x63, 0x01, 0x8C,
  0x3F, 0xFE, 0xFF, 0xF8, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6,
  0x00, 0x06, 0x00, 0x60, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0F, 0x70, 0x77,
  0x07, 0x70, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x78, 0xF7, 0xFE, 0x1F, 0xC0, 0x60, 0x06, 0x00,
  0x60, 0x18, 0x00, 0xFC, 0x01, 0x98, 0x07, 0x39, 0x8E, 0x73, 0x0C, 0xCC,
  0x1F, 0x98, 0x1E, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x19, 0xC0,
  0x67, 0xC0, 0xDC, 0xC3, 0x31, 0x86, 0x63, 0x04, 0xC6, 0x01, 0xFC, 0x01,
  0xF0, 0x07, 0x00, 0x7F, 0x03, 0xFC, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83,
  0x9C, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xF1, 0xDD, 0xE7, 0xF3, 0x9F,
  0x87, 0x6E, 0x0F, 0xB8, 0x3C, 0x71, 0xF9, 0xFF, 0xE3, 0xF9, 0xC0, 0xFF,
  0xFC, 0x02, 0x0C, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x0E,
  0x1C, 0x38, 0x70, 0x60, 0xC1, 0xC3, 0x83, 0x07, 0x06, 0x0E, 0x0E, 0x0C,
  0x08, 0x81, 0x81, 0x83, 0x83, 0x83, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x0E, 0x18, 0x61, 0xC2,
  0x00, 0x07, 0x00, 0x30, 0x01, 0x80, 0x8C, 0x2F, 0x6F, 0x3F, 0xFC, 0x1C,
  0x01, 0xE0, 0x1D, 0x81, 0xCE, 0x1E, 0x38, 0x21, 0x80, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x77, 0x77, 0xEE, 0xC4, 0xFF,
  0xFF, 0xF0, 0x6F, 0xFF, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0x06, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0,
  0xEE, 0x07, 0xE0, 0x7E, 0x1F, 0xE3, 0xFE, 0x77, 0xFC, 0x7F, 0x87, 0xF0,
  0x7E, 0x07, 0xE0, 0x7F, 0x0E, 0x71, 0xE3, 0xFC, 0x1F, 0x80, 0x07, 0x1F,
  0xFF, 0xFF, 0xC7, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x01, 0xFE, 0x1F, 0xF8, 0xE1, 0xEE, 0x07,
  0x70, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0x01, 0xFE, 0x1F, 0xF8, 0xE1, 0xEF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0x81, 0xDE,
  0x0E, 0x78, 0xF1, 0xFF, 0x07, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F,
  0xC0, 0x6E, 0x07, 0x70, 0x73, 0x83, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x39,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x7F, 0xE7, 0xFE, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x6F, 0x87, 0xFC,
  0xF3, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0xF7, 0x1E,
  0x7F, 0xC1, 0xF8, 0x00, 0x80, 0xF8, 0x1F, 0x83, 0xC0, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0xF8, 0xFF, 0xCF, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0E, 0x79, 0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x00, 0x0E, 0x03, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xE7, 0x0E, 0x7F, 0xC1, 0xF8, 0x7F, 0xCF, 0x0E, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xF1, 0xE7, 0xFE, 0x3F, 0x80, 0x0E, 0x03, 0xF8, 0x7F, 0xCF,
  0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0xFE, 0x0F, 0xFB, 0xE7,
  0xFE, 0x1E, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x3F, 0x83, 0xF0, 0x3C, 0x00,
  0x77, 0xBE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xEF, 0x7D, 0xC0, 0x77, 0xFE,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x39, 0xCE, 0x77, 0x38, 0x80, 0x00,
  0x20, 0x1C, 0x1F, 0x8F, 0xE7, 0xE1, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0xC0,
  0xFC, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xC0, 0x78, 0x7F, 0x7F, 0x1F, 0x83, 0xC0, 0x40, 0x00, 0x0F, 0x03, 0xFC,
  0x7F, 0xEF, 0x0E, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x0E, 0x00, 0x0F, 0xE0, 0x7B, 0xC3, 0x03, 0x98, 0x46, 0x67, 0xCB, 0x3B,
  0x3C, 0xCC, 0xF3, 0x33, 0xD8, 0xCF, 0x63, 0x3D, 0x8C, 0xB6, 0x36, 0xCF,
  0xFB, 0x39, 0xC6, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0xE1, 0xC3, 0x87, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0x03,
  0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x70, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0,
  0xEE, 0x07, 0x70, 0x3B, 0x83, 0xDF, 0xFC, 0xFF, 0xC7, 0xFF, 0x38, 0x1D,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xDF, 0xFE, 0xFF, 0xE7, 0xFC, 0x00,
  0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1F, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1D, 0xC0,
  0xEE, 0x07, 0x3C, 0xF1, 0xFF, 0x83, 0xF0, 0xFF, 0x0F, 0xFC, 0xE1, 0xEE,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xEE, 0x7C, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x03,
  0xB8, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xC3, 0xFE,
  0x03, 0xF8, 0x1D, 0xC0, 0xEF, 0x07, 0x3C, 0x78, 0xFF, 0xC3, 0xF8, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xF8, 0x3D, 0xC1, 0xCF, 0x1E, 0x3F, 0xE0, 0xFE, 0x00, 0xE0, 0x7B, 0x83,
  0xCE, 0x1E, 0x38, 0x70, 0xE3, 0x83, 0x9E, 0x0E, 0xF0, 0x3B, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0x78, 0x3C, 0xE0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38,
  0x3C, 0xE0, 0x7B, 0x80, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0x9F, 0xD9, 0xFD, 0xBF, 0xDF, 0x7E, 0xF7, 0xEF, 0x7E, 0xE7, 0xEE,
  0x7E, 0x67, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE,
  0x7E, 0x67, 0xE7, 0x7E, 0x37, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFE, 0x07, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xB8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1D, 0xC0, 0xEE, 0x0E, 0x3C, 0xF1, 0xFF, 0x03, 0xF0, 0xFF, 0xC7, 0xFF,
  0x38, 0x3D, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0E, 0xFF, 0xF7,
  0xFF, 0x3F, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x7F, 0x83, 0xFF, 0x1E, 0x1C, 0x70, 0x39,
  0xC0, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3B, 0x80, 0xE7, 0x03, 0x9C, 0x1E, 0x3C, 0xF0, 0xFF, 0x80, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0,
  0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xFF, 0xE7, 0xFE, 0x3F, 0xE1,
  0xC7, 0x8E, 0x1C, 0x70, 0xF3, 0x83, 0x9C, 0x1E, 0xE0, 0x77, 0x03, 0xC0,
  0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xF7, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3B, 0x80,
  0xFF, 0x01, 0xDC, 0x0E, 0x7C, 0x78, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x9E, 0x7F, 0xC1, 0xF8, 0xE0, 0x3F, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x38,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x70, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE3, 0x1F, 0x9C, 0x7E, 0x79, 0xF9, 0xE7,
  0xE7, 0x9F, 0x9E, 0x6E, 0x79, 0x9B, 0xEE, 0x6D, 0xB9, 0xF7, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF1, 0xF3, 0xC3, 0x8F, 0x0E, 0x3C, 0x38, 0x70, 0xE1,
  0xC0, 0xF0, 0x3D, 0xC1, 0xE3, 0x87, 0x0E, 0x3C, 0x1C, 0xE0, 0x77, 0x80,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1C, 0xE0,
  0xF3, 0xC3, 0x87, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xF0, 0xE0, 0x3D, 0xC0,
  0xE7, 0x07, 0x8E, 0x1C, 0x38, 0x70, 0xF3, 0x81, 0xCE, 0x07, 0x70, 0x0F,
  0xC0, 0x3E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFC, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0xFF, 0xF1, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xFF, 0xFC, 0x1C, 0x07, 0x81, 0xE0, 0xFC, 0x33, 0x1C, 0xC6, 0x39, 0x86,
  0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3, 0x87, 0x1F, 0x07, 0xFC, 0xF1,
  0xEE, 0x0E, 0x00, 0xE0, 0x0E, 0x3F, 0xE7, 0xFE, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEF, 0x1E, 0xFF, 0xE3, 0xE7, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xEF, 0x8F, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x9E, 0xFF, 0xEE, 0xF8, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x07, 0xE0, 0x77, 0x9E, 0x7F, 0xC1, 0xF8, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x1E, 0x77, 0xF7, 0x7F, 0xFF, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xF7, 0x9F, 0x7F,
  0xF3, 0xF7, 0x0F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xF0, 0x27, 0x8F, 0x3F, 0xE1, 0xFC, 0x03,
  0xF8, 0x3F, 0x83, 0xE4, 0x1C, 0x01, 0xE0, 0x0E, 0x03, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x77, 0xFF, 0x7F,
  0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xF7, 0x9F, 0x7F, 0xF3, 0xF7, 0x00, 0x74, 0x0E, 0x61, 0xEF, 0xFC, 0x3F,
  0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E,
  0xFE, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x07,
  0x07, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0xFE, 0xFC, 0x60, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xDC, 0x3C,
  0xE3, 0xC7, 0x3C, 0x3B, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xDE, 0x1C,
  0x70, 0xE3, 0xC7, 0x0F, 0x38, 0x3D, 0xC0, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xEE, 0x77, 0xFF, 0xFF, 0xFF, 0xCE, 0x3E, 0x71, 0xF3, 0x8F, 0x9C, 0x7C,
  0xE3, 0xE7, 0x1F, 0x38, 0xF9, 0xC7, 0xCE, 0x3E, 0x71, 0xF3, 0x8C, 0xE7,
  0x8E, 0xFE, 0xFF, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x0F, 0x80, 0xFF, 0x0F,
  0xFC, 0xE0, 0xE7, 0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3B, 0x81,
  0xDC, 0x1E, 0x79, 0xE3, 0xFE, 0x07, 0xE0, 0xEF, 0x8F, 0xFC, 0xFF, 0xEE,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEF,
  0x1E, 0xFF, 0xCE, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x1E, 0x77, 0xFF, 0x7F, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xF7, 0x9F, 0x7F, 0xF3, 0xF7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0xE7, 0xFB, 0xFF, 0xFF, 0xE0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F,
  0x83, 0xFE, 0x79, 0xEE, 0x07, 0xE0, 0x07, 0x80, 0x7F, 0x81, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xE3, 0xFC, 0x1C, 0x01, 0xC0, 0x1C,
  0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x10, 0xFF, 0x07, 0xF0, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xF7, 0x1F, 0x7F, 0x73, 0xE7, 0xE0, 0x3D, 0xC0, 0xE7, 0x03,
  0x9C, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x37,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE1, 0x8E, 0xC7, 0x1D,
  0xCE, 0x3B, 0x9C, 0x67, 0x3C, 0xCE, 0x79, 0x8D, 0xB7, 0x1B, 0x6E, 0x36,
  0x78, 0x7C, 0xF0, 0xF1, 0xE0, 0xE3, 0xC1, 0xC7, 0x83, 0x87, 0x00, 0xF0,
  0x3D, 0xE1, 0xE3, 0x87, 0x07, 0x38, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xCE, 0x0E, 0x1C, 0x78, 0x7B, 0xC0, 0xF0,
  0xE0, 0x1F, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0x38, 0x70, 0xE1, 0xC1, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x01, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0xC3, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x1E, 0x0F, 0x03, 0xC0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x3E, 0x0E, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x78, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0xF0, 0x78, 0x70, 0x70,
  0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC1, 0xC0, 0x80, 0x00,
  0x3E, 0x06, 0xFE, 0x1D, 0xCF, 0xF7, 0x0F, 0xE0, 0x07, 0x80,
};

const GFXglyph RobotoMono_Medium26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 18, 16, 6, -18 },
  { 10, 7, 7, 16, 4, -20 },
  { 17, 14, 18, 16, 1, -18 },
  { 49, 12, 24, 16, 2, -21 },
  { 85, 15, 19, 16, 0, -19 },
  { 121, 14, 19, 16, 1, -19 },
  { 155, 2, 7, 16, 6, -20 },
  { 157, 7, 27, 16, 4, -21 },
  { 181, 7, 27, 16, 4, -21 },
  { 205, 13, 12, 16, 2, -18 },
  { 225, 13, 13, 16, 1, -15 },
  { 247, 4, 8, 16, 5, -3 },
  { 251, 10, 2, 16, 3, -9 },
  { 254, 4, 4, 16, 6, -4 },
  { 256, 10, 20, 16, 3, -18 },
  { 281, 12, 19, 16, 2, -19 },
  { 310, 8, 18, 16, 2, -18 },
  { 328, 13, 19, 16, 1, -19 },
  { 359, 13, 19, 16, 1, -19 },
  { 390, 13, 18, 16, 1, -18 },
  { 420, 12, 18, 16, 2, -18 },
  { 447, 12, 19, 16, 2, -19 },
  { 476, 13, 18, 16, 1, -18 },
  { 506, 12, 19, 16, 2, -19 },
  { 535, 12, 19, 16, 2, -19 },
  { 564, 5, 15, 16, 6, -15 },
  { 574, 5, 20, 16, 6, -15 },
  { 587, 11, 12, 16, 2, -14 },
  { 604, 12, 8, 16, 2, -12 },
  { 616, 11, 12, 16, 2, -14 },
  { 633, 12, 19, 16, 2, -19 },
  { 662, 14, 18, 16, 1, -18 },
  { 694, 14, 18, 16, 1, -18 },
  { 726, 13, 18, 16, 2, -18 },
  { 756, 13, 19, 16, 1, -19 },
  { 787, 12, 18, 16, 2, -18 },
  { 814, 12, 18, 16, 2, -18 },
  { 841, 12, 18, 16, 2, -18 },
  { 868, 13, 19, 16, 1, -19 },
  { 899, 12, 18, 16, 2, -18 },
  { 926, 11, 18, 16, 2, -18 },
  { 951, 13, 18, 16, 1, -18 },
  { 981, 14, 18, 16, 2, -18 },
  { 1013, 12, 18, 16, 2, -18 },
  { 1040, 12, 18, 16, 2, -18 },
  { 1067, 12, 18, 16, 2, -18 },
  { 1094, 13, 19, 16, 1, -19 },
  { 1125, 13, 18, 16, 2, -18 },
  { 1155, 14, 22, 16, 1, -19 },
  { 1194, 13, 18, 16, 2, -18 },
  { 1224, 14, 19, 16, 1, -19 },
  { 1258, 14, 18, 16, 1, -18 },
  { 1290, 12, 18, 16, 2, -18 },
  { 1317, 14, 18, 16, 1, -18 },
  { 1349, 14, 18, 16, 1, -18 },
  { 1381, 14, 18, 16, 1, -18 },
  { 1413, 14, 18, 16, 1, -18 },
  { 1445, 13, 18, 16, 1, -18 },
  { 1475, 6, 25, 16, 5, -21 },
  { 1494, 10, 20, 16, 3, -18 },
  { 1519, 6, 25, 16, 5, -21 },
  { 1538, 10, 9, 16, 3, -18 },
  { 1550, 12, 2, 16, 2, 0 },
  { 1553, 6, 4, 16, 5, -19 },
  { 1556, 12, 14, 16, 2, -14 },
  { 1577, 12, 20, 16, 2, -20 },
  { 1607, 12, 14, 16, 2, -14 },
  { 1628, 12, 20, 16, 2, -20 },
  { 1658, 12, 14, 16, 2, -14 },
  { 1679, 13, 20, 16, 2, -20 },
  { 1712, 12, 19, 16, 2, -14 },
  { 1741, 12, 20, 16, 2, -20 },
  { 1771, 11, 19, 16, 3, -19 },
  { 1798, 8, 25, 16, 3, -19 },
  { 1823, 13, 20, 16, 2, -20 },
  { 1856, 11, 20, 16, 3, -20 },
  { 1884, 13, 14, 16, 1, -14 },
  { 1907, 12, 14, 16, 2, -14 },
  { 1928, 13, 14, 16, 1, -14 },
  { 1951, 12, 19, 16, 2, -14 },
  { 1980, 12, 19, 16, 2, -14 },
  { 2009, 10, 14, 16, 4, -14 },
  { 2027, 12, 14, 16, 2, -14 },
  { 2048, 12, 17, 16, 2, -17 },
  { 2074, 12, 14, 16, 2, -14 },
  { 2095, 14, 14, 16, 1, -14 },
  { 2120, 15, 14, 16, 0, -14 },
  { 2147, 14, 14, 16, 1, -14 },
  { 2172, 14, 20, 16, 1, -14 },
  { 2207, 12, 14, 16, 2, -14 },
  { 2228, 9, 25, 16, 4, -20 },
  { 2257, 2, 23, 16, 7, -18 },
  { 2263, 9, 25, 16, 4, -20 },
  { 2292, 15, 5, 16, 0, -10 },
};

const GFXfont RobotoMono_Medium26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium26pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_MEDIUM26PT7B_H_
