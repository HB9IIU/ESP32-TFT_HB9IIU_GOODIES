#ifndef _ROBOTOMONO_MEDIUM53PT7B_H_
#define _ROBOTOMONO_MEDIUM53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium53pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0,
  0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x1F, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x07, 0xF3, 0xF8,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x01, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0,
  0xF0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x3C,
  0x1E, 0x03, 0xC0, 0xF0, 0xF0, 0x0F, 0x83, 0xC3, 0xC0, 0x3E, 0x1F, 0x1E,
  0x00, 0x7E, 0xFC, 0x78, 0x01, 0xFF, 0xE3, 0xC0, 0x03, 0xFF, 0x1F, 0x00,
  0x03, 0xF8, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x8F, 0xF8, 0x00, 0x3C,
  0x7F, 0xF0, 0x01, 0xF3, 0xFF, 0xE0, 0x07, 0x8F, 0x8F, 0x80, 0x3E, 0x3C,
  0x1F, 0x00, 0xF1, 0xF0, 0x7C, 0x07, 0x87, 0xC1, 0xF0, 0x1E, 0x1F, 0x07,
  0xC0, 0xF0, 0x7C, 0x1F, 0x00, 0x41, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x01, 0xF8, 0x7F, 0xFE, 0x07, 0xE3, 0xF9, 0xFC, 0x1F, 0x0F, 0xC7, 0xF0,
  0x7C, 0x7F, 0x0F, 0xE1, 0xF1, 0xF8, 0x1F, 0xCF, 0xCF, 0xE0, 0x3F, 0xBF,
  0x3F, 0x80, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0x0F,
  0xE0, 0x07, 0xFC, 0x1F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x80, 0xFF,
  0xBF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE7, 0xF0, 0x0F, 0xFE, 0x0F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0xE0, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x18, 0x00, 0x20, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x1E,
  0x00, 0x70, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x01, 0x00, 0x78, 0x02, 0x78, 0x1E, 0x03, 0x9F, 0x87,
  0x87, 0xE7, 0xF9, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE1,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0x00, 0x78, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7,
  0xC7, 0xE1, 0xE0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xBF, 0xFC, 0x3F,
  0x3F, 0xFC, 0xFE, 0x3F, 0xFD, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x0F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x7E, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFE, 0x3E, 0x01,
  0xFE, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x01, 0xF9, 0xFF, 0xC0, 0xFD, 0xFF, 0xF0,
  0xFD, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0x9F, 0xF0, 0x0F,
  0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0xFE, 0x3F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE,
  0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x1F, 0xF3, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0x3F, 0x00, 0x18, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x3F, 0xDF, 0xEF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xFF, 0x7F, 0xBF, 0xFF, 0xEF, 0xF7, 0xF9, 0xF8, 0x30, 0x1F,
  0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF3, 0xF8, 0xFE, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0x80,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x81,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C,
  0x1F, 0x01, 0xC0, 0xF0, 0xF0, 0x3F, 0xC7, 0x87, 0x83, 0xFF, 0x1C, 0x78,
  0x3F, 0xF8, 0xF3, 0xC3, 0xE3, 0xC7, 0xBC, 0x3E, 0x1E, 0x1D, 0xE1, 0xE0,
  0xF0, 0xEF, 0x0F, 0x07, 0x07, 0x78, 0xF0, 0x38, 0x3B, 0x87, 0x81, 0xC1,
  0xFC, 0x3C, 0x0E, 0x0F, 0xE1, 0xE0, 0x70, 0x7F, 0x0F, 0x07, 0x87, 0xF8,
  0x78, 0x3C, 0x3F, 0xC3, 0xC1, 0xE1, 0xDE, 0x1E, 0x0F, 0x0E, 0xF0, 0xF0,
  0x78, 0xF3, 0xC7, 0xC7, 0xC7, 0x1E, 0x3F, 0xFF, 0xF8, 0xF0, 0xFF, 0x7F,
  0x87, 0x83, 0xF3, 0xF8, 0x1E, 0x0F, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF0,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0x0F, 0xF3, 0xF0,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x07,
  0xF3, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x3F, 0xCF,
  0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xFE, 0xFC, 0x01, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xE1, 0xFF, 0xC3, 0xF0,
  0x0F, 0xF1, 0xF8, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0,
  0x03, 0xFB, 0xF0, 0x03, 0xF9, 0xF8, 0x07, 0xF8, 0xFC, 0x0F, 0xFC, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF0, 0x07,
  0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x00, 0xFD, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x1F, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFC, 0xFC, 0x00,
  0xFE, 0x7F, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFC,
  0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07,
  0xF8, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0xC3, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xDF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x3F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x78, 0xFB,
  0xFF, 0xBE, 0x7D, 0xFF, 0xDF, 0x3E, 0xFF, 0xE7, 0x9E, 0x7F, 0xF3, 0xFF,
  0x3F, 0xF9, 0xFF, 0x9F, 0xFC, 0x7F, 0x8F, 0xFE, 0x3F, 0xC7, 0xFF, 0x1F,
  0xE3, 0xFF, 0x8F, 0xE1, 0xFF, 0xC3, 0xF0, 0xFF, 0xE1, 0xF8, 0x7F, 0xF0,
  0xF8, 0x3F, 0xF8, 0x3C, 0x1F, 0xFC, 0x1E, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xE0, 0x7F, 0xFD, 0xF8, 0x3F,
  0xFE, 0x7C, 0x1F, 0xFF, 0x3F, 0x0F, 0xFF, 0x8F, 0x87, 0xFF, 0xC7, 0xE3,
  0xFF, 0xE1, 0xF1, 0xFF, 0xF0, 0xFC, 0xFF, 0xF8, 0x3E, 0x7F, 0xFC, 0x1F,
  0xBF, 0xFE, 0x07, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0x80, 0xFF, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x3F, 0xF3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x10, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0x01, 0xFF, 0xCF, 0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFE, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF,
  0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFE,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0x80, 0xFF, 0xF0, 0x3F, 0x03,
  0xFF, 0xC0, 0xFC, 0x0F, 0xDF, 0x03, 0xF0, 0x3F, 0x7C, 0x0F, 0xC0, 0xF9,
  0xF8, 0x3F, 0x03, 0xE7, 0xE0, 0xFC, 0x1F, 0x9F, 0x87, 0xF8, 0x7E, 0x7E,
  0x1F, 0xE1, 0xF9, 0xF8, 0x7F, 0x87, 0xE3, 0xE1, 0xFE, 0x1F, 0x8F, 0x87,
  0xF8, 0x7E, 0x3E, 0x1F, 0xE1, 0xF0, 0xF8, 0x7F, 0xC7, 0xC3, 0xF3, 0xFF,
  0x1F, 0x0F, 0xCF, 0xFC, 0xFC, 0x3F, 0x3E, 0xF3, 0xF0, 0xFC, 0xF3, 0xCF,
  0xC1, 0xF3, 0xCF, 0x3F, 0x07, 0xCF, 0x3C, 0xF8, 0x1F, 0x7C, 0xFB, 0xE0,
  0x7D, 0xF3, 0xEF, 0x81, 0xF7, 0xC7, 0xBE, 0x07, 0xFE, 0x1E, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFB, 0xFC,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0x7D, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFE, 0x1F, 0xF0, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x3F, 0xC0, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x03,
  0xFE, 0x7F, 0xEF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF7, 0xF0, 0x7F, 0xE1, 0xF8, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x0F, 0xC7, 0xFC,
  0x07, 0xE7, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC0, 0xFF, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0xE0, 0x7F, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xF3, 0xFF, 0xC1, 0xF8, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFB, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xFB, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x02, 0x07, 0xF0, 0x1F, 0xF3, 0xF8, 0x3F, 0xFD, 0xFC, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xDF,
  0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFE, 0xFC, 0x1F, 0xFE, 0x7E, 0x03, 0xFE, 0x3F, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFB,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x83,
  0xF8, 0x00, 0x70, 0xFF, 0x00, 0x7E, 0x1F, 0xFD, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF0, 0x60, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x8F, 0xC1, 0xFF,
  0xF7, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xF0, 0x1F, 0xF1, 0xF8, 0x00,
  0x80, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x08, 0x00, 0x3F, 0x0F,
  0x00, 0x3F, 0x8F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x02, 0x00, 0xFC, 0x3F, 0xE0,
  0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0xFE, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x18, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xBF,
  0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0x3F, 0x03, 0xFC, 0x0F, 0xC1, 0xFE, 0x03, 0xF0, 0xFF, 0x00, 0xFC, 0x7F,
  0x80, 0x3F, 0x3F, 0xC0, 0x0F, 0xDF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xBF, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F,
  0xC0, 0xFC, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x07, 0xF8, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xFB,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x04, 0x0F, 0xCF, 0xE3, 0xF8, 0xFD, 0xFF,
  0x7F, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x1F, 0x87, 0xEF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8,
  0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x02, 0x00,
  0xFC, 0x3F, 0xE0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xF1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x7E, 0x3F, 0xE0, 0x3F, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xF9,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF8,
  0x03, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x1F, 0xBF, 0xFE, 0x0F, 0xC7, 0xFC, 0x07, 0xE0, 0x30, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0x8F, 0xC1, 0xFF, 0xE7, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xF0, 0x1F,
  0xF3, 0xF8, 0x00, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0x07, 0xE0, 0xFF, 0xFF, 0x1F, 0xFD, 0xF9, 0xFF, 0xEF, 0xDF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7F, 0x81, 0xFF, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x01,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0x3F, 0x07, 0xFC, 0x3F, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9,
  0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0x80,
  0xFF, 0xF0, 0x3E, 0x03, 0xEF, 0xC0, 0xF8, 0x0F, 0x9F, 0x03, 0xF0, 0x3E,
  0x7C, 0x0F, 0xC1, 0xF9, 0xF0, 0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0x1F,
  0x87, 0xF0, 0x7C, 0x3E, 0x1F, 0xE1, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xE1,
  0xDE, 0x1F, 0x0F, 0x8F, 0x78, 0xF8, 0x3E, 0x3D, 0xF3, 0xE0, 0x7C, 0xF3,
  0xCF, 0x81, 0xF3, 0xCF, 0x3E, 0x07, 0xDE, 0x3C, 0xF8, 0x1F, 0x78, 0xF3,
  0xC0, 0x7D, 0xE1, 0xFF, 0x01, 0xF7, 0x87, 0xFC, 0x03, 0xDC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x03,
  0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x0B, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x8F, 0xFF, 0x80, 0x1E, 0xFF, 0xFE,
  0x01, 0xF7, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xF1, 0xFB, 0xE0, 0x3F, 0xFF,
  0xDF, 0x00, 0xFF, 0xFC, 0xF0, 0x03, 0xFF, 0xE0, 0x40, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoMono_Medium53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 7, 38, 32, 12, -38 },
  { 35, 15, 13, 32, 8, -40 },
  { 60, 29, 38, 32, 1, -38 },
  { 198, 25, 49, 32, 4, -44 },
  { 352, 30, 39, 32, 1, -38 },
  { 499, 30, 39, 32, 2, -38 },
  { 646, 5, 14, 32, 12, -40 },
  { 655, 14, 54, 32, 9, -42 },
  { 750, 14, 54, 32, 8, -42 },
  { 845, 26, 26, 32, 4, -38 },
  { 930, 26, 27, 32, 3, -31 },
  { 1018, 9, 16, 32, 9, -6 },
  { 1036, 20, 5, 32, 7, -19 },
  { 1049, 9, 9, 32, 12, -8 },
  { 1060, 21, 41, 32, 6, -38 },
  { 1168, 24, 39, 32, 4, -38 },
  { 1285, 16, 38, 32, 5, -38 },
  { 1361, 26, 38, 32, 2, -38 },
  { 1485, 26, 39, 32, 2, -38 },
  { 1612, 27, 38, 32, 2, -38 },
  { 1741, 24, 39, 32, 4, -38 },
  { 1858, 25, 39, 32, 3, -38 },
  { 1980, 26, 38, 32, 2, -38 },
  { 2104, 24, 39, 32, 4, -38 },
  { 2221, 25, 38, 32, 3, -38 },
  { 2340, 9, 31, 32, 12, -30 },
  { 2375, 10, 40, 32, 12, -30 },
  { 2425, 23, 25, 32, 4, -29 },
  { 2497, 24, 16, 32, 4, -24 },
  { 2545, 23, 25, 32, 4, -29 },
  { 2617, 24, 38, 32, 4, -38 },
  { 2731, 29, 38, 32, 1, -38 },
  { 2869, 30, 38, 32, 1, -38 },
  { 3012, 26, 38, 32, 4, -38 },
  { 3136, 27, 39, 32, 2, -38 },
  { 3268, 25, 38, 32, 4, -38 },
  { 3387, 25, 38, 32, 4, -38 },
  { 3506, 25, 38, 32, 4, -38 },
  { 3625, 27, 39, 32, 2, -38 },
  { 3757, 25, 38, 32, 3, -38 },
  { 3876, 22, 38, 32, 5, -38 },
  { 3981, 25, 39, 32, 3, -38 },
  { 4103, 28, 38, 32, 4, -38 },
  { 4236, 25, 38, 32, 4, -38 },
  { 4355, 25, 38, 32, 4, -38 },
  { 4474, 25, 38, 32, 3, -38 },
  { 4593, 27, 39, 32, 2, -38 },
  { 4725, 26, 38, 32, 4, -38 },
  { 4849, 29, 45, 32, 2, -38 },
  { 5013, 26, 38, 32, 4, -38 },
  { 5137, 27, 38, 32, 3, -38 },
  { 5266, 30, 38, 32, 1, -38 },
  { 5409, 25, 39, 32, 3, -38 },
  { 5531, 29, 38, 32, 1, -38 },
  { 5669, 30, 38, 32, 1, -38 },
  { 5812, 30, 38, 32, 1, -38 },
  { 5955, 30, 38, 32, 1, -38 },
  { 6098, 26, 38, 32, 3, -38 },
  { 6222, 11, 51, 32, 11, -43 },
  { 6293, 21, 41, 32, 6, -38 },
  { 6401, 11, 51, 32, 10, -43 },
  { 6472, 21, 20, 32, 6, -38 },
  { 6525, 24, 5, 32, 4, 0 },
  { 6540, 11, 7, 32, 11, -38 },
  { 6550, 25, 30, 32, 3, -29 },
  { 6644, 25, 41, 32, 4, -40 },
  { 6773, 25, 30, 32, 3, -29 },
  { 6867, 25, 41, 32, 3, -40 },
  { 6996, 26, 30, 32, 3, -29 },
  { 7094, 26, 41, 32, 4, -41 },
  { 7228, 25, 40, 32, 3, -29 },
  { 7353, 24, 40, 32, 4, -40 },
  { 7473, 24, 39, 32, 5, -39 },
  { 7590, 17, 50, 32, 6, -39 },
  { 7697, 26, 40, 32, 4, -40 },
  { 7827, 24, 40, 32, 5, -40 },
  { 7947, 28, 29, 32, 2, -29 },
  { 8049, 24, 29, 32, 4, -29 },
  { 8136, 26, 30, 32, 3, -29 },
  { 8234, 25, 40, 32, 4, -29 },
  { 8359, 25, 40, 32, 3, -29 },
  { 8484, 21, 29, 32, 8, -29 },
  { 8561, 24, 30, 32, 4, -29 },
  { 8651, 25, 36, 32, 3, -35 },
  { 8764, 24, 29, 32, 4, -28 },
  { 8851, 28, 28, 32, 2, -28 },
  { 8949, 30, 28, 32, 1, -28 },
  { 9054, 27, 28, 32, 3, -28 },
  { 9149, 29, 39, 32, 2, -28 },
  { 9291, 25, 28, 32, 4, -28 },
  { 9379, 17, 50, 32, 8, -41 },
  { 9486, 4, 48, 32, 14, -38 },
  { 9510, 18, 50, 32, 8, -41 },
  { 9623, 29, 11, 32, 1, -21 },
};

const GFXfont RobotoMono_Medium53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium53pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_MEDIUM53PT7B_H_
