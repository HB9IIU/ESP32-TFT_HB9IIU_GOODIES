#ifndef _ROBOTOMONO_MEDIUM31PT7B_H_
#define _ROBOTOMONO_MEDIUM31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x6F, 0xFF,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x03, 0x8E, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xC3, 0x07, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x1C, 0x70, 0x0C, 0x30, 0x06, 0x18, 0x03,
  0x0C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x3C, 0x1E, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDE,
  0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x31, 0xC4, 0x18, 0xE3, 0x8C, 0x71, 0x86,
  0x39, 0xC3, 0x9C, 0xC1, 0xFC, 0xC0, 0x7C, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x19, 0xF0, 0x1D, 0xFC, 0x0C, 0xC7, 0x0E,
  0x63, 0x8E, 0x31, 0xC2, 0x18, 0xE0, 0x0E, 0x70, 0x07, 0xF0, 0x01, 0xF0,
  0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0x8F, 0x03, 0xC3, 0x81, 0xE1,
  0xC0, 0xF1, 0xE0, 0x39, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xFC, 0x3B, 0xCF, 0x3D, 0xC3, 0xDF, 0xE1, 0xEE, 0xF0, 0x7F,
  0x78, 0x1F, 0x1E, 0x0F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0x3C, 0xFF,
  0xFF, 0xFF, 0x01, 0x01, 0x81, 0xE1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x3C,
  0x0C, 0x02, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x70, 0xF0, 0xE0, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x04, 0x18, 0x2F, 0x33, 0xFF, 0xFF, 0x8F,
  0xFE, 0x03, 0xC0, 0x0F, 0x80, 0x3B, 0x80, 0x73, 0x81, 0xC7, 0x87, 0x87,
  0x82, 0x04, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x39, 0xCE, 0x73,
  0x9D, 0xEE, 0xF1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF,
  0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x9E, 0x0F, 0x70, 0x3F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7, 0xFF, 0x3D, 0xFD, 0xE7, 0xFE, 0x1F,
  0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x83, 0xCF, 0xFE,
  0x3F, 0xF0, 0x3F, 0x80, 0x01, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1,
  0xEF, 0x01, 0xDE, 0x03, 0xFC, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xE7, 0x81, 0xEE, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0xFB, 0xFF,
  0xE3, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xB8, 0x07, 0xB8, 0x07, 0x38, 0x0E, 0x38, 0x1E,
  0x38, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF0, 0x81, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x79, 0xE0,
  0xF3, 0xFF, 0xC3, 0xFF, 0x81, 0xFC, 0x00, 0x01, 0xE0, 0x3F, 0x81, 0xFE,
  0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x60, 0xF7, 0xF3, 0xFF,
  0xEF, 0xCF, 0xBC, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xF7, 0x87, 0xCF, 0xFE, 0x3F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3,
  0xC1, 0xE7, 0x03, 0xCE, 0x07, 0x9C, 0x0F, 0x3C, 0x1E, 0x78, 0x78, 0x7F,
  0xF0, 0x7F, 0x81, 0xFF, 0x87, 0xC7, 0x8E, 0x07, 0xBC, 0x07, 0x78, 0x0F,
  0xF0, 0x1F, 0xE0, 0x39, 0xE0, 0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xDE, 0x1F, 0x7F, 0xFC, 0xFF,
  0xF0, 0xF3, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x07, 0xF8, 0x1F,
  0xC0, 0x7C, 0x00, 0x31, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC7, 0xBF, 0xF9, 0xE0, 0x31, 0xE7, 0xDF, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xCE, 0x10, 0x00,
  0x04, 0x00, 0x70, 0x0F, 0xC0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0x3C,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x06, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x07, 0xE0, 0x0F, 0x03, 0xF8, 0xFF, 0x9F, 0xE1, 0xFC, 0x0F,
  0x00, 0x60, 0x00, 0x1F, 0xE3, 0xFF, 0xBF, 0xFF, 0xE0, 0xFE, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x8F, 0x87, 0x00, 0xC3,
  0x00, 0x73, 0x8F, 0x99, 0x8F, 0xCD, 0xCE, 0x67, 0xC6, 0x31, 0xE7, 0x18,
  0xF3, 0x8C, 0x79, 0x86, 0x6C, 0xC3, 0x36, 0x61, 0x9B, 0x39, 0xCD, 0x8F,
  0xFC, 0xE7, 0xBC, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x82, 0x01, 0xFF, 0x00,
  0x3F, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xF0, 0x0F, 0x38, 0x07, 0x1C, 0x03,
  0x8F, 0x03, 0xC7, 0x81, 0xC1, 0xC0, 0xE0, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x00, 0xEF, 0x00, 0x7F, 0x80,
  0x3C, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0xEF,
  0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3C, 0x1E, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x87, 0xCF, 0x03,
  0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC3, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0x70, 0x0F,
  0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x1F, 0xFF, 0x0F, 0xFE,
  0x07, 0xF8, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0,
  0x1F, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x83,
  0xC7, 0x81, 0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x07, 0xCF, 0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78,
  0x3E, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7C, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8D,
  0xFB, 0x3B, 0xF7, 0x77, 0xEE, 0xCF, 0xCF, 0x9F, 0x9F, 0x7F, 0x3C, 0xFE,
  0x39, 0xFC, 0x73, 0xF8, 0xC7, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xC0, 0xF0, 0x1F, 0xC0, 0x7F, 0x81,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xDC,
  0x7F, 0x79, 0xFC, 0xE7, 0xF3, 0xDF, 0xC7, 0x7F, 0x1F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x70, 0x07, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0x03, 0xEE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0E, 0xE0, 0x1D, 0xC0,
  0x7B, 0x83, 0xE7, 0xFF, 0xCF, 0xFE, 0x1F, 0xC0, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0,
  0x79, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xDE,
  0x00, 0xEF, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x1C, 0xE0, 0x1E, 0x78, 0x0F,
  0x3C, 0x0F, 0x0F, 0x07, 0x87, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x0F, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x3F, 0xE0, 0x7B, 0xFF, 0xE3, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1D, 0xE0, 0x79, 0xE0, 0xF3, 0xFF, 0xC3, 0xFF,
  0x01, 0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0x9C, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x0E, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xC0, 0x0E,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x71, 0xFC, 0x78, 0xFF, 0x3E,
  0x7F, 0x9F, 0x39, 0xCF, 0x9C, 0xE7, 0xCE, 0x73, 0x67, 0x3B, 0xB3, 0x9D,
  0xD9, 0xCE, 0xEF, 0xE7, 0x77, 0xE3, 0xF3, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC1, 0xC0, 0xE0,
  0xE0, 0xF8, 0x0F, 0xBC, 0x07, 0x9F, 0x07, 0xC7, 0x83, 0xC1, 0xE3, 0xC0,
  0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0xF7, 0x80, 0x3C,
  0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC3, 0xC1, 0xE1, 0xE0,
  0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x0E, 0x78, 0x07, 0xB8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xC0, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFC,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xDC, 0x0E, 0xE0, 0xE7,
  0x07, 0x1C, 0x38, 0xE3, 0x83, 0x9C, 0x1D, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x78, 0x70, 0x70, 0x03, 0x80, 0x3F, 0xE1, 0xFF,
  0xE3, 0xC3, 0xCF, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0xFE, 0x3F, 0xFC,
  0xF8, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0xBF, 0xFF, 0x3F,
  0xFE, 0x3F, 0x9E, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x70, 0x7B, 0xF8, 0xFF, 0xF9, 0xF8, 0xFB, 0xE0, 0xF7,
  0x80, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3B, 0xC0, 0xF7, 0xC1, 0xEF, 0xFF, 0x9F, 0xFF, 0x3D, 0xF8, 0x00, 0x03,
  0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0x1F, 0x78, 0x3F, 0xC0, 0x7F, 0x01, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x1D, 0xE0, 0xF3,
  0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x61, 0xC7, 0xF7, 0x3F, 0xFD, 0xF1, 0xF7, 0x83,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xDE, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xF9, 0xC0, 0x03, 0x80,
  0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x8F, 0x03,
  0x8F, 0xFF, 0x8F, 0xFC, 0x0F, 0xF0, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8,
  0x3E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0xFD, 0xFF,
  0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x7F, 0x73, 0xFF, 0xDF, 0x9F, 0x78, 0x3F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1D, 0xE0, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xDC, 0x00, 0x70, 0x03,
  0xC8, 0x0F, 0x7D, 0xF9, 0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x30, 0x7B, 0xFC, 0xFF,
  0xF9, 0xF8, 0xFB, 0xE0, 0xF7, 0x80, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0x80, 0x02, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0xF0,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0xFB, 0xFE, 0xFF, 0x1C, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x02, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7,
  0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xE0, 0xF1, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x1C, 0xEF, 0xBE, 0xFF, 0xFF, 0xF3, 0xEF, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0x00, 0xC3, 0xDF, 0xEF, 0xFF, 0xBF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1C, 0x07, 0x80, 0x3F, 0xC0, 0xFF, 0xE3,
  0xE7, 0xC7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x03, 0xCF, 0x07, 0x9F, 0xFE, 0x1F, 0xF8,
  0x0F, 0xE0, 0x01, 0xC1, 0xEF, 0xE3, 0xFF, 0xE7, 0xE7, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xEF, 0x03, 0xDF, 0x07, 0xBF, 0xFE, 0x7F, 0xFC, 0xF7, 0xE1, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x7F, 0x73, 0xFF, 0xDF, 0x1F, 0x78, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xE0, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1F, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0xEE, 0x7F, 0xEF, 0xEF, 0xFE, 0xF8, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xE7, 0x01, 0xCE, 0x03, 0x9E, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0x9F, 0x9F, 0x1F, 0xFC, 0x1F,
  0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x78, 0x3D, 0xFF,
  0xF3, 0xFD, 0xC7, 0xE7, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x38, 0x1E,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0xE1, 0xC3, 0xF0, 0xE3, 0xF8, 0xF1, 0xDC, 0x78, 0xEF, 0x3C, 0x73, 0x9F,
  0x39, 0xCD, 0x9C, 0xEE, 0xCC, 0x76, 0x6E, 0x3B, 0x3F, 0x0D, 0x9F, 0x87,
  0xC7, 0xC3, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x38, 0x38, 0x78, 0x0F,
  0x1E, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF7, 0x80, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xDE, 0x01, 0xEF, 0x01,
  0xE3, 0xC1, 0xE0, 0xF0, 0xF0, 0x3D, 0xF0, 0x1F, 0xF0, 0x07, 0xBC, 0x07,
  0x9E, 0x03, 0xC7, 0x01, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x0F, 0x38, 0x07, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0xF0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x3F, 0x0F, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0x70, 0x1F, 0x03, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xF0, 0x3C, 0x1F,
  0x0F, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0x83, 0xE0, 0xE0, 0x20, 0x00, 0x3E, 0x02, 0xBF, 0xC1, 0xBF, 0xF1,
  0xDC, 0x7F, 0xEC, 0x0F, 0xE0, 0x03, 0xE0,
};

const GFXglyph RobotoMono_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 4, 22, 19, 7, -22 },
  { 12, 8, 7, 19, 5, -23 },
  { 19, 17, 22, 19, 1, -22 },
  { 66, 15, 29, 19, 2, -26 },
  { 121, 17, 22, 19, 1, -22 },
  { 168, 17, 22, 19, 1, -22 },
  { 215, 3, 8, 19, 7, -23 },
  { 218, 9, 32, 19, 5, -25 },
  { 254, 8, 32, 19, 5, -25 },
  { 286, 15, 15, 19, 2, -22 },
  { 315, 15, 16, 19, 2, -18 },
  { 345, 5, 10, 19, 5, -4 },
  { 352, 12, 3, 19, 4, -11 },
  { 357, 5, 5, 19, 7, -5 },
  { 361, 12, 24, 19, 4, -22 },
  { 397, 14, 22, 19, 2, -22 },
  { 436, 9, 22, 19, 3, -22 },
  { 461, 15, 22, 19, 1, -22 },
  { 503, 15, 22, 19, 1, -22 },
  { 545, 16, 22, 19, 1, -22 },
  { 589, 15, 22, 19, 2, -22 },
  { 631, 14, 22, 19, 2, -22 },
  { 670, 16, 22, 19, 1, -22 },
  { 714, 15, 22, 19, 2, -22 },
  { 756, 14, 22, 19, 2, -22 },
  { 795, 6, 18, 19, 7, -18 },
  { 809, 6, 24, 19, 7, -18 },
  { 827, 14, 14, 19, 2, -17 },
  { 852, 14, 9, 19, 2, -14 },
  { 868, 13, 14, 19, 3, -17 },
  { 891, 13, 22, 19, 3, -22 },
  { 927, 17, 22, 19, 1, -22 },
  { 974, 17, 22, 19, 1, -22 },
  { 1021, 15, 22, 19, 2, -22 },
  { 1063, 16, 22, 19, 1, -22 },
  { 1107, 15, 22, 19, 2, -22 },
  { 1149, 15, 22, 19, 2, -22 },
  { 1191, 14, 22, 19, 3, -22 },
  { 1230, 16, 22, 19, 1, -22 },
  { 1274, 15, 22, 19, 2, -22 },
  { 1316, 13, 22, 19, 3, -22 },
  { 1352, 14, 22, 19, 2, -22 },
  { 1391, 17, 22, 19, 2, -22 },
  { 1438, 14, 22, 19, 3, -22 },
  { 1477, 15, 22, 19, 2, -22 },
  { 1519, 14, 22, 19, 2, -22 },
  { 1558, 16, 22, 19, 1, -22 },
  { 1602, 15, 22, 19, 3, -22 },
  { 1644, 17, 26, 19, 1, -22 },
  { 1700, 16, 22, 19, 2, -22 },
  { 1744, 15, 22, 19, 2, -22 },
  { 1786, 17, 22, 19, 1, -22 },
  { 1833, 15, 22, 19, 2, -22 },
  { 1875, 17, 22, 19, 1, -22 },
  { 1922, 17, 22, 19, 1, -22 },
  { 1969, 17, 22, 19, 1, -22 },
  { 2016, 17, 22, 19, 1, -22 },
  { 2063, 16, 22, 19, 1, -22 },
  { 2107, 7, 30, 19, 6, -25 },
  { 2134, 12, 24, 19, 4, -22 },
  { 2170, 7, 30, 19, 6, -25 },
  { 2197, 13, 12, 19, 3, -22 },
  { 2217, 14, 3, 19, 2, 0 },
  { 2223, 7, 4, 19, 6, -22 },
  { 2227, 15, 17, 19, 2, -17 },
  { 2259, 15, 23, 19, 2, -23 },
  { 2303, 14, 17, 19, 2, -17 },
  { 2333, 14, 23, 19, 2, -23 },
  { 2374, 15, 17, 19, 2, -17 },
  { 2406, 15, 24, 19, 2, -24 },
  { 2451, 14, 23, 19, 2, -17 },
  { 2492, 15, 23, 19, 2, -23 },
  { 2536, 14, 23, 19, 3, -23 },
  { 2577, 10, 30, 19, 3, -23 },
  { 2615, 16, 23, 19, 2, -23 },
  { 2661, 14, 23, 19, 3, -23 },
  { 2702, 16, 17, 19, 1, -17 },
  { 2736, 14, 17, 19, 2, -17 },
  { 2766, 15, 17, 19, 2, -17 },
  { 2798, 15, 23, 19, 2, -17 },
  { 2842, 14, 23, 19, 2, -17 },
  { 2883, 12, 17, 19, 5, -17 },
  { 2909, 15, 17, 19, 2, -17 },
  { 2941, 14, 20, 19, 2, -20 },
  { 2976, 14, 16, 19, 2, -16 },
  { 3004, 16, 16, 19, 1, -16 },
  { 3036, 17, 16, 19, 1, -16 },
  { 3070, 17, 16, 19, 1, -16 },
  { 3104, 17, 23, 19, 1, -16 },
  { 3153, 15, 16, 19, 2, -16 },
  { 3183, 10, 30, 19, 5, -24 },
  { 3221, 3, 28, 19, 8, -22 },
  { 3232, 10, 30, 19, 5, -24 },
  { 3270, 17, 6, 19, 1, -12 },
};

const GFXfont RobotoMono_Medium31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium31pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_MEDIUM31PT7B_H_
