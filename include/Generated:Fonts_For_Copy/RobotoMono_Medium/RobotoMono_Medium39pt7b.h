#ifndef _ROBOTOMONO_MEDIUM39PT7B_H_
#define _ROBOTOMONO_MEDIUM39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xF0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xE1, 0xC0, 0x00, 0xE1, 0xE0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x7D, 0xE0,
  0x0F, 0x78, 0x03, 0xDF, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0x7F, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x38, 0x70, 0x40, 0xE1, 0xC1, 0x83, 0x87, 0x0E, 0x0E,
  0x1C, 0x70, 0x38, 0x71, 0xC0, 0xE1, 0xCE, 0x03, 0xFF, 0x38, 0x07, 0xF9,
  0xC0, 0x0F, 0xC7, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x07, 0x1F, 0xC0, 0x1C, 0xFF, 0x80,
  0xE7, 0x8E, 0x03, 0x9C, 0x3C, 0x1C, 0x70, 0xF0, 0x71, 0xC3, 0xC3, 0x87,
  0x0F, 0x00, 0x1E, 0x38, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xE1,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3C, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x00,
  0xF1, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x1E, 0x7D, 0xF0, 0xF3, 0xC7, 0xC7, 0xBE,
  0x1F, 0x3D, 0xE0, 0xFD, 0xEF, 0x03, 0xFE, 0x78, 0x0F, 0xF3, 0xE0, 0x3F,
  0x1F, 0x01, 0xF8, 0x7E, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0x7C, 0x1F,
  0xE1, 0xF0, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0x00, 0x80, 0x70, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x02, 0x40, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81,
  0xE0, 0x38, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x81, 0xC0, 0x1C, 0x38, 0x77, 0xE7, 0x3E, 0xFF,
  0xFF, 0xE7, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0x78, 0x03, 0xC7, 0x00, 0xF8, 0xF0, 0x1E, 0x0F, 0x07, 0x81, 0xF0, 0x30,
  0x18, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3C, 0xF3, 0xCF, 0x7D, 0xF7, 0x9E, 0xFB, 0xC6, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E,
  0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7D, 0xFF, 0x3E, 0x7F, 0xDE, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xBE,
  0x01, 0xEF, 0x80, 0xF9, 0xF0, 0x3E, 0x7F, 0x3F, 0x0F, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x20, 0x1C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0x78, 0x03, 0xC7,
  0x80, 0x3E, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0x7F, 0x3F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xEF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x78,
  0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C,
  0x0F, 0x87, 0x80, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xBF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE3, 0x81, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7B, 0xF0, 0x3E, 0x7F,
  0x3F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE7, 0xF0, 0x3D, 0xFF,
  0x8F, 0xFF, 0xF9, 0xFF, 0x7F, 0x3F, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x03,
  0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x07,
  0x9F, 0x01, 0xF1, 0xF0, 0x3E, 0x3F, 0xBF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xE7, 0xC0, 0xF9, 0xF8,
  0x7C, 0x3F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F,
  0xBE, 0x03, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3E, 0x7E, 0x3F, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F,
  0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x0F,
  0x9F, 0x01, 0xE7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x01, 0xF7, 0xE0, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFE, 0xF0, 0x3E, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x80,
  0x3C, 0xFD, 0xFB, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF3, 0xC7,
  0x86, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFF, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x0F, 0xBE, 0x01,
  0xEF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0x07,
  0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x38, 0xE0, 0xF0, 0xC7, 0x0F, 0xE7, 0x70,
  0xFF, 0x3B, 0x8E, 0x39, 0xD8, 0xF1, 0xC7, 0xC7, 0x0E, 0x3E, 0x38, 0x61,
  0xF1, 0xC3, 0x0F, 0x9C, 0x18, 0x7C, 0xE0, 0xC7, 0xE7, 0x0E, 0x3F, 0x38,
  0x71, 0xB8, 0xE3, 0x8D, 0xC7, 0xFF, 0xE6, 0x3F, 0x7E, 0x38, 0xF1, 0xE1,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x02, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x7C, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x00,
  0xF9, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01, 0xFD, 0xE0, 0x0F, 0xBC,
  0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78,
  0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0x81, 0xFC, 0xF0,
  0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7C, 0x3F, 0x9F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0x07, 0xF1, 0xE0, 0x3F, 0x3C, 0x03, 0xE7, 0x80, 0x3E, 0xF0, 0x07, 0xDE,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78,
  0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0x3C, 0x07, 0xE7, 0x81, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE3, 0xE0, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDF, 0x00, 0x79, 0xF0, 0x1F,
  0x3F, 0xCF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x01, 0xF3, 0xE0, 0x7E, 0x7F, 0xBF,
  0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFF, 0x00,
  0x7E, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x1F, 0x8F, 0x03, 0xF0, 0xF0,
  0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xFC, 0x0F, 0x1F, 0x80, 0xF1, 0xF0, 0x0F,
  0x3E, 0x00, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFE, 0xF8, 0x0F, 0xCF, 0xC0, 0xF8, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x3F,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00,
  0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFF, 0x3B, 0xFF, 0xCE, 0xFF, 0x77, 0xBF, 0xDF, 0xCF,
  0xF7, 0xF3, 0xFC, 0xFC, 0xFF, 0x3E, 0x3F, 0xCF, 0x8F, 0xF1, 0xE3, 0xFC,
  0x78, 0xFF, 0x1C, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xEF, 0x0F, 0xFD, 0xE1, 0xFF, 0x9E, 0x3F, 0xF3, 0xC7, 0xFE, 0x3C, 0xFF,
  0xC7, 0x9F, 0xF8, 0x7B, 0xFF, 0x0F, 0x7F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x0F, 0xC7, 0xC0, 0x7C, 0x78, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xE7,
  0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x3F, 0xBF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7D,
  0xF0, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xE0,
  0xFC, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xE7,
  0xC0, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00,
  0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0xC0, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x40, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x01, 0xFD, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0xFD, 0xE0, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1E, 0x0F, 0x83, 0xC0, 0xF8,
  0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0x80, 0x7C,
  0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0,
  0x3E, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x3F, 0x8F,
  0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80,
  0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00,
  0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00,
  0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xFC, 0x01,
  0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x3E, 0x3F, 0xBF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0xC0,
  0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x00,
  0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBE,
  0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x78,
  0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xBC, 0x1E, 0x1E, 0xF8, 0xF8, 0x79,
  0xE3, 0xE1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x79, 0xE3,
  0xF3, 0xE7, 0x9F, 0xCF, 0x1E, 0x7F, 0x3C, 0x7D, 0xDE, 0xF0, 0xF7, 0x7B,
  0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3F, 0xCE, 0xF0, 0xFF, 0x3B, 0xC3,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x3C,
  0x07, 0xC0, 0xF0, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3D, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x87,
  0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xF1,
  0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00,
  0x78, 0xF8, 0x01, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0E, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x38, 0x3C,
  0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x7F, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFC, 0x3E, 0xF8,
  0x0F, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3E, 0xF8, 0x1F, 0xBF, 0x1F,
  0xEF, 0xFF, 0xF9, 0xFF, 0xDE, 0x1F, 0xE7, 0xC0, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF9, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFC,
  0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1E, 0xFC, 0x0F, 0xBF, 0xCF, 0xEF, 0xFF, 0xF3, 0xDF, 0xF8, 0xF3,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xE0, 0x7C, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1F, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0xFB, 0xE0, 0x1E, 0x3E, 0x07, 0xC7, 0xE3, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xE3,
  0xC3, 0xFE, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3E, 0x0F, 0xDF, 0x01, 0xF7,
  0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x0F, 0x7E, 0x07,
  0xCF, 0xC7, 0xF1, 0xFF, 0xFC, 0x3F, 0xEF, 0x07, 0xF3, 0xC0, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07,
  0x9F, 0x00, 0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x04,
  0x3E, 0x01, 0xC7, 0xF8, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF3, 0xE1, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xE0, 0xFE,
  0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x7E, 0x07, 0xE7, 0xF3, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x80, 0x3E, 0x38, 0x0F, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0xFC, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFC, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x06, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0xEF, 0xE7, 0xFF, 0x3F, 0xF1,
  0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xDF,
  0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x3E,
  0x7C, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8,
  0x3F, 0x1F, 0x03, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0x7E, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF3, 0xC7, 0x8F, 0xFE, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF1,
  0xF1, 0xFF, 0x0F, 0x1F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xF0, 0xFC, 0x3C, 0xFF, 0x8F, 0x7F,
  0xF3, 0xFF, 0xFE, 0xFC, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xE0, 0x1E, 0x7E, 0x07, 0xC7, 0xE3,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xF1, 0xF8, 0x3D, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF, 0x8F,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFB, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3E,
  0x0F, 0xDF, 0x01, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D,
  0xF0, 0x0F, 0x7E, 0x07, 0xCF, 0xC7, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x07,
  0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0xFF, 0xE3, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFD, 0xFE, 0x7C, 0x0F, 0xBE,
  0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7F, 0x18, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C,
  0x0F, 0xDF, 0x9F, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xE7, 0xC0, 0xF0,
  0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xC3,
  0xC0, 0x7C, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0xBC,
  0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0xF0, 0x70, 0x7F, 0xC1, 0xC1, 0xEF, 0x07, 0x87,
  0xBC, 0x3E, 0x1E, 0xF0, 0xF8, 0x79, 0xE3, 0xE1, 0xE7, 0x8F, 0x87, 0x1E,
  0x37, 0x3C, 0x79, 0xDC, 0xF1, 0xE7, 0x73, 0xC3, 0x9D, 0xCF, 0x0E, 0x73,
  0xB8, 0x3D, 0x8E, 0xE0, 0xFE, 0x3B, 0x83, 0xF8, 0xFE, 0x07, 0xE3, 0xF8,
  0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F,
  0x03, 0xC0, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xDF, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x3E,
  0x07, 0xC7, 0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7D, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0x78,
  0x78, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0xC0, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x7F, 0x07, 0xE0, 0x3E, 0x01, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xE0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xF8, 0x0F, 0xC0,
  0x3E, 0x07, 0xF0, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x3F, 0x01, 0xF0, 0x06, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFC, 0x01,
  0x1F, 0xF8, 0x0E, 0xFF, 0xE0, 0xFF, 0x9F, 0xCF, 0xF0, 0x3F, 0xFB, 0x80,
  0xFF, 0xC4, 0x03, 0xFC, 0x00, 0x03, 0x00,
};

const GFXglyph RobotoMono_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 28, 23, 9, -28 },
  { 19, 11, 9, 23, 6, -29 },
  { 32, 21, 28, 23, 1, -28 },
  { 106, 18, 36, 23, 3, -32 },
  { 187, 22, 28, 23, 1, -28 },
  { 264, 21, 28, 23, 2, -28 },
  { 338, 4, 10, 23, 9, -29 },
  { 343, 10, 40, 23, 7, -31 },
  { 393, 11, 40, 23, 6, -31 },
  { 448, 19, 19, 23, 3, -28 },
  { 494, 19, 20, 23, 2, -23 },
  { 542, 6, 11, 23, 7, -4 },
  { 551, 15, 4, 23, 5, -14 },
  { 559, 6, 6, 23, 9, -6 },
  { 564, 16, 30, 23, 4, -28 },
  { 624, 18, 28, 23, 3, -28 },
  { 687, 11, 28, 23, 4, -28 },
  { 726, 20, 28, 23, 1, -28 },
  { 796, 18, 28, 23, 2, -28 },
  { 859, 20, 28, 23, 1, -28 },
  { 929, 18, 28, 23, 3, -28 },
  { 992, 19, 28, 23, 2, -28 },
  { 1059, 19, 28, 23, 2, -28 },
  { 1126, 18, 28, 23, 3, -28 },
  { 1189, 18, 28, 23, 2, -28 },
  { 1252, 7, 22, 23, 9, -22 },
  { 1272, 7, 29, 23, 9, -22 },
  { 1298, 17, 18, 23, 3, -21 },
  { 1337, 18, 12, 23, 3, -18 },
  { 1364, 17, 18, 23, 3, -21 },
  { 1403, 18, 28, 23, 3, -28 },
  { 1466, 21, 28, 23, 1, -28 },
  { 1540, 22, 28, 23, 1, -28 },
  { 1617, 19, 28, 23, 3, -28 },
  { 1684, 20, 28, 23, 2, -28 },
  { 1754, 19, 28, 23, 3, -28 },
  { 1821, 18, 28, 23, 3, -28 },
  { 1884, 18, 28, 23, 3, -28 },
  { 1947, 19, 28, 23, 2, -28 },
  { 2014, 19, 28, 23, 2, -28 },
  { 2081, 16, 28, 23, 4, -28 },
  { 2137, 19, 28, 23, 2, -28 },
  { 2204, 20, 28, 23, 3, -28 },
  { 2274, 18, 28, 23, 3, -28 },
  { 2337, 18, 28, 23, 3, -28 },
  { 2400, 19, 28, 23, 2, -28 },
  { 2467, 20, 28, 23, 2, -28 },
  { 2537, 19, 28, 23, 3, -28 },
  { 2604, 21, 33, 23, 2, -28 },
  { 2691, 19, 28, 23, 3, -28 },
  { 2758, 20, 28, 23, 2, -28 },
  { 2828, 22, 28, 23, 1, -28 },
  { 2905, 19, 28, 23, 2, -28 },
  { 2972, 21, 28, 23, 1, -28 },
  { 3046, 22, 28, 23, 1, -28 },
  { 3123, 22, 28, 23, 1, -28 },
  { 3200, 22, 28, 23, 1, -28 },
  { 3277, 19, 28, 23, 2, -28 },
  { 3344, 8, 38, 23, 8, -32 },
  { 3382, 16, 30, 23, 4, -28 },
  { 3442, 8, 38, 23, 8, -32 },
  { 3480, 16, 15, 23, 4, -28 },
  { 3510, 17, 4, 23, 3, 0 },
  { 3519, 8, 5, 23, 8, -28 },
  { 3524, 18, 21, 23, 3, -21 },
  { 3572, 18, 29, 23, 3, -29 },
  { 3638, 19, 21, 23, 2, -21 },
  { 3688, 18, 29, 23, 2, -29 },
  { 3754, 19, 21, 23, 2, -21 },
  { 3804, 19, 30, 23, 3, -30 },
  { 3876, 19, 29, 23, 2, -21 },
  { 3945, 18, 29, 23, 3, -29 },
  { 4011, 17, 28, 23, 4, -28 },
  { 4071, 13, 36, 23, 4, -28 },
  { 4130, 19, 29, 23, 3, -29 },
  { 4199, 17, 29, 23, 4, -29 },
  { 4261, 20, 21, 23, 2, -21 },
  { 4314, 18, 21, 23, 3, -21 },
  { 4362, 19, 21, 23, 2, -21 },
  { 4412, 18, 29, 23, 3, -21 },
  { 4478, 18, 29, 23, 2, -21 },
  { 4544, 15, 21, 23, 6, -21 },
  { 4584, 18, 21, 23, 3, -21 },
  { 4632, 18, 26, 23, 3, -26 },
  { 4691, 18, 21, 23, 3, -21 },
  { 4739, 20, 21, 23, 2, -21 },
  { 4792, 22, 21, 23, 1, -21 },
  { 4850, 20, 21, 23, 2, -21 },
  { 4903, 22, 29, 23, 1, -21 },
  { 4983, 18, 21, 23, 3, -21 },
  { 5031, 13, 37, 23, 6, -30 },
  { 5092, 3, 36, 23, 10, -28 },
  { 5106, 13, 37, 23, 6, -30 },
  { 5167, 21, 9, 23, 1, -16 },
};

const GFXfont RobotoMono_Medium39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium39pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_MEDIUM39PT7B_H_
