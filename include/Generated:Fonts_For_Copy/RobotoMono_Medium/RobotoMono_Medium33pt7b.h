#ifndef _ROBOTOMONO_MEDIUM33PT7B_H_
#define _ROBOTOMONO_MEDIUM33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0xFF,
  0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x03, 0x87,
  0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0E, 0x00, 0xC3, 0x87,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0x87, 0x00, 0x61, 0xC0, 0x38,
  0x60, 0x0E, 0x18, 0x03, 0x8E, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x0C, 0x30,
  0x07, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x06, 0x1C, 0x03,
  0x86, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0x7E, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F,
  0x7C, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0x8C, 0x20, 0xC3,
  0x8E, 0x30, 0xE7, 0x0C, 0x39, 0x83, 0x9C, 0xE0, 0xFF, 0x30, 0x1F, 0x9C,
  0x00, 0x86, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0xF0,
  0x0E, 0xFE, 0x07, 0x3B, 0xC1, 0x9C, 0x70, 0xE7, 0x1C, 0x31, 0xC7, 0x04,
  0x71, 0xC0, 0x1E, 0x70, 0x03, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x07, 0x0F,
  0x00, 0xE1, 0xC0, 0x1E, 0x78, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0xC3, 0x8F, 0x78, 0x73, 0xC7, 0x9E, 0x78, 0xFB,
  0xDE, 0x0F, 0xF3, 0xC0, 0xFE, 0x3C, 0x0F, 0x87, 0x83, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0xFF, 0xB6, 0xC0, 0x03, 0x07, 0x0F,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x38,
  0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x40, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x03,
  0x83, 0x81, 0xC1, 0xC1, 0xC1, 0xE0, 0x40, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0xC3, 0x86, 0xF3, 0x9E, 0xFF, 0xFE, 0x3F, 0xFD,
  0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x70, 0x78, 0x3C,
  0x38, 0x38, 0x10, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x7B, 0xDE, 0xF7, 0xBD, 0xDE, 0xE3, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x78, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3E, 0x7C, 0x78, 0x1E, 0x78, 0x1E, 0x70,
  0x1E, 0xF0, 0x0E, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xEF, 0xF3,
  0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x78,
  0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01,
  0xC3, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7E,
  0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0F, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x03, 0x80, 0x3F, 0xE1, 0xFF, 0xE3, 0xE7, 0xEF,
  0x03, 0xDE, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x07,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x83, 0xCF, 0xFF, 0x8F, 0xFE, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F,
  0x03, 0x87, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC,
  0x38, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x0E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x00, 0x10, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x81, 0xEF, 0xE3, 0xFF, 0xF7, 0xFF, 0xEF, 0x83,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7B,
  0xC0, 0xF7, 0xC3, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x1F, 0xF0, 0x3F, 0xFC, 0x7E, 0x7C, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0xFF,
  0xCF, 0xFF, 0x8F, 0xEF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x3F, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x77, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xFE, 0x3C, 0xF9, 0xFB, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0x8F, 0x1E, 0x78, 0x60, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC0, 0xFF,
  0x0F, 0xF9, 0xFF, 0x0F, 0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x00, 0xFC, 0x1F, 0xF3, 0xFE, 0x3F, 0xE0,
  0xFE, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xC7, 0xFF, 0xBF,
  0xBF, 0xF0, 0x3F, 0xC0, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0x70, 0x0C, 0x38, 0x03, 0x9C,
  0x7E, 0x66, 0x3F, 0x99, 0x8C, 0x67, 0xE7, 0x18, 0xF1, 0x86, 0x3C, 0x61,
  0x8F, 0x38, 0x63, 0xCE, 0x39, 0xB3, 0x8E, 0x6C, 0xE3, 0x9B, 0x9D, 0xEE,
  0xE7, 0xDF, 0x18, 0xE3, 0x87, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x18, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x07, 0x3C,
  0x03, 0xCF, 0x00, 0xF1, 0xC0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x83, 0x81,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x1E, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x07, 0xE7,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03,
  0xDE, 0x07, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xF0, 0x03,
  0xFE, 0x07, 0xFF, 0x83, 0xE7, 0xE3, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xDE,
  0x01, 0xE7, 0x81, 0xF3, 0xE1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xF7, 0xE3, 0xC0,
  0xF3, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0xE0, 0x0F,
  0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xE7, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x03, 0xE3, 0xC0,
  0xF0, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x3D, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F,
  0x8F, 0x03, 0xC3, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0,
  0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xF7, 0xEF, 0xF7, 0xEF,
  0xF7, 0xEF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0x8F, 0xF1, 0x8F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F,
  0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xF3, 0xC0,
  0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xE7, 0x81, 0xE3, 0xE1, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x0F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x3C, 0x3E, 0x1F,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x38, 0x00, 0x04, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03,
  0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x0F, 0xBC, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xCF, 0xC7, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x78, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xE7,
  0xC1, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF0, 0x07,
  0xFE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x1C, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x1D, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xE1, 0xE1, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x78, 0xE7, 0x3F, 0x39, 0xCF, 0xCE, 0x73, 0xF3, 0x9C, 0xFC,
  0xE7, 0xBF, 0x79, 0xEC, 0xDE, 0x7F, 0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0x07, 0xDF, 0x01, 0xE3, 0xC0,
  0xF0, 0xF8, 0x3C, 0x1E, 0x1E, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3C, 0xF0, 0x0F, 0x3E, 0x07, 0x87, 0x83, 0xE1,
  0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x3C, 0xF0, 0x07,
  0xDE, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xDE, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x78,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1C, 0xE0, 0xE7, 0x0F, 0x1C, 0x70, 0xE3,
  0x87, 0xB8, 0x1D, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0xF0, 0xF0, 0xE0, 0xE0, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7C, 0x7C,
  0x78, 0x1E, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE,
  0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFE,
  0x7F, 0xFE, 0x1F, 0xDF, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x71, 0xE0, 0xEF, 0xF1, 0xFF, 0xF3, 0xF3,
  0xF7, 0x81, 0xEE, 0x03, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEF, 0x03, 0xDF, 0x0F, 0xBF, 0xFE, 0x77,
  0xFC, 0xE7, 0xE0, 0x03, 0xC0, 0x1F, 0xF0, 0xFF, 0xF1, 0xF3, 0xF7, 0x81,
  0xEF, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0xEF, 0x03, 0xDF, 0x07, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x83, 0xCF, 0x1F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xC0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xF7, 0x81, 0xEF, 0x87, 0xCF, 0xFF, 0x9F, 0xF7, 0x0F, 0xCE,
  0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7E, 0x78, 0x1E, 0x78, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x04, 0x7C, 0x0E, 0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x3F, 0xDC, 0xFF, 0xFB, 0xFB, 0xF7, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xEF, 0x03, 0xDF, 0x0F, 0x9F, 0xFF, 0x3F, 0xFE, 0x1F, 0xBC,
  0x00, 0x78, 0x00, 0xF3, 0x01, 0xEF, 0x8F, 0x9F, 0xFF, 0x0F, 0xF8, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0xE0, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0x7E, 0xF8,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xDF,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x3E, 0xFF,
  0xBF, 0xCF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x02, 0xE0, 0x7C, 0xE0, 0xF8, 0xE1,
  0xF0, 0xE3, 0xE0, 0xE7, 0xC0, 0xE7, 0x80, 0xEF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFB, 0xC0, 0xF3, 0xE0, 0xE1, 0xF0, 0xE0, 0xF0, 0xE0, 0xF8, 0xE0,
  0x7C, 0xE0, 0x3E, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x8E, 0x7F, 0xEF, 0xBF, 0xFF, 0xFF, 0x7E,
  0xFF, 0x1E, 0x3F, 0x8F, 0x1F, 0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8,
  0xF1, 0xFC, 0x78, 0xFE, 0x3C, 0x7F, 0x1E, 0x3F, 0x8F, 0x1F, 0xC7, 0x8F,
  0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xC0, 0x00, 0xE0, 0xF3, 0xFC, 0xF7,
  0xFC, 0xFF, 0x7E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xC0, 0x1F, 0xF0, 0x3F,
  0xFC, 0x7E, 0xFC, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7C,
  0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xC1, 0xDF, 0xE3, 0xFF,
  0xE7, 0xEF, 0xCF, 0x07, 0xDC, 0x07, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xDE, 0x07, 0xBC, 0x1F, 0x7F,
  0xFC, 0xFF, 0xF1, 0xCF, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xDC, 0xFF, 0xFB,
  0xF3, 0xF7, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xEF, 0x03, 0xDF, 0x0F, 0x9F, 0xFF,
  0x3F, 0xFE, 0x1F, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF7, 0x9F, 0xFF, 0xFD, 0xFF, 0xEF,
  0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x78,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xF7, 0xFF, 0xDF, 0xF7, 0x3F,
  0x9C, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF0,
  0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x0E, 0x3C, 0x07, 0x9E, 0x01, 0xCE,
  0x00, 0xEF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE1, 0xC3, 0xF8, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8E, 0x71,
  0xE3, 0x9C, 0xF8, 0xE7, 0x3F, 0x39, 0xCD, 0xDE, 0x73, 0x37, 0x1F, 0xCD,
  0xC3, 0xF3, 0x70, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0x87, 0x83, 0xE1, 0xE0,
  0x78, 0x78, 0x1C, 0x1E, 0x00, 0xF8, 0x0F, 0xBC, 0x0F, 0x0F, 0x0F, 0x83,
  0xC7, 0x81, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xFC, 0x03, 0xEF, 0x01, 0xE7, 0xC1, 0xE1, 0xE1, 0xF0,
  0x78, 0xF0, 0x3E, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xDE, 0x01, 0xE7, 0x80,
  0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78,
  0x0F, 0x1C, 0x03, 0xCF, 0x00, 0x7B, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40,
  0x3C, 0x0F, 0x83, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x07, 0xC0, 0x78, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x40, 0x1E, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0xFC, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0x00, 0x3E, 0x00,
  0x1F, 0xE0, 0x7F, 0xFC, 0x3B, 0x8F, 0xFE, 0xC0, 0xFF, 0xB0, 0x1F, 0xC0,
  0x01, 0xC0,
};

const GFXglyph RobotoMono_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 23, 20, 8, -23 },
  { 13, 9, 8, 20, 5, -25 },
  { 22, 18, 23, 20, 1, -23 },
  { 74, 16, 30, 20, 2, -27 },
  { 134, 18, 24, 20, 1, -24 },
  { 188, 19, 24, 20, 1, -24 },
  { 245, 3, 9, 20, 8, -25 },
  { 249, 8, 33, 20, 6, -26 },
  { 282, 9, 33, 20, 5, -26 },
  { 320, 16, 16, 20, 3, -23 },
  { 352, 16, 17, 20, 2, -19 },
  { 386, 5, 10, 20, 6, -4 },
  { 393, 13, 3, 20, 4, -12 },
  { 398, 6, 5, 20, 7, -5 },
  { 402, 13, 25, 20, 4, -23 },
  { 443, 16, 24, 20, 2, -24 },
  { 491, 10, 23, 20, 3, -23 },
  { 520, 16, 24, 20, 1, -24 },
  { 568, 15, 24, 20, 2, -24 },
  { 613, 17, 23, 20, 1, -23 },
  { 662, 16, 23, 20, 2, -23 },
  { 708, 15, 24, 20, 2, -24 },
  { 753, 17, 23, 20, 1, -23 },
  { 802, 16, 24, 20, 2, -24 },
  { 850, 15, 24, 20, 2, -24 },
  { 895, 5, 19, 20, 8, -19 },
  { 907, 7, 25, 20, 7, -19 },
  { 929, 14, 15, 20, 3, -18 },
  { 956, 15, 10, 20, 3, -15 },
  { 975, 14, 15, 20, 3, -18 },
  { 1002, 14, 24, 20, 3, -24 },
  { 1044, 18, 23, 20, 1, -23 },
  { 1096, 18, 23, 20, 1, -23 },
  { 1148, 17, 23, 20, 2, -23 },
  { 1197, 17, 24, 20, 1, -24 },
  { 1248, 16, 23, 20, 2, -23 },
  { 1294, 15, 23, 20, 3, -23 },
  { 1338, 15, 23, 20, 3, -23 },
  { 1382, 17, 24, 20, 1, -24 },
  { 1433, 16, 23, 20, 2, -23 },
  { 1479, 14, 23, 20, 3, -23 },
  { 1520, 15, 23, 20, 2, -23 },
  { 1564, 18, 23, 20, 2, -23 },
  { 1616, 15, 23, 20, 3, -23 },
  { 1660, 16, 23, 20, 2, -23 },
  { 1706, 16, 23, 20, 2, -23 },
  { 1752, 17, 24, 20, 1, -24 },
  { 1803, 16, 23, 20, 3, -23 },
  { 1849, 18, 28, 20, 1, -24 },
  { 1912, 17, 23, 20, 2, -23 },
  { 1961, 17, 24, 20, 2, -24 },
  { 2012, 18, 23, 20, 1, -23 },
  { 2064, 16, 23, 20, 2, -23 },
  { 2110, 18, 23, 20, 1, -23 },
  { 2162, 18, 23, 20, 1, -23 },
  { 2214, 18, 23, 20, 1, -23 },
  { 2266, 18, 23, 20, 1, -23 },
  { 2318, 16, 23, 20, 2, -23 },
  { 2364, 6, 32, 20, 7, -27 },
  { 2388, 13, 25, 20, 4, -23 },
  { 2429, 7, 32, 20, 6, -27 },
  { 2457, 13, 12, 20, 4, -23 },
  { 2477, 15, 3, 20, 2, 0 },
  { 2483, 7, 5, 20, 7, -24 },
  { 2488, 16, 18, 20, 2, -18 },
  { 2524, 15, 25, 20, 3, -25 },
  { 2571, 15, 18, 20, 2, -18 },
  { 2605, 15, 25, 20, 2, -25 },
  { 2652, 16, 18, 20, 2, -18 },
  { 2688, 16, 25, 20, 2, -25 },
  { 2738, 15, 25, 20, 2, -18 },
  { 2785, 16, 25, 20, 2, -25 },
  { 2835, 15, 24, 20, 3, -24 },
  { 2880, 10, 31, 20, 4, -24 },
  { 2919, 16, 25, 20, 3, -25 },
  { 2969, 15, 25, 20, 3, -25 },
  { 3016, 17, 18, 20, 1, -18 },
  { 3055, 16, 18, 20, 2, -18 },
  { 3091, 16, 18, 20, 2, -18 },
  { 3127, 15, 25, 20, 3, -18 },
  { 3174, 15, 25, 20, 2, -18 },
  { 3221, 13, 18, 20, 5, -18 },
  { 3251, 16, 18, 20, 2, -18 },
  { 3287, 16, 22, 20, 2, -22 },
  { 3331, 14, 17, 20, 3, -17 },
  { 3361, 17, 17, 20, 1, -17 },
  { 3398, 18, 17, 20, 1, -17 },
  { 3437, 17, 17, 20, 2, -17 },
  { 3474, 18, 24, 20, 1, -17 },
  { 3528, 16, 17, 20, 2, -17 },
  { 3562, 11, 32, 20, 5, -26 },
  { 3606, 2, 30, 20, 9, -23 },
  { 3614, 11, 32, 20, 5, -26 },
  { 3658, 18, 7, 20, 1, -13 },
};

const GFXfont RobotoMono_Medium33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium33pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_MEDIUM33PT7B_H_
