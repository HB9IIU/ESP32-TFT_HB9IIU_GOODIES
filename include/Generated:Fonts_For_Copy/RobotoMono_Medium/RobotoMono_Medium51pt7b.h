#ifndef _ROBOTOMONO_MEDIUM51PT7B_H_
#define _ROBOTOMONO_MEDIUM51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFF, 0xFF, 0xF3, 0xE0, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xBC, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7E,
  0x7F, 0x00, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x78, 0x3E, 0x04, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x3C, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x1F, 0x1E,
  0x01, 0xF0, 0xF1, 0xE0, 0x07, 0xFF, 0x8F, 0x00, 0x3F, 0xFC, 0xF0, 0x00,
  0xFF, 0xC7, 0x80, 0x01, 0xF8, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x07, 0x8F, 0xFC,
  0x00, 0x78, 0xFF, 0xE0, 0x03, 0xCF, 0x8F, 0x80, 0x3C, 0x78, 0x3C, 0x01,
  0xE3, 0xC1, 0xF0, 0x1E, 0x1E, 0x0F, 0x80, 0xF0, 0xF0, 0x7C, 0x0F, 0x07,
  0x83, 0xE0, 0x18, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x3E, 0x3F, 0x3F, 0x83, 0xE7,
  0xF1, 0xFC, 0x3E, 0x7E, 0x0F, 0xE7, 0xEF, 0xE0, 0x7E, 0x7E, 0xFC, 0x07,
  0xF7, 0xCF, 0xC0, 0x3F, 0xFC, 0xFC, 0x01, 0xFF, 0x8F, 0xC0, 0x0F, 0xF8,
  0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xC7, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0x07,
  0xF0, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x00, 0x00, 0x10, 0x01, 0x80, 0x1E, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x60, 0x00, 0x80, 0x40, 0x01, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0x00, 0xF0, 0x00, 0xE0,
  0x78, 0x0C, 0x7C, 0x3C, 0x1F, 0x7F, 0xCE, 0x7F, 0xBF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xE0, 0x3C, 0x03,
  0xE0, 0x0E, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0xFC, 0xF8, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF,
  0xFF, 0xFD, 0xFC, 0x7E, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7E, 0xFF,
  0xF1, 0xF9, 0xFF, 0xE7, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x80, 0xFC, 0x3F, 0xCF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x7C, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF8, 0x7F, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F,
  0xE1, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0x00, 0x7E, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F,
  0x00, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x07,
  0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE1, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFE, 0x0F, 0xF8, 0x70, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0xE3,
  0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x7C, 0xFF, 0xE0, 0xFD, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x80,
  0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE,
  0x3F, 0xE7, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xF8,
  0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xBE, 0x07, 0xFF, 0x7E, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x3F, 0xBF,
  0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xFD, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xE7, 0xE0, 0x40, 0x0E, 0x07, 0xE3, 0xFC, 0xFF,
  0x7F, 0xCF, 0xF3, 0xFC, 0x7E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xF8, 0x7F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC1, 0xF0,
  0x18, 0x1E, 0x1E, 0x0F, 0xF0, 0xE3, 0xC1, 0xFF, 0x8E, 0x3C, 0x3F, 0xF8,
  0xF3, 0x83, 0xC7, 0x8F, 0x78, 0x78, 0x78, 0x77, 0x87, 0x87, 0x87, 0x70,
  0xF0, 0x78, 0x77, 0x0F, 0x07, 0x87, 0xF0, 0xF0, 0x70, 0x7F, 0x0E, 0x07,
  0x07, 0xF1, 0xE0, 0x70, 0x7F, 0x1E, 0x07, 0x0F, 0xF1, 0xE0, 0x70, 0xEF,
  0x1E, 0x07, 0x0E, 0xF1, 0xE0, 0xF0, 0xEF, 0x0F, 0x0F, 0x1E, 0x70, 0xFB,
  0xF3, 0xC7, 0x8F, 0xFF, 0xFC, 0x78, 0x7F, 0x7F, 0x87, 0x83, 0xE3, 0xF0,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x0F, 0xF3, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF0,
  0x0F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x03,
  0xFB, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF8, 0x01,
  0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0xE3, 0xF0, 0x07, 0xF9, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x1F,
  0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F,
  0xC1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0xC0,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x7F, 0x0F, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0xE7, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFC,
  0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xF3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x7F,
  0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFB, 0xF8, 0x01, 0xFF, 0x7F,
  0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x0F,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xF7, 0xFF,
  0xBC, 0xFB, 0xFF, 0xDF, 0x7D, 0xFF, 0xEF, 0xBC, 0xFF, 0xF3, 0xDE, 0x7F,
  0xF9, 0xFF, 0x3F, 0xFC, 0xFF, 0x9F, 0xFE, 0x3F, 0x8F, 0xFF, 0x1F, 0xC7,
  0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xE1, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8,
  0x7F, 0xF8, 0x78, 0x3F, 0xFC, 0x1C, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFD, 0xF0, 0x3F, 0xFD, 0xF0, 0x3F, 0xFD, 0xF8, 0x3F,
  0xFC, 0xF8, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x3E, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x1F, 0x3F, 0xFC, 0x1F, 0xBF,
  0xFC, 0x0F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFC,
  0xFF, 0x81, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE,
  0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x47, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC,
  0xFC, 0x03, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF9, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xF0,
  0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xFE, 0x01, 0xFE, 0x3F,
  0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8,
  0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xE0,
  0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7C, 0xF8, 0x3F, 0x03, 0xE7, 0xC1, 0xF8,
  0x1F, 0x3E, 0x0F, 0xE0, 0xF9, 0xF0, 0x7F, 0x0F, 0xCF, 0xC3, 0xF8, 0x7E,
  0x7E, 0x1F, 0xC3, 0xF3, 0xF0, 0xFE, 0x1F, 0x8F, 0x8F, 0xF0, 0xF8, 0x7C,
  0x7F, 0xC7, 0xC3, 0xE3, 0xFE, 0x3E, 0x1F, 0x1E, 0xF1, 0xF0, 0xF8, 0xF7,
  0x8F, 0x87, 0xC7, 0xBC, 0xFC, 0x3F, 0x7D, 0xE7, 0xE1, 0xFB, 0xEF, 0xBE,
  0x07, 0xDE, 0x7D, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C, 0x0F,
  0xBC, 0x7B, 0xE0, 0x7D, 0xE3, 0xDF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0,
  0xFF, 0xC0, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x01,
  0xFD, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0x83, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF0, 0x7E, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0xFE, 0x7E, 0x01, 0xFE, 0x7F, 0x8F, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0x3F, 0x07, 0xFC, 0x3F, 0x00, 0x40, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x80,
  0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFC,
  0xFF, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFC,
  0xFF, 0x01, 0xFC, 0xFF, 0xEF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xF9, 0xFF, 0xE0, 0xF8, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xF7, 0xFC,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xFE, 0x3F, 0x07, 0xFF, 0xBF,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0xFF,
  0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF,
  0x3F, 0xE7, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF,
  0x03, 0xFE, 0x3F, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x87, 0xF0, 0x00, 0xC1,
  0xFE, 0x00, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xF7, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x03, 0xFE, 0x3F, 0x00, 0x30, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x7E, 0x1E, 0x00, 0xFE,
  0x3F, 0x83, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE1, 0xFE, 0x0F, 0xCF, 0xFF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xF7, 0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x8F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xEF, 0xC0, 0x1F,
  0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F,
  0xC0, 0x7E, 0x1F, 0xE0, 0x3F, 0x1F, 0xE0, 0x1F, 0x9F, 0xE0, 0x0F, 0xDF,
  0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE7, 0xF0, 0x0F,
  0xE1, 0xFC, 0x07, 0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0,
  0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0xCF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xFC, 0x7F,
  0x3E, 0xFF, 0xBF, 0xEF, 0xBF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0x7C, 0x1F, 0xFC,
  0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xF0, 0x7C, 0x1F,
  0xFC, 0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xF0, 0x7C,
  0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xF0,
  0x7C, 0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F,
  0xF0, 0x7C, 0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0,
  0x7C, 0xF8, 0x3F, 0xC1, 0xF1, 0xFF, 0xE3, 0xE7, 0xFF, 0xE7, 0xFF, 0xFF,
  0xEF, 0xFE, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFC,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07,
  0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x8F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xF8,
  0xFF, 0x81, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xE0, 0x3F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF,
  0xC0, 0x3F, 0xBF, 0xF1, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFB,
  0xFF, 0xC3, 0xF3, 0xFE, 0x07, 0xE0, 0x60, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE7,
  0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xBF, 0x03, 0xFE, 0x3F, 0x00, 0x30, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0xCF, 0xC0, 0x1F, 0xDF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x7F,
  0xBF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0x80,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F,
  0xEF, 0xC0, 0x3F, 0xDF, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7E,
  0x3F, 0xFC, 0xFC, 0x1F, 0xF1, 0xF8, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x0F, 0x01, 0xFF, 0xE0, 0x78, 0x0F, 0xBF, 0x03, 0xE0, 0x7C,
  0xF8, 0x1F, 0x03, 0xE7, 0xC1, 0xF8, 0x3F, 0x3E, 0x0F, 0xC1, 0xF1, 0xF0,
  0x7F, 0x0F, 0x8F, 0x83, 0xF8, 0x7C, 0x7E, 0x3F, 0xC3, 0xE1, 0xF1, 0xFE,
  0x1F, 0x0F, 0x8F, 0x70, 0xF8, 0x7C, 0x7B, 0xCF, 0x83, 0xE3, 0x9E, 0x7C,
  0x1F, 0x3C, 0xF3, 0xE0, 0x79, 0xE7, 0x9F, 0x03, 0xEF, 0x1C, 0xF8, 0x1F,
  0x70, 0xF7, 0x80, 0xFB, 0x87, 0xBC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x01,
  0xFC, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3F,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x60, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xF0,
  0x1F, 0x7F, 0xFF, 0x83, 0xEF, 0xC3, 0xFF, 0xFE, 0xF8, 0x0F, 0xFF, 0xEF,
  0x00, 0x7F, 0xFC, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
};

const GFXglyph RobotoMono_Medium51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 36, 31, 12, -36 },
  { 33, 14, 12, 31, 8, -38 },
  { 54, 28, 36, 31, 1, -36 },
  { 180, 24, 47, 31, 4, -42 },
  { 321, 29, 38, 31, 1, -37 },
  { 459, 28, 38, 31, 2, -37 },
  { 592, 5, 13, 31, 12, -38 },
  { 601, 13, 53, 31, 9, -41 },
  { 688, 14, 53, 31, 8, -41 },
  { 781, 25, 25, 31, 4, -36 },
  { 860, 25, 26, 31, 3, -30 },
  { 942, 8, 15, 31, 9, -6 },
  { 957, 20, 4, 31, 6, -18 },
  { 967, 9, 9, 31, 11, -8 },
  { 978, 20, 39, 31, 6, -36 },
  { 1076, 23, 38, 31, 4, -37 },
  { 1186, 15, 36, 31, 5, -36 },
  { 1254, 25, 37, 31, 2, -37 },
  { 1370, 24, 38, 31, 2, -37 },
  { 1484, 26, 36, 31, 2, -36 },
  { 1601, 23, 37, 31, 4, -36 },
  { 1708, 24, 37, 31, 3, -36 },
  { 1819, 25, 36, 31, 2, -36 },
  { 1932, 24, 38, 31, 3, -37 },
  { 2046, 24, 37, 31, 3, -37 },
  { 2157, 9, 30, 31, 12, -29 },
  { 2191, 10, 38, 31, 11, -29 },
  { 2239, 22, 23, 31, 4, -27 },
  { 2303, 23, 15, 31, 4, -23 },
  { 2347, 22, 23, 31, 4, -27 },
  { 2411, 23, 37, 31, 4, -37 },
  { 2518, 28, 36, 31, 1, -36 },
  { 2644, 29, 36, 31, 1, -36 },
  { 2775, 25, 36, 31, 4, -36 },
  { 2888, 26, 38, 31, 2, -37 },
  { 3012, 25, 36, 31, 3, -36 },
  { 3125, 24, 36, 31, 4, -36 },
  { 3233, 24, 36, 31, 4, -36 },
  { 3341, 26, 38, 31, 2, -37 },
  { 3465, 24, 36, 31, 3, -36 },
  { 3573, 21, 36, 31, 5, -36 },
  { 3668, 24, 37, 31, 3, -36 },
  { 3779, 27, 36, 31, 4, -36 },
  { 3901, 24, 36, 31, 4, -36 },
  { 4009, 25, 36, 31, 3, -36 },
  { 4122, 24, 36, 31, 3, -36 },
  { 4230, 26, 38, 31, 2, -37 },
  { 4354, 25, 36, 31, 4, -36 },
  { 4467, 28, 43, 31, 2, -37 },
  { 4618, 25, 36, 31, 4, -36 },
  { 4731, 26, 37, 31, 3, -37 },
  { 4852, 28, 36, 31, 1, -36 },
  { 4978, 24, 37, 31, 3, -36 },
  { 5089, 28, 36, 31, 1, -36 },
  { 5215, 29, 36, 31, 1, -36 },
  { 5346, 29, 36, 31, 1, -36 },
  { 5477, 29, 36, 31, 1, -36 },
  { 5608, 26, 36, 31, 2, -36 },
  { 5725, 11, 50, 31, 10, -42 },
  { 5794, 20, 39, 31, 6, -36 },
  { 5892, 11, 50, 31, 10, -42 },
  { 5961, 21, 19, 31, 5, -36 },
  { 6011, 23, 5, 31, 4, 0 },
  { 6026, 11, 7, 31, 10, -37 },
  { 6036, 24, 28, 31, 3, -27 },
  { 6120, 24, 39, 31, 4, -38 },
  { 6237, 24, 28, 31, 3, -27 },
  { 6321, 24, 39, 31, 3, -38 },
  { 6438, 25, 28, 31, 3, -27 },
  { 6526, 25, 39, 31, 3, -39 },
  { 6648, 24, 38, 31, 3, -27 },
  { 6762, 23, 38, 31, 4, -38 },
  { 6872, 22, 37, 31, 5, -37 },
  { 6974, 17, 48, 31, 5, -37 },
  { 7076, 25, 38, 31, 4, -38 },
  { 7195, 23, 38, 31, 5, -38 },
  { 7305, 26, 27, 31, 2, -27 },
  { 7393, 23, 27, 31, 4, -27 },
  { 7471, 25, 28, 31, 3, -27 },
  { 7559, 23, 37, 31, 4, -27 },
  { 7666, 24, 37, 31, 3, -27 },
  { 7777, 19, 27, 31, 8, -27 },
  { 7842, 23, 28, 31, 4, -27 },
  { 7923, 24, 35, 31, 3, -34 },
  { 8028, 23, 28, 31, 4, -27 },
  { 8109, 26, 27, 31, 2, -27 },
  { 8197, 29, 27, 31, 1, -27 },
  { 8295, 27, 27, 31, 2, -27 },
  { 8387, 29, 38, 31, 1, -27 },
  { 8525, 25, 27, 31, 3, -27 },
  { 8610, 17, 49, 31, 8, -40 },
  { 8715, 4, 46, 31, 13, -36 },
  { 8738, 17, 49, 31, 8, -40 },
  { 8843, 28, 10, 31, 1, -20 },
};

const GFXfont RobotoMono_Medium51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium51pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_MEDIUM51PT7B_H_
