#ifndef _JETBRAINSMONO_MEDIUMITALIC19PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x31, 0x00, 0x07, 0x30, 0x66, 0xCD,
  0x9B, 0x3C, 0xD9, 0x80, 0x06, 0x20, 0x46, 0x04, 0x40, 0xC4, 0x3F, 0xF0,
  0x88, 0x18, 0x81, 0x18, 0x11, 0x0F, 0xFC, 0x23, 0x02, 0x20, 0x62, 0x04,
  0x60, 0x02, 0x00, 0x80, 0x20, 0x3C, 0x3F, 0x8D, 0x36, 0x4D, 0x90, 0x74,
  0x0F, 0x81, 0xF0, 0x2E, 0x09, 0xB2, 0x6C, 0xBB, 0xFC, 0x7E, 0x04, 0x01,
  0x00, 0x40, 0x0E, 0x0C, 0x6C, 0x63, 0x33, 0x0C, 0xD8, 0x32, 0xC0, 0xFE,
  0x00, 0x10, 0x00, 0x80, 0x07, 0xE0, 0x34, 0xC1, 0xB3, 0x0C, 0xCC, 0x23,
  0x23, 0x07, 0x80, 0x0F, 0x83, 0xF8, 0x63, 0x0C, 0x01, 0x80, 0x30, 0x0F,
  0x03, 0xE3, 0x66, 0xCC, 0xF1, 0x8E, 0x31, 0xC7, 0xF8, 0xF9, 0x80, 0x6D,
  0xED, 0x80, 0x03, 0x0F, 0x1C, 0x38, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x10, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x1C, 0x38,
  0xF0, 0xC0, 0x06, 0x01, 0x00, 0xC1, 0x33, 0xF7, 0xCF, 0xC1, 0xC0, 0xD8,
  0x67, 0x18, 0xC0, 0x06, 0x03, 0x00, 0xC0, 0x31, 0xFF, 0xBF, 0xE0, 0xC0,
  0x60, 0x18, 0x00, 0x39, 0x9C, 0xCC, 0x60, 0xFF, 0xF0, 0x7F, 0x60, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0x0F, 0x0F, 0xE3, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0xD9, 0xB6,
  0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xFF, 0x1F, 0x80, 0x07, 0x0F, 0x8F, 0x8C,
  0xC4, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC,
  0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x18, 0x1C, 0x0E,
  0x03, 0x81, 0xF0, 0x0E, 0x01, 0x80, 0x6C, 0x1B, 0x0C, 0xFF, 0x1F, 0x00,
  0x01, 0x81, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xC6, 0xC3, 0xC1, 0xFF, 0xFF,
  0xC0, 0x60, 0x30, 0x18, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x60, 0x1B, 0xC7,
  0xF9, 0x86, 0x01, 0x80, 0x60, 0x1B, 0x0C, 0xFF, 0x1F, 0x80, 0x03, 0x03,
  0x03, 0x83, 0x81, 0x81, 0xB1, 0xFC, 0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x7F,
  0xF3, 0xF0, 0x7F, 0xFF, 0xEC, 0x1B, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x00, 0x0F, 0x0F, 0xE3, 0x1D,
  0x83, 0x71, 0x8C, 0xE1, 0xE0, 0xFC, 0x63, 0xB0, 0x6C, 0x1B, 0x0C, 0xFF,
  0x1F, 0x80, 0x1E, 0x3F, 0xB8, 0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0xFE, 0x36,
  0x06, 0x07, 0x03, 0x03, 0x03, 0x00, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x67,
  0xB8, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xC7, 0x18, 0xC3, 0x00,
  0x01, 0x83, 0xCF, 0x9E, 0x0C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x60, 0x3C, 0x07, 0x80,
  0xF0, 0x18, 0x3C, 0x78, 0xF0, 0xE0, 0x40, 0x00, 0x78, 0xFE, 0x18, 0x30,
  0x60, 0xDF, 0x3C, 0x60, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x07, 0xC1, 0xCE,
  0x30, 0x63, 0x02, 0x60, 0x26, 0x3A, 0x66, 0x66, 0x46, 0x6C, 0x64, 0xC6,
  0xCC, 0x4C, 0xCC, 0xC7, 0x4C, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x03,
  0x01, 0xE0, 0x78, 0x36, 0x0D, 0x86, 0x61, 0x98, 0x66, 0x31, 0x8F, 0xE7,
  0x19, 0x83, 0x60, 0xF0, 0x30, 0x3F, 0x0F, 0xE3, 0x1D, 0x83, 0x61, 0xD8,
  0x67, 0xF1, 0xFC, 0x61, 0xB0, 0x6C, 0x1B, 0x0E, 0xFF, 0x3F, 0x80, 0x0F,
  0x0F, 0xE3, 0x0D, 0x83, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x1B, 0x0C, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xD8,
  0x66, 0x19, 0x86, 0x61, 0xB8, 0x6C, 0x1B, 0x0C, 0xFE, 0x3F, 0x00, 0x3F,
  0xCF, 0xF3, 0x00, 0xC0, 0x60, 0x18, 0x07, 0xF9, 0xFC, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF3, 0x00, 0x80, 0x60, 0x18,
  0x07, 0xF9, 0xFE, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0F,
  0x0F, 0xE3, 0x0D, 0x83, 0x60, 0x18, 0x06, 0x01, 0x9E, 0x6F, 0xB0, 0x6C,
  0x1B, 0x0C, 0x7F, 0x1F, 0x80, 0x30, 0xCC, 0x33, 0x0D, 0x83, 0x61, 0x98,
  0x67, 0xF9, 0xFE, 0x61, 0xB8, 0x6C, 0x3B, 0x0C, 0xC3, 0x30, 0xC0, 0x3F,
  0xCF, 0xF0, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0xFF, 0x3F, 0xC0, 0x03, 0xE0, 0xFC, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x33, 0x86, 0x70, 0xC7, 0xF0, 0x7C,
  0x00, 0x30, 0xE6, 0x18, 0xC6, 0x31, 0xC6, 0x30, 0xCC, 0x1F, 0x83, 0xF0,
  0x66, 0x1C, 0xC3, 0x0C, 0x61, 0x8C, 0x31, 0x87, 0x00, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0F, 0xFF,
  0xF8, 0x18, 0x73, 0x8E, 0x38, 0xA3, 0xDE, 0x3D, 0x63, 0xF6, 0x27, 0x66,
  0x6C, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xCC, 0x18, 0x38, 0xCE,
  0x33, 0x8D, 0xE3, 0x68, 0xDB, 0x66, 0xD9, 0xB6, 0x4D, 0xB1, 0x6C, 0x5B,
  0x1C, 0xC7, 0x31, 0xC0, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xD8, 0x66,
  0x19, 0x86, 0x61, 0xB0, 0x6C, 0x1B, 0x0C, 0x7F, 0x1F, 0x80, 0x3F, 0x0F,
  0xF3, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x39, 0xFC, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xD8, 0x76,
  0x19, 0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xFF, 0x1F, 0x80, 0xC0, 0x18,
  0x07, 0x00, 0x3F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xD8, 0x77, 0xF9, 0xFC,
  0x66, 0x39, 0x8C, 0x63, 0x0C, 0xC3, 0x30, 0xE0, 0x0F, 0x8F, 0xE3, 0x0D,
  0x83, 0x60, 0x1C, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x6C, 0x1B, 0x0E, 0xFF,
  0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x30, 0xCC, 0x33, 0x0D,
  0x83, 0x61, 0xD8, 0x66, 0x19, 0x86, 0x61, 0xB0, 0x6C, 0x1B, 0x0C, 0x7F,
  0x1F, 0x80, 0xC0, 0xF0, 0x6C, 0x19, 0x86, 0x63, 0x18, 0xC6, 0x61, 0x98,
  0x64, 0x1B, 0x06, 0xC1, 0xE0, 0x78, 0x1C, 0x00, 0x66, 0x68, 0xCD, 0x39,
  0xA5, 0x24, 0xAD, 0x95, 0xB6, 0xB6, 0x94, 0xD7, 0x9E, 0xF3, 0x9E, 0x73,
  0x8E, 0x71, 0xCE, 0x00, 0x38, 0x71, 0x86, 0x18, 0xC0, 0xDC, 0x0D, 0x80,
  0xF0, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xB0, 0x3B, 0x83, 0x18, 0x61, 0x8C,
  0x0C, 0xC0, 0xF0, 0x66, 0x19, 0x8C, 0x66, 0x0D, 0x83, 0xC0, 0xF0, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x3F, 0xCF, 0xF0, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x80, 0xFF, 0x3F,
  0xC0, 0x3E, 0x7C, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C,
  0x18, 0x30, 0x60, 0xF9, 0xF0, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x0C, 0x30,
  0xC3, 0x0C, 0x18, 0x61, 0x86, 0x0C, 0x30, 0x3E, 0x7C, 0x18, 0x30, 0x61,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0xF9, 0xF0, 0x0C,
  0x1C, 0x16, 0x36, 0x62, 0x63, 0xC3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC6, 0x70,
  0x0C, 0x4F, 0xE7, 0x39, 0x86, 0x61, 0x98, 0x6C, 0x1B, 0x0E, 0xC3, 0x3F,
  0xC7, 0xB0, 0x30, 0x18, 0x0C, 0x0C, 0xC6, 0xFB, 0x8D, 0x86, 0xC3, 0x61,
  0xF0, 0xF0, 0x7C, 0x6F, 0xF6, 0xF0, 0x0E, 0x1F, 0xDC, 0x6C, 0x36, 0x03,
  0x03, 0x01, 0x83, 0xC3, 0x3F, 0x9F, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x33,
  0x3F, 0x9C, 0xE6, 0x19, 0x86, 0x61, 0xB0, 0x6C, 0x3B, 0x0C, 0xFF, 0x1E,
  0xC0, 0x0E, 0x1F, 0x9C, 0x6C, 0x36, 0x1B, 0xFF, 0x01, 0x80, 0xC3, 0x3F,
  0x9F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x0F, 0xF8,
  0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0xF8, 0x00, 0x0C, 0x4F, 0xE7, 0x39, 0x86, 0x61,
  0x98, 0x6C, 0x1B, 0x8E, 0x77, 0x1F, 0xC0, 0x30, 0x0C, 0x07, 0x1F, 0x80,
  0x30, 0x18, 0x0C, 0x0C, 0xC6, 0xFB, 0x8D, 0x86, 0xC3, 0x61, 0xF0, 0xF0,
  0x78, 0x6C, 0x36, 0x18, 0x07, 0x03, 0x81, 0x80, 0x00, 0x01, 0xF1, 0x18,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x00, 0xC0, 0x70,
  0x08, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x1E, 0x3F, 0x00, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x61, 0xD8, 0xE6, 0x31, 0x98, 0x7C, 0x1F, 0x8C, 0x63, 0x1C, 0xC3,
  0x30, 0xE0, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x70, 0x3F, 0x3F, 0x04, 0xC7, 0xFC, 0xD9, 0xB3, 0x36, 0x64, 0xCD,
  0x99, 0x33, 0x26, 0x6C, 0xC9, 0x9B, 0x33, 0x00, 0x06, 0x37, 0xDC, 0x6C,
  0x36, 0x1B, 0x0F, 0x87, 0x83, 0xC3, 0x61, 0xB0, 0xC0, 0x0E, 0x1F, 0x9C,
  0x6C, 0x36, 0x1B, 0x0F, 0x07, 0x83, 0xC3, 0x3F, 0x9F, 0x80, 0x03, 0x0D,
  0xF3, 0x8C, 0xC3, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0x71, 0x9F, 0xE6, 0xF1,
  0x80, 0x60, 0x30, 0x00, 0x0C, 0x4F, 0xE7, 0x39, 0x86, 0x61, 0x98, 0x6C,
  0x1B, 0x0E, 0xC3, 0x3F, 0xC7, 0xB0, 0x0C, 0x03, 0x01, 0xC0, 0x07, 0x0F,
  0xE7, 0x1D, 0x87, 0x61, 0xD8, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00,
  0x0E, 0x1F, 0xDC, 0x6C, 0x07, 0x01, 0xF8, 0x1E, 0x03, 0xC3, 0xFF, 0x9F,
  0x80, 0x0C, 0x03, 0x00, 0xC1, 0xFF, 0x98, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0x7C, 0x1F, 0x00, 0x61, 0xD8, 0x66, 0x19, 0x86, 0x61,
  0xB8, 0x6C, 0x3B, 0x8C, 0x7F, 0x1F, 0x00, 0xC1, 0xE1, 0xB0, 0xD8, 0xC6,
  0x63, 0x61, 0xB0, 0xF0, 0x78, 0x38, 0x00, 0xCC, 0x79, 0x9B, 0x33, 0x6E,
  0x4D, 0x49, 0xAB, 0x3D, 0x47, 0x28, 0xE7, 0x1C, 0xE0, 0x38, 0xE3, 0x38,
  0x7E, 0x07, 0x80, 0xE0, 0x1C, 0x06, 0xC1, 0x98, 0x71, 0x9C, 0x38, 0x61,
  0xD8, 0x66, 0x19, 0x86, 0x61, 0xB0, 0x6E, 0x31, 0xFC, 0x7B, 0x00, 0xC0,
  0x30, 0x18, 0x7E, 0x00, 0x7F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0x7F, 0x80, 0x01, 0xC1, 0xE0, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xF8, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1E, 0x07, 0x80, 0x33, 0x33, 0x37, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0xCC,
  0x1C, 0x07, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x07, 0xC1,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x78, 0x3C, 0x00, 0x38,
  0xDF, 0x3C, 0xDB, 0x1E,
};

const GFXglyph JetBrainsMono_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 14, 11, 3, -14 },
  { 10, 7, 6, 11, 3, -14 },
  { 16, 12, 14, 11, 0, -14 },
  { 37, 10, 20, 11, 1, -17 },
  { 62, 14, 14, 11, -1, -14 },
  { 87, 11, 14, 11, 0, -14 },
  { 107, 3, 6, 11, 5, -14 },
  { 110, 8, 18, 11, 3, -16 },
  { 128, 8, 18, 11, 1, -16 },
  { 146, 10, 10, 11, 1, -12 },
  { 159, 10, 9, 11, 1, -11 },
  { 171, 5, 6, 11, 2, -3 },
  { 175, 6, 2, 11, 3, -7 },
  { 177, 4, 3, 11, 3, -3 },
  { 179, 12, 18, 11, 0, -16 },
  { 206, 10, 14, 11, 1, -14 },
  { 224, 9, 14, 11, 1, -14 },
  { 240, 10, 14, 11, 1, -14 },
  { 258, 10, 14, 11, 1, -14 },
  { 276, 9, 14, 11, 1, -14 },
  { 292, 10, 14, 11, 1, -14 },
  { 310, 9, 14, 11, 1, -14 },
  { 326, 10, 14, 11, 2, -14 },
  { 344, 10, 14, 11, 1, -14 },
  { 362, 9, 14, 11, 2, -14 },
  { 378, 5, 11, 11, 3, -11 },
  { 385, 6, 14, 11, 2, -11 },
  { 396, 9, 10, 11, 2, -11 },
  { 408, 9, 7, 11, 1, -10 },
  { 416, 9, 10, 11, 1, -11 },
  { 428, 7, 14, 11, 3, -14 },
  { 441, 12, 17, 11, 0, -14 },
  { 467, 10, 14, 11, 0, -14 },
  { 485, 10, 14, 11, 1, -14 },
  { 503, 10, 14, 11, 1, -14 },
  { 521, 10, 14, 11, 1, -14 },
  { 539, 10, 14, 11, 1, -14 },
  { 557, 10, 14, 11, 1, -14 },
  { 575, 10, 14, 11, 1, -14 },
  { 593, 10, 14, 11, 1, -14 },
  { 611, 10, 14, 11, 1, -14 },
  { 629, 11, 14, 11, 0, -14 },
  { 649, 11, 14, 11, 1, -14 },
  { 669, 9, 14, 11, 1, -14 },
  { 685, 12, 14, 11, 0, -14 },
  { 706, 10, 14, 11, 1, -14 },
  { 724, 10, 14, 11, 1, -14 },
  { 742, 10, 14, 11, 1, -14 },
  { 760, 10, 17, 11, 1, -14 },
  { 782, 10, 14, 11, 1, -14 },
  { 800, 10, 14, 11, 1, -14 },
  { 818, 10, 14, 11, 2, -14 },
  { 836, 10, 14, 11, 1, -14 },
  { 854, 10, 14, 11, 2, -14 },
  { 872, 11, 14, 11, 1, -14 },
  { 892, 12, 14, 11, 0, -14 },
  { 913, 10, 14, 11, 2, -14 },
  { 931, 10, 14, 11, 1, -14 },
  { 949, 7, 18, 11, 3, -16 },
  { 965, 6, 18, 11, 3, -16 },
  { 979, 7, 18, 11, 2, -16 },
  { 995, 8, 8, 11, 2, -14 },
  { 1003, 9, 2, 11, 0, 0 },
  { 1006, 4, 3, 11, 5, -15 },
  { 1008, 10, 11, 11, 1, -11 },
  { 1022, 9, 14, 11, 1, -14 },
  { 1038, 9, 11, 11, 1, -11 },
  { 1051, 10, 14, 11, 1, -14 },
  { 1069, 9, 11, 11, 1, -11 },
  { 1082, 13, 17, 11, -1, -14 },
  { 1110, 10, 14, 11, 1, -11 },
  { 1128, 9, 14, 11, 1, -14 },
  { 1144, 9, 15, 11, 1, -15 },
  { 1161, 10, 18, 11, 0, -15 },
  { 1184, 10, 14, 11, 1, -14 },
  { 1202, 8, 14, 11, 2, -14 },
  { 1216, 11, 11, 11, 0, -11 },
  { 1232, 9, 11, 11, 1, -11 },
  { 1245, 9, 11, 11, 1, -11 },
  { 1258, 10, 14, 11, 0, -11 },
  { 1276, 10, 14, 11, 1, -11 },
  { 1294, 10, 11, 11, 1, -11 },
  { 1308, 9, 11, 11, 1, -11 },
  { 1321, 10, 13, 11, 1, -13 },
  { 1338, 10, 10, 11, 1, -10 },
  { 1351, 9, 10, 11, 2, -10 },
  { 1363, 11, 10, 11, 1, -10 },
  { 1377, 11, 10, 11, 0, -10 },
  { 1391, 10, 13, 11, 1, -10 },
  { 1408, 9, 10, 11, 1, -10 },
  { 1420, 10, 18, 11, 2, -16 },
  { 1443, 4, 18, 11, 4, -16 },
  { 1452, 10, 18, 11, 0, -16 },
  { 1475, 10, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_MEDIUMITALIC19PT7B_H_
