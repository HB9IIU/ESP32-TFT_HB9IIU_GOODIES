#ifndef _JETBRAINSMONO_MEDIUMITALIC53PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0x9F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x07,
  0x80, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80,
  0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0,
  0x1F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xDE, 0xFF, 0x01, 0xF8, 0xE1, 0xF8, 0x1F, 0x87, 0x0F, 0xC0, 0xFC, 0x38,
  0x7E, 0x07, 0xC1, 0xC3, 0xF0, 0x7E, 0x0E, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x1F, 0x87, 0x80, 0x00, 0xFE, 0x38, 0x00, 0x03, 0xF9, 0xC0, 0x00, 0x1F,
  0xEE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1D, 0xFE, 0x00, 0x01, 0xE3, 0xF8, 0x00,
  0x0E, 0x1F, 0xC0, 0x00, 0x70, 0x7E, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x1C,
  0x1F, 0x87, 0xC0, 0xE0, 0xFC, 0x3E, 0x0F, 0x0F, 0xC1, 0xF8, 0x78, 0x7E,
  0x0F, 0xC3, 0x87, 0xE0, 0x7F, 0x1C, 0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x03, 0xFF, 0x00,
  0x07, 0x80, 0x3F, 0xFC, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x3C,
  0x00, 0xF8, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x3C, 0x00, 0x3C, 0x07,
  0x83, 0xE0, 0x01, 0xE0, 0x3C, 0x3E, 0x00, 0x0F, 0x03, 0xE3, 0xE0, 0x00,
  0x78, 0x1F, 0x3E, 0x00, 0x03, 0xE1, 0xF1, 0xE0, 0x00, 0x1F, 0xFF, 0x1E,
  0x00, 0x00, 0x7F, 0xF1, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x0F, 0xF0, 0x00, 0x00, 0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0x9F, 0xFF, 0x00,
  0x00, 0xF9, 0xF9, 0xF8, 0x00, 0x07, 0x8F, 0x83, 0xC0, 0x00, 0x78, 0x78,
  0x1E, 0x00, 0x07, 0x87, 0xC0, 0xF0, 0x00, 0x7C, 0x3C, 0x07, 0x80, 0x07,
  0xC1, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x1F,
  0x00, 0x3C, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x00,
  0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xFC, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0xFC,
  0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0x3E,
  0x07, 0xE7, 0xC1, 0xF8, 0x1F, 0xBF, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0x80,
  0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFE, 0x01, 0xF8, 0x0F, 0xFC,
  0x07, 0xF9, 0xFF, 0xF0, 0x1F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x8F, 0x80,
  0x7F, 0xFC, 0x3F, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x70, 0x00, 0x00, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xFE, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E,
  0x7C, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x03,
  0x00, 0xF8, 0x06, 0x7E, 0x0F, 0x03, 0xE7, 0xF0, 0xF0, 0xFE, 0xFF, 0xCF,
  0x3F, 0xFF, 0xFE, 0x6F, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x0F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x01,
  0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C,
  0x3F, 0x0E, 0x07, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E, 0x3F, 0x8F, 0xC3, 0xE3,
  0xF8, 0xFC, 0x7E, 0x3F, 0x8F, 0x87, 0xE1, 0xF0, 0xF8, 0x7E, 0x0E, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF3, 0xE0, 0x0F, 0xF1,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xC0, 0x7E, 0x00, 0xC0,
  0x3F, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x07, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F,
  0x1F, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xFE,
  0x00, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE7, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF7, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE, 0x03, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x9F, 0xF8, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xF7,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07,
  0xF0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0xDF, 0x80, 0x1F, 0xCF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x0F, 0x00, 0x7F, 0x9F, 0x1F,
  0x01, 0xFF, 0xDE, 0x1F, 0x01, 0xFF, 0xDE, 0x1F, 0x03, 0xF0, 0x7E, 0x1F,
  0x03, 0xE0, 0x7E, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x07, 0xC0, 0x3E, 0x3E,
  0x07, 0xC0, 0x3C, 0x3E, 0x07, 0xC0, 0x7C, 0x3E, 0x07, 0x80, 0x7C, 0x3E,
  0x0F, 0x80, 0x7C, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x0F, 0x80, 0x7C, 0x3C,
  0x0F, 0x80, 0x78, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xFF, 0xF8, 0x78,
  0x0F, 0xFE, 0xF8, 0xF8, 0x07, 0xFC, 0xF0, 0xF8, 0x01, 0xF8, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x0F,
  0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x03,
  0xF8, 0x0F, 0x81, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7C,
  0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0xFC, 0x3F, 0x07, 0xFF, 0xC3, 0xE0, 0xFF, 0xF8, 0x7E, 0x0F, 0xFF, 0x87,
  0xE0, 0xFF, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x80, 0x7F, 0x81, 0xFF, 0x01, 0xEF, 0x03, 0xDE, 0x03, 0xDE, 0x07, 0xBC,
  0x0F, 0x7C, 0x0F, 0x3C, 0x1E, 0xF8, 0x1E, 0x78, 0x79, 0xF0, 0x3C, 0xF0,
  0xF3, 0xC0, 0xF9, 0xE3, 0xEF, 0x81, 0xF3, 0xC7, 0x9F, 0x03, 0xE7, 0x9F,
  0x3E, 0x07, 0xCF, 0x3C, 0x7C, 0x0F, 0x8F, 0x79, 0xF8, 0x1F, 0x1F, 0xE3,
  0xE0, 0x7E, 0x3F, 0xC7, 0xC0, 0xFC, 0x7F, 0x0F, 0x81, 0xF0, 0xFE, 0x1F,
  0x03, 0xE1, 0xF8, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0,
  0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0x00, 0x3E, 0x07, 0xF8,
  0x03, 0xF0, 0x7F, 0xC0, 0x1F, 0x83, 0xFE, 0x00, 0xFC, 0x1F, 0xF0, 0x07,
  0xC0, 0xFF, 0xC0, 0x3E, 0x07, 0xFE, 0x01, 0xF0, 0x3F, 0xF0, 0x0F, 0x83,
  0xF7, 0x80, 0xFC, 0x1F, 0x3C, 0x07, 0xE0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF,
  0x81, 0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x0F, 0x8F, 0x07,
  0xE0, 0xFC, 0x7C, 0x3F, 0x07, 0xE3, 0xE1, 0xF0, 0x3E, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x7C, 0x0F, 0x83, 0xC3, 0xE0, 0x7C, 0x1F, 0x3F, 0x07, 0xE0,
  0xF9, 0xF8, 0x3F, 0x07, 0xCF, 0x81, 0xF0, 0x3E, 0x7C, 0x0F, 0x80, 0xF3,
  0xE0, 0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x3E, 0xF8, 0x3F, 0x01, 0xF7, 0xC1,
  0xF8, 0x0F, 0xBE, 0x0F, 0x80, 0x3D, 0xE0, 0x7C, 0x01, 0xFF, 0x03, 0xE0,
  0x0F, 0xF8, 0x1F, 0x00, 0x7F, 0xC0, 0xF8, 0x03, 0xFE, 0x0F, 0xC0, 0x0F,
  0xF0, 0x7E, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x7E,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x7C, 0x00, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x3F, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x07,
  0xE0, 0x3E, 0x3E, 0x07, 0xE0, 0x3E, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x07,
  0xE0, 0x7C, 0x3E, 0x0F, 0xE0, 0x7C, 0x3C, 0x0E, 0xE0, 0x7C, 0x7C, 0x0E,
  0xE0, 0xF8, 0x7C, 0x1E, 0xE0, 0xF8, 0x7C, 0x1E, 0xE0, 0xF8, 0x7C, 0x1C,
  0xE0, 0xF0, 0x7C, 0x1C, 0xE1, 0xF0, 0x7C, 0x3C, 0xE1, 0xF0, 0x7C, 0x38,
  0xE1, 0xF0, 0x7C, 0x39, 0xE1, 0xE0, 0x7C, 0x39, 0xE3, 0xE0, 0x7C, 0x79,
  0xE3, 0xE0, 0x7C, 0x71, 0xE3, 0xE0, 0x7C, 0x71, 0xE3, 0xC0, 0x7C, 0xF1,
  0xE7, 0xC0, 0x7C, 0xF1, 0xC7, 0xC0, 0x78, 0xE1, 0xC7, 0xC0, 0x78, 0xE1,
  0xC7, 0x80, 0x79, 0xE1, 0xCF, 0x80, 0x79, 0xC1, 0xCF, 0x80, 0x79, 0xC1,
  0xCF, 0x00, 0x7B, 0xC1, 0xCF, 0x00, 0xFB, 0xC1, 0xDF, 0x00, 0xFB, 0x81,
  0xDF, 0x00, 0xFB, 0x81, 0xDE, 0x00, 0xFF, 0x81, 0xDE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x3F, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8, 0xFC, 0x07, 0xFF, 0x9F, 0x01,
  0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x87, 0xF0, 0x0F,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x01,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xBE, 0x01,
  0xFF, 0xE7, 0xC0, 0x1F, 0xF1, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x1F, 0x1F, 0xF8, 0x07,
  0xE7, 0xFF, 0x80, 0xFD, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F,
  0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFF, 0xDF, 0xF8, 0x3E, 0xFF, 0xFE, 0x07,
  0xDF, 0xFF, 0x81, 0xF9, 0xFF, 0xE0, 0x3F, 0x1F, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0xFE, 0x03, 0xF8,
  0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xE0, 0x7E, 0x00, 0xFF, 0xC7, 0xE0, 0x1F, 0xFE, 0x7C,
  0x03, 0xFF, 0xE7, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC1, 0xFC,
  0x03, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xF7, 0xE0,
  0x3F, 0xFF, 0x7C, 0x01, 0xFF, 0xE7, 0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8,
  0xFC, 0x07, 0xFF, 0x9F, 0x01, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xF1, 0xFF, 0x87, 0xF0, 0x0F, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xC0, 0x7F, 0xF9,
  0xF8, 0x03, 0xFC, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x1F, 0x1F, 0xF8, 0x07, 0xE7,
  0xFF, 0x80, 0xFD, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xF0,
  0x7F, 0x80, 0xFE, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x20,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x10,
  0x7E, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x7C, 0xFC,
  0x3F, 0x83, 0xEF, 0xF3, 0xFC, 0x1F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFD, 0xFF,
  0x87, 0xC1, 0xF0, 0xFC, 0x7E, 0x0F, 0x83, 0xE3, 0xF0, 0x78, 0x1F, 0x1F,
  0x03, 0xC0, 0xF8, 0xF8, 0x1E, 0x0F, 0xC7, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x1F, 0x83, 0xC0, 0xF8, 0xF8, 0x1E, 0x07,
  0xC7, 0xC0, 0xF0, 0x3E, 0x3E, 0x07, 0x83, 0xF1, 0xF0, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0xFC, 0x1E, 0x07, 0xC7, 0xC0, 0xF0, 0x3E, 0x3E, 0x07,
  0x81, 0xF1, 0xF0, 0x3C, 0x1F, 0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0xC7, 0xE0, 0xF0, 0x3E, 0x3F, 0x07, 0x81, 0xF1, 0xF0, 0x3C, 0x0F, 0x8F,
  0x81, 0xE0, 0xFC, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xF8,
  0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x07, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xF8, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0xFC, 0x03, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x3F,
  0xF0, 0x07, 0xE7, 0xFF, 0x80, 0x7E, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE3, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x3F,
  0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xEF, 0xBF,
  0xF0, 0x3E, 0xFF, 0xFE, 0x07, 0xEF, 0xFF, 0xC0, 0x7E, 0x7F, 0xF8, 0x07,
  0xE3, 0xFE, 0x00, 0x7E, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8, 0xFC, 0x07, 0xFF, 0x9F,
  0x03, 0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF3, 0xFF, 0x87, 0xF0,
  0x0F, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x7F,
  0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xBE,
  0x01, 0xFF, 0xE7, 0xC0, 0x1F, 0xF1, 0xF8, 0x00, 0x30, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0xFF, 0xC0,
  0x3F, 0x3F, 0xFC, 0x07, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0x78,
  0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0xEF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xF0, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x0F, 0xBC, 0x07, 0xE0,
  0x7D, 0xE0, 0x3F, 0x03, 0xCF, 0x03, 0xF8, 0x1E, 0x78, 0x1F, 0xC1, 0xF3,
  0xC0, 0xFE, 0x0F, 0x1E, 0x0E, 0xF0, 0x78, 0xF0, 0x77, 0x87, 0xC7, 0x83,
  0xBC, 0x3E, 0x3C, 0x3D, 0xE1, 0xE1, 0xE1, 0xCF, 0x1F, 0x0F, 0x0E, 0x78,
  0xF8, 0x78, 0xF3, 0xC7, 0x83, 0xC7, 0x1E, 0x7C, 0x1E, 0x38, 0xF3, 0xE0,
  0xF3, 0xC7, 0x9E, 0x07, 0x9C, 0x3C, 0xF0, 0x3C, 0xE1, 0xEF, 0x81, 0xEF,
  0x0F, 0x78, 0x0F, 0x70, 0x7B, 0xC0, 0x7B, 0x83, 0xFE, 0x03, 0xDC, 0x1F,
  0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F,
  0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x07, 0x7C, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFB, 0xF0, 0x1F, 0xFE, 0x7E, 0x01, 0xFF, 0x8F, 0xC0, 0x0F, 0xC1, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x03, 0xE3, 0xFF, 0x80, 0x7C, 0xFF, 0xF8, 0x0F, 0xBF,
  0xFF, 0x01, 0xF7, 0xE3, 0xF0, 0x7E, 0xF8, 0x3F, 0x0F, 0xBF, 0x07, 0xFF,
  0xF7, 0xC0, 0x7F, 0xFC, 0xF8, 0x07, 0xFF, 0x1F, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 39, 32, 10, -39 },
  { 65, 19, 16, 32, 9, -39 },
  { 103, 31, 39, 32, 1, -39 },
  { 255, 29, 53, 32, 2, -46 },
  { 448, 37, 39, 32, -2, -39 },
  { 629, 30, 40, 32, 1, -39 },
  { 779, 7, 16, 32, 15, -39 },
  { 793, 22, 52, 32, 8, -45 },
  { 936, 22, 52, 32, 3, -45 },
  { 1079, 28, 27, 32, 3, -32 },
  { 1174, 26, 25, 32, 3, -30 },
  { 1256, 14, 16, 32, 5, -8 },
  { 1284, 19, 5, 32, 7, -20 },
  { 1296, 10, 10, 32, 9, -9 },
  { 1309, 33, 50, 32, 0, -44 },
  { 1516, 28, 40, 32, 3, -39 },
  { 1656, 25, 39, 32, 2, -39 },
  { 1778, 28, 39, 32, 2, -39 },
  { 1915, 28, 40, 32, 2, -39 },
  { 2055, 26, 39, 32, 3, -39 },
  { 2182, 27, 40, 32, 3, -39 },
  { 2317, 27, 40, 32, 2, -39 },
  { 2452, 26, 39, 32, 6, -39 },
  { 2579, 28, 40, 32, 2, -39 },
  { 2719, 26, 39, 32, 5, -39 },
  { 2846, 14, 31, 32, 9, -30 },
  { 2901, 18, 38, 32, 5, -30 },
  { 2987, 26, 29, 32, 4, -32 },
  { 3082, 26, 19, 32, 3, -27 },
  { 3144, 26, 29, 32, 2, -32 },
  { 3239, 22, 39, 32, 7, -39 },
  { 3347, 32, 49, 32, 0, -39 },
  { 3543, 27, 39, 32, 0, -39 },
  { 3675, 29, 39, 32, 2, -39 },
  { 3817, 28, 40, 32, 3, -39 },
  { 3957, 28, 39, 32, 2, -39 },
  { 4094, 29, 39, 32, 3, -39 },
  { 4236, 30, 39, 32, 2, -39 },
  { 4383, 28, 40, 32, 3, -39 },
  { 4523, 29, 39, 32, 2, -39 },
  { 4665, 27, 39, 32, 3, -39 },
  { 4797, 29, 40, 32, 1, -39 },
  { 4942, 31, 39, 32, 2, -39 },
  { 5094, 24, 39, 32, 3, -39 },
  { 5211, 31, 39, 32, 1, -39 },
  { 5363, 29, 39, 32, 2, -39 },
  { 5505, 27, 40, 32, 3, -39 },
  { 5640, 30, 39, 32, 2, -39 },
  { 5787, 28, 49, 32, 3, -39 },
  { 5959, 29, 39, 32, 2, -39 },
  { 6101, 29, 40, 32, 2, -39 },
  { 6246, 27, 39, 32, 6, -39 },
  { 6378, 28, 40, 32, 3, -39 },
  { 6518, 27, 39, 32, 6, -39 },
  { 6650, 32, 39, 32, 3, -39 },
  { 6806, 34, 39, 32, -1, -39 },
  { 6972, 29, 39, 32, 5, -39 },
  { 7114, 29, 39, 32, 2, -39 },
  { 7256, 22, 50, 32, 7, -44 },
  { 7394, 17, 50, 32, 8, -44 },
  { 7501, 22, 50, 32, 4, -44 },
  { 7639, 24, 21, 32, 4, -39 },
  { 7702, 26, 5, 32, 0, 1 },
  { 7719, 10, 8, 32, 14, -42 },
  { 7729, 27, 31, 32, 3, -30 },
  { 7834, 27, 40, 32, 2, -39 },
  { 7969, 26, 31, 32, 3, -30 },
  { 8070, 28, 40, 32, 3, -39 },
  { 8210, 26, 31, 32, 3, -30 },
  { 8311, 37, 49, 32, -3, -39 },
  { 8538, 27, 40, 32, 3, -30 },
  { 8673, 27, 39, 32, 2, -39 },
  { 8805, 26, 41, 32, 2, -41 },
  { 8939, 28, 51, 32, 1, -41 },
  { 9118, 30, 39, 32, 2, -39 },
  { 9265, 23, 39, 32, 5, -39 },
  { 9378, 29, 30, 32, 1, -30 },
  { 9487, 27, 30, 32, 2, -30 },
  { 9589, 26, 31, 32, 3, -30 },
  { 9690, 28, 40, 32, 1, -30 },
  { 9830, 27, 40, 32, 3, -30 },
  { 9965, 27, 30, 32, 3, -30 },
  { 10067, 27, 31, 32, 2, -30 },
  { 10172, 26, 37, 32, 4, -37 },
  { 10293, 27, 30, 32, 3, -29 },
  { 10395, 26, 29, 32, 5, -29 },
  { 10490, 29, 29, 32, 4, -29 },
  { 10596, 31, 29, 32, 0, -29 },
  { 10709, 27, 39, 32, 3, -29 },
  { 10841, 27, 29, 32, 2, -29 },
  { 10939, 27, 50, 32, 5, -44 },
  { 11108, 13, 50, 32, 10, -44 },
  { 11190, 28, 50, 32, 1, -44 },
  { 11365, 27, 11, 32, 3, -24 },
};

const GFXfont JetBrainsMono_MediumItalic53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_MEDIUMITALIC53PT7B_H_
