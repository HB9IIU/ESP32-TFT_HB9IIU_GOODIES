#ifndef _JETBRAINSMONO_MEDIUMITALIC27PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0x83,
  0x06, 0x00, 0x00, 0x01, 0xE3, 0xC7, 0x80, 0x73, 0xF9, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1B, 0x8D, 0x8E, 0x00, 0xC3, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x30,
  0xC0, 0x30, 0xE0, 0xFF, 0xFC, 0x7F, 0xFC, 0x0C, 0x38, 0x06, 0x18, 0x07,
  0x0C, 0x03, 0x0E, 0x01, 0x86, 0x01, 0xC3, 0x03, 0xFF, 0xE3, 0xFF, 0xF0,
  0x70, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x1C, 0x30, 0x0C, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x87, 0x27,
  0x0C, 0x4E, 0x39, 0x80, 0x73, 0x00, 0xF6, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xBC, 0x03, 0x38, 0x06, 0x73, 0x8C, 0xE7, 0x93,
  0xC7, 0xAF, 0x0F, 0xFC, 0x0F, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x03, 0x80, 0x61, 0xF8, 0x18, 0x73, 0x06, 0x0C, 0x71, 0x81,
  0x8C, 0x60, 0x71, 0x9C, 0x0E, 0x37, 0x00, 0xFC, 0xC0, 0x1F, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xCF, 0x00, 0x3B, 0xF0, 0x0E, 0xE6, 0x01,
  0x98, 0xE0, 0x63, 0x18, 0x18, 0xE3, 0x06, 0x1C, 0x61, 0xC1, 0xF8, 0x70,
  0x1E, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x87,
  0x3B, 0x8E, 0x71, 0xDC, 0x70, 0xF8, 0x70, 0xF8, 0x70, 0x70, 0x70, 0xF0,
  0x71, 0xF8, 0x7F, 0xB8, 0x3F, 0x1C, 0x77, 0x77, 0x77, 0x6E, 0x00, 0x30,
  0x0E, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xF0, 0x1F, 0x00,
  0x70, 0x0C, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x1E, 0x07,
  0xC0, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x03, 0x0C, 0x27,
  0x99, 0xFF, 0xAF, 0xCF, 0xFC, 0x01, 0xC0, 0x07, 0xC0, 0x39, 0x80, 0x73,
  0x83, 0xC7, 0x83, 0x06, 0x02, 0x08, 0x00, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xE0, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0xE0, 0xFF,
  0xFF, 0xC0, 0x27, 0xBF, 0xEF, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x31, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x8C, 0xC7, 0x03,
  0x8E, 0x07, 0x18, 0x0E, 0x30, 0x1C, 0x70, 0x70, 0xF1, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0x01, 0xE0, 0x1F, 0x03, 0xF8, 0x3D, 0xC1, 0xCE, 0x18, 0x70,
  0x83, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0xC0,
  0x07, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xB8, 0x0E, 0xF0, 0x71, 0xE3, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0xFF, 0xE7, 0xFF, 0x3F,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x78, 0x3F, 0xF0,
  0xFF, 0xE3, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x9C, 0x0E,
  0x70, 0x71, 0xE3, 0xC7, 0xFE, 0x07, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xF0, 0xFF,
  0xE3, 0xC7, 0x9C, 0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xF0,
  0x71, 0xE3, 0xC7, 0xFE, 0x07, 0xE0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xB8,
  0x0E, 0xE0, 0x73, 0x81, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x07,
  0x18, 0x1C, 0xE0, 0x73, 0x81, 0xC7, 0x0E, 0x1E, 0xF0, 0x1F, 0x80, 0xFE,
  0x0F, 0x3C, 0x38, 0x79, 0xC0, 0xE6, 0x03, 0xB8, 0x0E, 0xF0, 0x71, 0xE3,
  0xC7, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8E, 0x0E, 0x70,
  0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0xFF, 0x0F,
  0xF8, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x8F, 0x9E, 0x3C, 0x00, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xC0, 0x1C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1E,
  0x00, 0x30, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0x80, 0x0E, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0x70, 0x03, 0x00, 0x00, 0x7C, 0x0F, 0xF1, 0xFF,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC7, 0xF0, 0xFC, 0x1C,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x70, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x31, 0xC0,
  0x18, 0xE0, 0x0C, 0x61, 0xF6, 0x31, 0xFB, 0x38, 0xE3, 0x9C, 0x61, 0xCE,
  0x70, 0xC7, 0x38, 0x63, 0x1C, 0x31, 0x8E, 0x38, 0xC7, 0x1C, 0xE3, 0x9E,
  0x70, 0xFE, 0x38, 0x20, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x6C, 0x03, 0xB0, 0x0E, 0xC0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0,
  0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xE3, 0xFF, 0x8E, 0x06, 0x70, 0x1D,
  0xC0, 0x77, 0x01, 0xF8, 0x07, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE0,
  0xE1, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0xF8, 0x7F, 0xC0,
  0xFF, 0xC3, 0x83, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x79, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1C, 0xE0,
  0xE3, 0xCF, 0x87, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7,
  0x0F, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x01, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x70, 0x73,
  0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x3F, 0xB8, 0xFC, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0xE3, 0xC7, 0x87, 0xFC, 0x0F, 0xC0, 0x1C, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0xE1, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x3F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E,
  0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x80, 0x0F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x78, 0x78, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x1E, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x78, 0x38, 0x70, 0x38, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xF0,
  0x70, 0x70, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0x1C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1C, 0x0E, 0x38, 0x3C, 0xD8, 0x79, 0xB1, 0xB3, 0x63, 0xE6,
  0xCD, 0xCD, 0x9B, 0x1B, 0x76, 0x76, 0xDC, 0xE7, 0xB9, 0xCE, 0x73, 0x80,
  0xE7, 0x01, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73,
  0x80, 0xC6, 0x03, 0x80, 0x1E, 0x0E, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0x63,
  0xF0, 0xC7, 0xE3, 0x8E, 0xC7, 0x1D, 0x8E, 0x3B, 0x1C, 0x67, 0x39, 0xCE,
  0x63, 0x8D, 0xC7, 0x1B, 0x8E, 0x37, 0x1C, 0x7E, 0x30, 0xFC, 0x60, 0xF1,
  0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x80, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x70,
  0x77, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xF8, 0x1D,
  0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x9F, 0x1F,
  0xF0, 0x7E, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0xF1, 0x80,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x71, 0xF8, 0xFF, 0xE3,
  0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0xE0,
  0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x39,
  0xC0, 0x73, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x70, 0xF1, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE1,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x3C, 0x7F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xF1,
  0xC0, 0xE3, 0x81, 0xC7, 0x03, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xE0, 0xE1, 0x81, 0xC7, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x70, 0x1C,
  0xF0, 0x78, 0xF1, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x18, 0x70, 0x70, 0xF1, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xB8, 0x0E, 0x60, 0x71, 0x81, 0xC7, 0x06, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x07, 0x70, 0x0D,
  0xC0, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0xE1, 0x87, 0xE3, 0x86,
  0xE3, 0x8E, 0xE2, 0x8E, 0xE6, 0x8C, 0xE6, 0x8C, 0xE7, 0x9C, 0xE5, 0x9C,
  0xED, 0x98, 0xCD, 0x98, 0xCD, 0xB8, 0xC9, 0xB8, 0xD9, 0xB0, 0xD9, 0xB0,
  0xD1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0,
  0x1C, 0x07, 0x87, 0x03, 0x83, 0x83, 0x81, 0xE3, 0xC0, 0x71, 0xC0, 0x39,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x38, 0xE0, 0x38, 0x38,
  0x3C, 0x1C, 0x1C, 0x0F, 0x1C, 0x03, 0x80, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0x9C, 0x1C, 0x70, 0x71, 0xC3, 0x83, 0x9C, 0x0E, 0x70, 0x3B, 0x80, 0x6E,
  0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xE3, 0xF8, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0x87, 0xF0, 0xFE, 0x00, 0xE0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x80,
  0x0F, 0xE1, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xC7, 0xF8, 0xFE, 0x00, 0x01,
  0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0E, 0xE1, 0xCE, 0x1C, 0x63, 0x87, 0x30,
  0x77, 0x03, 0xE0, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x70, 0x07,
  0xDC, 0x7F, 0x71, 0xEF, 0xCE, 0x0F, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x78, 0xF1, 0xFF, 0xC3,
  0xF7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE7,
  0xC3, 0xBF, 0x8F, 0xBE, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x73, 0xE3, 0xCE, 0xFE, 0x3B,
  0xF0, 0x0F, 0xC0, 0xFF, 0x8F, 0xFC, 0xE0, 0xF7, 0x03, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x1D, 0xC1, 0xCF, 0x1E, 0x3F, 0xE0,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0xFB, 0x87, 0xF7, 0x0F, 0x7E, 0x38, 0x3C, 0x70, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xF1, 0xE1,
  0xFF, 0xC1, 0xFB, 0x80, 0x0F, 0xC0, 0xFF, 0x0E, 0x3C, 0xE0, 0xE7, 0x03,
  0x70, 0x1B, 0xFF, 0xDF, 0xFE, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xCF,
  0x1E, 0x3F, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xB9, 0xFD, 0xCF, 0x7E, 0xE0, 0xF7, 0x07, 0x70, 0x3B,
  0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xF7, 0xC7, 0xFE, 0x1F,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC3, 0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE7, 0xC3, 0xBF, 0x8F,
  0x9E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x9C, 0x0E, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0x00, 0xE0,
  0x0F, 0x80, 0x78, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x3F, 0xE0, 0x7F, 0x81, 0xF8, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x03, 0xCE, 0x07, 0x1C,
  0x1C, 0x38, 0x70, 0x71, 0xE0, 0xE7, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0x1C, 0x70, 0x38, 0xF0, 0x70, 0xE0, 0xC1, 0xE3, 0x81, 0xC7, 0x03, 0xC0,
  0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0x1B, 0x9E, 0x1F, 0xFE, 0x39, 0xCE,
  0x38, 0xC6, 0x39, 0xCE, 0x39, 0xCE, 0x31, 0x8E, 0x31, 0x8E, 0x71, 0x8C,
  0x71, 0x8C, 0x71, 0x8C, 0x73, 0x9C, 0x63, 0x1C, 0x63, 0x1C, 0xE3, 0x1C,
  0x39, 0xF0, 0xEF, 0xE3, 0xE7, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xE0, 0xE7, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xCF, 0x1E,
  0x3F, 0xE0, 0xFC, 0x00, 0x1C, 0xF8, 0x3B, 0xF8, 0x7F, 0xF0, 0xE0, 0xE1,
  0xC1, 0xC3, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0,
  0x71, 0xC1, 0xC7, 0xC7, 0x8E, 0xFE, 0x1D, 0xF8, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x00, 0x07, 0xDC, 0x7F, 0x71, 0xEF, 0xCE,
  0x0F, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x07, 0x1C, 0x1C, 0x78, 0xF1, 0xFF, 0xC3, 0xF7, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x3B, 0xE1, 0xFF, 0x8F, 0xBE, 0xF0, 0x77,
  0x03, 0xB8, 0x1D, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0xE3, 0xE7, 0x8E,
  0x07, 0x38, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xE0,
  0x03, 0xB8, 0x0E, 0x70, 0xF1, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38,
  0x18, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x1C,
  0x1C, 0x78, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0xC0, 0x3F, 0x03, 0xB8, 0x1D,
  0xC1, 0xCE, 0x0E, 0x70, 0xE1, 0x87, 0x0E, 0x30, 0x73, 0x83, 0x9C, 0x1D,
  0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0xC3, 0x8F, 0x87, 0x1B,
  0x1E, 0x36, 0x3C, 0xEC, 0x51, 0x99, 0xA3, 0x33, 0x4E, 0x64, 0x98, 0xD9,
  0x31, 0xB2, 0xE3, 0x45, 0x87, 0x8B, 0x0F, 0x1E, 0x1C, 0x38, 0x38, 0x70,
  0x00, 0x1C, 0x0F, 0x1E, 0x1E, 0x0E, 0x1C, 0x0F, 0x38, 0x07, 0x70, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1C,
  0x70, 0x38, 0x70, 0x78, 0x38, 0xF0, 0x3C, 0x70, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0x77, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0xB8,
  0x39, 0xFF, 0xC7, 0xFE, 0x1E, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC3, 0xFE,
  0x3F, 0xE1, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x1F, 0xC0, 0x7E, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xC0, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70,
  0xE0, 0x1F, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xF8,
  0x1F, 0xE0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x3F, 0x0D, 0xFC,
  0x37, 0x39, 0xD8, 0xFE, 0xE1, 0xF8,
};

const GFXglyph JetBrainsMono_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 20, 16, 5, -20 },
  { 19, 9, 8, 16, 5, -20 },
  { 28, 17, 20, 16, 0, -20 },
  { 71, 15, 27, 16, 1, -23 },
  { 122, 19, 20, 16, -1, -20 },
  { 170, 16, 20, 16, 0, -20 },
  { 210, 4, 8, 16, 7, -20 },
  { 214, 12, 26, 16, 4, -23 },
  { 253, 12, 26, 16, 1, -23 },
  { 292, 15, 14, 16, 1, -16 },
  { 319, 13, 12, 16, 2, -15 },
  { 339, 8, 8, 16, 2, -4 },
  { 347, 9, 2, 16, 4, -10 },
  { 350, 5, 5, 16, 5, -5 },
  { 354, 17, 25, 16, 0, -22 },
  { 408, 15, 20, 16, 1, -20 },
  { 446, 13, 20, 16, 1, -20 },
  { 479, 14, 20, 16, 1, -20 },
  { 514, 14, 20, 16, 1, -20 },
  { 549, 14, 20, 16, 1, -20 },
  { 584, 14, 20, 16, 1, -20 },
  { 619, 14, 20, 16, 1, -20 },
  { 654, 14, 20, 16, 3, -20 },
  { 689, 14, 20, 16, 1, -20 },
  { 724, 14, 20, 16, 2, -20 },
  { 759, 7, 15, 16, 5, -15 },
  { 773, 9, 19, 16, 3, -15 },
  { 795, 13, 14, 16, 2, -16 },
  { 818, 13, 10, 16, 2, -14 },
  { 835, 14, 14, 16, 1, -16 },
  { 860, 11, 20, 16, 4, -20 },
  { 888, 17, 25, 16, 0, -20 },
  { 942, 14, 20, 16, 0, -20 },
  { 977, 15, 20, 16, 1, -20 },
  { 1015, 14, 20, 16, 2, -20 },
  { 1050, 14, 20, 16, 1, -20 },
  { 1085, 15, 20, 16, 1, -20 },
  { 1123, 15, 20, 16, 1, -20 },
  { 1161, 14, 20, 16, 2, -20 },
  { 1196, 15, 20, 16, 1, -20 },
  { 1234, 15, 20, 16, 1, -20 },
  { 1272, 16, 20, 16, 0, -20 },
  { 1312, 16, 20, 16, 1, -20 },
  { 1352, 12, 20, 16, 2, -20 },
  { 1382, 15, 20, 16, 1, -20 },
  { 1420, 15, 20, 16, 1, -20 },
  { 1458, 13, 20, 16, 2, -20 },
  { 1491, 15, 20, 16, 1, -20 },
  { 1529, 15, 25, 16, 1, -20 },
  { 1576, 15, 20, 16, 1, -20 },
  { 1614, 15, 20, 16, 1, -20 },
  { 1652, 14, 20, 16, 3, -20 },
  { 1687, 15, 20, 16, 1, -20 },
  { 1725, 14, 20, 16, 3, -20 },
  { 1760, 16, 20, 16, 2, -20 },
  { 1800, 17, 20, 16, 0, -20 },
  { 1843, 14, 20, 16, 3, -20 },
  { 1878, 15, 20, 16, 1, -20 },
  { 1916, 11, 25, 16, 4, -22 },
  { 1951, 9, 25, 16, 4, -22 },
  { 1980, 11, 25, 16, 2, -22 },
  { 2015, 12, 11, 16, 2, -20 },
  { 2032, 13, 2, 16, 0, 1 },
  { 2036, 5, 4, 16, 7, -21 },
  { 2039, 14, 15, 16, 1, -15 },
  { 2066, 14, 20, 16, 1, -20 },
  { 2101, 13, 15, 16, 2, -15 },
  { 2126, 15, 20, 16, 1, -20 },
  { 2164, 13, 15, 16, 2, -15 },
  { 2189, 18, 25, 16, -1, -20 },
  { 2246, 13, 20, 16, 2, -15 },
  { 2279, 14, 20, 16, 1, -20 },
  { 2314, 13, 21, 16, 1, -21 },
  { 2349, 15, 26, 16, 0, -21 },
  { 2398, 15, 20, 16, 1, -20 },
  { 2436, 12, 20, 16, 2, -20 },
  { 2466, 16, 15, 16, 0, -15 },
  { 2496, 14, 15, 16, 1, -15 },
  { 2523, 13, 15, 16, 2, -15 },
  { 2548, 15, 20, 16, 0, -15 },
  { 2586, 14, 20, 16, 1, -15 },
  { 2621, 13, 15, 16, 2, -15 },
  { 2646, 14, 15, 16, 1, -15 },
  { 2673, 13, 19, 16, 2, -19 },
  { 2704, 14, 15, 16, 1, -15 },
  { 2731, 13, 15, 16, 3, -15 },
  { 2756, 15, 15, 16, 2, -15 },
  { 2785, 16, 15, 16, 0, -15 },
  { 2815, 13, 20, 16, 2, -15 },
  { 2848, 14, 15, 16, 1, -15 },
  { 2875, 14, 25, 16, 2, -22 },
  { 2919, 7, 25, 16, 5, -22 },
  { 2941, 14, 25, 16, 1, -22 },
  { 2985, 14, 5, 16, 1, -12 },
};

const GFXfont JetBrainsMono_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_MEDIUMITALIC27PT7B_H_
