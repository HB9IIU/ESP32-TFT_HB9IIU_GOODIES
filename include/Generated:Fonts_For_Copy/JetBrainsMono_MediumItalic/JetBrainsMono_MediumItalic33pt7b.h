#ifndef _JETBRAINSMONO_MEDIUMITALIC33PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8,
  0xF8, 0x78, 0xF7, 0x0E, 0x71, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xE1, 0xCE,
  0x1C, 0xE1, 0xCE, 0x1C, 0x00, 0xE0, 0xE0, 0x18, 0x38, 0x07, 0x07, 0x00,
  0xE0, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0xE0, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x18,
  0x38, 0x07, 0x07, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xE0,
  0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x18, 0x38, 0x07, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x37, 0xC7, 0x8C, 0xF1,
  0xE6, 0x3C, 0x79, 0x80, 0x1E, 0x60, 0x07, 0x98, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0x7C, 0x00, 0xCF,
  0x00, 0x31, 0xC0, 0x0C, 0x71, 0xC6, 0x3C, 0x71, 0x8F, 0x1E, 0x67, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x0E, 0x1F, 0xE0, 0x38,
  0x39, 0xE0, 0xE0, 0xE1, 0xC3, 0x81, 0xC3, 0x8E, 0x03, 0x86, 0x38, 0x07,
  0x1C, 0x60, 0x0E, 0x39, 0xC0, 0x1F, 0xE7, 0x00, 0x3F, 0xDC, 0x00, 0x1E,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x78, 0x00, 0x3B,
  0xF8, 0x00, 0xEF, 0x78, 0x03, 0x9C, 0x70, 0x0E, 0x70, 0xE0, 0x38, 0xE1,
  0xC0, 0x61, 0xC3, 0x81, 0xC3, 0x86, 0x07, 0x07, 0x9C, 0x1C, 0x07, 0xF0,
  0x70, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x3C,
  0x0E, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC3, 0xDE, 0x78, 0xE7, 0x1E,
  0x73, 0xC3, 0xFC, 0xF0, 0xFE, 0x3C, 0x1F, 0x0E, 0x03, 0xC3, 0x81, 0xF0,
  0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xFC, 0xF0, 0xFE, 0x3C, 0x7B, 0xDE, 0xE7,
  0x7B, 0xDE, 0xE7, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x60,
  0x04, 0x00, 0x38, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0xE0, 0x7E,
  0x03, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x04, 0x1C, 0x0B, 0x8E, 0x3F, 0xF3, 0x7F, 0xFD, 0x7F, 0x1F, 0xFC, 0x00,
  0xE0, 0x01, 0xF8, 0x01, 0xDE, 0x01, 0xE7, 0x01, 0xE3, 0xC1, 0xE1, 0xF0,
  0xE0, 0x70, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x78,
  0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFE, 0x11, 0xEF, 0xFF, 0xFB, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0F, 0x78,
  0x07, 0x3C, 0x03, 0x9E, 0x71, 0xCE, 0x79, 0xE7, 0x3C, 0xF3, 0x8E, 0x7B,
  0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x9E, 0x03,
  0x8F, 0x03, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7C, 0x01,
  0xFC, 0x03, 0xFC, 0x0F, 0xBC, 0x1F, 0x3C, 0x1C, 0x38, 0x18, 0x38, 0x10,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x01, 0x1F, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x78,
  0x78, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x78,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0xF0, 0x1D, 0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xC7, 0x81,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0x8F, 0x07, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xBE, 0x07, 0xFF, 0x83,
  0xFF, 0xE3, 0xE0, 0xF1, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x70, 0x07,
  0xB8, 0x03, 0x9C, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E,
  0x0E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x0F, 0x03,
  0xC7, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xCF, 0x83, 0xC0,
  0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xE0, 0x3C,
  0x78, 0x1E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFE, 0x3C, 0x1F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F,
  0xB8, 0x1E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1F, 0x3F, 0x3F,
  0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC,
  0xFC, 0xF8, 0xF8, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x20,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x3F,
  0xC0, 0xFF, 0xC3, 0xFF, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x07, 0xF8, 0x1F, 0xC0, 0x7C, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xE3,
  0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF1, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x38, 0x1E, 0x73, 0x87, 0xF7, 0x38, 0x79, 0xE3, 0x8F, 0x0E, 0x38,
  0xE0, 0xE7, 0x8E, 0x0E, 0x70, 0xE0, 0xE7, 0x0E, 0x0E, 0x71, 0xE1, 0xC7,
  0x1C, 0x1C, 0x71, 0xC1, 0xC7, 0x1E, 0x3C, 0xE0, 0xFD, 0xCE, 0x0F, 0x9C,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x03,
  0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0x70,
  0x78, 0x38, 0x38, 0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0x01,
  0xC7, 0x80, 0xE7, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x0F, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x38, 0x1F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x03, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0E, 0x07, 0xC3, 0x80, 0xF0, 0xE0, 0x1E, 0x38,
  0x07, 0x1E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x3E, 0x1F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC1, 0xF1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F,
  0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x38, 0x3E, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C,
  0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x70, 0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC1, 0xF1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x1F, 0xE7, 0x8F, 0xF3, 0x87, 0xF9, 0xC7,
  0xF8, 0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F,
  0x83, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x01, 0xC3, 0xC0,
  0x70, 0xE0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38,
  0x78, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x38, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xE3,
  0xC0, 0x78, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x3C, 0x3C, 0x07, 0x87, 0xC1, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0x01, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1C, 0x3C,
  0x01, 0xC3, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xC7,
  0x80, 0x38, 0x78, 0x03, 0x83, 0x80, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78,
  0x1C, 0x07, 0x81, 0xE0, 0x70, 0x1E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0xEC, 0x37,
  0x1F, 0x8E, 0xE7, 0x71, 0xCC, 0xEE, 0x39, 0x99, 0xC7, 0x37, 0x70, 0xE6,
  0xCE, 0x1C, 0xF9, 0xC3, 0x9E, 0x38, 0xF3, 0xCF, 0x1E, 0x01, 0xE3, 0x80,
  0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x38, 0x03, 0x87, 0x00, 0x70, 0x0F, 0x81, 0xE1, 0xF0,
  0x38, 0x3E, 0x07, 0x0F, 0xC0, 0xE1, 0xF8, 0x3C, 0x3B, 0x87, 0x87, 0x70,
  0xE0, 0xEE, 0x1C, 0x1D, 0xC3, 0x83, 0xB8, 0x70, 0xF3, 0x8E, 0x1E, 0x73,
  0xC3, 0x8E, 0x78, 0x71, 0xCE, 0x0E, 0x39, 0xC1, 0xC3, 0xB8, 0x78, 0x77,
  0x0F, 0x0E, 0xE1, 0xC1, 0xFC, 0x38, 0x3F, 0x07, 0x03, 0xE0, 0xE0, 0x7C,
  0x3C, 0x0F, 0x87, 0x81, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0E, 0x38, 0x07,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F,
  0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0x03, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0xF0, 0x1E, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0x70, 0x0F, 0x78, 0x07,
  0x3C, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x7B, 0xC0,
  0x39, 0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F,
  0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xC7, 0x01, 0xE3, 0xC0, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x78, 0x38, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x01,
  0xE3, 0xC0, 0x3C, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3C, 0x1F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x3C,
  0x78, 0x1E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0xF8, 0x7C, 0x1F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xE0, 0x07, 0xF8, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF0, 0xE0, 0x78, 0x70,
  0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x03, 0xC7, 0x01,
  0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x70, 0xF0, 0xEE,
  0x1E, 0x1D, 0xC3, 0xC3, 0xB8, 0x78, 0xF7, 0x1B, 0x1C, 0xE3, 0x63, 0x9C,
  0x6C, 0x73, 0x9D, 0x9C, 0x73, 0x33, 0x8E, 0x66, 0x71, 0xCD, 0x8E, 0x73,
  0x33, 0x8E, 0x66, 0x71, 0xCC, 0xCE, 0x39, 0x99, 0xC7, 0x63, 0x70, 0xEC,
  0x6E, 0x1D, 0x8D, 0xC3, 0xF1, 0xB0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x0F, 0x00, 0xF8, 0x38, 0x07, 0x81,
  0xE0, 0x78, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x3C,
  0x00, 0x39, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x77, 0x80,
  0x07, 0x9C, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x1C, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xDC,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x38, 0x0E, 0x0F, 0x07, 0x83, 0xC3,
  0xC0, 0x70, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0x80,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF8, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFC, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x01,
  0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x39, 0xC0, 0x73, 0x80,
  0xEE, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xE1, 0xE0, 0x07, 0xE7, 0x1F, 0xF7, 0x3F, 0xF7, 0x3C, 0x1F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xBC,
  0x3F, 0x3C, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7B, 0xF8, 0x3B, 0xFE, 0x1D, 0xFF, 0x0F, 0x07, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0xC3, 0xE3, 0xBF,
  0xE1, 0xDF, 0xE1, 0xE7, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3C,
  0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x1C, 0xF8, 0x3C, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1F, 0x9C, 0x3F, 0xEE, 0x3F, 0xF7,
  0x1E, 0x0F, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F,
  0x87, 0xC3, 0xFF, 0xE1, 0xFE, 0xF0, 0x7E, 0x78, 0x07, 0xF8, 0x0F, 0xFC,
  0x1F, 0x3E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1C,
  0xF0, 0x3C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE7, 0x1F, 0xF7, 0x1F, 0xF7, 0x3C, 0x1F, 0x38, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0x78, 0x7C, 0x7F, 0xDC, 0x3F, 0xBC, 0x1F, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7B, 0xF8, 0x3B, 0xFE, 0x1D, 0xFF, 0x0F, 0x07, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x79,
  0xE0, 0x3C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x47, 0x80, 0xF0, 0xF0,
  0x3C, 0x1C, 0x0F, 0x83, 0x81, 0xE0, 0x70, 0x78, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x38, 0xF0, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x3C, 0x1C, 0x07,
  0x87, 0x80, 0x78, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x1D, 0xF7, 0xC3,
  0xFF, 0xF8, 0x79, 0xE7, 0x8E, 0x38, 0xF1, 0xC7, 0x1E, 0x78, 0xE3, 0x8F,
  0x1C, 0x71, 0xC3, 0x0E, 0x38, 0x61, 0xC7, 0x1C, 0x38, 0xE3, 0x8F, 0x1C,
  0x71, 0xC7, 0x8E, 0x38, 0xE1, 0xC7, 0x1C, 0x30, 0xE3, 0x8E, 0x1C, 0x71,
  0xC7, 0x9E, 0x38, 0xF0, 0x1E, 0xFE, 0x0E, 0xFF, 0x87, 0x7F, 0xC3, 0xC1,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xC0, 0x38,
  0xE0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3C, 0x1E, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8,
  0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0x7F, 0x03, 0xBF, 0xE0,
  0xEF, 0xF8, 0x3C, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0xEF, 0xF8, 0x3B, 0xFC, 0x1E, 0x7E, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE7, 0x1F, 0xF7, 0x3F, 0xFF, 0x3C, 0x1F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xBC, 0x3F,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x1C, 0xFE, 0x0E, 0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xE3, 0xC0, 0x79,
  0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0x3C, 0x0F,
  0x38, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1E, 0xE0, 0x1E, 0xF0, 0x3C, 0xFF, 0xFC,
  0x7F, 0xF8, 0x3F, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x3C, 0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xE1, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0x9C, 0x03, 0x8E,
  0x03, 0xC7, 0x01, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x38, 0x70,
  0x1C, 0x78, 0x0E, 0x38, 0x07, 0x3C, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xE0, 0xE1, 0xF8, 0x78,
  0x7E, 0x1E, 0x1B, 0x87, 0x8E, 0xE3, 0x63, 0xB8, 0xD8, 0xEE, 0x36, 0x73,
  0x99, 0x9C, 0xE6, 0x67, 0x39, 0x9B, 0x8E, 0xC6, 0xE3, 0xB1, 0xB8, 0xEC,
  0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x1E,
  0x00, 0x1F, 0x01, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x3C,
  0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x07, 0x87,
  0x81, 0xE0, 0x78, 0x78, 0x0F, 0x1F, 0x00, 0xF0, 0x3C, 0x07, 0x38, 0x07,
  0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x7C, 0xFC,
  0x7F, 0xDC, 0x3F, 0xBC, 0x0E, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x01, 0xC0, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78,
  0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E,
  0x0F, 0x07, 0x83, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0x03,
  0xBF, 0xC3, 0xDF, 0xF1, 0xDE, 0x78, 0xEE, 0x1F, 0xF7, 0x07, 0xF3, 0x81,
  0xE0,
};

const GFXglyph JetBrainsMono_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 24, 20, 6, -24 },
  { 25, 12, 10, 20, 6, -24 },
  { 40, 19, 24, 20, 1, -24 },
  { 97, 18, 34, 20, 1, -29 },
  { 174, 23, 24, 20, -1, -24 },
  { 243, 18, 24, 20, 1, -24 },
  { 297, 5, 10, 20, 9, -24 },
  { 304, 14, 32, 20, 5, -28 },
  { 360, 13, 32, 20, 2, -28 },
  { 412, 17, 17, 20, 2, -20 },
  { 449, 16, 16, 20, 2, -19 },
  { 481, 9, 10, 20, 3, -5 },
  { 493, 12, 4, 20, 4, -13 },
  { 499, 6, 6, 20, 6, -6 },
  { 504, 20, 31, 20, 0, -27 },
  { 582, 17, 24, 20, 2, -24 },
  { 633, 16, 24, 20, 1, -24 },
  { 681, 18, 24, 20, 1, -24 },
  { 735, 18, 24, 20, 1, -24 },
  { 789, 16, 24, 20, 2, -24 },
  { 837, 17, 24, 20, 2, -24 },
  { 888, 17, 24, 20, 1, -24 },
  { 939, 16, 24, 20, 4, -24 },
  { 987, 18, 24, 20, 1, -24 },
  { 1041, 16, 24, 20, 3, -24 },
  { 1089, 8, 18, 20, 6, -18 },
  { 1107, 11, 23, 20, 3, -18 },
  { 1139, 16, 18, 20, 3, -20 },
  { 1175, 16, 12, 20, 2, -17 },
  { 1199, 16, 18, 20, 2, -20 },
  { 1235, 14, 24, 20, 4, -24 },
  { 1277, 20, 30, 20, 0, -24 },
  { 1352, 17, 24, 20, 0, -24 },
  { 1403, 18, 24, 20, 1, -24 },
  { 1457, 17, 24, 20, 2, -24 },
  { 1508, 18, 24, 20, 1, -24 },
  { 1562, 18, 24, 20, 2, -24 },
  { 1616, 19, 24, 20, 1, -24 },
  { 1673, 17, 24, 20, 2, -24 },
  { 1724, 18, 24, 20, 1, -24 },
  { 1778, 17, 24, 20, 2, -24 },
  { 1829, 19, 24, 20, 0, -24 },
  { 1886, 20, 24, 20, 1, -24 },
  { 1946, 15, 24, 20, 2, -24 },
  { 1991, 19, 24, 20, 1, -24 },
  { 2048, 19, 24, 20, 1, -24 },
  { 2105, 17, 24, 20, 2, -24 },
  { 2156, 19, 24, 20, 1, -24 },
  { 2213, 17, 30, 20, 2, -24 },
  { 2277, 18, 24, 20, 1, -24 },
  { 2331, 18, 24, 20, 1, -24 },
  { 2385, 17, 24, 20, 4, -24 },
  { 2436, 18, 24, 20, 2, -24 },
  { 2490, 17, 24, 20, 4, -24 },
  { 2541, 19, 24, 20, 2, -24 },
  { 2598, 21, 24, 20, 0, -24 },
  { 2661, 18, 24, 20, 3, -24 },
  { 2715, 18, 24, 20, 1, -24 },
  { 2769, 14, 31, 20, 4, -27 },
  { 2824, 11, 31, 20, 5, -27 },
  { 2867, 13, 31, 20, 3, -27 },
  { 2918, 15, 13, 20, 3, -24 },
  { 2943, 16, 3, 20, 0, 1 },
  { 2949, 7, 5, 20, 8, -26 },
  { 2954, 16, 18, 20, 2, -18 },
  { 2990, 17, 24, 20, 1, -24 },
  { 3041, 16, 18, 20, 2, -18 },
  { 3077, 17, 24, 20, 2, -24 },
  { 3128, 16, 18, 20, 2, -18 },
  { 3164, 23, 30, 20, -2, -24 },
  { 3251, 16, 24, 20, 2, -18 },
  { 3299, 17, 24, 20, 1, -24 },
  { 3350, 16, 26, 20, 1, -26 },
  { 3402, 18, 32, 20, 0, -26 },
  { 3474, 19, 24, 20, 1, -24 },
  { 3531, 14, 24, 20, 3, -24 },
  { 3573, 19, 18, 20, 0, -18 },
  { 3616, 17, 18, 20, 1, -18 },
  { 3655, 16, 18, 20, 2, -18 },
  { 3691, 18, 24, 20, 0, -18 },
  { 3745, 16, 24, 20, 2, -18 },
  { 3793, 17, 18, 20, 2, -18 },
  { 3832, 16, 18, 20, 2, -18 },
  { 3868, 16, 23, 20, 3, -23 },
  { 3914, 17, 18, 20, 2, -18 },
  { 3953, 17, 18, 20, 3, -18 },
  { 3992, 18, 18, 20, 2, -18 },
  { 4033, 19, 18, 20, 0, -18 },
  { 4076, 16, 24, 20, 2, -18 },
  { 4124, 17, 18, 20, 1, -18 },
  { 4163, 17, 31, 20, 3, -27 },
  { 4229, 9, 31, 20, 6, -27 },
  { 4264, 17, 31, 20, 1, -27 },
  { 4330, 17, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_MEDIUMITALIC33PT7B_H_
