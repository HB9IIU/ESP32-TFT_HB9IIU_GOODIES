#ifndef _JETBRAINSMONO_MEDIUMITALIC52PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE7, 0xE0,
  0xFC, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83,
  0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x0F,
  0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xF9, 0xC7, 0xE0,
  0x7E, 0x1C, 0x7F, 0x07, 0xE1, 0xC3, 0xF0, 0x7C, 0x3C, 0x3F, 0x0F, 0xC3,
  0xC3, 0xF0, 0xFC, 0x38, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0xFC, 0x38, 0x00,
  0x0F, 0xE3, 0x80, 0x00, 0x7F, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0E, 0x3F, 0x80, 0x00, 0xE1, 0xF8, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0xE0,
  0xF8, 0x00, 0x1E, 0x0F, 0x87, 0xC1, 0xE1, 0xF8, 0x7C, 0x1C, 0x1F, 0x87,
  0xC1, 0xC1, 0xF0, 0x7E, 0x1C, 0x3F, 0x07, 0xF1, 0xC7, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0x0F, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x3E,
  0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x78,
  0x00, 0xF8, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x7C, 0x00, 0x3C, 0x07,
  0x87, 0xC0, 0x01, 0xE0, 0x7C, 0x7C, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x3E, 0x3C, 0x00, 0x03, 0xFF, 0xE3, 0xC0, 0x00, 0x1F, 0xFF, 0x3C,
  0x00, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x00, 0x1F,
  0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0x3F, 0xFF, 0x00,
  0x00, 0xF1, 0xE0, 0xF8, 0x00, 0x0F, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0xF0,
  0x1E, 0x00, 0x0F, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x3C, 0x0F, 0x80, 0x0F,
  0x81, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x1E,
  0x00, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x7C, 0x00,
  0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x03,
  0xF3, 0xF9, 0xF8, 0x1F, 0x1F, 0x8F, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F, 0x87,
  0xC1, 0xF8, 0xF8, 0x7E, 0x07, 0xEF, 0x83, 0xF0, 0x1F, 0xFC, 0x1F, 0x80,
  0xFF, 0xC0, 0xF8, 0x03, 0xFC, 0x07, 0xC0, 0x1F, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x7E, 0x07, 0xFE, 0x03,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xF7, 0xC0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF,
  0xE0, 0xFC, 0x07, 0xFC, 0x07, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0xF8, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0x00, 0x7C, 0x02, 0x78, 0x0F, 0x01, 0xEF, 0xE1, 0xE1, 0xFF, 0xFE,
  0x38, 0xFF, 0xFF, 0xE7, 0x3F, 0xFF, 0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xFC, 0x03, 0xC0, 0x1E, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x0F, 0xE7, 0xF9, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE1,
  0xF0, 0xF8, 0xFE, 0x3E, 0x3F, 0x1F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x3C, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0,
  0xFE, 0x01, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xE7, 0xE0, 0x0F, 0xE3,
  0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xC0, 0xF8, 0x01, 0x80, 0x7C, 0x01, 0x80,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x07, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x7F,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xFB, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x07, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x03, 0xF8,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0x9F,
  0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0x87, 0xF0,
  0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x7E, 0x03, 0xFF, 0xBF, 0x00, 0x7F, 0xDF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFE, 0x0F,
  0xF0, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x04, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80,
  0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x7F, 0x3E,
  0x1F, 0x00, 0xFF, 0xBE, 0x1F, 0x01, 0xFF, 0xFE, 0x1F, 0x03, 0xF9, 0xFE,
  0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0x7C,
  0x3E, 0x07, 0x80, 0x7C, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x0F, 0x80, 0x7C,
  0x3E, 0x0F, 0x80, 0x78, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x80, 0xF8,
  0x3C, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0xF8,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0xFF, 0xF0,
  0x78, 0x0F, 0xFE, 0xF0, 0xF8, 0x07, 0xFC, 0xF0, 0xF8, 0x03, 0xF1, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x81,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0,
  0x03, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x07,
  0xF0, 0x7C, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x01,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00,
  0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0x07,
  0xFF, 0xC3, 0xE0, 0xFF, 0xF8, 0xFC, 0x1F, 0xFF, 0x1F, 0x83, 0xFF, 0xE3,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xFD, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1D, 0xC0, 0x1F, 0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0xF7, 0x80, 0xF7,
  0x81, 0xEF, 0x03, 0xFE, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0xBC, 0x0F, 0x78,
  0x0F, 0x78, 0x3C, 0xF0, 0x3E, 0x78, 0x7B, 0xE0, 0x7C, 0xF1, 0xE7, 0xC0,
  0xF9, 0xE3, 0xCF, 0x81, 0xF3, 0xCF, 0x1E, 0x03, 0xE7, 0x9E, 0x7C, 0x07,
  0xCF, 0x78, 0xF8, 0x0F, 0x9E, 0xF1, 0xF0, 0x3E, 0x1D, 0xE3, 0xE0, 0x7C,
  0x3F, 0x8F, 0xC0, 0xF8, 0x7F, 0x1F, 0x01, 0xF0, 0xFC, 0x3E, 0x03, 0xE1,
  0xF8, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0x7C, 0x0F, 0xF8, 0x03, 0xE0, 0x7F, 0xC0, 0x1F, 0x03,
  0xFE, 0x00, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0xFF, 0x80, 0x7E, 0x07, 0xBE,
  0x03, 0xE0, 0x7D, 0xF0, 0x1F, 0x03, 0xEF, 0x80, 0xF8, 0x1F, 0x3C, 0x07,
  0xC0, 0xF9, 0xE0, 0x3E, 0x07, 0xCF, 0x83, 0xF0, 0x3E, 0x7C, 0x1F, 0x03,
  0xF3, 0xE0, 0xF8, 0x1F, 0x8F, 0x07, 0xC0, 0xF8, 0x78, 0x3E, 0x07, 0xC3,
  0xE1, 0xF0, 0x3E, 0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0xF8, 0x0F, 0x87, 0xC7,
  0xC0, 0xFC, 0x1E, 0x3E, 0x07, 0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF, 0x81,
  0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x07, 0xBE, 0x07, 0xE0,
  0x3F, 0xF0, 0x3E, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0x80, 0x7F,
  0xE0, 0x7C, 0x01, 0xFF, 0x03, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x81,
  0xF8, 0x03, 0xFC, 0x0F, 0x80, 0x1F, 0xE0, 0x7C, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x81, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03,
  0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00,
  0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1,
  0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x7C, 0x0F, 0xC0, 0x78,
  0xF8, 0x1F, 0x81, 0xF1, 0xF0, 0x3F, 0x03, 0xE3, 0xC0, 0xFE, 0x07, 0xC7,
  0x81, 0xDC, 0x0F, 0x0F, 0x03, 0xB8, 0x3E, 0x3E, 0x07, 0xF0, 0x7C, 0x7C,
  0x1F, 0xE0, 0xF8, 0xF8, 0x3B, 0xC1, 0xE1, 0xF0, 0x77, 0x87, 0xC3, 0xE0,
  0xEF, 0x0F, 0x87, 0xC3, 0xDC, 0x1E, 0x0F, 0x87, 0x38, 0x3C, 0x1F, 0x0E,
  0x70, 0xF8, 0x3E, 0x3C, 0xE1, 0xF0, 0x7C, 0x71, 0xC3, 0xC0, 0xF8, 0xE3,
  0x8F, 0x81, 0xF1, 0xC7, 0x1F, 0x03, 0xC7, 0x8E, 0x3E, 0x07, 0x8E, 0x1C,
  0x78, 0x0F, 0x1C, 0x39, 0xF0, 0x1E, 0x78, 0x73, 0xE0, 0x3C, 0xE0, 0xE7,
  0xC0, 0x79, 0xC1, 0xCF, 0x00, 0xF3, 0x83, 0xBE, 0x03, 0xEF, 0x07, 0x7C,
  0x07, 0xDC, 0x0E, 0xF0, 0x0F, 0xB8, 0x1D, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0x78, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x3C, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF8, 0x00, 0x7F, 0x0F,
  0xC0, 0x7F, 0xF3, 0xF0, 0x3F, 0xFE, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0xFF, 0x87, 0xF8, 0x1F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF0, 0x7F, 0xCF, 0x7C, 0x1F, 0xFF, 0xDF, 0x03, 0xFF, 0xEF,
  0xC0, 0x7F, 0xF3, 0xF0, 0x0F, 0xF8, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0xFC, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0x79,
  0xFF, 0x07, 0xDF, 0xFF, 0xC3, 0xF7, 0xFF, 0xE0, 0xFC, 0xFF, 0xF0, 0x3F,
  0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xF8,
  0x1F, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0x7F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0xFC, 0x01, 0xFF, 0xCF, 0xC0, 0x3F,
  0xFE, 0xFC, 0x07, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x07, 0xFC, 0xF7, 0xC0, 0x7F, 0xFF, 0x7C, 0x03, 0xFF,
  0xEF, 0xC0, 0x1F, 0xFC, 0xFC, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0x9F, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7,
  0xC0, 0x03, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x11, 0xF0, 0x01,
  0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x7F,
  0xF3, 0xF0, 0x3F, 0xFE, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x83,
  0xF8, 0x1F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFD,
  0xF0, 0x3F, 0xFF, 0x7C, 0x07, 0xFF, 0x1F, 0x00, 0x7F, 0x8F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0xFC, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x07,
  0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0x8F, 0x07, 0xC0, 0x7D, 0xFC, 0x7F, 0x03,
  0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC1,
  0xE0, 0xF8, 0x7C, 0x0F, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0x7C, 0x3E, 0x0F, 0x03, 0xE3,
  0xE0, 0x78, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x78, 0x1F, 0x1F, 0x03, 0xC1,
  0xF8, 0xF8, 0x1E, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE1,
  0xF0, 0x78, 0x1F, 0x0F, 0x83, 0xC0, 0xF8, 0xFC, 0x1E, 0x07, 0xC7, 0xC0,
  0xF0, 0x7C, 0x3E, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0,
  0xF8, 0x00, 0x07, 0xC3, 0xFC, 0x03, 0xF3, 0xFF, 0x80, 0xFD, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xE7,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F,
  0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF8, 0x03,
  0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xE1, 0xFE, 0x00, 0xFC, 0xFF, 0xE0, 0x1F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFE, 0x03, 0xF8, 0x3E, 0xF3, 0xFE, 0x07,
  0xDF, 0xFF, 0xC1, 0xFB, 0xFF, 0xF0, 0x3F, 0x3F, 0xFC, 0x07, 0xE3, 0xFE,
  0x00, 0xFC, 0x04, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x7F, 0xF3, 0xF0, 0x3F, 0xFE, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xEF,
  0x87, 0xF8, 0x1F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF0, 0x7F, 0xCF, 0x7C, 0x1F, 0xFF, 0xDF, 0x03, 0xFF, 0xEF, 0xC0,
  0x7F, 0xF3, 0xF0, 0x0F, 0xF8, 0xFC, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xC3, 0xFC, 0x01, 0xF9, 0xFF, 0xC0, 0x3F, 0x7F, 0xFC, 0x07, 0xDF,
  0xFF, 0xC0, 0xFB, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF0,
  0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x07,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00,
  0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x1F,
  0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xEF, 0x03, 0xF0, 0x3E,
  0xF0, 0x3F, 0x03, 0xEF, 0x03, 0xF0, 0x3C, 0xF0, 0x7F, 0x03, 0xCF, 0x07,
  0x70, 0x7C, 0xF0, 0x77, 0x07, 0x8F, 0x0F, 0x70, 0x78, 0xF0, 0xE7, 0x0F,
  0x8F, 0x0E, 0x70, 0xF0, 0xF0, 0xE7, 0x0F, 0x0F, 0x1C, 0x71, 0xF0, 0xF1,
  0xC7, 0x1F, 0x0F, 0x1C, 0x71, 0xE0, 0xF3, 0x87, 0x1E, 0x0F, 0x38, 0x73,
  0xE0, 0xF3, 0x87, 0x3C, 0x0F, 0x78, 0x73, 0xC0, 0xF7, 0x07, 0x7C, 0x0F,
  0x70, 0x77, 0x80, 0xFF, 0x07, 0x78, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xFE, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFD, 0xF0, 0x3F,
  0xFE, 0x7C, 0x03, 0xFF, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x40, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x21, 0xFF, 0x00, 0xF8, 0xFF, 0xF0, 0x1F, 0x1F, 0xFF, 0x03, 0xE7, 0xFF,
  0xE0, 0x7C, 0xF8, 0x7E, 0x0F, 0xBE, 0x07, 0xE3, 0xE7, 0xC0, 0xFF, 0xFC,
  0xF8, 0x0F, 0xFF, 0x1F, 0x00, 0xFF, 0xC3, 0xE0, 0x0F, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 38, 31, 9, -38 },
  { 68, 19, 16, 31, 9, -38 },
  { 106, 31, 38, 31, 1, -38 },
  { 254, 28, 52, 31, 2, -45 },
  { 436, 37, 38, 31, -2, -38 },
  { 612, 29, 39, 31, 1, -38 },
  { 754, 8, 16, 31, 14, -38 },
  { 770, 22, 51, 31, 8, -44 },
  { 911, 21, 51, 31, 3, -44 },
  { 1045, 27, 27, 31, 3, -32 },
  { 1137, 26, 24, 31, 3, -29 },
  { 1215, 14, 16, 31, 5, -8 },
  { 1243, 18, 5, 31, 7, -20 },
  { 1255, 10, 10, 31, 9, -9 },
  { 1268, 32, 49, 31, 0, -43 },
  { 1464, 27, 39, 31, 3, -38 },
  { 1596, 25, 38, 31, 2, -38 },
  { 1715, 28, 38, 31, 2, -38 },
  { 1848, 27, 39, 31, 2, -38 },
  { 1980, 26, 38, 31, 3, -38 },
  { 2104, 27, 39, 31, 3, -38 },
  { 2236, 26, 39, 31, 2, -38 },
  { 2363, 26, 38, 31, 6, -38 },
  { 2487, 27, 40, 31, 2, -39 },
  { 2622, 26, 38, 31, 4, -38 },
  { 2746, 13, 30, 31, 9, -29 },
  { 2795, 17, 37, 31, 5, -29 },
  { 2874, 26, 28, 31, 4, -31 },
  { 2965, 26, 18, 31, 3, -26 },
  { 3024, 26, 28, 31, 2, -31 },
  { 3115, 22, 38, 31, 7, -38 },
  { 3220, 32, 47, 31, 0, -38 },
  { 3408, 27, 38, 31, 0, -38 },
  { 3537, 28, 38, 31, 2, -38 },
  { 3670, 27, 39, 31, 3, -38 },
  { 3802, 28, 38, 31, 2, -38 },
  { 3935, 28, 38, 31, 3, -38 },
  { 4068, 29, 38, 31, 2, -38 },
  { 4206, 27, 39, 31, 3, -38 },
  { 4338, 29, 38, 31, 2, -38 },
  { 4476, 27, 38, 31, 3, -38 },
  { 4605, 29, 39, 31, 1, -38 },
  { 4747, 31, 38, 31, 2, -38 },
  { 4895, 23, 38, 31, 3, -38 },
  { 5005, 31, 38, 31, 1, -38 },
  { 5153, 29, 38, 31, 2, -38 },
  { 5291, 27, 39, 31, 3, -38 },
  { 5423, 29, 38, 31, 2, -38 },
  { 5561, 27, 47, 31, 3, -38 },
  { 5720, 29, 38, 31, 2, -38 },
  { 5858, 28, 40, 31, 2, -39 },
  { 5998, 26, 38, 31, 6, -38 },
  { 6122, 28, 39, 31, 3, -38 },
  { 6259, 27, 38, 31, 6, -38 },
  { 6388, 31, 38, 31, 3, -38 },
  { 6536, 34, 38, 31, -1, -38 },
  { 6698, 28, 38, 31, 5, -38 },
  { 6831, 28, 38, 31, 2, -38 },
  { 6964, 21, 49, 31, 7, -43 },
  { 7093, 16, 49, 31, 8, -43 },
  { 7191, 22, 49, 31, 4, -43 },
  { 7326, 24, 20, 31, 4, -38 },
  { 7386, 26, 5, 31, 0, 1 },
  { 7403, 11, 7, 31, 13, -41 },
  { 7413, 26, 30, 31, 3, -29 },
  { 7511, 26, 39, 31, 2, -38 },
  { 7638, 26, 30, 31, 3, -29 },
  { 7736, 28, 39, 31, 3, -38 },
  { 7873, 25, 30, 31, 3, -29 },
  { 7967, 36, 47, 31, -3, -38 },
  { 8179, 26, 38, 31, 3, -29 },
  { 8303, 26, 38, 31, 2, -38 },
  { 8427, 25, 41, 31, 2, -41 },
  { 8556, 27, 50, 31, 1, -41 },
  { 8725, 29, 38, 31, 2, -38 },
  { 8863, 22, 38, 31, 5, -38 },
  { 8968, 29, 29, 31, 1, -29 },
  { 9074, 26, 29, 31, 2, -29 },
  { 9169, 25, 30, 31, 3, -29 },
  { 9263, 27, 38, 31, 1, -29 },
  { 9392, 26, 38, 31, 3, -29 },
  { 9516, 27, 29, 31, 3, -29 },
  { 9614, 26, 30, 31, 2, -29 },
  { 9712, 25, 36, 31, 4, -36 },
  { 9825, 26, 30, 31, 3, -29 },
  { 9923, 26, 29, 31, 5, -29 },
  { 10018, 28, 29, 31, 4, -29 },
  { 10120, 30, 29, 31, 0, -29 },
  { 10229, 26, 38, 31, 3, -29 },
  { 10353, 27, 29, 31, 2, -29 },
  { 10451, 26, 49, 31, 5, -43 },
  { 10611, 13, 49, 31, 10, -43 },
  { 10691, 27, 49, 31, 1, -43 },
  { 10857, 27, 11, 31, 3, -24 },
};

const GFXfont JetBrainsMono_MediumItalic52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_MEDIUMITALIC52PT7B_H_
