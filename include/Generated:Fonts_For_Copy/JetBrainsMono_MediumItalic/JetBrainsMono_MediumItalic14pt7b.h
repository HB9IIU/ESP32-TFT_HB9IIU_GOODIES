#ifndef _JETBRAINSMONO_MEDIUMITALIC14PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x90, 0xD8, 0x6A, 0x53, 0xB0, 0x09, 0x0C, 0x9F, 0xEF,
  0xE3, 0x21, 0x23, 0xF8, 0x88, 0x48, 0x64, 0x00, 0x08, 0x10, 0xFB, 0xB5,
  0x0E, 0x1E, 0x0E, 0x15, 0x2B, 0xB7, 0xC2, 0x04, 0x00, 0x3C, 0x49, 0x22,
  0x50, 0xE8, 0x04, 0x02, 0x41, 0xE8, 0x52, 0x24, 0xB1, 0xC0, 0x1E, 0x32,
  0x20, 0x30, 0x30, 0x5B, 0x4A, 0xCC, 0xCE, 0x7A, 0xFA, 0x04, 0x73, 0x08,
  0x61, 0x04, 0x10, 0xC3, 0x0C, 0x18, 0x30, 0x40, 0x20, 0xC1, 0x82, 0x08,
  0x20, 0x82, 0x18, 0x61, 0x08, 0xC2, 0x00, 0x18, 0x22, 0x4F, 0xF1, 0x0F,
  0x33, 0x24, 0x18, 0x20, 0x47, 0xF3, 0x06, 0x0C, 0x00, 0x36, 0x6C, 0xF8,
  0x7C, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x04, 0x06, 0x00, 0x3C, 0xCD, 0x1E, 0x3F, 0x7A, 0xA1, 0x42,
  0xCC, 0xF0, 0x39, 0xA4, 0x86, 0x18, 0x61, 0x04, 0x13, 0xF0, 0x3C, 0xCF,
  0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xF8, 0x7E, 0x08, 0x61, 0x83, 0xC0,
  0x81, 0x42, 0xCD, 0xF0, 0x0E, 0x10, 0x41, 0x86, 0x58, 0xA1, 0x7E, 0x0C,
  0x18, 0x7E, 0xC1, 0x02, 0xC7, 0xD0, 0x81, 0x02, 0xCC, 0xF0, 0x0C, 0x30,
  0xC3, 0x07, 0xD8, 0xA1, 0xC2, 0xCC, 0xF0, 0xFF, 0x0A, 0x30, 0xC1, 0x86,
  0x08, 0x30, 0x41, 0x80, 0x3C, 0xCD, 0x1B, 0x23, 0x8D, 0xB1, 0x42, 0xCD,
  0xF0, 0x3C, 0xCF, 0x0E, 0x3C, 0x6F, 0x82, 0x08, 0x30, 0xC0, 0x37, 0x00,
  0x00, 0x6E, 0x19, 0xC0, 0x00, 0x00, 0xCC, 0x66, 0x00, 0x06, 0x39, 0xC6,
  0x07, 0x03, 0x01, 0x00, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x60, 0x60, 0x78,
  0x21, 0xDC, 0x20, 0x00, 0x78, 0x20, 0xC2, 0x79, 0x84, 0x00, 0xC3, 0x00,
  0x1F, 0x10, 0x98, 0x49, 0xE4, 0x92, 0xCB, 0x65, 0xA6, 0x9F, 0x40, 0x30,
  0x0F, 0x01, 0x80, 0x0C, 0x18, 0x70, 0xB3, 0x64, 0xDF, 0xB1, 0x43, 0x84,
  0x7C, 0x8D, 0x1A, 0x3F, 0x99, 0xB1, 0x42, 0x8D, 0xF0, 0x3C, 0xCD, 0x1A,
  0x0C, 0x18, 0x30, 0x42, 0xCC, 0xF0, 0x7C, 0x8D, 0x1A, 0x3C, 0x78, 0xB1,
  0x42, 0x9D, 0xE0, 0x7E, 0xC1, 0x02, 0x07, 0xD8, 0x30, 0x60, 0x81, 0xF8,
  0x7E, 0x81, 0x02, 0x0F, 0xDF, 0xB0, 0x60, 0x81, 0x00, 0x3C, 0xCD, 0x1A,
  0x0C, 0x1B, 0xF1, 0x42, 0xCC, 0xF0, 0x62, 0x8D, 0x1A, 0x3F, 0xD8, 0xB1,
  0x46, 0x8D, 0x18, 0x7E, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x31, 0xF8,
  0x0F, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0xC6, 0xC4, 0x78, 0x63, 0x46,
  0x4C, 0x48, 0xF8, 0xD8, 0xC8, 0x88, 0x8C, 0x8C, 0x61, 0x86, 0x10, 0x41,
  0x0C, 0x30, 0xC3, 0xF0, 0x33, 0x33, 0x35, 0x75, 0x7F, 0x4B, 0x42, 0x42,
  0x42, 0xC6, 0x62, 0xC5, 0xDA, 0xBD, 0x7A, 0xA5, 0x4E, 0x9D, 0x18, 0x3C,
  0xCD, 0x1A, 0x3C, 0x78, 0xB1, 0x42, 0xCC, 0xF0, 0x7E, 0x8D, 0x0A, 0x1C,
  0xFF, 0x30, 0x40, 0x81, 0x00, 0x3C, 0xCD, 0x1E, 0x3C, 0x78, 0xA1, 0x42,
  0xCC, 0xF0, 0x60, 0xC0, 0x80, 0x7C, 0x8D, 0x0A, 0x3F, 0xDF, 0x36, 0x44,
  0x8D, 0x18, 0x3E, 0xCD, 0x02, 0x07, 0x83, 0x81, 0x42, 0xCD, 0xF0, 0x7F,
  0x98, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x62, 0x8D, 0x1A,
  0x3C, 0x78, 0xB1, 0x42, 0xCC, 0xF0, 0x87, 0x0A, 0x34, 0x4D, 0x9A, 0x34,
  0x78, 0xE0, 0xC0, 0xD9, 0xDB, 0x9A, 0xAA, 0xAA, 0xAE, 0xAC, 0xCC, 0xCC,
  0xC8, 0x31, 0x99, 0x85, 0x83, 0x81, 0x80, 0xE0, 0xF0, 0x48, 0x66, 0x63,
  0x00, 0xC3, 0x46, 0x64, 0x2C, 0x28, 0x30, 0x30, 0x30, 0x30, 0x20, 0x7E,
  0x0C, 0x30, 0x41, 0x06, 0x18, 0x20, 0x81, 0xF8, 0x3C, 0xE2, 0x18, 0x61,
  0x84, 0x10, 0x41, 0x0C, 0x30, 0xF3, 0xC0, 0xC6, 0x10, 0x86, 0x30, 0x84,
  0x21, 0x8C, 0x21, 0x0C, 0x3C, 0xF0, 0xC2, 0x08, 0x21, 0x86, 0x18, 0x41,
  0x04, 0xF3, 0xC0, 0x18, 0x70, 0xB3, 0x2C, 0x60, 0xFF, 0xFC, 0x90, 0x3E,
  0xDF, 0x16, 0x2C, 0x51, 0xB3, 0x7E, 0x60, 0x81, 0x73, 0x6C, 0x78, 0xB1,
  0x42, 0xCD, 0x70, 0x38, 0xDB, 0x1E, 0x0C, 0x10, 0xB3, 0x3C, 0x02, 0x0C,
  0xFB, 0x7C, 0x58, 0xB1, 0x46, 0xCD, 0xF8, 0x38, 0xDB, 0x17, 0xEF, 0xD0,
  0x33, 0x3C, 0x07, 0xC1, 0x00, 0x40, 0xFE, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x83, 0xC0, 0xC0, 0x00, 0x3E, 0xDF, 0x16, 0x2C, 0x59,
  0xBF, 0x16, 0x0D, 0xF3, 0x80, 0x60, 0x81, 0x73, 0x6C, 0x78, 0xB1, 0x42,
  0x8D, 0x18, 0x04, 0x18, 0x01, 0xE3, 0xC1, 0x82, 0x04, 0x08, 0x33, 0xF8,
  0x02, 0x06, 0x00, 0x3E, 0x3E, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08,
  0xF8, 0xC0, 0x60, 0x81, 0x1A, 0x2C, 0xDF, 0x3E, 0x6C, 0x89, 0x18, 0xF0,
  0x43, 0x0C, 0x30, 0x82, 0x08, 0x20, 0xF0, 0x7B, 0x6F, 0x4B, 0x4B, 0x4B,
  0x5A, 0xD2, 0xD2, 0x5C, 0xDB, 0x1E, 0x2C, 0x50, 0xA3, 0x46, 0x38, 0xDB,
  0x1E, 0x2C, 0x50, 0xB3, 0x3C, 0x2E, 0x36, 0x63, 0x62, 0x62, 0x42, 0x66,
  0x5C, 0xC0, 0xC0, 0xC0, 0x3E, 0xDF, 0x16, 0x2C, 0x51, 0xB3, 0x7E, 0x0C,
  0x10, 0x20, 0x5C, 0xDD, 0x1A, 0x3C, 0x18, 0x30, 0x40, 0x3C, 0xDF, 0x03,
  0x83, 0xC0, 0xA3, 0x7C, 0x10, 0x23, 0xFF, 0xF3, 0x04, 0x08, 0x10, 0x20,
  0x78, 0x46, 0x8F, 0x1E, 0x2C, 0x51, 0xB3, 0x3C, 0xC3, 0x8D, 0x12, 0x64,
  0x8F, 0x1C, 0x18, 0x93, 0x92, 0xAA, 0xAE, 0xB4, 0xD4, 0xCC, 0xC8, 0x63,
  0x36, 0x14, 0x1C, 0x18, 0x3C, 0x64, 0xC6, 0x46, 0x8F, 0x16, 0x2C, 0x59,
  0xBF, 0x06, 0x09, 0xF3, 0x80, 0x7E, 0xF8, 0x30, 0xC3, 0x0C, 0x30, 0x7E,
  0x02, 0x1C, 0x20, 0x40, 0x83, 0x3C, 0x78, 0x10, 0x20, 0x41, 0x81, 0xC1,
  0x00, 0x2D, 0xB6, 0x92, 0xDB, 0x49, 0x00, 0x30, 0x38, 0x08, 0x08, 0x18,
  0x18, 0x0F, 0x1E, 0x10, 0x10, 0x10, 0x30, 0xF0, 0xC0, 0xF3, 0x3C, 0x20,
};

const GFXglyph JetBrainsMono_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 5, 4, 8, 2, -10 },
  { 8, 9, 10, 8, 0, -10 },
  { 20, 7, 14, 8, 1, -12 },
  { 33, 10, 10, 8, -1, -10 },
  { 46, 8, 10, 8, 0, -10 },
  { 56, 2, 4, 8, 4, -10 },
  { 57, 6, 14, 8, 2, -12 },
  { 68, 6, 14, 8, 1, -12 },
  { 79, 7, 8, 8, 1, -9 },
  { 86, 7, 7, 8, 1, -8 },
  { 93, 4, 4, 8, 1, -2 },
  { 95, 5, 1, 8, 2, -5 },
  { 96, 3, 2, 8, 2, -2 },
  { 97, 9, 14, 8, 0, -12 },
  { 113, 7, 10, 8, 1, -10 },
  { 122, 6, 10, 8, 1, -10 },
  { 130, 7, 10, 8, 1, -10 },
  { 139, 7, 10, 8, 1, -10 },
  { 148, 7, 10, 8, 1, -10 },
  { 157, 7, 10, 8, 1, -10 },
  { 166, 7, 10, 8, 1, -10 },
  { 175, 7, 10, 8, 2, -10 },
  { 184, 7, 10, 8, 1, -10 },
  { 193, 7, 10, 8, 1, -10 },
  { 202, 4, 8, 8, 2, -8 },
  { 206, 5, 10, 8, 1, -8 },
  { 213, 7, 7, 8, 1, -8 },
  { 220, 7, 5, 8, 1, -7 },
  { 225, 7, 7, 8, 1, -8 },
  { 232, 6, 10, 8, 2, -10 },
  { 240, 9, 13, 8, 0, -10 },
  { 255, 7, 10, 8, 0, -10 },
  { 264, 7, 10, 8, 1, -10 },
  { 273, 7, 10, 8, 1, -10 },
  { 282, 7, 10, 8, 1, -10 },
  { 291, 7, 10, 8, 1, -10 },
  { 300, 7, 10, 8, 1, -10 },
  { 309, 7, 10, 8, 1, -10 },
  { 318, 7, 10, 8, 1, -10 },
  { 327, 7, 10, 8, 1, -10 },
  { 336, 8, 10, 8, 0, -10 },
  { 346, 8, 10, 8, 1, -10 },
  { 356, 6, 10, 8, 1, -10 },
  { 364, 8, 10, 8, 0, -10 },
  { 374, 7, 10, 8, 1, -10 },
  { 383, 7, 10, 8, 1, -10 },
  { 392, 7, 10, 8, 1, -10 },
  { 401, 7, 13, 8, 1, -10 },
  { 413, 7, 10, 8, 1, -10 },
  { 422, 7, 10, 8, 1, -10 },
  { 431, 8, 10, 8, 1, -10 },
  { 441, 7, 10, 8, 1, -10 },
  { 450, 7, 10, 8, 2, -10 },
  { 459, 8, 10, 8, 1, -10 },
  { 469, 9, 10, 8, 0, -10 },
  { 481, 8, 10, 8, 1, -10 },
  { 491, 7, 10, 8, 1, -10 },
  { 500, 6, 14, 8, 2, -12 },
  { 511, 5, 14, 8, 2, -12 },
  { 520, 6, 14, 8, 1, -12 },
  { 531, 7, 5, 8, 1, -10 },
  { 536, 7, 2, 8, 0, 0 },
  { 538, 2, 2, 8, 4, -11 },
  { 539, 7, 8, 8, 1, -8 },
  { 546, 7, 10, 8, 1, -10 },
  { 555, 7, 8, 8, 1, -8 },
  { 562, 7, 10, 8, 1, -10 },
  { 571, 7, 8, 8, 1, -8 },
  { 578, 10, 13, 8, -1, -10 },
  { 595, 7, 11, 8, 1, -8 },
  { 605, 7, 10, 8, 1, -10 },
  { 614, 7, 11, 8, 0, -11 },
  { 624, 8, 14, 8, 0, -11 },
  { 638, 7, 10, 8, 1, -10 },
  { 647, 6, 10, 8, 1, -10 },
  { 655, 8, 8, 8, 0, -8 },
  { 663, 7, 8, 8, 1, -8 },
  { 670, 7, 8, 8, 1, -8 },
  { 677, 8, 11, 8, 0, -8 },
  { 688, 7, 11, 8, 1, -8 },
  { 698, 7, 8, 8, 1, -8 },
  { 705, 7, 8, 8, 1, -8 },
  { 712, 7, 10, 8, 1, -10 },
  { 721, 7, 8, 8, 1, -8 },
  { 728, 7, 8, 8, 1, -8 },
  { 735, 8, 8, 8, 1, -8 },
  { 743, 8, 8, 8, 0, -8 },
  { 751, 7, 11, 8, 1, -8 },
  { 761, 7, 8, 8, 1, -8 },
  { 768, 7, 14, 8, 1, -12 },
  { 781, 3, 14, 8, 3, -12 },
  { 787, 8, 14, 8, 0, -12 },
  { 801, 7, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_MEDIUMITALIC14PT7B_H_
