#ifndef _JETBRAINSMONO_MEDIUMITALIC25PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x8C, 0x30, 0xC7, 0x18, 0x00, 0x00,
  0x38, 0xF3, 0x80, 0x73, 0xB9, 0xDC, 0xEC, 0x76, 0x33, 0x1B, 0x8C, 0x01,
  0x86, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x61, 0x87, 0xFF, 0xC1, 0x8E,
  0x06, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x61, 0x83, 0xFF, 0xCF, 0xFF, 0x86,
  0x18, 0x0C, 0x30, 0x18, 0xE0, 0x61, 0x80, 0xC3, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x07, 0xF0, 0x7F, 0xE1, 0xDB, 0x8E, 0x6E, 0x39,
  0x00, 0xE4, 0x03, 0xB0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x2F, 0x00,
  0x9C, 0x02, 0x73, 0x99, 0xCE, 0x67, 0x3D, 0xB8, 0x7F, 0xC0, 0xFE, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0x81, 0xC7, 0x70, 0xC1,
  0x8C, 0x60, 0x63, 0x30, 0x31, 0xDC, 0x0C, 0x66, 0x01, 0xFB, 0x00, 0x79,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3B, 0xE0, 0x0D, 0xF8, 0x06, 0xC6,
  0x03, 0x31, 0x81, 0x8C, 0x60, 0xC3, 0x18, 0x60, 0xFC, 0x38, 0x1E, 0x00,
  0x00, 0x80, 0x1F, 0xC0, 0xFF, 0x83, 0x8E, 0x0C, 0x38, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0xFC, 0x03, 0xB1, 0xDC, 0xE6, 0x71, 0xF9, 0xC7,
  0xC6, 0x0E, 0x18, 0x38, 0x71, 0xF1, 0xFE, 0xC3, 0xF3, 0x80, 0x7E, 0xEE,
  0xEE, 0xC0, 0x00, 0xC0, 0xF0, 0x7C, 0x3C, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x18, 0x0C, 0x01, 0xE0, 0x3E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xE0, 0xF8, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x18, 0xC2,
  0x7B, 0x3B, 0xFB, 0xF1, 0xFC, 0x01, 0xC0, 0x0D, 0x80, 0x67, 0x03, 0x9C,
  0x1C, 0x38, 0x20, 0x80, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x0F,
  0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1E, 0x38,
  0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0x7F, 0xFF, 0xC0, 0x7B, 0xFE, 0xE0, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x80, 0x3F, 0x87,
  0xFE, 0x38, 0x73, 0x83, 0x98, 0x0C, 0xC0, 0xE6, 0x07, 0x73, 0x3B, 0xB9,
  0xDD, 0xCC, 0xE0, 0x66, 0x07, 0x30, 0x3B, 0x81, 0xDC, 0x0C, 0x71, 0xE3,
  0xFE, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x1F, 0xC3, 0x9C, 0x31, 0xC2, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x3F, 0x87, 0xFC, 0x38,
  0x73, 0x83, 0x98, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x17, 0xFF, 0x3F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x70, 0x3B,
  0x83, 0x9E, 0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x86, 0x38, 0x73, 0xC3, 0x9C,
  0x1C, 0xC0, 0xE7, 0xFE, 0x7F, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xEF,
  0x07, 0xFC, 0x3C, 0xF1, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3B,
  0x83, 0x8E, 0x3C, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x7C, 0x3F, 0xF3, 0xC3, 0x9C,
  0x1D, 0xC0, 0x6E, 0x03, 0x70, 0x3B, 0x81, 0xCE, 0x3C, 0x7F, 0xC1, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x0E, 0xC0, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0x87, 0xFE, 0x38, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x0E, 0x1F, 0xE0, 0x3C, 0x07, 0xF8, 0x71, 0xC7,
  0x07, 0x30, 0x3B, 0x81, 0xDC, 0x0E, 0x70, 0xE3, 0xFE, 0x0F, 0xE0, 0x01,
  0x00, 0x7F, 0x0F, 0xFC, 0xF0, 0xE7, 0x03, 0x30, 0x1B, 0x80, 0xDC, 0x0E,
  0xE0, 0x73, 0x87, 0x1F, 0xF8, 0x7F, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x7C, 0xF0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC3, 0xCF, 0x8E, 0x00, 0x07, 0x07, 0xC3, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0x81, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0x70, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x3F, 0x0F,
  0xC0, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xC0,
  0x02, 0x7F, 0xF7, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x20, 0x03, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x30, 0x0F, 0x03, 0xE0, 0xF8, 0x7E, 0x0F, 0x80, 0xC0, 0x08, 0x00,
  0x3F, 0x07, 0xF8, 0x0F, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x1E, 0x3F,
  0x87, 0xC0, 0xE0, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x0E,
  0x00, 0x00, 0x40, 0x07, 0xF0, 0x3F, 0xF0, 0xE0, 0x71, 0x80, 0x67, 0x00,
  0xCC, 0x01, 0x98, 0x7B, 0x31, 0xFE, 0xE7, 0x1D, 0xCC, 0x33, 0x18, 0x66,
  0x30, 0xCC, 0x61, 0x99, 0xC7, 0x71, 0x8E, 0xE3, 0xF9, 0x81, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x37, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x0E,
  0x70, 0xE1, 0x87, 0x0C, 0x3F, 0xE3, 0xFF, 0x1C, 0x19, 0xC0, 0xCE, 0x07,
  0x60, 0x3F, 0x01, 0xC0, 0x1F, 0xF0, 0xFF, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xC1, 0xC7, 0xFC, 0x3F, 0xC3, 0xFF, 0x1C, 0x1C, 0xE0, 0xE7,
  0x03, 0x30, 0x39, 0x81, 0xDC, 0x3C, 0xFF, 0xC7, 0xF8, 0x00, 0x00, 0x80,
  0x3F, 0x87, 0xFE, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x81, 0xCC, 0x0C,
  0x71, 0xE3, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x8E, 0x1E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xE6, 0x07, 0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x30, 0x39, 0x83, 0x9C, 0x7C, 0xFF, 0xC7, 0xF8, 0x00, 0x1F,
  0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x3F, 0xF1, 0xFF,
  0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x80, 0x3F, 0x87, 0xFE, 0x38, 0x73, 0x83, 0x9C,
  0x1C, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x9F, 0xDC, 0xFC, 0xE7, 0xE7, 0x07,
  0x30, 0x39, 0x81, 0xCC, 0x0C, 0x71, 0xE3, 0xFE, 0x0F, 0xE0, 0x1C, 0x1C,
  0x60, 0x63, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8F, 0xFC,
  0x3F, 0xF1, 0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x06,
  0x38, 0x38, 0xE0, 0xE3, 0x83, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x7F, 0xE7, 0xFF, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x31, 0x81,
  0xC7, 0x07, 0x1C, 0x38, 0x7F, 0xC0, 0x7E, 0x00, 0x1C, 0x1E, 0x30, 0x38,
  0xE0, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x70, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0C, 0x1C, 0x18, 0x38,
  0x70, 0x70, 0xE0, 0x71, 0xC0, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xF8, 0x3C, 0x3C, 0xF0, 0xF3, 0xC6,
  0xCF, 0x1F, 0x34, 0x78, 0xDB, 0x67, 0x6D, 0x9D, 0xEE, 0x77, 0xB9, 0x9C,
  0xE6, 0x03, 0x18, 0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC0,
  0x63, 0x01, 0x80, 0x1C, 0x1C, 0x78, 0x73, 0xE1, 0x8F, 0x86, 0x36, 0x18,
  0xD8, 0xE3, 0x73, 0x8D, 0xCE, 0x73, 0x31, 0xCC, 0xC7, 0x33, 0x18, 0xDC,
  0x63, 0xF1, 0x87, 0xCE, 0x1E, 0x38, 0x78, 0xE1, 0xE3, 0x87, 0x80, 0x00,
  0x80, 0x3F, 0x87, 0xFE, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE6, 0x07,
  0x30, 0x3B, 0x81, 0x9C, 0x0C, 0xE0, 0xE7, 0x07, 0x30, 0x39, 0x81, 0xCC,
  0x1C, 0x71, 0xE3, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE3, 0x83, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x0E, 0x7F, 0xF1, 0xFF, 0x87,
  0xF8, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x80, 0x3F, 0x87, 0xFE, 0x38, 0x73, 0x83, 0x9C, 0x1C,
  0xC0, 0xE6, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0x66, 0x07, 0x30,
  0x3B, 0x81, 0xDC, 0x1C, 0x71, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x1F, 0xF0, 0x7F, 0xE3, 0x83, 0x8E, 0x0F,
  0x38, 0x1C, 0xE0, 0x63, 0x83, 0x8C, 0x1E, 0x7F, 0xF1, 0xFF, 0x87, 0xF8,
  0x1C, 0x70, 0x71, 0xC1, 0x87, 0x06, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x81,
  0xC0, 0x00, 0x80, 0x1F, 0xC1, 0xFF, 0x87, 0x0E, 0x38, 0x38, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xCE, 0x07, 0x38, 0x1C, 0xF0, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0x8E, 0x0E,
  0x38, 0x38, 0xE0, 0xE3, 0x03, 0x8C, 0x0E, 0x70, 0x31, 0xC0, 0xC7, 0x07,
  0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x0E, 0x1C, 0x78, 0x7F, 0xC0, 0xFE,
  0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0x61, 0x87,
  0x0C, 0x38, 0x63, 0x83, 0x1C, 0x18, 0xC0, 0xEE, 0x07, 0x60, 0x3B, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x00, 0x71, 0xC6, 0xE3, 0x9D, 0xCE,
  0x3B, 0x1C, 0x66, 0x28, 0xCC, 0xD3, 0x99, 0xA6, 0x32, 0x4C, 0x64, 0x98,
  0xD9, 0x71, 0xB2, 0xC3, 0x45, 0x87, 0x9B, 0x0F, 0x3E, 0x1E, 0x78, 0x38,
  0xF0, 0xF1, 0xE1, 0xE3, 0x80, 0x1C, 0x0F, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E,
  0x38, 0x07, 0x70, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x38,
  0x70, 0x70, 0x30, 0xE0, 0x38, 0xE0, 0x3F, 0x03, 0xB8, 0x18, 0xC1, 0xC7,
  0x1C, 0x38, 0xC0, 0xCE, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F,
  0xFC, 0x7F, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xE1, 0xF8, 0x3F, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFC, 0x1F, 0x87, 0xF0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x70,
  0x30, 0x38, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E,
  0x0E, 0x06, 0x07, 0x07, 0x0F, 0xC3, 0xF1, 0xFC, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x3F, 0x8F, 0xE3, 0xF8, 0x03, 0x80,
  0xF0, 0x3E, 0x06, 0xE1, 0xCC, 0x31, 0x8C, 0x3B, 0x87, 0x60, 0x7C, 0x0C,
  0xFF, 0xFF, 0xFF, 0xE3, 0x8E, 0x70, 0x0F, 0xB8, 0xFF, 0xCF, 0x3E, 0x70,
  0xE7, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x60, 0x73, 0x03, 0x9C, 0x38,
  0xE2, 0xC7, 0xFE, 0x1F, 0x70, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xBE, 0x1F, 0xF8, 0xD3, 0xC7, 0x0E, 0x70, 0x33, 0x81, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x30, 0x39, 0xC3, 0x9E, 0x3C, 0xFF, 0xC7, 0x7C, 0x00, 0x07,
  0xC0, 0xFF, 0x8F, 0xBC, 0x70, 0x67, 0x03, 0xB8, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x03, 0x98, 0x18, 0xE3, 0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x0F, 0xB8, 0x7F, 0xE3, 0xCF, 0x8E, 0x1C,
  0x70, 0x31, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0xC7, 0x0E,
  0x1C, 0x58, 0x7F, 0xE0, 0xFB, 0x80, 0x07, 0xC0, 0xFF, 0x0F, 0x1C, 0x70,
  0x67, 0x03, 0x38, 0x19, 0xFF, 0xCF, 0xFE, 0x60, 0x03, 0x00, 0x18, 0x18,
  0xE1, 0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xB8, 0xFF, 0xCF, 0x3E, 0x70,
  0xE7, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x9E, 0x78,
  0xFE, 0xC3, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x18, 0x7F, 0xC3, 0xFC, 0x1F,
  0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBE, 0x1F, 0xF8, 0xD3,
  0xC7, 0x0E, 0x70, 0x33, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x39,
  0x81, 0x9C, 0x0C, 0xE0, 0xE7, 0x07, 0x00, 0x00, 0x80, 0x1E, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x3F, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01,
  0xC1, 0xFE, 0x1F, 0xE0, 0xF0, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x1C, 0xE0, 0xE3, 0x87, 0x0C, 0x38, 0x31, 0xC1, 0xCF, 0x07,
  0xF8, 0x1F, 0xE0, 0x73, 0x81, 0xC7, 0x06, 0x1C, 0x38, 0x38, 0xE0, 0xE3,
  0x81, 0xC0, 0x7F, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xF0,
  0x1F, 0xE1, 0xFC, 0x3B, 0xB8, 0xFF, 0xF3, 0x9C, 0xCC, 0x63, 0x31, 0x9C,
  0xC6, 0x73, 0x19, 0xDC, 0xC6, 0x73, 0x19, 0xCC, 0x66, 0x31, 0x98, 0xCE,
  0x63, 0x3B, 0x9C, 0xE0, 0x3B, 0xE1, 0xFF, 0x8D, 0x3C, 0x70, 0xE7, 0x03,
  0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x03, 0x98, 0x19, 0xC0, 0xCE,
  0x0E, 0x70, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0x3C, 0x70, 0xE7, 0x03, 0x38,
  0x19, 0xC1, 0xCE, 0x0E, 0x60, 0x73, 0x03, 0x98, 0x38, 0xE3, 0xC7, 0xFC,
  0x1F, 0xC0, 0x1D, 0xF0, 0x7F, 0xE1, 0xA7, 0x87, 0x0E, 0x38, 0x18, 0xE0,
  0x63, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xE3, 0x87, 0x1E, 0x3C, 0x7F,
  0xE1, 0xDF, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x0F, 0xB8, 0xFF, 0xCF, 0x3E, 0x70, 0xE7, 0x03, 0x38, 0x39, 0xC1, 0xCE,
  0x0E, 0x60, 0x73, 0x03, 0x9C, 0x38, 0xE2, 0xC7, 0xFE, 0x1F, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x19, 0xE1, 0xDF, 0x8F, 0x9E,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0x1C, 0x70,
  0x73, 0x00, 0x1C, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xB8, 0x1D,
  0xE1, 0xC7, 0xFE, 0x1F, 0xC0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x01, 0xC0, 0x1F, 0xC0, 0xFC, 0x38, 0x39, 0xC1, 0xCC,
  0x0E, 0x60, 0x77, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x03,
  0x9C, 0x38, 0xE3, 0xC7, 0xFC, 0x1F, 0xC0, 0xE0, 0x3B, 0x03, 0x98, 0x1C,
  0xE1, 0xC7, 0x0E, 0x38, 0x61, 0xC7, 0x06, 0x30, 0x33, 0x81, 0x98, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0xC7, 0x1E, 0x38, 0xF1, 0xCF, 0x9E,
  0x6C, 0xF3, 0x65, 0x9B, 0x6D, 0x9B, 0x6C, 0xD3, 0x67, 0x9E, 0x3C, 0xF1,
  0xC7, 0x8E, 0x38, 0x71, 0xC0, 0x1C, 0x1E, 0x38, 0x78, 0x38, 0xE0, 0x73,
  0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x1D, 0x80,
  0x73, 0x81, 0xC3, 0x07, 0x07, 0x1E, 0x0F, 0x00, 0x38, 0x39, 0xC1, 0xCC,
  0x0E, 0x60, 0x67, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87,
  0x1E, 0x78, 0xFF, 0xC3, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x38, 0x7F, 0xC3,
  0xFC, 0x1F, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC1, 0xFC, 0x0F, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0x70, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x38,
  0xE3, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8E, 0x30, 0x1C,
  0x01, 0xF0, 0x1F, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x3F, 0x03, 0xF0, 0x70, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x08,
  0x01, 0xF0, 0xDF, 0xC6, 0xC7, 0x7E, 0x3F, 0x70, 0xF0,
};

const GFXglyph JetBrainsMono_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 18, 15, 5, -18 },
  { 15, 9, 7, 15, 4, -18 },
  { 23, 15, 18, 15, 0, -18 },
  { 57, 14, 26, 15, 1, -22 },
  { 103, 18, 18, 15, -1, -18 },
  { 144, 14, 19, 15, 0, -19 },
  { 178, 4, 7, 15, 7, -18 },
  { 182, 10, 24, 15, 4, -21 },
  { 212, 11, 24, 15, 1, -21 },
  { 245, 14, 13, 15, 1, -15 },
  { 268, 12, 12, 15, 2, -14 },
  { 286, 7, 8, 15, 2, -4 },
  { 293, 9, 2, 15, 3, -9 },
  { 296, 5, 4, 15, 4, -4 },
  { 299, 15, 24, 15, 0, -21 },
  { 344, 13, 19, 15, 1, -19 },
  { 375, 12, 18, 15, 1, -18 },
  { 402, 13, 19, 15, 1, -19 },
  { 433, 13, 18, 15, 1, -18 },
  { 463, 13, 18, 15, 1, -18 },
  { 493, 13, 18, 15, 1, -18 },
  { 523, 13, 18, 15, 1, -18 },
  { 553, 12, 18, 15, 3, -18 },
  { 580, 13, 19, 15, 1, -19 },
  { 611, 13, 19, 15, 2, -19 },
  { 642, 7, 14, 15, 4, -14 },
  { 655, 9, 18, 15, 2, -14 },
  { 676, 12, 14, 15, 2, -15 },
  { 697, 12, 9, 15, 2, -13 },
  { 711, 12, 14, 15, 1, -15 },
  { 732, 11, 18, 15, 3, -18 },
  { 757, 15, 24, 15, 0, -19 },
  { 802, 13, 18, 15, 0, -18 },
  { 832, 13, 18, 15, 1, -18 },
  { 862, 13, 19, 15, 1, -19 },
  { 893, 13, 18, 15, 1, -18 },
  { 923, 14, 18, 15, 1, -18 },
  { 955, 14, 18, 15, 1, -18 },
  { 987, 13, 19, 15, 1, -19 },
  { 1018, 14, 18, 15, 1, -18 },
  { 1050, 13, 18, 15, 1, -18 },
  { 1080, 14, 18, 15, 0, -18 },
  { 1112, 15, 18, 15, 1, -18 },
  { 1146, 11, 18, 15, 2, -18 },
  { 1171, 14, 18, 15, 1, -18 },
  { 1203, 14, 18, 15, 1, -18 },
  { 1235, 13, 19, 15, 1, -19 },
  { 1266, 14, 18, 15, 1, -18 },
  { 1298, 13, 24, 15, 1, -19 },
  { 1337, 14, 18, 15, 1, -18 },
  { 1369, 14, 19, 15, 1, -19 },
  { 1403, 13, 18, 15, 3, -18 },
  { 1433, 14, 18, 15, 1, -18 },
  { 1465, 13, 18, 15, 3, -18 },
  { 1495, 15, 18, 15, 1, -18 },
  { 1529, 16, 18, 15, 0, -18 },
  { 1565, 13, 18, 15, 3, -18 },
  { 1595, 14, 18, 15, 1, -18 },
  { 1627, 11, 24, 15, 3, -21 },
  { 1660, 8, 24, 15, 4, -21 },
  { 1684, 10, 24, 15, 2, -21 },
  { 1714, 11, 10, 15, 2, -18 },
  { 1728, 12, 2, 15, 0, 1 },
  { 1731, 5, 4, 15, 6, -20 },
  { 1734, 13, 14, 15, 1, -14 },
  { 1757, 13, 18, 15, 1, -18 },
  { 1787, 13, 14, 15, 1, -14 },
  { 1810, 14, 18, 15, 1, -18 },
  { 1842, 13, 14, 15, 1, -14 },
  { 1865, 17, 23, 15, -1, -18 },
  { 1914, 13, 19, 15, 1, -14 },
  { 1945, 13, 18, 15, 1, -18 },
  { 1975, 12, 20, 15, 1, -20 },
  { 2005, 13, 25, 15, 0, -20 },
  { 2046, 14, 18, 15, 1, -18 },
  { 2078, 11, 18, 15, 2, -18 },
  { 2103, 14, 14, 15, 0, -14 },
  { 2128, 13, 14, 15, 1, -14 },
  { 2151, 13, 14, 15, 1, -14 },
  { 2174, 14, 19, 15, 0, -14 },
  { 2208, 13, 19, 15, 1, -14 },
  { 2239, 13, 14, 15, 1, -14 },
  { 2262, 13, 14, 15, 1, -14 },
  { 2285, 12, 18, 15, 2, -18 },
  { 2312, 13, 14, 15, 1, -14 },
  { 2335, 13, 14, 15, 2, -14 },
  { 2358, 13, 14, 15, 2, -14 },
  { 2381, 15, 14, 15, 0, -14 },
  { 2408, 13, 19, 15, 1, -14 },
  { 2439, 13, 14, 15, 1, -14 },
  { 2462, 13, 24, 15, 2, -21 },
  { 2501, 6, 24, 15, 5, -21 },
  { 2519, 12, 24, 15, 1, -21 },
  { 2555, 13, 6, 15, 1, -12 },
};

const GFXfont JetBrainsMono_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_MEDIUMITALIC25PT7B_H_
