#ifndef _JETBRAINSMONO_MEDIUMITALIC42PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xF0,
  0xFE, 0x3F, 0x0F, 0x80, 0x3E, 0x1E, 0x78, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7,
  0xC3, 0xEF, 0x87, 0xDE, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1,
  0xE7, 0x83, 0xCF, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x1C, 0x0F, 0x00, 0x1E, 0x07,
  0x00, 0x0F, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC0,
  0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x1E,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03,
  0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7C, 0xCF,
  0xC3, 0xE3, 0x1F, 0x0F, 0x1C, 0x7C, 0x7C, 0x71, 0xF1, 0xF1, 0xC0, 0x07,
  0xC7, 0x00, 0x1F, 0x18, 0x00, 0x7E, 0x60, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x37, 0xF0, 0x01, 0xCF, 0xC0, 0x07, 0x1F, 0x00, 0x1C, 0x7C, 0x00,
  0x71, 0xF3, 0xE1, 0x87, 0xCF, 0x86, 0x1F, 0x3E, 0x38, 0xF8, 0xFC, 0xE7,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x07, 0xFC, 0x01,
  0xE0, 0x3F, 0xF0, 0x07, 0x01, 0xF1, 0xE0, 0x38, 0x07, 0x87, 0x81, 0xC0,
  0x1C, 0x1E, 0x0F, 0x00, 0x70, 0x78, 0x78, 0x03, 0xC1, 0xC3, 0xC0, 0x0F,
  0x07, 0x1E, 0x00, 0x3C, 0x1C, 0x70, 0x00, 0xF0, 0xF3, 0x80, 0x01, 0xFF,
  0x9E, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x01, 0xE7, 0xF8, 0x00, 0x0F, 0x3F, 0xF0, 0x00, 0x79, 0xE3, 0xC0,
  0x03, 0xCF, 0x07, 0x00, 0x0E, 0x3C, 0x1C, 0x00, 0x70, 0xE0, 0xF0, 0x03,
  0x83, 0x83, 0xC0, 0x1E, 0x0E, 0x0F, 0x00, 0xF0, 0x38, 0x38, 0x07, 0x80,
  0xE1, 0xE0, 0x3C, 0x03, 0xFF, 0x00, 0xE0, 0x07, 0xFC, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x40, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x3E, 0x78, 0xF8, 0x79, 0xF1, 0xF1, 0xE3, 0xC1, 0xF7, 0xC7,
  0x83, 0xEF, 0x0F, 0x03, 0xFC, 0x1E, 0x03, 0xF8, 0x7C, 0x07, 0xE0, 0xF8,
  0x07, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x7F, 0x87, 0xF7, 0xFF, 0x07, 0xFF,
  0xDF, 0x0F, 0xFF, 0x1E, 0x07, 0xF8, 0x3E, 0x00, 0x7D, 0xF7, 0x9E, 0xFB,
  0xEF, 0xBE, 0xF3, 0xCF, 0x3C, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x08,
  0x0F, 0x03, 0x3E, 0x1C, 0x3E, 0x7F, 0x39, 0xFD, 0xFF, 0x67, 0xFD, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x77,
  0x80, 0x03, 0xEF, 0x00, 0x0F, 0x9F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x01, 0x00, 0x40, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1E, 0x7F, 0x7F, 0x7F, 0xFF, 0x7E, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F,
  0x3F, 0x3E, 0x3C, 0x7C, 0xF9, 0xF1, 0xE3, 0xC7, 0xC0, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x78,
  0xF8, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFC, 0xF8, 0x0F,
  0x8F, 0x01, 0xE0, 0xF0, 0x1C, 0x0F, 0x01, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x08, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x0F, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x78, 0x3E, 0x03, 0xC3, 0xE0, 0x3E,
  0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF,
  0xE0, 0x1E, 0xFF, 0xC0, 0x7B, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xC0, 0xFC,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0xF8, 0x03,
  0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0x03, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xE7,
  0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7C, 0x00, 0xFB, 0xC0, 0x0F, 0x9E, 0x00,
  0x78, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0xC7, 0xC0, 0x1E,
  0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC7, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x80, 0x3F, 0x3F, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF1,
  0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0,
  0x0F, 0x8F, 0xC0, 0x7C, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00,
  0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0xE3, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xF7, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0x00, 0xF8, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0x83, 0xF0, 0x00,
  0x20, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x08, 0x78, 0x78, 0x1F, 0xDE, 0x1E, 0x0F,
  0xFF, 0x87, 0x07, 0xEF, 0xE3, 0xC1, 0xE0, 0xF8, 0xF0, 0x78, 0x3C, 0x3C,
  0x3C, 0x0F, 0x0F, 0x0F, 0x03, 0xC3, 0xC3, 0xC0, 0xF0, 0xE0, 0xF0, 0x3C,
  0x78, 0x3C, 0x0F, 0x1E, 0x1E, 0x03, 0x87, 0x87, 0x81, 0xE1, 0xE1, 0xE0,
  0x78, 0x78, 0x78, 0x1E, 0x1E, 0x1F, 0x1F, 0x8F, 0x03, 0xFD, 0xE3, 0xC0,
  0xFF, 0x70, 0xF0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78,
  0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0xF8,
  0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0x01, 0xF8, 0x3C, 0x03, 0xF0, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80,
  0x3C, 0x1E, 0x03, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C,
  0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01,
  0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3E, 0x01, 0xF0, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x1E, 0x00, 0x78,
  0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x07, 0xF8, 0x3C, 0x03,
  0xE0, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x81, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE0, 0xFC,
  0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x0F, 0xFE, 0x3C, 0x3F, 0xF8, 0xF0, 0xFF, 0xC7,
  0xC3, 0xFF, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80,
  0x1F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x0F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1E,
  0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE0,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x08, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1E,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0E, 0xE0, 0x7F,
  0x0E, 0xE0, 0x77, 0x0E, 0xE0, 0xFF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE,
  0x1E, 0xF1, 0xDE, 0x1E, 0xF1, 0xDE, 0x1E, 0x73, 0x9E, 0x1E, 0x73, 0x9E,
  0x1E, 0x77, 0x9E, 0x1E, 0x77, 0x3C, 0x1E, 0x7F, 0x3C, 0x3E, 0x7E, 0x3C,
  0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF8,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x1E,
  0x1F, 0x80, 0x7C, 0x3F, 0x80, 0xF0, 0x7F, 0x01, 0xE0, 0xFE, 0x03, 0xC1,
  0xFC, 0x07, 0x87, 0xB8, 0x0F, 0x0F, 0x70, 0x3E, 0x1E, 0xF0, 0x7C, 0x3D,
  0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF3, 0x83, 0xC3, 0xE7, 0x07, 0x87, 0xCF,
  0x0F, 0x0F, 0x1E, 0x3E, 0x1E, 0x3C, 0x78, 0x3C, 0x78, 0xF0, 0x78, 0x71,
  0xE0, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7, 0x87, 0x83, 0xCF, 0x0F, 0x07, 0xBC,
  0x1E, 0x07, 0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x1F, 0xE1, 0xF0, 0x3F, 0xC3,
  0xC0, 0x7F, 0x87, 0x80, 0x7F, 0x0F, 0x00, 0xFC, 0x1E, 0x01, 0xF8, 0x3C,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xC1, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF0, 0x3F, 0xC1, 0xE0, 0x0F, 0xC3, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C,
  0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8,
  0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF9, 0xF0, 0x03,
  0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0xC7,
  0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF0,
  0x3F, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x3C, 0x3E, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x0F,
  0x87, 0xC0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0x81,
  0xF0, 0x1F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x8F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x1F, 0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x83,
  0xE0, 0xE3, 0xC3, 0xF0, 0xF1, 0xE1, 0xF8, 0x78, 0xE0, 0xDC, 0x3C, 0x70,
  0x6C, 0x1C, 0x78, 0x76, 0x1E, 0x3C, 0x3B, 0x0F, 0x1E, 0x19, 0x87, 0x8F,
  0x1C, 0xC3, 0x87, 0x8E, 0x63, 0xC3, 0xC7, 0x31, 0xE1, 0xE3, 0x18, 0xF0,
  0xF3, 0x8C, 0x70, 0x79, 0xCE, 0x78, 0x3C, 0xC7, 0x3C, 0x1E, 0xE3, 0x9C,
  0x0F, 0x71, 0xDE, 0x07, 0xB8, 0xEF, 0x03, 0x98, 0x77, 0x81, 0xDC, 0x3B,
  0x80, 0xEE, 0x1F, 0xC0, 0x76, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x07,
  0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x3E,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x00,
  0x7C, 0x3E, 0x00, 0x78, 0xF8, 0x00, 0xF9, 0xE0, 0x01, 0xF7, 0xC0, 0x01,
  0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0x9C, 0x00, 0xF3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE0, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC3, 0xC0, 0x78, 0xF8, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0xF8, 0x78, 0x7C, 0x3E, 0x1E, 0x1F, 0x00, 0x30, 0x00, 0x0F, 0xF3, 0xC1,
  0xFF, 0xDE, 0x1F, 0xFE, 0xF0, 0xFE, 0xFF, 0x8F, 0x80, 0xFC, 0x78, 0x07,
  0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFD, 0xE0, 0xFF, 0xCF, 0x03, 0xFC, 0xF8, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x40, 0x1F, 0x3F, 0xC0, 0xFB, 0xFF, 0x07,
  0xBF, 0xFC, 0x3F, 0xDF, 0xE1, 0xF8, 0x1F, 0x1F, 0x80, 0x78, 0xF8, 0x03,
  0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x00, 0x3C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x81, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x79, 0xFF, 0x83, 0xC7, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x7C,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x18, 0x3E, 0x01, 0xFE, 0x78,
  0x0F, 0xFE, 0xF0, 0x3F, 0xFD, 0xE0, 0x7F, 0x7F, 0xC1, 0xF0, 0x1F, 0x83,
  0xC0, 0x3F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF0, 0x3F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xBC, 0x07, 0xFE, 0x78,
  0x07, 0xF9, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0xC7, 0xC0,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xF1, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xCF, 0x0F, 0xFE,
  0xF1, 0xFF, 0xEF, 0x1F, 0xDF, 0xF3, 0xE0, 0x3F, 0x3C, 0x03, 0xF7, 0xC0,
  0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0xFC, 0xFF, 0x3F, 0xC7, 0xFF, 0xFC, 0x7F, 0xF7, 0x83, 0xFE, 0x78,
  0x02, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x40, 0x1F, 0x3F,
  0xC0, 0xFB, 0xFF, 0x07, 0xBF, 0xFC, 0x3F, 0xCF, 0xE1, 0xF8, 0x1F, 0x1F,
  0x80, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF0, 0x0F, 0x81, 0xE0,
  0x3E, 0x03, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x1F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x7C, 0x3C, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x10, 0x10, 0x3D, 0xF9, 0xF8, 0x7F, 0xF7,
  0xF0, 0xFF, 0xEF, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0xC3, 0xCF, 0x07, 0x07,
  0x9E, 0x0E, 0x1F, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF1,
  0xE1, 0xC1, 0xE7, 0xC3, 0x83, 0xCF, 0x07, 0x0F, 0x9E, 0x0E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF3, 0xE1, 0xC1, 0xE7, 0x83,
  0x83, 0xCF, 0x07, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0x00, 0x02, 0x00, 0xF9, 0xFE, 0x07, 0xDF, 0xF8, 0x3D, 0xFF, 0xE1,
  0xFE, 0x7F, 0x0F, 0xC0, 0xF8, 0xFC, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00,
  0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0xC7, 0xC0,
  0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x0F, 0x9F,
  0xE0, 0x1F, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x0F,
  0x83, 0xF0, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE1, 0xFC, 0x0F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0x3F,
  0xF0, 0x1E, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xE3, 0xC1, 0xFF, 0x9E, 0x1F,
  0xFE, 0xF0, 0xFE, 0xFF, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x1E,
  0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3,
  0xC0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFD,
  0xE0, 0xFF, 0xCF, 0x03, 0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x3C, 0x7F, 0x80, 0xF7, 0xFF, 0x03,
  0xDF, 0xFE, 0x0F, 0xF3, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0,
  0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0x80,
  0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0xF1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00,
  0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0x7C, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x78, 0x0F,
  0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0,
  0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x78,
  0x1F, 0xE0, 0xF0, 0x3B, 0xC1, 0xE0, 0xF7, 0x87, 0xC1, 0xEF, 0x0D, 0x83,
  0x9E, 0x1B, 0x0F, 0x3C, 0x76, 0x1E, 0x78, 0xEC, 0x38, 0xF1, 0x98, 0x71,
  0xE7, 0x31, 0xE3, 0xCE, 0x63, 0x87, 0x98, 0xC7, 0x0E, 0x71, 0x9E, 0x1C,
  0xE3, 0x3C, 0x39, 0x86, 0x70, 0x77, 0x0D, 0xE0, 0xEE, 0x1B, 0xC1, 0xD8,
  0x37, 0x03, 0xB0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x8F, 0x80,
  0x03, 0xCF, 0x80, 0x01, 0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xF0,
  0x07, 0xC3, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x01,
  0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE7, 0xC0,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x0F, 0xCF,
  0xFF, 0xFC, 0x7F, 0xF7, 0xC3, 0xFE, 0x78, 0x1F, 0xC7, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x04, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x3C, 0x7F, 0xC0, 0xF3,
  0xFF, 0x03, 0xDF, 0x3E, 0x1E, 0x78, 0x7C, 0x79, 0xE1, 0xFF, 0xE7, 0x83,
  0xFF, 0x3C, 0x07, 0xF8, 0x00, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 31, 25, 8, -31 },
  { 40, 15, 13, 25, 7, -31 },
  { 65, 25, 31, 25, 1, -31 },
  { 162, 22, 43, 25, 2, -37 },
  { 281, 30, 31, 25, -2, -31 },
  { 398, 23, 31, 25, 1, -31 },
  { 488, 6, 13, 25, 12, -31 },
  { 498, 18, 40, 25, 6, -35 },
  { 588, 18, 40, 25, 2, -35 },
  { 678, 23, 22, 25, 2, -26 },
  { 742, 20, 20, 25, 3, -24 },
  { 792, 11, 13, 25, 4, -6 },
  { 810, 14, 4, 25, 6, -16 },
  { 817, 8, 7, 25, 7, -7 },
  { 824, 26, 40, 25, 0, -35 },
  { 954, 22, 31, 25, 2, -31 },
  { 1040, 20, 31, 25, 2, -31 },
  { 1118, 22, 31, 25, 2, -31 },
  { 1204, 22, 31, 25, 2, -31 },
  { 1290, 21, 31, 25, 2, -31 },
  { 1372, 22, 31, 25, 2, -31 },
  { 1458, 21, 31, 25, 2, -31 },
  { 1540, 21, 31, 25, 5, -31 },
  { 1622, 22, 31, 25, 2, -31 },
  { 1708, 21, 31, 25, 4, -31 },
  { 1790, 11, 24, 25, 7, -24 },
  { 1823, 14, 31, 25, 4, -24 },
  { 1878, 21, 22, 25, 3, -25 },
  { 1936, 20, 14, 25, 3, -21 },
  { 1971, 21, 22, 25, 2, -25 },
  { 2029, 17, 31, 25, 6, -31 },
  { 2095, 26, 39, 25, 0, -31 },
  { 2222, 22, 31, 25, 0, -31 },
  { 2308, 22, 31, 25, 2, -31 },
  { 2394, 22, 31, 25, 2, -31 },
  { 2480, 22, 31, 25, 2, -31 },
  { 2566, 23, 31, 25, 2, -31 },
  { 2656, 23, 31, 25, 2, -31 },
  { 2746, 22, 31, 25, 2, -31 },
  { 2832, 23, 31, 25, 2, -31 },
  { 2922, 22, 31, 25, 2, -31 },
  { 3008, 24, 31, 25, 0, -31 },
  { 3101, 24, 31, 25, 2, -31 },
  { 3194, 18, 31, 25, 3, -31 },
  { 3264, 24, 31, 25, 1, -31 },
  { 3357, 23, 31, 25, 2, -31 },
  { 3447, 22, 31, 25, 2, -31 },
  { 3533, 23, 31, 25, 2, -31 },
  { 3623, 22, 39, 25, 2, -31 },
  { 3731, 23, 31, 25, 2, -31 },
  { 3821, 22, 31, 25, 2, -31 },
  { 3907, 22, 31, 25, 4, -31 },
  { 3993, 23, 31, 25, 2, -31 },
  { 4083, 21, 31, 25, 5, -31 },
  { 4165, 25, 31, 25, 2, -31 },
  { 4262, 26, 31, 25, 0, -31 },
  { 4363, 23, 31, 25, 4, -31 },
  { 4453, 22, 31, 25, 2, -31 },
  { 4539, 17, 40, 25, 6, -35 },
  { 4624, 14, 40, 25, 6, -35 },
  { 4694, 18, 40, 25, 3, -35 },
  { 4784, 19, 17, 25, 4, -31 },
  { 4825, 21, 4, 25, 0, 1 },
  { 4836, 8, 6, 25, 11, -33 },
  { 4842, 21, 24, 25, 2, -24 },
  { 4905, 21, 31, 25, 2, -31 },
  { 4987, 21, 24, 25, 2, -24 },
  { 5050, 23, 31, 25, 2, -31 },
  { 5140, 21, 24, 25, 2, -24 },
  { 5203, 29, 39, 25, -2, -31 },
  { 5345, 20, 32, 25, 3, -24 },
  { 5425, 21, 31, 25, 2, -31 },
  { 5507, 21, 33, 25, 1, -33 },
  { 5594, 23, 41, 25, 0, -33 },
  { 5712, 23, 31, 25, 2, -31 },
  { 5802, 18, 31, 25, 4, -31 },
  { 5872, 23, 24, 25, 1, -24 },
  { 5941, 21, 24, 25, 2, -24 },
  { 6004, 21, 24, 25, 2, -24 },
  { 6067, 23, 32, 25, 0, -24 },
  { 6159, 21, 32, 25, 2, -24 },
  { 6243, 22, 24, 25, 2, -24 },
  { 6309, 21, 24, 25, 2, -24 },
  { 6372, 21, 29, 25, 3, -29 },
  { 6449, 22, 23, 25, 2, -23 },
  { 6513, 21, 23, 25, 4, -23 },
  { 6574, 23, 23, 25, 3, -23 },
  { 6641, 25, 23, 25, 0, -23 },
  { 6713, 20, 31, 25, 3, -23 },
  { 6791, 21, 23, 25, 2, -23 },
  { 6852, 21, 40, 25, 4, -35 },
  { 6957, 11, 40, 25, 8, -35 },
  { 7012, 22, 40, 25, 1, -35 },
  { 7122, 22, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_MEDIUMITALIC42PT7B_H_
