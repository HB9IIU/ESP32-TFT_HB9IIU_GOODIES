#ifndef _JETBRAINSMONO_MEDIUMITALIC57PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF,
  0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0x80, 0xF8,
  0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xEE, 0xFF, 0x80, 0x7F, 0x1C, 0x7F,
  0x01, 0xFC, 0x78, 0x7E, 0x03, 0xF0, 0xF0, 0xFC, 0x0F, 0xE1, 0xE1, 0xF8,
  0x1F, 0x83, 0x83, 0xF0, 0x3F, 0x07, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x00,
  0xFC, 0x3C, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x07,
  0xFD, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0x3F, 0xE0, 0x00, 0x1E, 0x3F, 0xC0, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x78,
  0x7F, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x01, 0xC0, 0xFC, 0x3F, 0x03, 0x83,
  0xF8, 0x7E, 0x0F, 0x07, 0xE0, 0xFC, 0x1E, 0x0F, 0xC1, 0xFC, 0x3C, 0x3F,
  0x83, 0xF8, 0x78, 0xFE, 0x07, 0xFC, 0xE7, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xF8,
  0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x78, 0x01, 0xF8, 0xFC, 0x00, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0xF8, 0x00, 0x07, 0xE1, 0xF1,
  0xF0, 0x00, 0x07, 0xFF, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xE7, 0xC0, 0x00,
  0x01, 0xFF, 0xC7, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x01, 0xF1, 0xFF, 0x00, 0x00, 0x03, 0xE7, 0xFF, 0x80, 0x00, 0x07, 0xCF,
  0xFF, 0xC0, 0x00, 0x0F, 0x8F, 0xCF, 0xE0, 0x00, 0x1F, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x00,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0x1F, 0xCF, 0xC0,
  0x7E, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xF1,
  0xF8, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x03, 0xFB, 0xF0, 0x7E, 0x01, 0xFF,
  0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x7F,
  0x80, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x83,
  0xF0, 0x0F, 0xFE, 0x03, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x3F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xF8, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x30, 0x07, 0xC0, 0x18, 0xF8, 0x1F, 0x03, 0xE7, 0xF8, 0x78,
  0x3F, 0xDF, 0xF0, 0xE3, 0xFF, 0xFF, 0xF3, 0x9F, 0xFF, 0xFF, 0xED, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x02, 0x03, 0xF0, 0xFF, 0x3F, 0xE7, 0xFD, 0xFF, 0xBF,
  0xF7, 0xFE, 0x7F, 0x8F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80,
  0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7C, 0x08, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF1, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x07, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xDF, 0x80, 0x1F, 0xF3, 0xF0, 0x03, 0xF8, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xF8, 0x03, 0xC0, 0x7F, 0x00, 0x60, 0x0F,
  0xC0, 0x08, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0x80,
  0x0F, 0xCF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x78, 0x00, 0x1F, 0xDF, 0xF8, 0x01, 0xFD, 0xFF, 0xF0, 0x0F,
  0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0xFF, 0x00, 0x3F,
  0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0x83, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFE, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x3F, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xF8, 0x1F, 0xC0, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x7C, 0x01, 0xFF,
  0x3E, 0x0F, 0x80, 0x7F, 0xF7, 0xC1, 0xF0, 0x1F, 0xFE, 0xF8, 0x7E, 0x07,
  0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0x01, 0xF8, 0x3E,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0xFC,
  0x3F, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x1F, 0x80,
  0x7C, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x0F,
  0x80, 0x7E, 0x1F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x3E, 0x01, 0xF0, 0x7C,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0xC7, 0xF8,
  0x3E, 0x03, 0xFF, 0xDF, 0x07, 0xC0, 0x3F, 0xFB, 0xE1, 0xF8, 0x03, 0xFC,
  0x78, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x80, 0x0F,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFC, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x83, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0x3F, 0xFF,
  0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x87,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0xF7, 0x80, 0x7F, 0xE0, 0x3D, 0xE0, 0x1F, 0xF8, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xDF, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xF7, 0xC0, 0x7D,
  0xF0, 0x7D, 0xF0, 0x1F, 0x3C, 0x1E, 0x7C, 0x07, 0xCF, 0x0F, 0x9F, 0x01,
  0xF3, 0xC3, 0xCF, 0x80, 0x7C, 0xF1, 0xF3, 0xE0, 0x3F, 0x3E, 0x78, 0xF8,
  0x0F, 0xCF, 0xBE, 0x3E, 0x03, 0xF1, 0xEF, 0x1F, 0x80, 0xF8, 0x7B, 0xC7,
  0xE0, 0x3E, 0x1F, 0xF1, 0xF8, 0x0F, 0x87, 0xF8, 0x7C, 0x07, 0xE1, 0xFE,
  0x1F, 0x01, 0xF8, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC3, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0x03,
  0xFE, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03,
  0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7E, 0x07,
  0xFF, 0x00, 0x7C, 0x07, 0xFF, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0xFC, 0x07,
  0xCF, 0x80, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x0F,
  0xCF, 0x80, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F,
  0xC7, 0xC1, 0xF8, 0x0F, 0xC7, 0xC1, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x0F,
  0x87, 0xC1, 0xF8, 0x1F, 0x87, 0xE1, 0xF0, 0x1F, 0x83, 0xE3, 0xF0, 0x1F,
  0x83, 0xE3, 0xF0, 0x1F, 0x83, 0xE3, 0xF0, 0x1F, 0x03, 0xE3, 0xF0, 0x1F,
  0x03, 0xE3, 0xF0, 0x3F, 0x01, 0xF3, 0xE0, 0x3F, 0x01, 0xF3, 0xE0, 0x3F,
  0x01, 0xF3, 0xE0, 0x3F, 0x01, 0xF7, 0xE0, 0x3F, 0x01, 0xF7, 0xE0, 0x3E,
  0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E,
  0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0x7C,
  0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x01,
  0xFE, 0x03, 0xF0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x03,
  0xFC, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0x81,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x03, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0x80, 0xFC, 0xF8, 0x0F, 0xE0, 0x3E, 0x3E, 0x03, 0xF8,
  0x0F, 0x8F, 0x80, 0xFE, 0x07, 0xE3, 0xE0, 0x3F, 0x81, 0xF0, 0xF8, 0x1F,
  0xE0, 0x7C, 0x3E, 0x07, 0xF8, 0x1F, 0x0F, 0x81, 0xDE, 0x0F, 0xC3, 0xE0,
  0x77, 0x83, 0xE0, 0xF8, 0x3D, 0xE0, 0xF8, 0x3E, 0x0F, 0x78, 0x3E, 0x0F,
  0x83, 0x9E, 0x1F, 0x83, 0xE1, 0xE7, 0x87, 0xC0, 0xF8, 0x79, 0xC1, 0xF0,
  0x7E, 0x1C, 0x70, 0x7C, 0x1F, 0x87, 0x1C, 0x3E, 0x07, 0xE3, 0xC7, 0x0F,
  0x81, 0xF0, 0xF1, 0xC3, 0xE0, 0x7C, 0x38, 0x70, 0xF8, 0x1F, 0x1E, 0x1C,
  0x7C, 0x07, 0xC7, 0x87, 0x1F, 0x01, 0xF1, 0xE1, 0xC7, 0xC0, 0x7C, 0x70,
  0x71, 0xF0, 0x1F, 0x3C, 0x3C, 0xF8, 0x07, 0xCF, 0x0F, 0x3E, 0x01, 0xF3,
  0x83, 0xCF, 0x80, 0x7D, 0xE0, 0xF3, 0xE0, 0x1F, 0x78, 0x3D, 0xF0, 0x07,
  0xDE, 0x0F, 0x7C, 0x01, 0xF7, 0x03, 0xDF, 0x00, 0x7F, 0xC0, 0xF7, 0x80,
  0x1E, 0xF0, 0x3F, 0xE0, 0x07, 0xB8, 0x0F, 0xF8, 0x01, 0xEE, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0xEF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFC,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x7F, 0xFE, 0xFE,
  0x07, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xF8, 0x3F,
  0xC0, 0x7F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xDF, 0x80, 0x7F, 0xFC, 0xFC, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC7, 0xFF, 0x00, 0x7E, 0x7F, 0xFC,
  0x03, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFB, 0xFF, 0xFE, 0x0F,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFB, 0xFF, 0xFC, 0x0F, 0xDF,
  0xFF, 0xC0, 0x7E, 0x7F, 0xF8, 0x07, 0xE1, 0xFF, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x3F,
  0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xFF, 0x0F, 0xC0, 0x1F, 0xFF, 0xBF, 0x80,
  0x7F, 0xFF, 0x7E, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFB, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xDF, 0x80, 0x1F, 0xFF, 0x3F, 0x00,
  0x0F, 0xF8, 0x7E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x87,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x8F, 0xC0, 0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0x7F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xF8, 0x01, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE3, 0xFF,
  0x81, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x3F, 0x00,
  0xFF, 0xF3, 0xF8, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC7, 0xFF, 0x00, 0x7E,
  0x7F, 0xFC, 0x03, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE7,
  0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x07, 0xCF, 0xE3,
  0xFC, 0x07, 0xDF, 0xE7, 0xFE, 0x0F, 0xFF, 0xF7, 0xFE, 0x0F, 0xBF, 0xFF,
  0xFE, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x81, 0xE0, 0x7E, 0x1F, 0x81, 0xE0,
  0x7E, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0xFC, 0x3F, 0x03, 0xC0,
  0xFC, 0x3F, 0x03, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x7E, 0x07, 0x81,
  0xF8, 0x7E, 0x07, 0x81, 0xF8, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x03,
  0xF0, 0xFC, 0x0F, 0x03, 0xF0, 0xFC, 0x0F, 0x03, 0xF0, 0xF8, 0x1F, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0xFC, 0x01, 0xF9, 0xFF, 0xF0,
  0x0F, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x87, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC7, 0xFF,
  0x00, 0x3F, 0x3F, 0xFE, 0x00, 0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x81, 0xFE, 0x00, 0x7E, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0x80, 0xFD, 0xFF, 0xFC, 0x07, 0xF3, 0xFF,
  0xC0, 0x1F, 0xC7, 0xFE, 0x00, 0x7E, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0x0F, 0xC0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF,
  0xBF, 0x07, 0xFF, 0x7F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xF8, 0x01, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x37, 0xE0, 0xFF, 0xFF, 0xBF,
  0x03, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xDF, 0x80, 0x7F, 0xFC, 0xFC, 0x00,
  0xFF, 0x87, 0xE0, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xFE, 0x00,
  0x7E, 0x7F, 0xFE, 0x01, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0x7C, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x81,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x9F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0xF0, 0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x03,
  0xEF, 0x81, 0xFC, 0x07, 0xDF, 0x03, 0xB8, 0x1F, 0x3E, 0x07, 0x70, 0x3E,
  0x7C, 0x1E, 0xE0, 0x7C, 0xF8, 0x3D, 0xC1, 0xF1, 0xF0, 0x73, 0x83, 0xE3,
  0xE1, 0xE7, 0x07, 0xC7, 0xC3, 0xCE, 0x1F, 0x0F, 0x87, 0x1C, 0x3E, 0x1F,
  0x1E, 0x38, 0x7C, 0x3E, 0x3C, 0x70, 0xF0, 0x7C, 0x70, 0xE3, 0xE0, 0xF8,
  0xE1, 0xC7, 0xC1, 0xF3, 0xC3, 0x8F, 0x03, 0xE7, 0x07, 0x3E, 0x07, 0xCE,
  0x0E, 0x7C, 0x0F, 0xBC, 0x1C, 0xF0, 0x1F, 0x70, 0x3B, 0xE0, 0x3E, 0xE0,
  0x77, 0xC0, 0x7F, 0xC0, 0xEF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x1F, 0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xDF,
  0x80, 0xFF, 0xFC, 0xFC, 0x07, 0xFF, 0xCF, 0xE0, 0x0F, 0xFC, 0x7E, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xF8, 0x7F, 0xF0, 0x07, 0xC7, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0x01, 0xF3,
  0xFF, 0xF8, 0x1F, 0xBF, 0x0F, 0xE0, 0xFD, 0xF0, 0x3F, 0x8F, 0xCF, 0x81,
  0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xE7, 0xE0, 0x1F, 0xFE, 0x3F, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 42, 34, 10, -42 },
  { 80, 20, 17, 34, 10, -42 },
  { 123, 34, 42, 34, 1, -42 },
  { 302, 31, 58, 34, 2, -50 },
  { 527, 40, 42, 34, -2, -42 },
  { 737, 32, 43, 34, 1, -42 },
  { 909, 8, 17, 34, 16, -42 },
  { 926, 24, 55, 34, 9, -48 },
  { 1091, 24, 55, 34, 3, -48 },
  { 1256, 30, 30, 34, 3, -35 },
  { 1369, 28, 27, 34, 4, -32 },
  { 1464, 16, 18, 34, 5, -9 },
  { 1500, 19, 6, 34, 8, -22 },
  { 1515, 11, 11, 34, 10, -10 },
  { 1531, 35, 53, 34, 0, -47 },
  { 1763, 30, 43, 34, 3, -42 },
  { 1925, 27, 42, 34, 2, -42 },
  { 2067, 30, 42, 34, 2, -42 },
  { 2225, 30, 43, 34, 2, -42 },
  { 2387, 28, 42, 34, 3, -42 },
  { 2534, 29, 43, 34, 3, -42 },
  { 2690, 29, 43, 34, 2, -42 },
  { 2846, 29, 42, 34, 6, -42 },
  { 2999, 30, 43, 34, 2, -42 },
  { 3161, 28, 42, 34, 5, -42 },
  { 3308, 14, 33, 34, 10, -32 },
  { 3366, 19, 41, 34, 5, -32 },
  { 3464, 27, 31, 34, 5, -34 },
  { 3569, 27, 20, 34, 4, -29 },
  { 3637, 28, 31, 34, 3, -34 },
  { 3746, 23, 42, 34, 8, -42 },
  { 3867, 35, 52, 34, 0, -42 },
  { 4095, 29, 42, 34, 0, -42 },
  { 4248, 31, 42, 34, 2, -42 },
  { 4411, 30, 43, 34, 3, -42 },
  { 4573, 31, 42, 34, 2, -42 },
  { 4736, 31, 42, 34, 3, -42 },
  { 4899, 31, 42, 34, 3, -42 },
  { 5062, 30, 43, 34, 3, -42 },
  { 5224, 31, 42, 34, 2, -42 },
  { 5387, 30, 42, 34, 3, -42 },
  { 5545, 32, 43, 34, 1, -42 },
  { 5717, 34, 42, 34, 2, -42 },
  { 5896, 25, 42, 34, 4, -42 },
  { 6028, 34, 42, 34, 1, -42 },
  { 6207, 32, 42, 34, 2, -42 },
  { 6375, 30, 43, 34, 3, -42 },
  { 6537, 32, 42, 34, 2, -42 },
  { 6705, 30, 52, 34, 3, -42 },
  { 6900, 32, 42, 34, 2, -42 },
  { 7068, 31, 43, 34, 2, -42 },
  { 7235, 29, 42, 34, 6, -42 },
  { 7388, 31, 43, 34, 3, -42 },
  { 7555, 29, 42, 34, 7, -42 },
  { 7708, 34, 42, 34, 3, -42 },
  { 7887, 37, 42, 34, -1, -42 },
  { 8082, 31, 42, 34, 6, -42 },
  { 8245, 31, 42, 34, 2, -42 },
  { 8408, 23, 53, 34, 8, -47 },
  { 8561, 18, 53, 34, 9, -47 },
  { 8681, 23, 53, 34, 5, -47 },
  { 8834, 26, 23, 34, 5, -42 },
  { 8909, 28, 6, 34, 0, 1 },
  { 8930, 11, 8, 34, 15, -45 },
  { 8941, 29, 33, 34, 3, -32 },
  { 9061, 29, 43, 34, 2, -42 },
  { 9217, 28, 33, 34, 3, -32 },
  { 9333, 31, 43, 34, 3, -42 },
  { 9500, 28, 33, 34, 3, -32 },
  { 9616, 39, 52, 34, -3, -42 },
  { 9870, 29, 42, 34, 3, -32 },
  { 10023, 29, 42, 34, 2, -42 },
  { 10176, 28, 45, 34, 2, -45 },
  { 10334, 30, 55, 34, 1, -45 },
  { 10541, 32, 42, 34, 2, -42 },
  { 10709, 25, 42, 34, 5, -42 },
  { 10841, 32, 32, 34, 1, -32 },
  { 10969, 29, 32, 34, 2, -32 },
  { 11085, 28, 33, 34, 3, -32 },
  { 11201, 30, 42, 34, 1, -32 },
  { 11359, 29, 42, 34, 3, -32 },
  { 11512, 30, 32, 34, 3, -32 },
  { 11632, 28, 33, 34, 3, -32 },
  { 11748, 28, 40, 34, 4, -40 },
  { 11888, 29, 32, 34, 3, -31 },
  { 12004, 29, 31, 34, 5, -31 },
  { 12117, 31, 31, 34, 4, -31 },
  { 12238, 33, 31, 34, 0, -31 },
  { 12366, 29, 41, 34, 3, -31 },
  { 12515, 29, 31, 34, 2, -31 },
  { 12628, 29, 53, 34, 5, -47 },
  { 12821, 14, 53, 34, 11, -47 },
  { 12914, 30, 53, 34, 1, -47 },
  { 13113, 29, 12, 34, 3, -26 },
};

const GFXfont JetBrainsMono_MediumItalic57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_MEDIUMITALIC57PT7B_H_
