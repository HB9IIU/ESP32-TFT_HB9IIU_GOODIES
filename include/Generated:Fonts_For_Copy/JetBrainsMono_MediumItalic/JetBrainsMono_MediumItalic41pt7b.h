#ifndef _JETBRAINSMONO_MEDIUMITALIC41PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0,
  0xFB, 0xE1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1F, 0x3C, 0x3E, 0x78, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x1E,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x38,
  0x00, 0xF0, 0x38, 0x00, 0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80,
  0x0F, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xF9, 0xCF, 0x83, 0xC7, 0x1E, 0x1F, 0x1C, 0x78,
  0x7C, 0x61, 0xE1, 0xE1, 0x80, 0x07, 0xC6, 0x00, 0x1F, 0x38, 0x00, 0x7E,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x73, 0xE0, 0x01, 0xC7, 0x80,
  0x06, 0x1F, 0x00, 0x18, 0x78, 0xF8, 0xE1, 0xE3, 0xE3, 0x87, 0x8F, 0x8E,
  0x3E, 0x3F, 0x39, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x78,
  0x0F, 0xF0, 0x03, 0x80, 0xFF, 0xC0, 0x38, 0x0F, 0x0E, 0x03, 0x80, 0x70,
  0x70, 0x3C, 0x03, 0x83, 0x83, 0xC0, 0x3C, 0x1C, 0x3C, 0x01, 0xE0, 0xE1,
  0xC0, 0x0F, 0x0F, 0x1C, 0x00, 0x78, 0x79, 0xC0, 0x03, 0xE7, 0x9C, 0x00,
  0x0F, 0xF9, 0xE0, 0x00, 0x3F, 0x9E, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0xF3,
  0xF8, 0x00, 0x0F, 0x7F, 0xE0, 0x00, 0xF3, 0xCF, 0x00, 0x0F, 0x3C, 0x3C,
  0x00, 0x71, 0xC1, 0xE0, 0x07, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x70, 0x07,
  0x87, 0x83, 0x80, 0x78, 0x3C, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x38, 0x07,
  0xFE, 0x03, 0x80, 0x3F, 0xE0, 0x78, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x7C, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8,
  0xF1, 0xE0, 0xF3, 0xC3, 0xC1, 0xFF, 0x87, 0x81, 0xFE, 0x0F, 0x03, 0xF8,
  0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x83,
  0xFB, 0xFF, 0x83, 0xFF, 0xEF, 0x07, 0xFF, 0x1F, 0x03, 0xFC, 0x1F, 0x00,
  0x3C, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0x00, 0x00, 0x40,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x01, 0x80, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x80, 0xE0, 0x17, 0x83, 0x83, 0x9F,
  0x8E, 0x3F, 0xFF, 0x33, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x18,
  0x06, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFE, 0x1C, 0x7E, 0x7F, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x30, 0xF8,
  0xF1, 0xE3, 0xC3, 0xCF, 0x8F, 0x1F, 0x3E, 0x3C, 0x7C, 0x78, 0xF1, 0xE0,
  0x87, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xC1, 0xF0, 0x1F, 0x07,
  0xFB, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0xF0, 0x1F,
  0x1E, 0x07, 0xC7, 0xC0, 0xE0, 0xF8, 0x18, 0x1F, 0x02, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x1F,
  0x8F, 0x80, 0x7C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC7,
  0xC0, 0x7C, 0x1F, 0xDF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0x0F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC7,
  0x80, 0x3C, 0xFF, 0x01, 0xEF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0x87,
  0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x78, 0xF8,
  0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7E, 0x03, 0xF7, 0xC0, 0x1F,
  0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x7C, 0x7F, 0xBF, 0x83, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07,
  0x8F, 0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x7E, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0xF8, 0x3E,
  0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xE0,
  0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xE0, 0x3E, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3E, 0x03, 0xE7, 0xC0, 0x1E, 0x78,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF,
  0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xFC, 0x0F, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xE3, 0xFC,
  0xFF, 0x3F, 0x87, 0xC0, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1E,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x20, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7E, 0x07,
  0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0xF9, 0xC3, 0xC1,
  0xFE, 0xE1, 0xC1, 0xFF, 0x71, 0xE0, 0xF0, 0xF8, 0xF0, 0xF0, 0x3C, 0x78,
  0x78, 0x1E, 0x3C, 0x3C, 0x0F, 0x1E, 0x1E, 0x07, 0x0E, 0x0E, 0x07, 0x8F,
  0x0F, 0x03, 0xC7, 0x87, 0x81, 0xE3, 0xC3, 0xC0, 0xF1, 0xE1, 0xE0, 0x78,
  0xF0, 0xF0, 0x78, 0x70, 0x7C, 0x7C, 0x78, 0x3F, 0xEE, 0x3C, 0x0F, 0xE7,
  0x1E, 0x01, 0xC4, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x3E,
  0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07,
  0xFC, 0x00, 0x3C, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0x01, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0xC0,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x7C,
  0x3E, 0x0F, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3C,
  0x0F, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE3,
  0xE0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xC0, 0xF8, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xF0,
  0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xF0, 0x3F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F,
  0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x0F, 0x8F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8,
  0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC3, 0xFF, 0x0F, 0x0F, 0xFC, 0x3C, 0x3F, 0xF1, 0xF0, 0xFF, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x3C,
  0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03,
  0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xF0, 0x07, 0x87, 0xC0,
  0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x0F, 0x00,
  0x7C, 0x0F, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x0E, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xFE,
  0x1E, 0xE1, 0xDE, 0x1E, 0xE3, 0xDE, 0x1E, 0xE3, 0x9C, 0x1E, 0xF7, 0xBC,
  0x1E, 0x77, 0x3C, 0x1E, 0x77, 0x3C, 0x1C, 0x7E, 0x3C, 0x3C, 0x7E, 0x7C,
  0x3C, 0x7C, 0x78, 0x3C, 0x7C, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xF0,
  0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x0F, 0xC0, 0x3C,
  0x3F, 0x00, 0xF0, 0xFC, 0x03, 0xC3, 0xF0, 0x0F, 0x0F, 0xE0, 0x7C, 0x7F,
  0x81, 0xE1, 0xFE, 0x07, 0x87, 0xB8, 0x1E, 0x1E, 0xE0, 0x78, 0x7B, 0xC1,
  0xE1, 0xEF, 0x0F, 0x8F, 0xBC, 0x3C, 0x3C, 0x70, 0xF0, 0xF1, 0xC3, 0xC3,
  0xC7, 0x8F, 0x0F, 0x1E, 0x3C, 0x3C, 0x79, 0xF1, 0xF0, 0xE7, 0x87, 0x83,
  0x9E, 0x1E, 0x0F, 0x78, 0x78, 0x3D, 0xE1, 0xE0, 0xF7, 0x87, 0x83, 0xDE,
  0x1E, 0x07, 0x78, 0xF8, 0x1F, 0xC3, 0xC0, 0x7F, 0x0F, 0x01, 0xFC, 0x3C,
  0x07, 0xF0, 0xF0, 0x0F, 0xC3, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x7C,
  0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80,
  0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78,
  0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xF0, 0x0F, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F,
  0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x3C, 0x03, 0xE1, 0xF0,
  0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1F,
  0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0x01, 0xF8, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00,
  0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x3E, 0x01, 0xF0,
  0xF8, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1E, 0x0F,
  0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x80, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0x80,
  0xF8, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x8F,
  0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x07,
  0x87, 0xC0, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x8F,
  0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78,
  0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D,
  0xE0, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00,
  0xF8, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x7C, 0x3C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C,
  0x1E, 0x07, 0x9E, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x07, 0xC1, 0xE3,
  0x83, 0x60, 0xE1, 0xC1, 0xB0, 0xF1, 0xE1, 0xD8, 0x78, 0xF0, 0xFC, 0x3C,
  0x78, 0x6E, 0x1C, 0x3C, 0x37, 0x1E, 0x1E, 0x3B, 0x8F, 0x0F, 0x1D, 0xC7,
  0x87, 0x8C, 0xE3, 0x83, 0xCE, 0x73, 0xC1, 0xE7, 0x39, 0xE0, 0xF3, 0x1C,
  0xF0, 0x79, 0x8E, 0x70, 0x3D, 0xC7, 0x78, 0x1C, 0xE3, 0xBC, 0x0E, 0x61,
  0x9C, 0x07, 0x70, 0xCE, 0x03, 0xB8, 0x6F, 0x01, 0xDC, 0x37, 0x80, 0xEC,
  0x1B, 0x80, 0x7E, 0x0D, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0x0F,
  0xC1, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xE0,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xDE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x3C, 0x01,
  0xF0, 0xF0, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x80,
  0x7C, 0x3C, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3E,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0xF1, 0xC0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3C,
  0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x00, 0xF8, 0x78, 0x1F, 0xF7, 0xC1,
  0xFF, 0xBE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x07,
  0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C,
  0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1F, 0x03, 0xF0, 0xFF, 0xF7, 0x87, 0xFF,
  0xFC, 0x1F, 0xFB, 0xE0, 0x7F, 0x9E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF1, 0xF0, 0x1E, 0x7F, 0xC1, 0xEF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C,
  0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xE7,
  0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0xFC, 0x07, 0xCF, 0xC0, 0xFC,
  0xFF, 0xBF, 0x8F, 0x7F, 0xF0, 0xF3, 0xFE, 0x0F, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F,
  0x80, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x3E, 0x03, 0xFE, 0xF8,
  0x1F, 0xFB, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF1, 0xF0, 0x07,
  0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87,
  0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xFF,
  0xBC, 0x1F, 0xFF, 0xF0, 0x3F, 0xF7, 0xC0, 0x7F, 0x9E, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x01, 0xF1, 0xE0,
  0x1F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x7C, 0x07, 0xC7, 0xE1, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x78, 0x1F, 0xF7, 0xC1,
  0xFF, 0xBE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x07,
  0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x07, 0xC3, 0xF8, 0xFE, 0x0F, 0xFE, 0xF0, 0x7F, 0xF7, 0x81, 0xFE,
  0x7C, 0x01, 0x83, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x1E, 0x7F, 0xC1,
  0xEF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x7C, 0x01,
  0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x7C, 0xF0,
  0x07, 0xCF, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x78, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0x80,
  0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0,
  0x3C, 0x3E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x0F, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x1E,
  0x78, 0x70, 0x3D, 0xFB, 0xF0, 0x7F, 0xF7, 0xF0, 0xF9, 0xF3, 0xE1, 0xE1,
  0xC3, 0xC7, 0x83, 0x87, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x38,
  0x3C, 0x78, 0x70, 0x78, 0xF0, 0xE1, 0xE3, 0xC1, 0xC3, 0xC7, 0x87, 0x87,
  0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x38, 0x3C, 0x78, 0x70, 0xF1,
  0xE0, 0xE1, 0xE3, 0xC1, 0xC3, 0xC7, 0x87, 0x87, 0x8F, 0x0F, 0x0F, 0x1E,
  0x1C, 0x1E, 0x3C, 0x38, 0x78, 0x00, 0x1F, 0x1F, 0x01, 0xE7, 0xFC, 0x1E,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x83, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE7, 0xC0, 0x1E,
  0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03,
  0xCF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x07, 0xCF, 0x00,
  0x7C, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F,
  0x3C, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0x80,
  0x7C, 0x7C, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x1E, 0x7F, 0xC0, 0x7B, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xE0, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F,
  0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00,
  0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xFB, 0xF8, 0x3D, 0xFF, 0xC0,
  0xF3, 0xFE, 0x03, 0xC7, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x78, 0x1F, 0xF7, 0xC1, 0xFF, 0xBE, 0x1F, 0xFF, 0xE1,
  0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C,
  0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x3E,
  0x1F, 0x03, 0xF0, 0xFF, 0xF7, 0x87, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0, 0x7F,
  0x9E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x79,
  0xFF, 0x03, 0xDF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0x01, 0xF1, 0xE0, 0x0F,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0xE1, 0xFC, 0x7F,
  0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x78, 0xF0,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00,
  0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x8F,
  0x00, 0x7C, 0x78, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x7C,
  0x78, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xE7,
  0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x78, 0x1F, 0xC1, 0xE0,
  0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x0E, 0xE0, 0xF8, 0x7B, 0x83, 0xE1, 0xEE,
  0x1F, 0x87, 0x38, 0x6E, 0x3C, 0xE1, 0xB8, 0xF3, 0x8E, 0xE3, 0x8E, 0x33,
  0x8E, 0x38, 0xCE, 0x78, 0xE7, 0x39, 0xC3, 0x9C, 0xE7, 0x0E, 0x63, 0xBC,
  0x3B, 0x8E, 0xE0, 0xEE, 0x3B, 0x83, 0xB0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0xFC, 0x03,
  0xE0, 0xF8, 0x01, 0xE1, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0xF0,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78,
  0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F,
  0x80, 0xFC, 0x7C, 0x0F, 0xC3, 0xFD, 0xFE, 0x0F, 0xFE, 0xF0, 0x7F, 0xEF,
  0x80, 0xFE, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x03, 0xCF, 0xFC, 0x1E,
  0xFF, 0xE0, 0xF7, 0x8F, 0x87, 0xBC, 0x3F, 0xF9, 0xC0, 0xFF, 0xDE, 0x07,
  0xFC, 0xF0, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 30, 25, 7, -30 },
  { 43, 15, 12, 25, 7, -30 },
  { 66, 24, 30, 25, 1, -30 },
  { 156, 22, 42, 25, 2, -36 },
  { 272, 29, 30, 25, -2, -30 },
  { 381, 23, 30, 25, 1, -30 },
  { 468, 6, 12, 25, 11, -30 },
  { 477, 18, 40, 25, 6, -35 },
  { 567, 17, 40, 25, 2, -35 },
  { 652, 22, 21, 25, 2, -25 },
  { 710, 20, 19, 25, 3, -23 },
  { 758, 11, 13, 25, 4, -6 },
  { 776, 14, 4, 25, 6, -16 },
  { 783, 8, 7, 25, 7, -7 },
  { 790, 25, 39, 25, 0, -34 },
  { 912, 22, 30, 25, 2, -30 },
  { 995, 19, 30, 25, 2, -30 },
  { 1067, 21, 30, 25, 2, -30 },
  { 1146, 21, 30, 25, 2, -30 },
  { 1225, 21, 30, 25, 2, -30 },
  { 1304, 21, 30, 25, 2, -30 },
  { 1383, 20, 30, 25, 2, -30 },
  { 1458, 21, 30, 25, 4, -30 },
  { 1537, 21, 30, 25, 2, -30 },
  { 1616, 20, 30, 25, 4, -30 },
  { 1691, 10, 23, 25, 7, -23 },
  { 1720, 14, 30, 25, 4, -23 },
  { 1773, 20, 23, 25, 3, -25 },
  { 1831, 20, 14, 25, 3, -21 },
  { 1866, 20, 23, 25, 2, -25 },
  { 1924, 18, 30, 25, 5, -30 },
  { 1992, 25, 37, 25, 0, -30 },
  { 2108, 21, 30, 25, 0, -30 },
  { 2187, 22, 30, 25, 2, -30 },
  { 2270, 22, 30, 25, 2, -30 },
  { 2353, 21, 30, 25, 2, -30 },
  { 2432, 22, 30, 25, 2, -30 },
  { 2515, 23, 30, 25, 2, -30 },
  { 2602, 22, 30, 25, 2, -30 },
  { 2685, 22, 30, 25, 2, -30 },
  { 2768, 22, 30, 25, 2, -30 },
  { 2851, 24, 30, 25, 0, -30 },
  { 2941, 24, 30, 25, 2, -30 },
  { 3031, 18, 30, 25, 3, -30 },
  { 3099, 24, 30, 25, 1, -30 },
  { 3189, 22, 30, 25, 2, -30 },
  { 3272, 21, 30, 25, 2, -30 },
  { 3351, 23, 30, 25, 2, -30 },
  { 3438, 22, 37, 25, 2, -30 },
  { 3540, 22, 30, 25, 2, -30 },
  { 3623, 22, 30, 25, 2, -30 },
  { 3706, 21, 30, 25, 4, -30 },
  { 3785, 22, 30, 25, 2, -30 },
  { 3868, 21, 30, 25, 5, -30 },
  { 3947, 25, 30, 25, 2, -30 },
  { 4041, 26, 30, 25, 0, -30 },
  { 4139, 22, 30, 25, 4, -30 },
  { 4222, 22, 30, 25, 2, -30 },
  { 4305, 17, 39, 25, 5, -34 },
  { 4388, 13, 39, 25, 6, -34 },
  { 4452, 17, 39, 25, 3, -34 },
  { 4535, 19, 16, 25, 3, -30 },
  { 4573, 20, 4, 25, 0, 1 },
  { 4583, 9, 6, 25, 10, -32 },
  { 4590, 21, 23, 25, 2, -23 },
  { 4651, 20, 30, 25, 2, -30 },
  { 4726, 21, 23, 25, 2, -23 },
  { 4787, 22, 30, 25, 2, -30 },
  { 4870, 20, 23, 25, 2, -23 },
  { 4928, 28, 37, 25, -2, -30 },
  { 5058, 21, 30, 25, 2, -23 },
  { 5137, 20, 30, 25, 2, -30 },
  { 5212, 21, 32, 25, 1, -32 },
  { 5296, 22, 39, 25, 0, -32 },
  { 5404, 22, 30, 25, 2, -30 },
  { 5487, 18, 30, 25, 4, -30 },
  { 5555, 23, 23, 25, 1, -23 },
  { 5622, 20, 23, 25, 2, -23 },
  { 5680, 20, 23, 25, 2, -23 },
  { 5738, 22, 30, 25, 0, -23 },
  { 5821, 21, 30, 25, 2, -23 },
  { 5900, 21, 23, 25, 2, -23 },
  { 5961, 20, 23, 25, 2, -23 },
  { 6019, 20, 29, 25, 3, -29 },
  { 6092, 21, 23, 25, 2, -23 },
  { 6153, 20, 23, 25, 4, -23 },
  { 6211, 22, 23, 25, 3, -23 },
  { 6275, 24, 23, 25, 0, -23 },
  { 6344, 21, 30, 25, 2, -23 },
  { 6423, 20, 23, 25, 2, -23 },
  { 6481, 21, 39, 25, 4, -34 },
  { 6584, 10, 39, 25, 8, -34 },
  { 6633, 21, 39, 25, 1, -34 },
  { 6736, 21, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_MEDIUMITALIC41PT7B_H_
