#ifndef _JETBRAINSMONO_MEDIUMITALIC9PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB7, 0x00, 0x28, 0xA7, 0xD4, 0xF9, 0x4A, 0x00, 0x11,
  0x96, 0xA7, 0x1E, 0xAE, 0x20, 0x66, 0xAB, 0x14, 0x39, 0xA9, 0x80, 0x32,
  0x50, 0xCA, 0xCB, 0xE0, 0x58, 0x13, 0x44, 0x44, 0x44, 0x60, 0x23, 0x11,
  0x11, 0x12, 0xC0, 0x16, 0xCC, 0xA0, 0x24, 0xF4, 0x60, 0xE0, 0xC0, 0x0C,
  0x61, 0x08, 0x21, 0x04, 0x20, 0x32, 0x52, 0xD4, 0xC5, 0xC0, 0x13, 0x94,
  0x21, 0x13, 0xE0, 0x32, 0x42, 0x23, 0x23, 0xE0, 0x78, 0x4C, 0x60, 0xC5,
  0xC0, 0x08, 0x88, 0x94, 0xF8, 0x40, 0x3A, 0x10, 0xF0, 0xA5, 0xC0, 0x10,
  0x88, 0xF4, 0xC5, 0xC0, 0xFC, 0x84, 0x42, 0x22, 0x00, 0x32, 0x52, 0x65,
  0xC5, 0xC0, 0x69, 0x99, 0x64, 0xC0, 0xC0, 0x80, 0x60, 0x05, 0x00, 0x3C,
  0x87, 0xF0, 0x0F, 0x60, 0xC7, 0xC0, 0x61, 0x16, 0x40, 0xC0, 0x31, 0x25,
  0xAA, 0xAA, 0xAB, 0x20, 0x60, 0x11, 0x8C, 0xA7, 0x2A, 0x20, 0x72, 0x52,
  0xE4, 0xA7, 0xC0, 0x69, 0x88, 0x89, 0xE0, 0x72, 0x52, 0x94, 0xAF, 0xC0,
  0x7A, 0x10, 0xF4, 0x23, 0xC0, 0x7A, 0x10, 0xF4, 0x22, 0x00, 0x69, 0x88,
  0xB9, 0xE0, 0x4A, 0x52, 0xF4, 0xAA, 0x40, 0x78, 0x84, 0x42, 0x13, 0xC0,
  0x18, 0x42, 0x10, 0xC9, 0xC0, 0x45, 0x25, 0x1C, 0x51, 0x49, 0x80, 0x48,
  0x88, 0x88, 0xF0, 0x4B, 0x5E, 0xF4, 0xC6, 0x60, 0x6B, 0x5A, 0xD6, 0xAE,
  0x40, 0x69, 0x99, 0x99, 0xE0, 0x72, 0x52, 0xF4, 0x22, 0x00, 0x32, 0x52,
  0x94, 0xA5, 0xC2, 0x10, 0x72, 0x52, 0xF5, 0x2A, 0x60, 0x32, 0x50, 0xE0,
  0xC5, 0xC0, 0xF9, 0x08, 0x84, 0x21, 0x00, 0x4A, 0x52, 0x94, 0xA9, 0xC0,
  0x8C, 0xA5, 0x4A, 0x51, 0x00, 0x55, 0x57, 0x9E, 0x59, 0x4D, 0x00, 0x45,
  0x23, 0x08, 0x31, 0x49, 0x80, 0x8C, 0x98, 0xC4, 0x21, 0x00, 0x78, 0x44,
  0x42, 0x23, 0xC0, 0x74, 0x44, 0x44, 0x8E, 0xC9, 0x24, 0x49, 0x64, 0x92,
  0x96, 0x26, 0x69, 0xF0, 0xC0, 0x7A, 0x52, 0xA7, 0x00, 0x42, 0x1E, 0x94,
  0xA6, 0xC0, 0x79, 0x89, 0xE0, 0x08, 0x5E, 0x94, 0xA9, 0xC0, 0x69, 0xF8,
  0xE0, 0x0C, 0xC2, 0x1E, 0x20, 0x82, 0x10, 0x80, 0xF9, 0x9A, 0xE2, 0xC0,
  0x42, 0x1E, 0x94, 0xA6, 0x40, 0x10, 0x1C, 0x22, 0x13, 0xE0, 0x18, 0x1C,
  0x21, 0x08, 0x44, 0xC0, 0x42, 0x12, 0xA6, 0x2A, 0x60, 0xC4, 0x44, 0x44,
  0x70, 0x7B, 0x6B, 0x5A, 0x80, 0x7A, 0x52, 0x99, 0x00, 0x69, 0x99, 0xE0,
  0x7A, 0x52, 0x9B, 0x42, 0x00, 0x7A, 0x52, 0xA7, 0x08, 0x40, 0xF9, 0x88,
  0x80, 0x7A, 0x1D, 0x17, 0x00, 0x4F, 0x44, 0x46, 0x4A, 0x52, 0xA7, 0x00,
  0x99, 0xAA, 0x40, 0xFE, 0xAD, 0x4A, 0x00, 0x49, 0x88, 0xAD, 0x80, 0x99,
  0x9A, 0xE2, 0xC0, 0x78, 0x88, 0x8F, 0x00, 0x32, 0x2C, 0x24, 0x46, 0x56,
  0xAA, 0x61, 0x08, 0x72, 0x10, 0x98, 0x6C, 0xC0,
};

const GFXglyph JetBrainsMono_MediumItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 6, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 7, 5, 0, -7 },
  { 23, 5, 7, 5, 0, -7 },
  { 28, 2, 3, 5, 2, -7 },
  { 29, 4, 9, 5, 1, -8 },
  { 34, 4, 9, 5, 0, -8 },
  { 39, 5, 4, 5, 0, -5 },
  { 42, 4, 4, 5, 1, -5 },
  { 44, 2, 2, 5, 1, -1 },
  { 45, 3, 1, 5, 1, -3 },
  { 46, 1, 2, 5, 2, -2 },
  { 47, 6, 8, 5, 0, -7 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 5, 7, 5, 0, -7 },
  { 73, 5, 7, 5, 0, -7 },
  { 78, 5, 7, 5, 0, -7 },
  { 83, 5, 7, 5, 0, -7 },
  { 88, 5, 7, 5, 1, -7 },
  { 93, 5, 7, 5, 0, -7 },
  { 98, 4, 7, 5, 1, -7 },
  { 102, 2, 5, 5, 2, -5 },
  { 104, 3, 6, 5, 1, -5 },
  { 107, 4, 4, 5, 1, -5 },
  { 109, 4, 4, 5, 1, -5 },
  { 111, 5, 4, 5, 0, -5 },
  { 114, 4, 7, 5, 1, -7 },
  { 118, 6, 9, 5, 0, -7 },
  { 125, 5, 7, 5, 0, -7 },
  { 130, 5, 7, 5, 0, -7 },
  { 135, 4, 7, 5, 1, -7 },
  { 139, 5, 7, 5, 0, -7 },
  { 144, 5, 7, 5, 0, -7 },
  { 149, 5, 7, 5, 0, -7 },
  { 154, 4, 7, 5, 1, -7 },
  { 158, 5, 7, 5, 0, -7 },
  { 163, 5, 7, 5, 0, -7 },
  { 168, 5, 7, 5, 0, -7 },
  { 173, 6, 7, 5, 0, -7 },
  { 179, 4, 7, 5, 1, -7 },
  { 183, 5, 7, 5, 0, -7 },
  { 188, 5, 7, 5, 0, -7 },
  { 193, 4, 7, 5, 1, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 5, 9, 5, 0, -7 },
  { 208, 5, 7, 5, 0, -7 },
  { 213, 5, 7, 5, 0, -7 },
  { 218, 5, 7, 5, 1, -7 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 5, 7, 5, 1, -7 },
  { 233, 6, 7, 5, 0, -7 },
  { 239, 6, 7, 5, 0, -7 },
  { 245, 5, 7, 5, 1, -7 },
  { 250, 5, 7, 5, 0, -7 },
  { 255, 4, 8, 5, 1, -7 },
  { 259, 3, 8, 5, 1, -7 },
  { 262, 3, 8, 5, 1, -7 },
  { 265, 4, 4, 5, 1, -7 },
  { 267, 4, 1, 5, 0, 0 },
  { 268, 2, 1, 5, 2, -7 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 5, 7, 5, 0, -7 },
  { 278, 4, 5, 5, 1, -5 },
  { 281, 5, 7, 5, 0, -7 },
  { 286, 4, 5, 5, 1, -5 },
  { 289, 6, 9, 5, 0, -7 },
  { 296, 4, 7, 5, 1, -5 },
  { 300, 5, 7, 5, 0, -7 },
  { 305, 5, 7, 5, 0, -7 },
  { 310, 5, 9, 5, 0, -7 },
  { 316, 5, 7, 5, 0, -7 },
  { 321, 4, 7, 5, 1, -7 },
  { 325, 5, 5, 5, 0, -5 },
  { 329, 5, 5, 5, 0, -5 },
  { 333, 4, 5, 5, 1, -5 },
  { 336, 5, 7, 5, 0, -5 },
  { 341, 5, 7, 5, 0, -5 },
  { 346, 4, 5, 5, 1, -5 },
  { 349, 5, 5, 5, 0, -5 },
  { 353, 4, 6, 5, 1, -6 },
  { 356, 5, 5, 5, 0, -5 },
  { 360, 4, 5, 5, 1, -5 },
  { 363, 5, 5, 5, 1, -5 },
  { 367, 5, 5, 5, 0, -5 },
  { 371, 4, 7, 5, 1, -5 },
  { 375, 5, 5, 5, 0, -5 },
  { 379, 4, 8, 5, 1, -7 },
  { 383, 2, 8, 5, 2, -7 },
  { 385, 5, 8, 5, 0, -7 },
  { 390, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_MediumItalic9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_MEDIUMITALIC9PT7B_H_
