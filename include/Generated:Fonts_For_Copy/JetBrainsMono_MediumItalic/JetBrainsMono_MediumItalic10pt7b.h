#ifndef _JETBRAINSMONO_MEDIUMITALIC10PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xB6, 0x80, 0x35, 0xF2, 0x92, 0xF9, 0x49, 0x00, 0x10,
  0x43, 0xD5, 0x70, 0xE2, 0xBA, 0x70, 0x80, 0x77, 0x31, 0xC0, 0x83, 0xCA,
  0xA6, 0x00, 0x39, 0x02, 0x19, 0x9A, 0x4E, 0x80, 0xE0, 0x19, 0x10, 0x84,
  0x21, 0x08, 0x20, 0x62, 0x33, 0x22, 0x24, 0x80, 0x11, 0x5F, 0x8C, 0x48,
  0x21, 0x3E, 0x84, 0x00, 0x6A, 0x40, 0xF0, 0xB0, 0x04, 0x20, 0x84, 0x10,
  0x86, 0x10, 0xC0, 0x7C, 0x63, 0xE9, 0x4B, 0x80, 0x3A, 0x84, 0x21, 0x0B,
  0xE0, 0x39, 0x10, 0x86, 0x31, 0x0F, 0x80, 0x3C, 0x63, 0x02, 0x09, 0x27,
  0x00, 0x19, 0x11, 0x29, 0x38, 0x40, 0x7C, 0x3D, 0x21, 0x4B, 0x80, 0x19,
  0x8C, 0x94, 0xA5, 0xC0, 0xFC, 0xC4, 0x42, 0x23, 0x00, 0x39, 0x16, 0x8C,
  0x49, 0x27, 0x00, 0x7C, 0x63, 0xE2, 0x13, 0x00, 0x70, 0x30, 0x2C, 0x06,
  0xB4, 0x0B, 0xA1, 0x83, 0x00, 0xF8, 0x3C, 0x41, 0x82, 0x3E, 0x00, 0x70,
  0x84, 0xC4, 0x03, 0x00, 0x3D, 0x15, 0xE9, 0xA6, 0xA9, 0x20, 0x60, 0x19,
  0x4A, 0xD7, 0xA6, 0x20, 0x79, 0x14, 0x9E, 0x49, 0x2F, 0x00, 0x7C, 0x61,
  0x08, 0x4B, 0x80, 0x79, 0x14, 0xD2, 0x49, 0x2F, 0x00, 0x3D, 0x04, 0x1E,
  0x41, 0x0F, 0x80, 0x7D, 0x04, 0x1E, 0x41, 0x0C, 0x00, 0x7C, 0x61, 0x69,
  0x4B, 0x80, 0x65, 0x14, 0x9E, 0x49, 0x2C, 0x80, 0x79, 0x08, 0x46, 0x23,
  0xC0, 0x1C, 0x20, 0x82, 0x0A, 0x27, 0x00, 0x65, 0x25, 0x1C, 0x51, 0x2C,
  0x80, 0x44, 0x88, 0x88, 0xF0, 0x6D, 0xB7, 0x5E, 0x4A, 0x28, 0x80, 0x65,
  0x96, 0x96, 0x59, 0x69, 0x80, 0x74, 0x65, 0x29, 0x4B, 0x80, 0x7D, 0x14,
  0x5E, 0x41, 0x0C, 0x00, 0x74, 0x67, 0x29, 0x4B, 0x84, 0x30, 0x7D, 0x14,
  0xDE, 0x51, 0x6C, 0x80, 0x3D, 0x16, 0x0E, 0x0B, 0x27, 0x00, 0xF9, 0x08,
  0x44, 0x21, 0x00, 0xCC, 0x65, 0x29, 0x4B, 0x80, 0x8C, 0xE4, 0xA6, 0x31,
  0x00, 0xAE, 0xAE, 0xBA, 0xF2, 0xCB, 0x00, 0x64, 0xA3, 0x0C, 0x31, 0x68,
  0x80, 0x8A, 0x94, 0xC4, 0x21, 0x00, 0x7C, 0x21, 0x0C, 0x21, 0x0F, 0x80,
  0x32, 0x44, 0x44, 0x44, 0xE0, 0x92, 0x44, 0x92, 0x60, 0x71, 0x22, 0x22,
  0x22, 0xE0, 0x25, 0x59, 0xF8, 0xB0, 0x6E, 0xA5, 0x29, 0x78, 0x62, 0x9A,
  0x94, 0xA7, 0xC0, 0x26, 0xA1, 0x09, 0x70, 0x0B, 0x75, 0x29, 0x4B, 0xC0,
  0x2D, 0x9F, 0x9E, 0x0E, 0x10, 0xF8, 0x81, 0x02, 0x04, 0x08, 0xE0, 0x6E,
  0xA5, 0x2B, 0x68, 0xDC, 0x62, 0x9A, 0x94, 0xA7, 0x20, 0x18, 0x9C, 0x21,
  0x08, 0x5F, 0x08, 0x4E, 0x91, 0x88, 0x42, 0x17, 0x00, 0x61, 0x14, 0x94,
  0x71, 0x4C, 0x80, 0xE6, 0x44, 0x44, 0x70, 0x69, 0x55, 0x5A, 0xAA, 0xA0,
  0x53, 0x52, 0x94, 0xE4, 0x2D, 0x99, 0x9E, 0x53, 0x52, 0x94, 0xFA, 0x10,
  0x6E, 0xA5, 0x29, 0x78, 0x44, 0xB6, 0xE7, 0x08, 0x40, 0x32, 0x50, 0x70,
  0xBC, 0x27, 0xD0, 0x84, 0x21, 0xC0, 0x8C, 0xA5, 0x29, 0x70, 0x8C, 0xA5,
  0x46, 0x30, 0xAD, 0x7B, 0xEB, 0x58, 0x44, 0xA3, 0x0C, 0x53, 0x20, 0x9C,
  0xA5, 0x2B, 0x28, 0xDC, 0x78, 0x44, 0x44, 0x7C, 0x19, 0x08, 0x4C, 0x10,
  0x88, 0x30, 0x55, 0x6A, 0x80, 0x30, 0x84, 0x41, 0x90, 0x84, 0xC0, 0x4D,
  0x4C,
};

const GFXglyph JetBrainsMono_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 10, 6, 0, -9 },
  { 19, 7, 7, 6, 0, -7 },
  { 26, 6, 7, 6, 0, -7 },
  { 32, 1, 3, 6, 3, -7 },
  { 33, 5, 9, 6, 1, -8 },
  { 39, 4, 9, 6, 1, -8 },
  { 44, 6, 5, 6, 0, -6 },
  { 48, 5, 5, 6, 1, -6 },
  { 52, 3, 4, 6, 1, -2 },
  { 54, 4, 1, 6, 1, -4 },
  { 55, 2, 2, 6, 2, -2 },
  { 56, 6, 9, 6, 0, -8 },
  { 63, 5, 7, 6, 1, -7 },
  { 68, 5, 7, 6, 0, -7 },
  { 73, 6, 7, 6, 0, -7 },
  { 79, 6, 7, 6, 0, -7 },
  { 85, 5, 7, 6, 1, -7 },
  { 90, 5, 7, 6, 1, -7 },
  { 95, 5, 7, 6, 0, -7 },
  { 100, 5, 7, 6, 1, -7 },
  { 105, 6, 7, 6, 0, -7 },
  { 111, 5, 7, 6, 1, -7 },
  { 116, 2, 6, 6, 2, -6 },
  { 118, 3, 8, 6, 1, -6 },
  { 121, 5, 5, 6, 1, -6 },
  { 125, 5, 3, 6, 1, -5 },
  { 127, 5, 5, 6, 0, -6 },
  { 131, 5, 7, 6, 1, -7 },
  { 136, 6, 9, 6, 0, -7 },
  { 143, 5, 7, 6, 0, -7 },
  { 148, 6, 7, 6, 0, -7 },
  { 154, 5, 7, 6, 1, -7 },
  { 159, 6, 7, 6, 0, -7 },
  { 165, 6, 7, 6, 0, -7 },
  { 171, 6, 7, 6, 0, -7 },
  { 177, 5, 7, 6, 1, -7 },
  { 182, 6, 7, 6, 0, -7 },
  { 188, 5, 7, 6, 1, -7 },
  { 193, 6, 7, 6, 0, -7 },
  { 199, 6, 7, 6, 0, -7 },
  { 205, 4, 7, 6, 1, -7 },
  { 209, 6, 7, 6, 0, -7 },
  { 215, 6, 7, 6, 0, -7 },
  { 221, 5, 7, 6, 1, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 5, 9, 6, 1, -7 },
  { 238, 6, 7, 6, 0, -7 },
  { 244, 6, 7, 6, 0, -7 },
  { 250, 5, 7, 6, 1, -7 },
  { 255, 5, 7, 6, 1, -7 },
  { 260, 5, 7, 6, 1, -7 },
  { 265, 6, 7, 6, 1, -7 },
  { 271, 6, 7, 6, 0, -7 },
  { 277, 5, 7, 6, 1, -7 },
  { 282, 6, 7, 6, 0, -7 },
  { 288, 4, 9, 6, 1, -8 },
  { 293, 3, 9, 6, 2, -8 },
  { 297, 4, 9, 6, 1, -8 },
  { 302, 4, 4, 6, 1, -7 },
  { 304, 5, 1, 6, 0, 0 },
  { 305, 2, 2, 6, 3, -8 },
  { 306, 5, 6, 6, 1, -6 },
  { 310, 5, 7, 6, 0, -7 },
  { 315, 5, 6, 6, 1, -6 },
  { 319, 5, 7, 6, 1, -7 },
  { 324, 4, 6, 6, 1, -6 },
  { 327, 7, 9, 6, -1, -7 },
  { 335, 5, 8, 6, 1, -6 },
  { 340, 5, 7, 6, 0, -7 },
  { 345, 5, 8, 6, 0, -8 },
  { 350, 5, 10, 6, 0, -8 },
  { 357, 6, 7, 6, 0, -7 },
  { 363, 4, 7, 6, 1, -7 },
  { 367, 6, 6, 6, 0, -6 },
  { 372, 5, 6, 6, 0, -6 },
  { 376, 4, 6, 6, 1, -6 },
  { 379, 5, 8, 6, 0, -6 },
  { 384, 5, 8, 6, 1, -6 },
  { 389, 5, 6, 6, 1, -6 },
  { 393, 5, 6, 6, 0, -6 },
  { 397, 5, 7, 6, 1, -7 },
  { 402, 5, 6, 6, 1, -6 },
  { 406, 5, 6, 6, 1, -6 },
  { 410, 5, 6, 6, 1, -6 },
  { 414, 6, 6, 6, 0, -6 },
  { 419, 5, 8, 6, 1, -6 },
  { 424, 5, 6, 6, 0, -6 },
  { 428, 5, 9, 6, 1, -8 },
  { 434, 2, 9, 6, 2, -8 },
  { 437, 5, 9, 6, 0, -8 },
  { 443, 5, 3, 6, 1, -5 },
};

const GFXfont JetBrainsMono_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_MEDIUMITALIC10PT7B_H_
