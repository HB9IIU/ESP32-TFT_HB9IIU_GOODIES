#ifndef _JETBRAINSMONO_MEDIUMITALIC17PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x22, 0x66, 0x00, 0xEE, 0xCF, 0x3C, 0xF2, 0xC8, 0x0C,
  0xC3, 0x20, 0x88, 0xFF, 0x19, 0x04, 0x43, 0x33, 0xFE, 0xFF, 0x99, 0x84,
  0x41, 0x30, 0x04, 0x02, 0x03, 0x07, 0xE3, 0x5B, 0x4D, 0xA0, 0xF0, 0x3E,
  0x07, 0x82, 0xC2, 0x6D, 0x37, 0xF1, 0xF0, 0x20, 0x30, 0x00, 0x08, 0x01,
  0xE3, 0x32, 0x62, 0x6C, 0x26, 0x83, 0xD0, 0x02, 0x00, 0x48, 0x0F, 0xE1,
  0xA6, 0x32, 0x62, 0x24, 0xC3, 0xC0, 0x06, 0x07, 0xC1, 0x98, 0xC0, 0x30,
  0x06, 0x03, 0x81, 0xB3, 0x65, 0x91, 0xCC, 0x71, 0xBC, 0x79, 0x80, 0xFE,
  0x80, 0x06, 0x38, 0xC3, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x0C, 0x1C, 0x08, 0x30, 0x38, 0x30, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18,
  0x30, 0x61, 0x86, 0x38, 0x60, 0x0C, 0x06, 0x32, 0x7F, 0xF0, 0x81, 0xE1,
  0x99, 0x8C, 0x0C, 0x0C, 0x08, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x19, 0xCC,
  0xC6, 0x60, 0xFC, 0x7F, 0x80, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x1A, 0x09, 0x6D, 0x96,
  0xC3, 0x61, 0xB0, 0x9D, 0xC7, 0xC0, 0x1E, 0x36, 0x64, 0x4C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x08, 0x18, 0xFF, 0xFF, 0x0C, 0x1F, 0x9C, 0xCC, 0x30, 0x10,
  0x18, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x1F, 0xEF, 0xE0, 0x3F, 0x81, 0x81,
  0x81, 0x81, 0xC0, 0xF0, 0x0C, 0x06, 0x03, 0x63, 0x3B, 0x8F, 0x80, 0x03,
  0x06, 0x0C, 0x18, 0x30, 0x63, 0xE3, 0xC3, 0xFE, 0x06, 0x06, 0x06, 0x3F,
  0x90, 0x18, 0x0C, 0x07, 0xE3, 0xB8, 0x0C, 0x06, 0x03, 0x61, 0x3B, 0x8F,
  0x80, 0x06, 0x0C, 0x18, 0x30, 0x3C, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xEE,
  0x7C, 0xFF, 0xC3, 0xC2, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0xC0, 0x0C, 0x1F, 0x8C, 0xEC, 0x26, 0x31, 0xB8, 0x70, 0xEC, 0xC3, 0x61,
  0xB0, 0xDD, 0xC7, 0xC0, 0x0C, 0x1F, 0x9C, 0xEC, 0x34, 0x1A, 0x0D, 0x8C,
  0xFE, 0x06, 0x06, 0x06, 0x06, 0x07, 0x00, 0x27, 0x70, 0x00, 0x04, 0xEE,
  0x11, 0xCE, 0x00, 0x00, 0x06, 0x73, 0x11, 0x88, 0x00, 0x01, 0x83, 0x87,
  0x0E, 0x0C, 0x03, 0x80, 0x70, 0x1E, 0x02, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x60, 0x70, 0x1C, 0x07, 0x03, 0x0F, 0x38, 0xE0, 0x80, 0x7C,
  0x1C, 0x18, 0x30, 0x67, 0x8E, 0x30, 0x00, 0x01, 0x87, 0x00, 0x03, 0x07,
  0xF3, 0x0C, 0x81, 0x60, 0x59, 0xD6, 0xCD, 0x33, 0x4C, 0xF2, 0x2C, 0x9B,
  0x3A, 0xC0, 0x30, 0x07, 0x00, 0xF0, 0x07, 0x07, 0x83, 0xC3, 0x61, 0xB0,
  0x98, 0xCC, 0x7E, 0x7F, 0x30, 0x98, 0x78, 0x30, 0x3F, 0x31, 0xD8, 0x6C,
  0x26, 0x33, 0xE1, 0x1D, 0x86, 0xC3, 0x61, 0xBF, 0x9F, 0x80, 0x0C, 0x1F,
  0x8C, 0xEC, 0x36, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0xDD, 0xC7,
  0xC0, 0x7F, 0x31, 0x98, 0x6C, 0x26, 0x13, 0x19, 0x0D, 0x86, 0xC3, 0x63,
  0x3F, 0x9F, 0x00, 0x3F, 0x90, 0x18, 0x0C, 0x06, 0x03, 0xF9, 0x80, 0x80,
  0xC0, 0x60, 0x3F, 0x9F, 0xC0, 0x3F, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0xF9,
  0xFD, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x0C, 0x1F, 0x8C, 0xEC, 0x36,
  0x03, 0x01, 0x01, 0x9E, 0xC3, 0x61, 0xB0, 0xDD, 0xC7, 0xC0, 0x31, 0xB0,
  0xD8, 0x6C, 0x26, 0x33, 0xF9, 0x0D, 0x86, 0xC3, 0x61, 0x31, 0x98, 0xC0,
  0x3F, 0x86, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x3F,
  0x9F, 0xC0, 0x07, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0xC1, 0x30, 0xC6, 0x61, 0xF0, 0x21, 0xD8, 0xC6, 0x31, 0x98, 0x6C, 0x1F,
  0x04, 0xC3, 0x30, 0xC6, 0x31, 0x8C, 0x63, 0x0C, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xFF, 0xFE, 0x38, 0xCA, 0x52, 0x9C,
  0xAF, 0x2A, 0xDB, 0xA6, 0xD9, 0x86, 0x61, 0x98, 0x64, 0x1B, 0x04, 0x71,
  0xB8, 0xDC, 0x6F, 0x27, 0x92, 0x5B, 0x2D, 0x96, 0xCF, 0x67, 0x33, 0x90,
  0xC0, 0x0C, 0x1F, 0x8C, 0xCC, 0x36, 0x13, 0x19, 0x0D, 0x86, 0xC3, 0x61,
  0xB1, 0x9D, 0xC7, 0xC0, 0x3F, 0x30, 0xD8, 0x6C, 0x36, 0x1B, 0xF9, 0xF9,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x1B,
  0x09, 0x0D, 0x86, 0xC3, 0x61, 0xB0, 0x9D, 0xC7, 0xC0, 0x60, 0x30, 0x0C,
  0x3F, 0x31, 0xD8, 0x6C, 0x36, 0x33, 0xF9, 0xF1, 0x98, 0xC4, 0x63, 0x31,
  0x98, 0xE0, 0x0C, 0x1F, 0x8C, 0x6C, 0x36, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x01, 0xB0, 0xDD, 0xC7, 0xC0, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x00, 0x61, 0xB0, 0xD8, 0x6C, 0x26,
  0x33, 0x19, 0x0D, 0x86, 0xC3, 0x63, 0x3B, 0x8F, 0x80, 0xC3, 0xE1, 0xB0,
  0x98, 0xCC, 0x62, 0x61, 0x30, 0x90, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0x4C,
  0xF3, 0x3C, 0xCB, 0x56, 0xD5, 0xB5, 0x4D, 0x53, 0x9C, 0xE7, 0x39, 0x8E,
  0x63, 0x18, 0x30, 0xE3, 0x30, 0x66, 0x0D, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x33, 0x06, 0x61, 0x8C, 0x60, 0xC0, 0xC3, 0xE1, 0x91, 0x8C, 0x86,
  0xC1, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x00, 0x3F, 0xA1, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x70, 0x3F, 0x9F, 0xC0, 0x1E,
  0x3C, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x3E,
  0x7C, 0xC6, 0x31, 0x84, 0x31, 0x8C, 0x21, 0x8C, 0x63, 0x08, 0x63, 0x1E,
  0x3C, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x1E,
  0x7C, 0x0C, 0x1E, 0x12, 0x32, 0x63, 0xE3, 0xFF, 0xFF, 0xE3, 0x08, 0x9E,
  0x98, 0xCC, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xEE, 0x3F, 0x00, 0x20, 0x60,
  0x64, 0x7F, 0x63, 0x63, 0x43, 0xC3, 0xC3, 0xC2, 0xEE, 0xFC, 0x08, 0x3F,
  0x63, 0x63, 0xC0, 0xC0, 0xC0, 0xC3, 0xEE, 0x7C, 0x01, 0x80, 0xC2, 0x67,
  0xA6, 0x33, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x3B, 0x8F, 0xC0, 0x08, 0x3E,
  0x63, 0x43, 0xC3, 0xFF, 0xC0, 0xC0, 0xE6, 0x7C, 0x03, 0xF0, 0x30, 0x06,
  0x00, 0x60, 0x3F, 0xE0, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x0F, 0x80, 0xF0, 0x00, 0x08, 0x9E, 0x98, 0xCC, 0x6C,
  0x36, 0x1B, 0x0D, 0xCC, 0x7E, 0x03, 0x01, 0x8F, 0xCF, 0xC0, 0x20, 0x60,
  0x64, 0x7F, 0x63, 0x63, 0x43, 0xC3, 0xC3, 0xC2, 0xC6, 0xC6, 0x0E, 0x0E,
  0x00, 0x00, 0x7C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0xFF, 0xFF, 0x01,
  0x81, 0xC0, 0x00, 0x01, 0xF1, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x33, 0xF1, 0xF0, 0x30, 0x30, 0x18, 0x0C, 0x76, 0x33, 0x31,
  0xF1, 0xF8, 0xCC, 0x67, 0x31, 0x98, 0xE0, 0xF8, 0x60, 0xC1, 0x83, 0x06,
  0x08, 0x30, 0x60, 0xC1, 0xF9, 0xF0, 0x08, 0x8F, 0xF6, 0x4D, 0x92, 0x64,
  0x9B, 0x24, 0xD9, 0x26, 0xC9, 0xB2, 0x60, 0x04, 0x7F, 0x63, 0x63, 0x43,
  0xC3, 0xC3, 0xC2, 0xC6, 0xC6, 0x08, 0x3E, 0x63, 0x63, 0xC3, 0xC3, 0xC3,
  0xC2, 0xEE, 0x7C, 0x02, 0x1F, 0xCC, 0x66, 0x32, 0x1B, 0x0D, 0x86, 0xC2,
  0x77, 0x3F, 0x10, 0x18, 0x0C, 0x00, 0x08, 0x9E, 0x98, 0xCC, 0x6C, 0x36,
  0x1B, 0x0D, 0x8C, 0xEE, 0x3F, 0x01, 0x80, 0xC0, 0x60, 0x04, 0x3F, 0x9C,
  0xCC, 0x36, 0x33, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x0C, 0x3F, 0x63,
  0x60, 0x70, 0x3E, 0x03, 0x03, 0xC6, 0x7C, 0x18, 0x0C, 0x06, 0x1F, 0xF1,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0F, 0x83, 0xC0, 0x61, 0xB1, 0x98,
  0xC8, 0x6C, 0x36, 0x1B, 0x19, 0xDC, 0x7C, 0x00, 0xC3, 0xC6, 0xC6, 0xCC,
  0xCC, 0x58, 0x58, 0x70, 0x70, 0xCC, 0xEA, 0xF5, 0x7A, 0xAF, 0x77, 0x3B,
  0x99, 0xCC, 0xC6, 0x00, 0x31, 0xC6, 0xC1, 0xB0, 0x38, 0x0C, 0x07, 0x83,
  0x61, 0x8C, 0xE3, 0x80, 0x61, 0x63, 0x43, 0x43, 0xC3, 0xC3, 0xE6, 0x7E,
  0x06, 0x06, 0x7E, 0xF8, 0x7F, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE,
  0xFE, 0x03, 0x83, 0xC1, 0x80, 0xC0, 0x40, 0x60, 0x30, 0xF0, 0xF8, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0x78, 0x1C, 0x19, 0x8C, 0x63, 0x18, 0x8C,
  0x63, 0x18, 0xC6, 0x23, 0x18, 0x1C, 0x0F, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x0F, 0x0F, 0x8C, 0x06, 0x03, 0x01, 0x80, 0xC1, 0xC1, 0xC0, 0x71,
  0xFC, 0xF3, 0xD9, 0xC0,
};

const GFXglyph JetBrainsMono_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 17, 10, 1, -15 },
  { 46, 12, 13, 10, -1, -13 },
  { 66, 10, 13, 10, 0, -13 },
  { 83, 2, 5, 10, 5, -12 },
  { 85, 7, 16, 10, 3, -14 },
  { 99, 7, 16, 10, 1, -14 },
  { 113, 9, 8, 10, 1, -10 },
  { 122, 8, 8, 10, 1, -10 },
  { 130, 5, 6, 10, 1, -3 },
  { 134, 6, 1, 10, 2, -6 },
  { 135, 3, 3, 10, 3, -3 },
  { 137, 11, 16, 10, 0, -14 },
  { 159, 9, 13, 10, 1, -13 },
  { 174, 8, 12, 10, 1, -12 },
  { 186, 9, 13, 10, 1, -13 },
  { 201, 9, 12, 10, 1, -12 },
  { 215, 8, 12, 10, 1, -12 },
  { 227, 9, 12, 10, 1, -12 },
  { 241, 8, 12, 10, 1, -12 },
  { 253, 8, 12, 10, 2, -12 },
  { 265, 9, 13, 10, 1, -13 },
  { 280, 9, 13, 10, 1, -13 },
  { 295, 4, 10, 10, 3, -10 },
  { 300, 5, 13, 10, 2, -10 },
  { 309, 9, 9, 10, 1, -10 },
  { 320, 8, 6, 10, 1, -9 },
  { 326, 8, 9, 10, 1, -10 },
  { 335, 7, 12, 10, 2, -12 },
  { 346, 10, 16, 10, 0, -13 },
  { 366, 9, 12, 10, 0, -12 },
  { 380, 9, 12, 10, 1, -12 },
  { 394, 9, 13, 10, 1, -13 },
  { 409, 9, 12, 10, 1, -12 },
  { 423, 9, 12, 10, 1, -12 },
  { 437, 9, 12, 10, 1, -12 },
  { 451, 9, 13, 10, 1, -13 },
  { 466, 9, 12, 10, 1, -12 },
  { 480, 9, 12, 10, 1, -12 },
  { 494, 10, 12, 10, 0, -12 },
  { 509, 10, 12, 10, 1, -12 },
  { 524, 8, 12, 10, 1, -12 },
  { 536, 10, 12, 10, 0, -12 },
  { 551, 9, 12, 10, 1, -12 },
  { 565, 9, 13, 10, 1, -13 },
  { 580, 9, 12, 10, 1, -12 },
  { 594, 9, 16, 10, 1, -13 },
  { 612, 9, 12, 10, 1, -12 },
  { 626, 9, 13, 10, 1, -13 },
  { 641, 9, 12, 10, 2, -12 },
  { 655, 9, 12, 10, 1, -12 },
  { 669, 9, 12, 10, 2, -12 },
  { 683, 10, 12, 10, 1, -12 },
  { 698, 11, 12, 10, 0, -12 },
  { 715, 9, 12, 10, 2, -12 },
  { 729, 9, 12, 10, 1, -12 },
  { 743, 7, 16, 10, 2, -14 },
  { 757, 5, 16, 10, 3, -14 },
  { 767, 7, 16, 10, 1, -14 },
  { 781, 8, 6, 10, 1, -12 },
  { 787, 8, 2, 10, 0, 0 },
  { 789, 4, 2, 10, 4, -13 },
  { 790, 9, 10, 10, 1, -10 },
  { 802, 8, 12, 10, 1, -12 },
  { 814, 8, 10, 10, 1, -10 },
  { 824, 9, 12, 10, 1, -12 },
  { 838, 8, 10, 10, 1, -10 },
  { 848, 12, 15, 10, -1, -12 },
  { 871, 9, 13, 10, 1, -10 },
  { 886, 8, 12, 10, 1, -12 },
  { 898, 8, 13, 10, 1, -13 },
  { 911, 9, 16, 10, 0, -13 },
  { 929, 9, 12, 10, 1, -12 },
  { 943, 7, 12, 10, 2, -12 },
  { 954, 10, 10, 10, 0, -10 },
  { 967, 8, 10, 10, 1, -10 },
  { 977, 8, 10, 10, 1, -10 },
  { 987, 9, 13, 10, 0, -10 },
  { 1002, 9, 13, 10, 1, -10 },
  { 1017, 9, 10, 10, 1, -10 },
  { 1029, 8, 10, 10, 1, -10 },
  { 1039, 9, 12, 10, 1, -12 },
  { 1053, 9, 9, 10, 1, -9 },
  { 1064, 8, 9, 10, 2, -9 },
  { 1073, 9, 9, 10, 1, -9 },
  { 1084, 10, 9, 10, 0, -9 },
  { 1096, 8, 12, 10, 1, -9 },
  { 1108, 8, 9, 10, 1, -9 },
  { 1117, 9, 16, 10, 1, -14 },
  { 1135, 5, 16, 10, 3, -14 },
  { 1145, 9, 16, 10, 0, -14 },
  { 1163, 9, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_MEDIUMITALIC17PT7B_H_
