#ifndef _JETBRAINSMONO_MEDIUMITALIC49PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0xBF, 0x0F, 0xDF,
  0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xF7, 0xE0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E,
  0xF8, 0x3F, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x81,
  0xF3, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xF3, 0x9F, 0xC1, 0xF8, 0xE3, 0xF0,
  0xFC, 0x38, 0xFC, 0x3F, 0x1E, 0x1F, 0x0F, 0x87, 0x08, 0x03, 0xE1, 0xC0,
  0x00, 0xFC, 0x70, 0x00, 0x3F, 0x1C, 0x00, 0x0F, 0xE7, 0x00, 0x03, 0xFD,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1C, 0xFE,
  0x00, 0x07, 0x1F, 0xC0, 0x01, 0xC3, 0xF0, 0x00, 0x70, 0xFC, 0x00, 0x1C,
  0x3F, 0x00, 0x07, 0x0F, 0xCF, 0xC3, 0xC3, 0xE3, 0xF0, 0xE0, 0xF8, 0xFC,
  0x38, 0x7E, 0x1F, 0x8E, 0x3F, 0x07, 0xFB, 0xBF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x1F, 0xF8, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x1E, 0x01, 0xFF,
  0xF0, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x07, 0xC0, 0x07, 0x81, 0xE1, 0xF0,
  0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x8F, 0x00, 0x03, 0xC1, 0xE3,
  0xC0, 0x00, 0x7C, 0x7C, 0xF0, 0x00, 0x0F, 0xFF, 0x3C, 0x00, 0x00, 0xFF,
  0xCF, 0x80, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0x03, 0xCF,
  0xFE, 0x00, 0x00, 0xF3, 0xF7, 0xE0, 0x00, 0x3C, 0x78, 0x3C, 0x00, 0x0F,
  0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0xF0, 0x00, 0xF8, 0x78, 0x1E, 0x00,
  0x3E, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x1E,
  0x00, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0xF9, 0xF8, 0x07, 0x80, 0x1F,
  0xFE, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x0F, 0x9F, 0x9F, 0x83, 0xF3, 0xE1, 0xF0, 0x7C, 0x7C, 0x3F,
  0x1F, 0x1F, 0x83, 0xE7, 0xC3, 0xE0, 0x7F, 0xF8, 0x7C, 0x07, 0xFE, 0x0F,
  0x80, 0xFF, 0x81, 0xF0, 0x0F, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xFF, 0x03, 0xF0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE7, 0xC0, 0xFF, 0xF0, 0xFC, 0x0F, 0xFC, 0x0F,
  0xC0, 0x7E, 0xFD, 0xF3, 0xE7, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF,
  0x1E, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xC0,
  0x78, 0x0E, 0x3E, 0x0F, 0x0F, 0xCF, 0xF1, 0xC7, 0xF9, 0xFF, 0x39, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x1F, 0x0F, 0xE7, 0xF9, 0xFF, 0x7F, 0x9F, 0xE7, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x8F, 0xF0, 0x7E, 0x01, 0xF8,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x78, 0x3E, 0x3E, 0x3E, 0x1F, 0x3E, 0x3F,
  0x1F, 0x9F, 0x1F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7, 0xC3, 0xC3, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7,
  0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1E, 0x07, 0xC0, 0x30, 0x0F, 0x80, 0x40, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x81, 0xFC,
  0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x7C,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x30, 0x00, 0xF9, 0xFF, 0x00, 0x7D, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xC0, 0x1F, 0x87,
  0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xF8, 0x3F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x03, 0xF3, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E,
  0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xE1, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x7C, 0x07, 0xF9,
  0xE1, 0xF0, 0x3F, 0xF7, 0x87, 0x81, 0xFF, 0xFE, 0x1E, 0x07, 0xC1, 0xF8,
  0x78, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x0F, 0x0F, 0x83, 0xC0, 0x3C, 0x3E,
  0x0F, 0x01, 0xF0, 0xF8, 0x3C, 0x07, 0xC3, 0xC1, 0xF0, 0x1F, 0x0F, 0x07,
  0xC0, 0x7C, 0x3C, 0x1F, 0x01, 0xE1, 0xF0, 0x7C, 0x07, 0x87, 0xC1, 0xE0,
  0x3E, 0x1F, 0x07, 0x80, 0xF8, 0x78, 0x1F, 0x03, 0xE1, 0xE0, 0x7E, 0x3F,
  0x87, 0x81, 0xFF, 0xFC, 0x3E, 0x03, 0xFE, 0xF0, 0xF8, 0x07, 0xF3, 0xC3,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xF0, 0x03,
  0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x0F, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xDF, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF8, 0x07, 0xE0,
  0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x1F, 0xE0,
  0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03,
  0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0,
  0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87,
  0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x7F, 0x01, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x0F,
  0xC7, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x07,
  0xFF, 0x8F, 0x87, 0xFF, 0x8F, 0xC3, 0xFF, 0xC7, 0xE1, 0xFF, 0xE3, 0xE0,
  0xFF, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x80,
  0x7E, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x0F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xF0, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7,
  0x03, 0xFE, 0x0F, 0xB8, 0x3D, 0xE0, 0x7D, 0xE1, 0xEF, 0x03, 0xCF, 0x1E,
  0x78, 0x1E, 0x78, 0xF7, 0xC0, 0xF3, 0xCF, 0x3E, 0x07, 0x9E, 0x79, 0xF0,
  0x7C, 0x73, 0x8F, 0x03, 0xE3, 0xBC, 0x78, 0x1F, 0x1F, 0xC7, 0xC0, 0xF8,
  0xFE, 0x3E, 0x07, 0xC7, 0xF1, 0xF0, 0x3E, 0x3F, 0x0F, 0x81, 0xE0, 0x00,
  0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x03, 0xE0,
  0xFE, 0x00, 0x7C, 0x1F, 0xE0, 0x0F, 0x83, 0xFC, 0x01, 0xE0, 0x7F, 0x80,
  0x7C, 0x0F, 0xF0, 0x0F, 0x83, 0xFE, 0x01, 0xF0, 0x7F, 0xE0, 0x3E, 0x0F,
  0xFC, 0x07, 0xC1, 0xF7, 0x80, 0xF0, 0x3E, 0xF0, 0x3E, 0x07, 0x9E, 0x07,
  0xC0, 0xF3, 0xC0, 0xF8, 0x3E, 0x7C, 0x1F, 0x07, 0xC7, 0x83, 0xE0, 0xF8,
  0xF0, 0x7C, 0x1F, 0x1E, 0x1F, 0x03, 0xE3, 0xC3, 0xE0, 0x7C, 0x7C, 0x7C,
  0x1F, 0x0F, 0x8F, 0x83, 0xE0, 0xF1, 0xF0, 0x7C, 0x1E, 0x3E, 0x0F, 0x83,
  0xC7, 0x81, 0xF0, 0x7D, 0xF0, 0x3E, 0x0F, 0xBE, 0x0F, 0x80, 0xF7, 0xC1,
  0xF0, 0x1E, 0xF8, 0x3E, 0x03, 0xDF, 0x07, 0xC0, 0x7F, 0xC0, 0xF8, 0x0F,
  0xF8, 0x1F, 0x00, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0xF8, 0x03, 0xFC, 0x1F,
  0x00, 0x7F, 0x83, 0xE0, 0x0F, 0xF0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xDF, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07,
  0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xFE,
  0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xFC, 0x1F,
  0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00,
  0x1F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x8F, 0x80, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0x80, 0x3F, 0x81, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xFC,
  0x1F, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0xFF,
  0x81, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xC3, 0xE0, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0xFB, 0xE0, 0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x3C, 0xF8,
  0x1F, 0x83, 0xE7, 0xC0, 0xFC, 0x1F, 0x3E, 0x0E, 0xE0, 0xF1, 0xF0, 0x7E,
  0x07, 0x8F, 0x83, 0xF0, 0x7C, 0x7C, 0x3F, 0x83, 0xE3, 0xE1, 0xDC, 0x1E,
  0x1F, 0x0E, 0xE0, 0xF0, 0xF0, 0x77, 0x0F, 0x87, 0x87, 0x38, 0x7C, 0x3C,
  0x39, 0xC3, 0xC1, 0xE1, 0xCE, 0x1E, 0x0F, 0x1E, 0x71, 0xF0, 0x78, 0xE3,
  0x8F, 0x83, 0xC7, 0x1C, 0x78, 0x1E, 0x38, 0xE3, 0xC0, 0xF3, 0xC7, 0x3E,
  0x07, 0x9C, 0x39, 0xE0, 0x7C, 0xE1, 0xCF, 0x03, 0xE7, 0x0E, 0x78, 0x1F,
  0x70, 0x77, 0xC0, 0xFB, 0x83, 0xBC, 0x07, 0xDC, 0x1D, 0xE0, 0x3D, 0xE1,
  0xEF, 0x01, 0xEE, 0x0E, 0xF8, 0x0F, 0x70, 0x77, 0x80, 0x7B, 0x83, 0xBC,
  0x03, 0xF8, 0x1D, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xE0,
  0x0F, 0x87, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x3E,
  0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x79, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0x83, 0xF0, 0x00, 0xFF, 0x1F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xDF,
  0x0F, 0xFF, 0xDF, 0x1F, 0xE1, 0xFF, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFF, 0x0E, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFD, 0xF8, 0x3F, 0xF9, 0xF0, 0x1F, 0xF1, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xFC, 0x03, 0xE7, 0xFF, 0x01, 0xF7,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x7E, 0xFF, 0xF8, 0x3E, 0x7F,
  0xF0, 0x1F, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFE, 0x01, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC7, 0xC0, 0x3F,
  0xF9, 0xF0, 0x1F, 0xFF, 0x7C, 0x0F, 0xFF, 0xDF, 0x07, 0xF8, 0x7F, 0xC1,
  0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xFC, 0x3B, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0x9F, 0x00, 0x7F, 0xC7, 0xC0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0x03,
  0xFF, 0x9F, 0x07, 0xFF, 0xDF, 0x0F, 0xFF, 0xDF, 0x1F, 0xE1, 0xFF, 0x1F,
  0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F,
  0xFE, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xFD, 0xF8, 0x0F, 0xF1, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC3, 0xFC, 0x03, 0xE7, 0xFF, 0x01, 0xF7, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x7C,
  0x1F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00,
  0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0x3F, 0x1F, 0x81, 0xEF, 0xE7, 0xF8, 0x3D, 0xFE, 0xFF, 0x0F, 0xEF, 0xFF,
  0xF1, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0xC1, 0xE0, 0xF8, 0xF8,
  0x3C, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0xC1, 0xE0, 0xF8, 0xF8, 0x3C, 0x1F,
  0x1F, 0x07, 0x83, 0xE3, 0xE0, 0xF0, 0x7C, 0x7C, 0x1E, 0x0F, 0x8F, 0x03,
  0xC1, 0xE1, 0xE0, 0xF0, 0x7C, 0x7C, 0x1E, 0x0F, 0x8F, 0x83, 0xC1, 0xF1,
  0xF0, 0x78, 0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0xC1, 0xE0, 0xF0, 0xF0, 0x78,
  0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0xC1, 0xE0, 0xF8, 0xF8, 0x3C, 0x1F, 0x1F,
  0x07, 0x83, 0xE3, 0xE0, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xF8, 0x07, 0xCF,
  0xFE, 0x03, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xF0, 0xFE,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFE,
  0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xC3, 0xFC, 0x01, 0xF3, 0xFF, 0x80,
  0x7D, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xF8, 0x07,
  0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7E,
  0xFF, 0xF8, 0x1F, 0x3F, 0xF8, 0x07, 0xC7, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x1F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xDF, 0x0F,
  0xFF, 0xDF, 0x1F, 0xE1, 0xFF, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFF, 0x0E, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFD, 0xF8, 0x3F, 0xF9, 0xF0, 0x1F, 0xF1, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x0F, 0x8F, 0xF8, 0x07, 0xCF, 0xFE, 0x03, 0xEF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE1, 0xF7, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07,
  0xC7, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1,
  0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x7F, 0xE0,
  0x7C, 0x0F, 0x7C, 0x1F, 0x81, 0xEF, 0x83, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F,
  0x3E, 0x1D, 0xC1, 0xE7, 0xC3, 0xB8, 0x3C, 0xF8, 0x77, 0x0F, 0x1F, 0x1C,
  0xE1, 0xE3, 0xE3, 0x9C, 0x3C, 0x7C, 0x73, 0x8F, 0x8F, 0x8E, 0x71, 0xE1,
  0xF3, 0x8E, 0x3C, 0x3E, 0x71, 0xCF, 0x87, 0xCE, 0x39, 0xE0, 0xFB, 0x87,
  0x3C, 0x1F, 0x70, 0xE7, 0x83, 0xCE, 0x1D, 0xE0, 0x7B, 0x83, 0xBC, 0x0F,
  0x70, 0x77, 0x81, 0xEE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0,
  0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7F, 0xDF, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xFC, 0xF8, 0x1F,
  0xF9, 0xF8, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xCF, 0xFE, 0x03, 0xE7, 0xFF, 0x81,
  0xF7, 0xFF, 0xC0, 0xF7, 0xC3, 0xF0, 0xFB, 0xE0, 0xFC, 0xFD, 0xF0, 0x3F,
  0xFC, 0xF8, 0x1F, 0xFE, 0x78, 0x07, 0xFE, 0x3C, 0x00, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 36, 29, 9, -36 },
  { 55, 17, 15, 29, 9, -36 },
  { 87, 29, 36, 29, 1, -36 },
  { 218, 26, 50, 29, 2, -43 },
  { 381, 35, 36, 29, -2, -36 },
  { 539, 27, 36, 29, 1, -36 },
  { 661, 7, 15, 29, 14, -36 },
  { 675, 21, 47, 29, 7, -41 },
  { 799, 21, 47, 29, 2, -41 },
  { 923, 27, 26, 29, 2, -30 },
  { 1011, 24, 23, 29, 3, -28 },
  { 1080, 14, 15, 29, 4, -7 },
  { 1107, 17, 5, 29, 7, -19 },
  { 1118, 10, 8, 29, 8, -8 },
  { 1128, 30, 46, 29, 0, -41 },
  { 1301, 25, 36, 29, 3, -36 },
  { 1414, 23, 36, 29, 2, -36 },
  { 1518, 26, 36, 29, 2, -36 },
  { 1635, 26, 36, 29, 2, -36 },
  { 1752, 24, 36, 29, 3, -36 },
  { 1860, 25, 36, 29, 3, -36 },
  { 1973, 25, 36, 29, 2, -36 },
  { 2086, 25, 36, 29, 5, -36 },
  { 2199, 26, 36, 29, 2, -36 },
  { 2316, 25, 36, 29, 4, -36 },
  { 2429, 13, 27, 29, 8, -27 },
  { 2473, 16, 35, 29, 5, -27 },
  { 2543, 24, 26, 29, 4, -29 },
  { 2621, 24, 17, 29, 3, -25 },
  { 2672, 24, 26, 29, 2, -29 },
  { 2750, 20, 36, 29, 7, -36 },
  { 2840, 30, 45, 29, 0, -36 },
  { 3009, 25, 36, 29, 0, -36 },
  { 3122, 26, 36, 29, 2, -36 },
  { 3239, 25, 36, 29, 3, -36 },
  { 3352, 26, 36, 29, 2, -36 },
  { 3469, 27, 36, 29, 2, -36 },
  { 3591, 27, 36, 29, 2, -36 },
  { 3713, 25, 36, 29, 3, -36 },
  { 3826, 27, 36, 29, 2, -36 },
  { 3948, 25, 36, 29, 3, -36 },
  { 4061, 27, 36, 29, 1, -36 },
  { 4183, 29, 36, 29, 2, -36 },
  { 4314, 22, 36, 29, 3, -36 },
  { 4413, 29, 36, 29, 1, -36 },
  { 4544, 27, 36, 29, 2, -36 },
  { 4666, 25, 36, 29, 3, -36 },
  { 4779, 28, 36, 29, 2, -36 },
  { 4905, 25, 45, 29, 3, -36 },
  { 5046, 27, 36, 29, 2, -36 },
  { 5168, 26, 36, 29, 2, -36 },
  { 5285, 25, 36, 29, 5, -36 },
  { 5398, 26, 36, 29, 3, -36 },
  { 5515, 25, 36, 29, 6, -36 },
  { 5628, 29, 36, 29, 3, -36 },
  { 5759, 31, 36, 29, 0, -36 },
  { 5899, 27, 36, 29, 5, -36 },
  { 6021, 26, 36, 29, 2, -36 },
  { 6138, 20, 46, 29, 7, -41 },
  { 6253, 15, 46, 29, 8, -41 },
  { 6340, 20, 46, 29, 4, -41 },
  { 6455, 22, 19, 29, 4, -36 },
  { 6508, 24, 5, 29, 0, 1 },
  { 6523, 10, 6, 29, 12, -38 },
  { 6531, 24, 27, 29, 3, -27 },
  { 6612, 25, 36, 29, 2, -36 },
  { 6725, 24, 27, 29, 3, -27 },
  { 6806, 26, 36, 29, 3, -36 },
  { 6923, 24, 27, 29, 3, -27 },
  { 7004, 34, 45, 29, -3, -36 },
  { 7196, 24, 36, 29, 3, -27 },
  { 7304, 25, 36, 29, 2, -36 },
  { 7417, 24, 38, 29, 2, -38 },
  { 7531, 25, 47, 29, 1, -38 },
  { 7678, 27, 36, 29, 2, -36 },
  { 7800, 21, 36, 29, 5, -36 },
  { 7895, 27, 27, 29, 1, -27 },
  { 7987, 25, 27, 29, 2, -27 },
  { 8072, 24, 27, 29, 3, -27 },
  { 8153, 26, 36, 29, 1, -27 },
  { 8270, 24, 36, 29, 3, -27 },
  { 8378, 25, 27, 29, 3, -27 },
  { 8463, 25, 27, 29, 2, -27 },
  { 8548, 24, 34, 29, 4, -34 },
  { 8650, 24, 27, 29, 3, -27 },
  { 8731, 24, 27, 29, 5, -27 },
  { 8812, 27, 27, 29, 3, -27 },
  { 8904, 29, 27, 29, 0, -27 },
  { 9002, 24, 36, 29, 3, -27 },
  { 9110, 25, 27, 29, 2, -27 },
  { 9195, 26, 46, 29, 4, -41 },
  { 9345, 13, 46, 29, 9, -41 },
  { 9420, 25, 46, 29, 1, -41 },
  { 9564, 25, 11, 29, 3, -23 },
};

const GFXfont JetBrainsMono_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_MEDIUMITALIC49PT7B_H_
