#ifndef _NOTOSANS_REGULAR58PT7B_H_
#define _NOTOSANS_REGULAR58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x70, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x70, 0x1E,
  0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x0E, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0x7F, 0xCF, 0xE1, 0xC0, 0xE3, 0xF0, 0x70, 0x00, 0xF8,
  0x1C, 0x00, 0x3E, 0x07, 0x00, 0x0F, 0x81, 0xC0, 0x03, 0xE0, 0x70, 0x00,
  0xF8, 0x1C, 0x00, 0x3F, 0x07, 0x00, 0x0F, 0xE1, 0xC0, 0x01, 0xFF, 0x70,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xDF, 0xF8,
  0x00, 0x70, 0xFE, 0x00, 0x1C, 0x0F, 0xC0, 0x07, 0x01, 0xF0, 0x01, 0xC0,
  0x7C, 0x00, 0x70, 0x1F, 0x00, 0x1C, 0x07, 0xC0, 0x07, 0x03, 0xF8, 0x01,
  0xC0, 0xFB, 0x80, 0x70, 0xFE, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x20, 0x03, 0xFE,
  0x00, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x03,
  0xE1, 0xE0, 0xFE, 0x0F, 0x80, 0xF0, 0xF8, 0xFF, 0xE1, 0xE0, 0x3C, 0x3C,
  0x3F, 0xFC, 0x78, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x07, 0x87, 0x8F, 0x83,
  0xE3, 0xFF, 0xE3, 0xE3, 0xC0, 0x78, 0x7F, 0xF0, 0xF0, 0xF0, 0x1F, 0x0F,
  0xF8, 0x7C, 0x3C, 0x03, 0xC1, 0xF8, 0x1E, 0x1F, 0x00, 0xF0, 0x00, 0x0F,
  0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x3C,
  0x00, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0x01, 0xF1, 0xF8, 0x01, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0x03, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0xE3, 0xF8, 0x00, 0xF8,
  0x3F, 0x83, 0xF8, 0x01, 0xF0, 0xFE, 0x03, 0xF8, 0x07, 0xE1, 0xF8, 0x03,
  0xF8, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C,
  0x1F, 0x80, 0x01, 0xFD, 0xF8, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x7C, 0x00,
  0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xF0,
  0x00, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x03,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDC, 0xE7, 0x39, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xF0, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x60, 0x0F, 0x00, 0x6F, 0xC1, 0xE0, 0xFD, 0xFF, 0x3D, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xC0, 0x38, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C,
  0x3E, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xDF, 0x3F, 0x9F, 0x7F, 0x1F,
  0xFE, 0x1F, 0x7C, 0x1F, 0x30, 0x1F, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFC,
  0x00, 0xFE, 0x0F, 0x00, 0x07, 0xE1, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFC, 0x00, 0x7E,
  0x1E, 0x00, 0x07, 0xE1, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xEC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x18, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE8, 0x00, 0x03, 0xF3, 0x00, 0x01, 0xFC, 0xF8, 0x01,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF0, 0x10, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x0F, 0xE0, 0x0F, 0x8F, 0xFF, 0x83, 0xE3, 0xFF, 0xF8, 0x7C, 0xFF,
  0xFF, 0x8F, 0xBE, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xF7,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x7E,
  0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xF8,
  0x3F, 0x80, 0x7F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3E, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x0F,
  0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x00,
  0xFE, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x07,
  0xF7, 0xE0, 0x01, 0xFE, 0x7E, 0x00, 0xFF, 0xCF, 0xFF, 0xFE, 0xF8, 0xFF,
  0xFF, 0x9F, 0x07, 0xFF, 0xE3, 0xE0, 0x7F, 0xF0, 0x7C, 0x00, 0x60, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x38,
  0x0E, 0x0F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C,
  0x7E, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0x8F,
  0x00, 0x3F, 0x90, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x3C, 0x1F, 0x00,
  0x3F, 0xFF, 0x80, 0xF8, 0x78, 0x03, 0xFF, 0xFE, 0x01, 0xE3, 0xC0, 0x1F,
  0xFF, 0xF8, 0x07, 0x8F, 0x00, 0xFC, 0x01, 0xE0, 0x1E, 0x7C, 0x03, 0xE0,
  0x07, 0x80, 0x79, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF7, 0x80, 0x7C, 0x00,
  0xF8, 0x03, 0xDE, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x78, 0x0F, 0x80, 0x0F,
  0x80, 0x3F, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0xF8,
  0x03, 0xFE, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x00, 0x0F, 0x80,
  0x7B, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xEF, 0x80, 0xF8, 0x00, 0xF8, 0x07,
  0xBE, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x78, 0x07, 0x80, 0x1F, 0x80, 0xF1,
  0xE0, 0x1F, 0x00, 0xFE, 0x07, 0xC7, 0x80, 0x7E, 0x07, 0xBC, 0x3E, 0x1E,
  0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xE1, 0xFF, 0x80, 0xF0,
  0x03, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xFC, 0x7C,
  0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xE0, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x3F, 0xCF, 0x80, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0x03, 0xFC, 0x00,
  0x02, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x40, 0xFF, 0xC0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xD0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0x0F, 0xFE, 0x07, 0xC0, 0x00, 0xFF, 0x83, 0xE0, 0x00,
  0x1F, 0xE1, 0xF0, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01,
  0xFC, 0x7C, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x07,
  0xFC, 0x0F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x7F, 0x00, 0x00,
  0x30, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0x7C,
  0x7F, 0x80, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x07, 0xC1, 0xFF, 0x80, 0x07,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0x80, 0xF8, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00,
  0x7E, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC,
  0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xF3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03,
  0xE0, 0x3F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x03, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01,
  0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFC,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xBE, 0x00, 0x00, 0x0F, 0xFF, 0xDF, 0x00, 0x00, 0x07, 0xBF, 0xEF, 0x80,
  0x00, 0x07, 0xDF, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xF9, 0xF0, 0x00, 0x01,
  0xE7, 0xFC, 0xF8, 0x00, 0x01, 0xF3, 0xFE, 0x3E, 0x00, 0x00, 0xF1, 0xFF,
  0x1F, 0x00, 0x00, 0xF8, 0xFF, 0x87, 0xC0, 0x00, 0x7C, 0x7F, 0xC3, 0xE0,
  0x00, 0x3C, 0x3F, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0xF0, 0x7C, 0x00, 0x1F,
  0x0F, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xFC, 0x1F, 0x00, 0x0F, 0x83, 0xFE,
  0x07, 0xC0, 0x07, 0x81, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0x80, 0xF8,
  0x03, 0xE0, 0x7F, 0xC0, 0x7C, 0x01, 0xE0, 0x3F, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xFC,
  0x03, 0xE0, 0x7C, 0x03, 0xFE, 0x00, 0xF8, 0x3C, 0x01, 0xFF, 0x00, 0x7C,
  0x3E, 0x00, 0xFF, 0x80, 0x1F, 0x1F, 0x00, 0x7F, 0xC0, 0x0F, 0x9F, 0x00,
  0x3F, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xE0, 0x00,
  0x0F, 0xF7, 0xE0, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x0F, 0xF1, 0xF8, 0x00,
  0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0x7E, 0x00,
  0x0F, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0x80,
  0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x03, 0xF0,
  0x0F, 0xF0, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0xFC,
  0x0F, 0xF0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x3F,
  0x0F, 0xF0, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x0F,
  0xCF, 0xF0, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0x3E, 0x00, 0x1F, 0xEF, 0x80, 0x01,
  0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xEF, 0x80, 0x03, 0xF3, 0xE0, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x0F, 0x80, 0x1F, 0xF0, 0x7C, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x03,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x03, 0xC7,
  0xE0, 0x00, 0x11, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x0B, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x9F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x7D,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x78, 0x03, 0xF8, 0x30,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xF0, 0x07,
  0xDF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xFE, 0xF9, 0xFF,
  0xFE, 0x3C, 0x7F, 0xFE, 0x1E, 0x1F, 0xFC, 0x0F, 0x00, 0x60, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x30, 0x01, 0xF0, 0xFF, 0xE0, 0x3E,
  0x3F, 0xFF, 0x07, 0xDF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x07,
  0xF3, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7D, 0xFC, 0x00, 0x1F, 0xBF, 0xC0, 0x07, 0xE7,
  0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0x1E, 0x7F, 0xFF, 0xC3, 0xC3, 0xFF,
  0xF0, 0x78, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC,
  0x03, 0x87, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x08, 0xFF, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0A, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x1F, 0xFE, 0x1F, 0x03, 0xFF, 0xF1, 0xF0,
  0x7F, 0xFF, 0x9F, 0x0F, 0xFF, 0xFD, 0xF1, 0xFC, 0x03, 0xFF, 0x3F, 0x80,
  0x0F, 0xF3, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF1,
  0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0x9F, 0x03, 0xFF,
  0xF1, 0xF0, 0x0F, 0xFC, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x02, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0x81, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0xFE, 0x0F, 0x03, 0xFF, 0xF1, 0xF0, 0x7F, 0xFF, 0x9F, 0x0F,
  0xFF, 0xFD, 0xF1, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xF0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x03, 0xFF, 0x0F,
  0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0x9F, 0x03, 0xFF, 0xF1, 0xF0, 0x0F, 0xFC,
  0x1F, 0x00, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE2, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x1F, 0xC1, 0xFE, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x3E, 0x1F, 0xFE, 0x0F,
  0x8F, 0xFF, 0xE3, 0xEF, 0xFF, 0xFC, 0xFB, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F,
  0xEF, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0x73, 0xEF, 0xBF, 0xFB, 0xE7, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x00, 0x70,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0xC7, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0,
  0x7F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xFB, 0xE0, 0x01,
  0xF9, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE0,
  0xFC, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03,
  0xF9, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x3F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x3C,
  0x7F, 0xFF, 0x07, 0xFF, 0xE1, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xBF,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFB, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x3C, 0x1F, 0xFE, 0x0F, 0x0F, 0xFF, 0xE3, 0xEF, 0xFF,
  0xFC, 0xFB, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xEF, 0xF0, 0x01, 0xFB, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1E,
  0x0F, 0xFE, 0x03, 0xC3, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0x0F, 0xBF, 0xFF,
  0xF1, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB,
  0xFC, 0x00, 0x7E, 0x7F, 0xE0, 0x1F, 0xCF, 0xFF, 0xFF, 0xF1, 0xF7, 0xFF,
  0xFC, 0x3E, 0x3F, 0xFF, 0x07, 0xC3, 0xFF, 0x80, 0xF8, 0x02, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xFE, 0x0F, 0x03, 0xFF, 0xF1, 0xF0, 0x7F, 0xFF, 0x9F, 0x0F, 0xFF,
  0xFD, 0xF1, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x03, 0xFF, 0x0F, 0xFF,
  0xFD, 0xF0, 0x7F, 0xFF, 0x9F, 0x03, 0xFF, 0xF1, 0xF0, 0x0F, 0xFC, 0x1F,
  0x00, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xBC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFE, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xF8, 0x01, 0xCF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x01, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x0F, 0xFD, 0xFF, 0xFF, 0xDF,
  0x3F, 0xFF, 0xE7, 0xC7, 0xFF, 0xF1, 0xF0, 0x7F, 0xF8, 0x3C, 0x00, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE7, 0xC0,
  0x03, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xC0, 0x03, 0xE7, 0xC0, 0x07,
  0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7B, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xBE,
  0x00, 0x7C, 0x3E, 0x00, 0xF9, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x9F, 0x00,
  0xF8, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0x1F, 0x01, 0xF0, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x0F, 0x83,
  0xE0, 0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0,
  0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x3E,
  0x7C, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x1E, 0x7C,
  0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x83, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xA0, 0x00, 0x7F, 0xC0,
};

const GFXglyph NotoSans_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 42, 16, 4, -41 },
  { 38, 16, 15, 24, 4, -41 },
  { 68, 35, 41, 37, 1, -41 },
  { 248, 26, 47, 33, 4, -44 },
  { 401, 42, 43, 48, 3, -42 },
  { 627, 39, 43, 42, 3, -42 },
  { 837, 5, 15, 13, 4, -41 },
  { 847, 14, 50, 17, 2, -41 },
  { 935, 13, 50, 17, 2, -41 },
  { 1017, 27, 26, 32, 2, -44 },
  { 1105, 27, 29, 33, 3, -35 },
  { 1203, 9, 14, 16, 2, -7 },
  { 1219, 14, 5, 19, 2, -18 },
  { 1228, 7, 8, 16, 4, -7 },
  { 1235, 20, 41, 22, 1, -41 },
  { 1338, 27, 43, 33, 3, -42 },
  { 1484, 16, 41, 33, 5, -41 },
  { 1566, 27, 42, 33, 3, -42 },
  { 1708, 27, 43, 33, 3, -42 },
  { 1854, 31, 42, 33, 1, -42 },
  { 2017, 26, 42, 33, 4, -41 },
  { 2154, 27, 43, 33, 3, -42 },
  { 2300, 27, 41, 33, 3, -41 },
  { 2439, 27, 43, 33, 3, -42 },
  { 2585, 27, 43, 33, 3, -42 },
  { 2731, 7, 33, 16, 4, -32 },
  { 2760, 9, 39, 16, 2, -32 },
  { 2804, 27, 28, 33, 3, -35 },
  { 2899, 27, 15, 33, 3, -28 },
  { 2950, 27, 28, 33, 3, -35 },
  { 3045, 23, 43, 25, 1, -42 },
  { 3169, 46, 46, 52, 3, -41 },
  { 3434, 37, 42, 37, 0, -42 },
  { 3629, 29, 41, 38, 6, -41 },
  { 3778, 31, 43, 37, 4, -42 },
  { 3945, 33, 41, 42, 6, -41 },
  { 4115, 23, 41, 32, 6, -41 },
  { 4233, 23, 41, 30, 6, -41 },
  { 4351, 34, 43, 42, 4, -42 },
  { 4534, 31, 41, 43, 6, -41 },
  { 4693, 15, 41, 20, 2, -41 },
  { 4770, 16, 52, 16, -5, -41 },
  { 4874, 30, 41, 36, 6, -41 },
  { 5028, 23, 41, 30, 6, -41 },
  { 5146, 41, 41, 53, 6, -41 },
  { 5357, 32, 41, 44, 6, -41 },
  { 5521, 38, 43, 45, 4, -42 },
  { 5726, 26, 41, 35, 6, -41 },
  { 5860, 38, 52, 45, 4, -42 },
  { 6107, 29, 41, 36, 6, -41 },
  { 6256, 26, 43, 32, 3, -42 },
  { 6396, 31, 41, 32, 1, -41 },
  { 6555, 32, 42, 42, 5, -41 },
  { 6723, 35, 41, 35, 0, -41 },
  { 6903, 52, 41, 54, 1, -41 },
  { 7170, 34, 41, 34, 0, -41 },
  { 7345, 33, 41, 33, 0, -41 },
  { 7515, 29, 41, 33, 2, -41 },
  { 7664, 13, 50, 19, 5, -41 },
  { 7746, 20, 41, 22, 1, -41 },
  { 7849, 13, 50, 19, 1, -41 },
  { 7931, 29, 27, 33, 2, -42 },
  { 8029, 26, 4, 26, 0, 5 },
  { 8042, 12, 9, 16, 2, -44 },
  { 8056, 25, 33, 33, 3, -32 },
  { 8160, 27, 45, 36, 5, -44 },
  { 8312, 23, 33, 28, 3, -32 },
  { 8407, 28, 45, 36, 3, -44 },
  { 8565, 27, 33, 33, 3, -32 },
  { 8677, 21, 44, 20, 1, -44 },
  { 8793, 28, 46, 36, 3, -32 },
  { 8954, 26, 44, 36, 5, -44 },
  { 9097, 6, 43, 15, 5, -43 },
  { 9130, 14, 57, 15, -3, -43 },
  { 9230, 25, 44, 31, 5, -44 },
  { 9368, 5, 44, 15, 5, -44 },
  { 9396, 45, 32, 54, 5, -32 },
  { 9576, 26, 32, 36, 5, -32 },
  { 9680, 29, 33, 35, 3, -32 },
  { 9800, 27, 46, 36, 5, -32 },
  { 9956, 28, 46, 36, 3, -32 },
  { 10117, 18, 32, 24, 5, -32 },
  { 10189, 22, 33, 28, 3, -32 },
  { 10280, 19, 39, 21, 1, -38 },
  { 10373, 26, 32, 36, 5, -31 },
  { 10477, 29, 31, 29, 0, -31 },
  { 10590, 44, 31, 46, 1, -31 },
  { 10761, 29, 31, 31, 1, -31 },
  { 10874, 30, 45, 30, 0, -31 },
  { 11043, 23, 31, 27, 2, -31 },
  { 11133, 18, 50, 22, 2, -41 },
  { 11246, 4, 58, 32, 14, -44 },
  { 11275, 18, 50, 22, 2, -41 },
  { 11388, 27, 7, 33, 3, -24 },
};

const GFXfont NotoSans_Regular58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular58pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_REGULAR58PT7B_H_
