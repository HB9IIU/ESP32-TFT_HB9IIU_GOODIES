#ifndef _NOTOSANS_REGULAR56PT7B_H_
#define _NOTOSANS_REGULAR56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x71, 0xF7, 0xFF, 0xFF, 0xFF, 0xBE,
  0x38, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3B, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xCE, 0x03, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C,
  0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xF1, 0xE0, 0xF1, 0xF0, 0x78, 0x04, 0x7C, 0x1E, 0x00,
  0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0xF1, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xE7, 0xF8, 0x00, 0x78,
  0x7E, 0x00, 0x1E, 0x0F, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x7C, 0x00,
  0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x83, 0xEE, 0x01, 0xE1, 0xFB,
  0xF8, 0x7B, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFE,
  0x00, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x3E,
  0x00, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x1F, 0x00, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0x07, 0x80, 0x80, 0x78, 0x07, 0x87, 0x87, 0xF8, 0x3C, 0x03, 0xC7, 0xC7,
  0xFF, 0x0F, 0x03, 0xC3, 0xC7, 0xFF, 0x87, 0x81, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE1, 0xF1, 0xE3, 0xE0, 0xF8, 0xFF, 0xF1, 0xF1, 0xE0, 0x3C, 0x3F, 0xF0,
  0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF8, 0x78, 0x0F, 0x00, 0x80, 0x78, 0x78,
  0x07, 0xC0, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xC0,
  0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x3F,
  0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x81, 0xFE, 0xFE, 0x00,
  0x3E, 0x0F, 0xE1, 0xFC, 0x00, 0xF8, 0x3F, 0x03, 0xF8, 0x07, 0xC1, 0xF8,
  0x07, 0xF0, 0x1F, 0x07, 0xC0, 0x0F, 0xE0, 0x7C, 0x3F, 0x00, 0x1F, 0xC3,
  0xE0, 0xF8, 0x00, 0x3F, 0x8F, 0x83, 0xE0, 0x00, 0x7F, 0x7C, 0x0F, 0x80,
  0x00, 0xFF, 0xF0, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x03, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xDF, 0x80, 0xFF, 0xFF, 0xFE, 0x3F,
  0x01, 0xFF, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDE, 0xF7, 0xBC, 0xE7, 0x38, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x40,
  0x1E, 0x00, 0xDF, 0x03, 0x81, 0xF7, 0xF8, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0xC7, 0xC0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xE0,
  0x1F, 0x01, 0xF0, 0x01, 0x80, 0x70, 0x00, 0x20, 0x08, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x3E, 0x1F, 0x0F, 0x07, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF,
  0xEF, 0xBF, 0x9F, 0xFE, 0x3E, 0xF0, 0x7C, 0xC0, 0xF9, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xC0,
  0x03, 0xF0, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x3F,
  0x87, 0x80, 0x03, 0xF0, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFA, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xA0, 0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xDE, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x1F, 0xE0, 0x3E, 0x1F, 0xFE, 0x0F,
  0x9F, 0xFF, 0xC3, 0xEF, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0x3F, 0xC0, 0x07,
  0xEF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0xC0,
  0x3F, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xF7,
  0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xC0,
  0x7E, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x8F, 0xFC, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xCF, 0xE0,
  0x3F, 0xF1, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0x9F, 0x07, 0xFF, 0xC7, 0xC0,
  0x7F, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xBF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x0E,
  0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C,
  0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xE0,
  0x0F, 0xE6, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x01, 0xFF, 0x80, 0x3E, 0x1E,
  0x00, 0x7F, 0xFF, 0x01, 0xE3, 0xE0, 0x0F, 0xFF, 0xF0, 0x1E, 0x3C, 0x01,
  0xFE, 0x7F, 0x01, 0xE3, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x78, 0x07, 0xC0,
  0x1F, 0x00, 0xF7, 0x80, 0x78, 0x01, 0xF0, 0x0F, 0x78, 0x0F, 0x80, 0x1F,
  0x00, 0xF7, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0x1E, 0x00,
  0xFF, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0x1E, 0x00, 0xFF,
  0x01, 0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0x1E, 0x00, 0xFF, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xEF, 0x00, 0xF0,
  0x03, 0xE0, 0x1E, 0x78, 0x0F, 0x80, 0x7F, 0x03, 0xC7, 0x80, 0x7C, 0x0F,
  0x70, 0x7C, 0x78, 0x07, 0xFF, 0xE7, 0xFF, 0x87, 0x80, 0x3F, 0xFC, 0x3F,
  0xF0, 0x7C, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xCF, 0x80, 0x01, 0xFC, 0xF8, 0x00,
  0x0F, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x01, 0xFE, 0x00, 0x06,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x68, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x03, 0xFF, 0xE0,
  0xF8, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFC,
  0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x1F, 0xE0,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xC0,
  0x7F, 0x80, 0x00, 0x60, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x01, 0xF0, 0xFE,
  0x00, 0x00, 0x7C, 0x1F, 0xE0, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF,
  0xE3, 0xFE, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x0F, 0x9F, 0xC0, 0x00, 0x3E, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFE, 0xFC, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xEF,
  0xFF, 0xC0, 0x00, 0x03, 0xEF, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0xFB, 0xE0,
  0x00, 0x03, 0xCF, 0xF9, 0xE0, 0x00, 0x07, 0xDF, 0xF9, 0xF0, 0x00, 0x07,
  0x9F, 0xF9, 0xF0, 0x00, 0x07, 0x9F, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0xF8,
  0xF8, 0x00, 0x0F, 0x1F, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0xF8, 0x7C, 0x00,
  0x1F, 0x1F, 0xF8, 0x7C, 0x00, 0x1E, 0x1F, 0xF8, 0x3C, 0x00, 0x3E, 0x1F,
  0xF8, 0x3E, 0x00, 0x3C, 0x1F, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0xF8, 0x1F,
  0x00, 0x7C, 0x1F, 0xF8, 0x1F, 0x00, 0x78, 0x1F, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0xF8,
  0x07, 0x81, 0xF0, 0x1F, 0xF8, 0x07, 0xC1, 0xE0, 0x1F, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xF8, 0x03, 0xE3, 0xC0, 0x1F,
  0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01,
  0xF7, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xF0,
  0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x1F, 0xF8, 0xFC,
  0x00, 0x1F, 0xF8, 0x7C, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x1F, 0xF8, 0x3F,
  0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0xF8, 0x0F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x03,
  0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x1F, 0xF8, 0x00,
  0xF8, 0x1F, 0xF8, 0x00, 0xFC, 0x1F, 0xF8, 0x00, 0x7E, 0x1F, 0xF8, 0x00,
  0x3E, 0x1F, 0xF8, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x1F, 0x8F, 0xF8, 0x00,
  0x1F, 0x8F, 0xF8, 0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x07, 0xEF, 0xF8, 0x00,
  0x07, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x0F,
  0xFF, 0x3E, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF3, 0xE0,
  0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x7F, 0xF0, 0x7C, 0x00, 0x3F,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFC, 0x01, 0xF1, 0xF8,
  0x00, 0x18, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xD8, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xE7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xCF, 0x00, 0x07, 0xC3, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xE0, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1E,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xCF, 0x80, 0x01, 0xF3,
  0xE0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xF7, 0xFE, 0x0E,
  0x00, 0x7E, 0x08, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFE, 0x1F, 0x7F,
  0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xDF, 0xEF, 0x7F, 0xFF, 0xCF, 0x3F,
  0xFF, 0x0F, 0x0F, 0xFE, 0x0F, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x06, 0x00, 0x3E, 0x1F, 0xF8, 0x0F, 0x9F, 0xFF, 0x83, 0xEF, 0xFF, 0xF0,
  0xF7, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF,
  0xF8, 0x07, 0xF3, 0xDF, 0xFF, 0xF8, 0xF3, 0xFF, 0xFC, 0x3C, 0x7F, 0xFE,
  0x0E, 0x07, 0xFE, 0x00, 0x00, 0x14, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x00, 0xE3,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x3E, 0x03, 0xFF, 0x87, 0xC0, 0xFF,
  0xF8, 0xF8, 0x7F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFB, 0xE3, 0xF0, 0x07, 0xFC,
  0xFC, 0x00, 0x7F, 0x9F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xF8, 0x00,
  0x0F, 0xDF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xC7, 0xE0, 0x0F, 0xF8, 0xFF,
  0xFF, 0xDF, 0x0F, 0xFF, 0xFB, 0xE0, 0xFF, 0xFC, 0x7C, 0x07, 0xFF, 0x07,
  0x80, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x21, 0xFC, 0x00, 0x70, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0x87, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF8, 0x3C,
  0x0F, 0xFF, 0x8F, 0x87, 0xFF, 0xFD, 0xF1, 0xFF, 0xFF, 0xBE, 0x3F, 0x00,
  0x7F, 0xCF, 0xC0, 0x07, 0xF9, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0x7E, 0x00, 0xFF,
  0x8F, 0xFD, 0xFD, 0xF0, 0xFF, 0xFF, 0xBE, 0x0F, 0xFF, 0xC7, 0xC0, 0x7F,
  0xF0, 0xF8, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x88, 0x00, 0x07, 0xE1, 0xE0, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x20, 0x07, 0xC3, 0xFF, 0x83, 0xE7, 0xFF, 0xF1, 0xF7, 0xFF, 0xFC,
  0xF7, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xBF, 0x80, 0x07, 0xDF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xE0, 0x79, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x00, 0xF0, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7F, 0xC0,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00,
  0xF9, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0xF7, 0xF0, 0x00, 0xF7, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x1E, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xC7,
  0xFF, 0xE0, 0xFF, 0xFC, 0x79, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x1F, 0xF0,
  0x01, 0xF7, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x06, 0x00, 0x78, 0x3F, 0xF8, 0x3C, 0x7F, 0xFF, 0x1E, 0x7F, 0xFF, 0xCF,
  0x7F, 0xFF, 0xF7, 0xFC, 0x03, 0xFB, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x1F, 0xF8, 0x0F, 0x1F,
  0xFF, 0x83, 0xCF, 0xFF, 0xF0, 0xF7, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xCF,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xF8, 0x07, 0xF3, 0xDF, 0xFF, 0xF8, 0xF3,
  0xFF, 0xFC, 0x3E, 0x7F, 0xFE, 0x0F, 0x87, 0xFE, 0x03, 0xE0, 0x10, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF8, 0x3C, 0x0F, 0xFF,
  0x8F, 0x87, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0xBE, 0x3F, 0x00, 0x7F, 0xCF,
  0xC0, 0x07, 0xF9, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0x80, 0x00,
  0xFD, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0x7E, 0x00, 0xFF, 0x8F, 0xFF,
  0xFD, 0xF0, 0xFF, 0xFF, 0x3E, 0x0F, 0xFF, 0xC7, 0xC0, 0x7F, 0xF0, 0xF8,
  0x00, 0x40, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x78, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xBE, 0x03, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFD, 0xFF, 0x7E, 0x00, 0x33, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xFE, 0x7F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x07, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x3F, 0xDF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0x0F,
  0xFF, 0xE3, 0xC0, 0xFF, 0xE0, 0xF0, 0x05, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xFE, 0x00, 0x3E, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0xF8, 0x03, 0xCF, 0x00, 0x7C,
  0x3E, 0x00, 0xF3, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0xF8, 0x07, 0xC1, 0xE0,
  0x1F, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0x87, 0x80, 0xF8, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x03,
  0xE1, 0xE0, 0x3E, 0x1F, 0x00, 0x7C, 0x78, 0x07, 0x8F, 0x80, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x5F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xC8, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 41, 15, 4, -40 },
  { 37, 15, 14, 23, 4, -40 },
  { 64, 34, 40, 36, 1, -40 },
  { 234, 26, 46, 32, 3, -43 },
  { 384, 41, 42, 47, 3, -41 },
  { 600, 38, 42, 41, 3, -41 },
  { 800, 5, 14, 13, 4, -40 },
  { 809, 13, 49, 17, 2, -40 },
  { 889, 13, 49, 17, 2, -40 },
  { 969, 26, 26, 31, 2, -43 },
  { 1054, 26, 27, 32, 3, -33 },
  { 1142, 9, 14, 15, 2, -7 },
  { 1158, 14, 4, 18, 2, -17 },
  { 1165, 7, 8, 15, 4, -7 },
  { 1172, 19, 40, 21, 1, -40 },
  { 1267, 26, 42, 32, 3, -41 },
  { 1404, 15, 40, 32, 5, -40 },
  { 1479, 26, 41, 32, 3, -41 },
  { 1613, 26, 42, 32, 3, -41 },
  { 1750, 30, 40, 32, 1, -40 },
  { 1900, 25, 41, 32, 4, -40 },
  { 2029, 26, 42, 32, 3, -41 },
  { 2166, 27, 40, 32, 2, -40 },
  { 2301, 26, 42, 32, 3, -41 },
  { 2438, 26, 42, 32, 3, -41 },
  { 2575, 7, 32, 15, 4, -31 },
  { 2603, 9, 38, 15, 2, -31 },
  { 2646, 26, 28, 32, 3, -34 },
  { 2737, 26, 15, 32, 3, -27 },
  { 2786, 26, 28, 32, 3, -34 },
  { 2877, 22, 42, 24, 1, -41 },
  { 2993, 44, 45, 50, 3, -40 },
  { 3241, 36, 40, 36, 0, -40 },
  { 3421, 28, 40, 36, 5, -40 },
  { 3561, 31, 42, 35, 3, -41 },
  { 3724, 32, 40, 41, 5, -40 },
  { 3884, 23, 40, 31, 5, -40 },
  { 3999, 23, 40, 29, 5, -40 },
  { 4114, 34, 42, 41, 3, -41 },
  { 4293, 31, 40, 42, 5, -40 },
  { 4448, 15, 40, 19, 2, -40 },
  { 4523, 14, 51, 15, -4, -40 },
  { 4613, 30, 40, 35, 5, -40 },
  { 4763, 23, 40, 29, 5, -40 },
  { 4878, 40, 40, 51, 5, -40 },
  { 5078, 32, 40, 43, 5, -40 },
  { 5238, 37, 42, 44, 3, -41 },
  { 5433, 26, 40, 34, 5, -40 },
  { 5563, 37, 51, 44, 3, -41 },
  { 5799, 29, 40, 35, 5, -40 },
  { 5944, 25, 42, 31, 3, -41 },
  { 6076, 30, 40, 31, 1, -40 },
  { 6226, 31, 41, 41, 5, -40 },
  { 6385, 34, 40, 34, 0, -40 },
  { 6555, 50, 40, 52, 1, -40 },
  { 6805, 33, 40, 33, 0, -40 },
  { 6970, 32, 40, 32, 0, -40 },
  { 7130, 28, 40, 32, 2, -40 },
  { 7270, 13, 49, 18, 4, -40 },
  { 7350, 19, 40, 21, 1, -40 },
  { 7445, 13, 49, 18, 1, -40 },
  { 7525, 28, 25, 32, 2, -40 },
  { 7613, 25, 4, 25, 0, 5 },
  { 7626, 12, 9, 16, 2, -43 },
  { 7640, 24, 32, 31, 3, -31 },
  { 7736, 26, 44, 34, 5, -43 },
  { 7879, 22, 32, 27, 3, -31 },
  { 7967, 27, 44, 34, 3, -43 },
  { 8116, 26, 32, 32, 3, -31 },
  { 8220, 21, 43, 19, 1, -43 },
  { 8333, 27, 44, 34, 3, -31 },
  { 8482, 25, 43, 35, 5, -43 },
  { 8617, 6, 41, 14, 4, -41 },
  { 8648, 13, 54, 14, -3, -41 },
  { 8736, 24, 43, 30, 5, -43 },
  { 8865, 5, 43, 14, 5, -43 },
  { 8892, 43, 31, 52, 5, -31 },
  { 9059, 25, 31, 35, 5, -31 },
  { 9156, 28, 32, 34, 3, -31 },
  { 9268, 26, 44, 34, 5, -31 },
  { 9411, 27, 44, 34, 3, -31 },
  { 9560, 17, 31, 23, 5, -31 },
  { 9626, 21, 32, 27, 3, -31 },
  { 9710, 18, 38, 20, 1, -37 },
  { 9796, 26, 31, 35, 4, -30 },
  { 9897, 28, 30, 28, 0, -30 },
  { 10002, 42, 30, 44, 1, -30 },
  { 10160, 28, 30, 30, 1, -30 },
  { 10265, 29, 43, 29, 0, -30 },
  { 10421, 22, 30, 26, 2, -30 },
  { 10504, 17, 49, 21, 2, -40 },
  { 10609, 4, 57, 31, 13, -43 },
  { 10638, 18, 49, 21, 2, -40 },
  { 10749, 26, 7, 32, 3, -23 },
};

const GFXfont NotoSans_Regular56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular56pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_REGULAR56PT7B_H_
