#ifndef _NOTOSANS_REGULAR18PT7B_H_
#define _NOTOSANS_REGULAR18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xC9, 0x24, 0x92, 0x40, 0x6E, 0xDE, 0x73, 0x94, 0x80, 0x0C, 0xC1,
  0x90, 0x22, 0x04, 0x47, 0xFE, 0x33, 0x06, 0x40, 0x88, 0xFF, 0xE2, 0x20,
  0xCC, 0x19, 0x02, 0x20, 0x08, 0x08, 0x7F, 0xEB, 0xC8, 0xC8, 0x78, 0x3C,
  0x0F, 0x09, 0x09, 0xCF, 0xFE, 0x08, 0x08, 0x70, 0x66, 0xC2, 0x22, 0x21,
  0x13, 0x08, 0x90, 0x45, 0xBB, 0x6B, 0x6E, 0xD1, 0x04, 0x88, 0x64, 0x42,
  0x22, 0x21, 0x33, 0x07, 0x00, 0x3E, 0x06, 0x60, 0x63, 0x06, 0x20, 0x26,
  0x03, 0xC0, 0x38, 0x06, 0xC6, 0xC7, 0x6C, 0x3C, 0xC1, 0xCE, 0x3E, 0x7E,
  0x70, 0xFF, 0x40, 0x36, 0x4C, 0xCC, 0x88, 0x88, 0xCC, 0xC4, 0x63, 0x8C,
  0x66, 0x22, 0x33, 0x33, 0x22, 0x66, 0xC8, 0x18, 0x18, 0x18, 0xD7, 0xFF,
  0x38, 0x2C, 0x66, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x7E, 0xFF, 0xDC, 0x06, 0x18, 0x30, 0x41, 0x83, 0x04, 0x18, 0x20, 0xC1,
  0x82, 0x0C, 0x00, 0x3C, 0x66, 0xC3, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0xC1,
  0xC1, 0xC3, 0x66, 0x3C, 0x17, 0xD9, 0x11, 0x11, 0x11, 0x11, 0x10, 0x3C,
  0xE6, 0x83, 0x03, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFF,
  0x7C, 0xC6, 0x03, 0x03, 0x03, 0x0E, 0x3C, 0x03, 0x03, 0x01, 0x03, 0x87,
  0xFE, 0x03, 0x01, 0xC0, 0x50, 0x34, 0x19, 0x04, 0x42, 0x11, 0x84, 0x41,
  0x3F, 0xF0, 0x10, 0x04, 0x01, 0x00, 0x7E, 0x7E, 0x40, 0x40, 0x40, 0xFC,
  0x6E, 0x03, 0x01, 0x01, 0x03, 0x86, 0xFC, 0x1E, 0x30, 0x60, 0x40, 0xC0,
  0xDE, 0xE3, 0xC1, 0xC1, 0xC1, 0xC1, 0x63, 0x3E, 0xFF, 0xFF, 0x03, 0x02,
  0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x3E, 0x67, 0xC3,
  0xC3, 0x43, 0x7E, 0x3C, 0x66, 0xC3, 0x81, 0xC1, 0xC3, 0x7E, 0x3C, 0x66,
  0xC3, 0xC1, 0x81, 0xC1, 0xC3, 0x7D, 0x01, 0x03, 0x02, 0x0E, 0x78, 0xDD,
  0x00, 0x00, 0xDC, 0xF4, 0x00, 0xFE, 0x01, 0x07, 0x1C, 0x70, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x07, 0x38, 0xE0, 0x80, 0x7D, 0x8C, 0x08, 0x10, 0x61, 0x86, 0x08,
  0x10, 0x00, 0x01, 0x83, 0x00, 0x07, 0xC0, 0x71, 0xC3, 0x01, 0x98, 0x02,
  0x47, 0xC7, 0x31, 0x18, 0x84, 0x62, 0x11, 0x88, 0xC6, 0x33, 0x2C, 0x73,
  0x90, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x38,
  0x05, 0x81, 0x90, 0x23, 0x04, 0x61, 0x84, 0x3F, 0xCC, 0x19, 0x81, 0xA0,
  0x3C, 0x02, 0xFC, 0x7F, 0xA0, 0xD0, 0x28, 0x34, 0x33, 0xF9, 0x06, 0x81,
  0xC0, 0xE0, 0x70, 0xEF, 0xE0, 0x1F, 0xCE, 0x66, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xE2, 0x1F, 0x80, 0xFC, 0x3F,
  0xC8, 0x1A, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1A,
  0x1C, 0xFC, 0x00, 0xFF, 0xFE, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02,
  0x04, 0x0F, 0xE0, 0xFF, 0xFE, 0x04, 0x08, 0x10, 0x3F, 0xFF, 0x81, 0x02,
  0x04, 0x08, 0x00, 0x0F, 0xE7, 0x19, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0xFE, 0x1F, 0xC0, 0x68, 0x0D, 0x81, 0x9C, 0x31, 0xFE, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0xF0, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x3E, 0x81, 0xC1, 0xA1, 0x91, 0x89, 0x85, 0x83,
  0xC1, 0xB0, 0x8C, 0x43, 0x21, 0x90, 0x68, 0x18, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xC0, 0x3F, 0x01, 0xF8,
  0x1F, 0x40, 0xBB, 0x05, 0xC8, 0x6E, 0x62, 0x73, 0x33, 0x89, 0x1C, 0x68,
  0xE3, 0xC7, 0x0C, 0x38, 0x61, 0x80, 0xC0, 0xF0, 0x3E, 0x0E, 0xC3, 0x90,
  0xE6, 0x38, 0xCE, 0x13, 0x86, 0xE0, 0xF8, 0x36, 0x07, 0x80, 0xC0, 0x1F,
  0x83, 0x9C, 0x60, 0x64, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x34, 0x03, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0xFC, 0xFE, 0x83, 0x83, 0x83,
  0x83, 0x8E, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x83, 0x9C, 0x60,
  0x64, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x02, 0x60,
  0x63, 0x0C, 0x1F, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0xFC, 0x7F, 0x20, 0xD0,
  0x68, 0x34, 0x1B, 0xF9, 0xF8, 0x8C, 0x43, 0x20, 0x90, 0x68, 0x18, 0x3F,
  0x66, 0xC0, 0xC0, 0xC0, 0x70, 0x3C, 0x06, 0x03, 0x03, 0x03, 0x86, 0xFC,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x2C, 0x19, 0x8E, 0x3E, 0x00, 0xC0, 0x78,
  0x09, 0x83, 0x30, 0x62, 0x08, 0x63, 0x0C, 0x60, 0x88, 0x1B, 0x03, 0x40,
  0x28, 0x07, 0x00, 0xC0, 0xC1, 0x81, 0xA0, 0xE1, 0x98, 0x70, 0xCC, 0x68,
  0x66, 0x34, 0x21, 0x13, 0x30, 0xC8, 0x98, 0x6C, 0x4C, 0x36, 0x34, 0x0A,
  0x1E, 0x05, 0x07, 0x03, 0x83, 0x01, 0x81, 0x80, 0xC0, 0xD8, 0x23, 0x18,
  0x4C, 0x1A, 0x03, 0x80, 0xC0, 0x38, 0x1B, 0x0C, 0x42, 0x19, 0x83, 0xC0,
  0xC0, 0xC0, 0xD0, 0x26, 0x18, 0xC4, 0x33, 0x06, 0x81, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFF, 0x7F, 0x80, 0xC0, 0xC0, 0x40,
  0x60, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x0F, 0xF8, 0xFC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x04, 0x08,
  0x18, 0x10, 0x30, 0x60, 0x60, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x18, 0x0C, 0x0F, 0x04, 0x86, 0x62, 0x13, 0x0D, 0x03, 0xFF, 0xC8,
  0x80, 0x3C, 0x76, 0x03, 0x03, 0x3F, 0xE3, 0xC3, 0x83, 0xC7, 0x7B, 0x80,
  0x80, 0x80, 0x80, 0xBC, 0xFE, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC6,
  0xBC, 0x1E, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x62, 0x7C, 0x01, 0x80,
  0xC0, 0x60, 0x33, 0xDB, 0xFF, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x36,
  0x39, 0xEC, 0x1C, 0x76, 0x43, 0xC1, 0xFF, 0xC0, 0xC0, 0xC0, 0x61, 0x3F,
  0x0E, 0x7C, 0xC1, 0x87, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x00, 0x3D, 0xBF, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x63, 0x9E,
  0xC0, 0x60, 0x24, 0x33, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xFE, 0xC3,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xD1, 0x55, 0x55, 0x40, 0x31,
  0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xF0, 0x81, 0x02, 0x04, 0x08,
  0x71, 0xA6, 0x58, 0xA1, 0xE2, 0x64, 0x68, 0xD0, 0xC0, 0xFF, 0xFC, 0xBC,
  0xF7, 0xFF, 0xF1, 0xC3, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41,
  0x82, 0x0C, 0x10, 0x40, 0x9C, 0xFE, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x1C, 0x3F, 0x90, 0x58, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x63,
  0x1F, 0x00, 0xBC, 0xFE, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC6, 0xBC,
  0x80, 0x80, 0x80, 0x80, 0x3D, 0xBF, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x63, 0x9E, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x9F, 0xF1, 0x08, 0x42,
  0x10, 0x84, 0x00, 0x3F, 0xDA, 0x06, 0x07, 0x03, 0x81, 0x83, 0x87, 0xF8,
  0x20, 0x87, 0xFF, 0x20, 0x82, 0x08, 0x20, 0x83, 0x0F, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x63, 0xBE, 0xC0, 0xC1, 0xE0, 0xD0,
  0x4C, 0x62, 0x31, 0x90, 0xD8, 0x28, 0x14, 0x0E, 0x00, 0xC3, 0x0D, 0x0C,
  0x34, 0x38, 0x99, 0xE2, 0x64, 0x98, 0x93, 0x62, 0xCD, 0x0E, 0x1C, 0x38,
  0x70, 0x61, 0x80, 0xC1, 0xB1, 0x8C, 0xC2, 0xC1, 0xC0, 0x60, 0x78, 0x64,
  0x63, 0x60, 0xC0, 0xC1, 0xE0, 0xD8, 0x4C, 0x62, 0x31, 0x90, 0xD8, 0x28,
  0x1C, 0x06, 0x02, 0x03, 0x01, 0x07, 0x80, 0xFF, 0xFC, 0x30, 0x41, 0x86,
  0x18, 0x20, 0xC1, 0xFC, 0x0C, 0x71, 0x04, 0x10, 0x41, 0x38, 0xE0, 0x41,
  0x04, 0x10, 0x41, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0x42,
  0x10, 0x87, 0x39, 0x08, 0x42, 0x33, 0x98, 0x21, 0xFD, 0x8F,
};

const GFXglyph NotoSans_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 5, 5, 7, 1, -13 },
  { 10, 11, 13, 12, 0, -13 },
  { 28, 8, 15, 10, 1, -14 },
  { 43, 13, 13, 15, 1, -13 },
  { 65, 12, 13, 13, 1, -13 },
  { 85, 2, 5, 4, 1, -13 },
  { 87, 4, 16, 5, 1, -13 },
  { 95, 4, 16, 5, 1, -13 },
  { 103, 8, 8, 10, 1, -14 },
  { 111, 8, 9, 10, 1, -11 },
  { 120, 2, 4, 5, 1, -2 },
  { 121, 4, 2, 6, 1, -6 },
  { 122, 3, 2, 5, 1, -2 },
  { 123, 7, 13, 7, 0, -13 },
  { 135, 8, 13, 10, 1, -13 },
  { 148, 4, 13, 10, 2, -13 },
  { 155, 8, 13, 10, 1, -13 },
  { 168, 8, 13, 10, 1, -13 },
  { 181, 10, 13, 10, 0, -13 },
  { 198, 8, 13, 10, 1, -13 },
  { 211, 8, 13, 10, 1, -13 },
  { 224, 8, 13, 10, 1, -13 },
  { 237, 8, 13, 10, 1, -13 },
  { 250, 8, 13, 10, 1, -13 },
  { 263, 3, 10, 5, 1, -10 },
  { 267, 2, 12, 5, 1, -10 },
  { 270, 8, 9, 10, 1, -11 },
  { 279, 8, 5, 10, 1, -9 },
  { 284, 8, 9, 10, 1, -11 },
  { 293, 7, 13, 8, 0, -13 },
  { 305, 14, 15, 16, 1, -13 },
  { 332, 11, 13, 12, 0, -13 },
  { 350, 9, 13, 12, 2, -13 },
  { 365, 10, 13, 11, 1, -13 },
  { 382, 10, 13, 13, 2, -13 },
  { 399, 7, 13, 10, 2, -13 },
  { 411, 7, 13, 9, 2, -13 },
  { 423, 11, 13, 13, 1, -13 },
  { 441, 10, 13, 13, 2, -13 },
  { 458, 4, 13, 6, 1, -13 },
  { 465, 4, 16, 5, -1, -13 },
  { 473, 9, 13, 11, 2, -13 },
  { 488, 7, 13, 9, 2, -13 },
  { 500, 13, 13, 16, 2, -13 },
  { 522, 10, 13, 14, 2, -13 },
  { 539, 12, 13, 14, 1, -13 },
  { 559, 8, 13, 11, 2, -13 },
  { 572, 12, 16, 14, 1, -13 },
  { 596, 9, 13, 11, 2, -13 },
  { 611, 8, 13, 10, 1, -13 },
  { 624, 10, 13, 10, 0, -13 },
  { 641, 10, 13, 13, 2, -13 },
  { 658, 11, 13, 11, 0, -13 },
  { 676, 17, 13, 17, 0, -13 },
  { 704, 10, 13, 11, 0, -13 },
  { 721, 10, 13, 10, 0, -13 },
  { 738, 9, 13, 10, 1, -13 },
  { 753, 4, 16, 6, 1, -13 },
  { 761, 7, 13, 7, 0, -13 },
  { 773, 4, 16, 6, 0, -13 },
  { 781, 9, 8, 10, 1, -13 },
  { 790, 8, 1, 8, 0, 2 },
  { 791, 3, 3, 5, 1, -14 },
  { 793, 8, 10, 10, 1, -10 },
  { 803, 8, 14, 11, 2, -14 },
  { 817, 7, 10, 9, 1, -10 },
  { 826, 9, 14, 11, 1, -14 },
  { 842, 8, 10, 10, 1, -10 },
  { 852, 7, 14, 6, 0, -14 },
  { 865, 9, 14, 11, 1, -10 },
  { 881, 8, 14, 11, 2, -14 },
  { 895, 2, 13, 5, 1, -13 },
  { 899, 4, 17, 5, -1, -13 },
  { 908, 7, 14, 10, 2, -14 },
  { 921, 1, 14, 5, 2, -14 },
  { 923, 13, 10, 17, 2, -10 },
  { 940, 8, 10, 11, 2, -10 },
  { 950, 9, 10, 11, 1, -10 },
  { 962, 8, 14, 11, 2, -10 },
  { 976, 9, 14, 11, 1, -10 },
  { 992, 5, 10, 7, 2, -10 },
  { 999, 7, 10, 9, 1, -10 },
  { 1008, 6, 12, 7, 0, -12 },
  { 1017, 9, 10, 11, 1, -10 },
  { 1029, 9, 10, 9, 0, -10 },
  { 1041, 14, 10, 14, 0, -10 },
  { 1059, 9, 10, 10, 0, -10 },
  { 1071, 9, 14, 9, 0, -10 },
  { 1087, 7, 10, 8, 1, -10 },
  { 1096, 6, 16, 7, 0, -13 },
  { 1108, 2, 18, 10, 4, -14 },
  { 1113, 5, 16, 7, 1, -13 },
  { 1123, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_Regular18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular18pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_REGULAR18PT7B_H_
