#ifndef _NOTOSANS_REGULAR69PT7B_H_
#define _NOTOSANS_REGULAR69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x1F, 0xDF, 0xEF, 0xF7, 0xFF, 0xFD, 0xFE, 0x7F, 0x1E, 0x00, 0xFE, 0x07,
  0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xC7, 0xC3, 0xF8, 0x7F, 0x07, 0xC0, 0x30, 0x7E,
  0x07, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x7F, 0x87, 0xC0, 0x00, 0x3F,
  0xE7, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xCF, 0xFC, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x07, 0xC0, 0xFE, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x80,
  0x07, 0xC0, 0xFE, 0xE0, 0x07, 0xC1, 0xFE, 0xFE, 0x07, 0xC7, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x7F, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x3F, 0xF8, 0x1F,
  0x00, 0x7C, 0x1F, 0x0F, 0xFF, 0x83, 0xF0, 0x0F, 0x87, 0xC3, 0xFF, 0xF8,
  0x3E, 0x03, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE0, 0xFC, 0x3E, 0x1F, 0x81,
  0xF0, 0x7F, 0x7F, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0xFF, 0xE1, 0xF0, 0xFC,
  0x03, 0xE0, 0xFF, 0xF8, 0x7E, 0x1F, 0x00, 0x7C, 0x0F, 0xFE, 0x0F, 0x83,
  0xE0, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x7F,
  0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xF8, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0xF0, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0x3F,
  0xC3, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x7C, 0x03, 0xC0, 0x3E, 0xFF,
  0x83, 0xC3, 0xFE, 0xFF, 0xFB, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3F, 0xBF, 0xDF,
  0xEF, 0xFF, 0xFB, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFD, 0xF8, 0xFF, 0x3F,
  0x3F, 0xC7, 0xEF, 0xF0, 0xFF, 0xFC, 0x1F, 0xBF, 0x03, 0xF3, 0x80, 0x7E,
  0x20, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x07, 0xF8, 0x1C,
  0x00, 0x01, 0xFC, 0x04, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x78, 0x00,
  0x03, 0xF8, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xA0, 0x00,
  0x00, 0x3F, 0x9C, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x7F, 0xC7, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x80, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x10,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xFF, 0x80,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xF8,
  0xFD, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x01,
  0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0xC7, 0xFE, 0x07, 0xF7, 0xE1, 0xFF, 0xFF,
  0xF3, 0xF0, 0x7F, 0xFF, 0xF1, 0xF0, 0x0F, 0xFF, 0xF1, 0xF8, 0x01, 0xFF,
  0xE0, 0xFC, 0x00, 0x07, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x70, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0xFE, 0xFF, 0x7F, 0xBF, 0xFF, 0xEF, 0xF3, 0xF8, 0xF0, 0x07, 0x81, 0xF8,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0x1F, 0x00, 0x0F, 0xF1, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x3E, 0x3F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xF8, 0xF8, 0x00,
  0xFF, 0xDF, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0x9F,
  0x80, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7D, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x07,
  0xE0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xFF, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xBE, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x3E, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFB, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0x3F,
  0x00, 0x7E, 0x00, 0xF7, 0x80, 0xF8, 0x7C, 0x00, 0xFE, 0x07, 0xDF, 0x07,
  0xE1, 0xF0, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xC0, 0x07, 0xFF, 0xF0,
  0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3E, 0x00, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xFF, 0x8F, 0xC0,
  0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC0, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x7F,
  0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x1F, 0xF3,
  0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x7F,
  0xC0, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x20, 0x3F, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF4, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x03, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0xE0, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xF0,
  0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0x9F, 0x80,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xF0,
  0x00, 0x1F, 0xFC, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x87,
  0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0xE3,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x01, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F,
  0xCF, 0xF0, 0x00, 0x00, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xCF,
  0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01,
  0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF7,
  0xE0, 0x00, 0x00, 0x0F, 0xBF, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xFC,
  0xFC, 0x00, 0x00, 0x07, 0xEF, 0xFE, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xFF,
  0x3F, 0x00, 0x00, 0x03, 0xF3, 0xFF, 0x8F, 0xC0, 0x00, 0x01, 0xF1, 0xFF,
  0xC7, 0xE0, 0x00, 0x00, 0xF8, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7F,
  0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x07,
  0xFF, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0x81,
  0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x7F, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0xF8,
  0x07, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xE3,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xF0, 0x00, 0x01, 0xFF, 0xCF,
  0xE0, 0x00, 0x03, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xE0, 0x00,
  0x0F, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0x80,
  0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x03,
  0xF8, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0x00,
  0x07, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0xE1, 0xFF, 0xC0, 0x00, 0x0F, 0xE3,
  0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xFE, 0x00,
  0x00, 0x1F, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF3,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x0F, 0xFF, 0x3F, 0x00, 0x03,
  0xFE, 0x7E, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xBF,
  0x00, 0x01, 0xFE, 0x7E, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x01, 0xFF, 0x07,
  0xE0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x18, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFA, 0x00,
  0x00, 0x0F, 0xF6, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xE0, 0x7C, 0x00, 0x7F, 0x80,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0x80, 0x03, 0xF7, 0xF8, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xFD, 0xFF, 0x83, 0xFD, 0xF3, 0xFF, 0xFF, 0xE7, 0xC7, 0xFF, 0xFF, 0x1F,
  0x0F, 0xFF, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0x80, 0x01, 0xF8, 0x3F, 0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x7E, 0x7F,
  0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xEF, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0x9F, 0xE0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x0F, 0xE3, 0xFF, 0x80,
  0x1F, 0xE1, 0xF7, 0xFC, 0x7F, 0xF0, 0xF9, 0xFF, 0xFF, 0xF0, 0x7C, 0x7F,
  0xFF, 0xF0, 0x3E, 0x1F, 0xFF, 0xE0, 0x1E, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87,
  0xFC, 0x00, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x02, 0x1F, 0xF0, 0x01, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xFE,
  0x1F, 0x81, 0xFF, 0xFF, 0x8F, 0xC1, 0xFF, 0xFF, 0xE7, 0xE1, 0xFF, 0xC7,
  0xFB, 0xF1, 0xFE, 0x00, 0x7F, 0xF9, 0xFE, 0x00, 0x0F, 0xFC, 0xFE, 0x00,
  0x03, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x0F,
  0xFC, 0x7F, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xBF, 0x0F, 0xFF, 0xFF,
  0x9F, 0x81, 0xFF, 0xFF, 0x8F, 0xC0, 0x7F, 0xFF, 0x87, 0xE0, 0x0F, 0xFF,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x1F, 0xF8,
  0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE1, 0xC0, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x07, 0xC0, 0x7F, 0xFF, 0x87, 0xE0, 0x7F, 0xFF, 0xE3, 0xF0,
  0x7F, 0xFF, 0xF9, 0xF8, 0x7F, 0xF7, 0xFE, 0xFC, 0x7F, 0x80, 0x1F, 0xFE,
  0x3F, 0x80, 0x03, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x9F, 0x80, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x87,
  0xFE, 0x0F, 0xEF, 0xC1, 0xFF, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0xE3, 0xF0,
  0x1F, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x30, 0x00, 0x03,
  0xFC, 0x1F, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x38, 0x00, 0x7E, 0x07, 0xFF, 0x80, 0xFC, 0x3F, 0xFF, 0xC1,
  0xF9, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xCF,
  0xFE, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0x7F,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x3C, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x9E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xF8, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0x04, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F,
  0x8F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x03,
  0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC,
  0x03, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x3E, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE1, 0xF1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFB,
  0xFF, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xDF, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF7, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x1F, 0xFE, 0x03, 0xE0, 0xFF, 0xFF, 0x07, 0xC7,
  0xFF, 0xFF, 0x8F, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8,
  0x00, 0xFF, 0x7F, 0xE0, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFD, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0x80, 0x3E, 0x1F, 0xFF,
  0xE0, 0x1F, 0x1F, 0xFF, 0xFC, 0x0F, 0x9F, 0xFF, 0xFF, 0x07, 0xFF, 0xFB,
  0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07,
  0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x07,
  0xF8, 0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0xFF, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF,
  0xFC, 0x1F, 0x9F, 0xFF, 0xFC, 0x0F, 0xC7, 0xFF, 0xF8, 0x07, 0xE0, 0xFF,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xC0, 0x7F, 0xFF, 0x87,
  0xE0, 0x7F, 0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0xF9, 0xF8, 0x7F, 0xE1, 0xFE,
  0xFC, 0x7F, 0x80, 0x1F, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0x3F, 0x80, 0x00,
  0xFF, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xC0, 0x00,
  0x0F, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFF,
  0x1F, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x1F, 0xEF, 0xC3, 0xFF, 0xFF, 0xE7,
  0xE0, 0x7F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xC1,
  0xFC, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF7, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xE0,
  0x00, 0xF3, 0xF0, 0x00, 0x08, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0xF0,
  0x00, 0x3F, 0xBF, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x0C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0x3F, 0xC0, 0x07,
  0xFF, 0x3F, 0xF8, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF,
  0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF9, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x81, 0xFC, 0x01, 0xF0, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF9, 0xF0, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x63, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x8F, 0xFF, 0x80, 0x00, 0xCF, 0xFF, 0xF0, 0x00, 0xEF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFD, 0x80, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x0F, 0xF8, 0x00,
};

const GFXglyph NotoSans_Regular69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 50, 19, 5, -49 },
  { 58, 20, 18, 28, 4, -49 },
  { 103, 41, 49, 45, 2, -49 },
  { 355, 32, 56, 39, 4, -52 },
  { 579, 51, 51, 57, 3, -50 },
  { 905, 46, 51, 51, 4, -50 },
  { 1199, 7, 18, 16, 4, -49 },
  { 1215, 16, 60, 21, 3, -49 },
  { 1335, 16, 60, 21, 2, -49 },
  { 1455, 32, 31, 38, 3, -52 },
  { 1579, 33, 33, 39, 3, -41 },
  { 1716, 10, 17, 18, 3, -8 },
  { 1738, 16, 5, 22, 3, -21 },
  { 1748, 9, 9, 18, 5, -8 },
  { 1759, 24, 49, 26, 1, -49 },
  { 1906, 33, 51, 39, 3, -50 },
  { 2117, 19, 49, 39, 6, -49 },
  { 2234, 33, 50, 39, 3, -50 },
  { 2441, 33, 51, 39, 3, -50 },
  { 2652, 37, 50, 39, 1, -50 },
  { 2884, 32, 50, 39, 4, -49 },
  { 3084, 32, 51, 39, 4, -50 },
  { 3288, 33, 49, 39, 3, -49 },
  { 3491, 33, 51, 39, 3, -50 },
  { 3702, 33, 51, 39, 3, -50 },
  { 3913, 9, 39, 18, 5, -38 },
  { 3957, 11, 47, 18, 2, -38 },
  { 4022, 33, 34, 39, 3, -42 },
  { 4163, 31, 19, 39, 4, -34 },
  { 4237, 33, 34, 39, 3, -42 },
  { 4378, 27, 51, 30, 1, -50 },
  { 4551, 54, 55, 62, 4, -49 },
  { 4923, 44, 49, 44, 0, -49 },
  { 5193, 34, 49, 45, 7, -49 },
  { 5402, 37, 51, 44, 4, -50 },
  { 5638, 39, 49, 50, 7, -49 },
  { 5877, 27, 49, 38, 7, -49 },
  { 6043, 27, 49, 36, 7, -49 },
  { 6209, 41, 51, 50, 4, -50 },
  { 6471, 37, 49, 51, 7, -49 },
  { 6698, 18, 49, 23, 3, -49 },
  { 6809, 18, 62, 19, -5, -49 },
  { 6949, 36, 49, 43, 7, -49 },
  { 7170, 27, 49, 36, 7, -49 },
  { 7336, 49, 49, 63, 7, -49 },
  { 7637, 39, 49, 52, 7, -49 },
  { 7876, 46, 51, 54, 4, -50 },
  { 8170, 31, 49, 42, 7, -49 },
  { 8360, 46, 62, 54, 4, -50 },
  { 8717, 35, 49, 43, 7, -49 },
  { 8932, 31, 51, 38, 4, -50 },
  { 9130, 37, 49, 38, 1, -49 },
  { 9357, 38, 50, 50, 6, -49 },
  { 9595, 41, 49, 41, 0, -49 },
  { 9847, 62, 49, 64, 1, -49 },
  { 10227, 40, 49, 40, 0, -49 },
  { 10472, 39, 49, 39, 0, -49 },
  { 10711, 34, 49, 39, 3, -49 },
  { 10920, 15, 60, 23, 6, -49 },
  { 11033, 24, 49, 26, 1, -49 },
  { 11180, 15, 60, 23, 2, -49 },
  { 11293, 34, 32, 39, 3, -50 },
  { 11429, 31, 5, 31, 0, 6 },
  { 11449, 14, 11, 19, 3, -53 },
  { 11469, 30, 39, 39, 3, -38 },
  { 11616, 33, 53, 42, 6, -52 },
  { 11835, 27, 39, 33, 4, -38 },
  { 11967, 33, 53, 42, 4, -52 },
  { 12186, 31, 39, 39, 4, -38 },
  { 12338, 26, 53, 24, 1, -53 },
  { 12511, 33, 55, 42, 4, -38 },
  { 12738, 31, 52, 43, 6, -52 },
  { 12940, 7, 51, 18, 5, -51 },
  { 12985, 16, 68, 18, -4, -51 },
  { 13121, 30, 52, 37, 6, -52 },
  { 13316, 6, 52, 18, 6, -52 },
  { 13355, 53, 38, 65, 6, -38 },
  { 13607, 31, 38, 43, 6, -38 },
  { 13755, 34, 39, 42, 4, -38 },
  { 13921, 33, 55, 42, 6, -38 },
  { 14148, 33, 55, 42, 4, -38 },
  { 14375, 21, 38, 29, 6, -38 },
  { 14475, 26, 39, 33, 4, -38 },
  { 14602, 22, 46, 25, 1, -45 },
  { 14729, 32, 38, 43, 5, -37 },
  { 14881, 35, 37, 35, 0, -37 },
  { 15043, 52, 37, 54, 1, -37 },
  { 15284, 34, 37, 37, 1, -37 },
  { 15442, 35, 54, 35, 0, -37 },
  { 15679, 27, 37, 32, 3, -37 },
  { 15804, 22, 60, 26, 2, -49 },
  { 15969, 6, 69, 38, 16, -52 },
  { 16021, 22, 60, 26, 2, -49 },
  { 16186, 33, 9, 39, 3, -29 },
};

const GFXfont NotoSans_Regular69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular69pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_REGULAR69PT7B_H_
