#ifndef _NOTOSANS_REGULAR48PT7B_H_
#define _NOTOSANS_REGULAR48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x00, 0x39, 0xF7,
  0xFF, 0x7D, 0xF3, 0x80, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xB8, 0x3D, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x70,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80,
  0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1C, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFD, 0xFC, 0x7C, 0x70, 0x33, 0xE1, 0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x1C,
  0x00, 0xF0, 0x70, 0x03, 0xE1, 0xC0, 0x0F, 0xC7, 0x00, 0x1F, 0xDC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x01, 0xDF, 0xE0, 0x07, 0x0F, 0x80, 0x1C, 0x1F, 0x00, 0x70,
  0x7C, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x1C, 0x1E, 0x80, 0x70, 0xFB,
  0xE1, 0xDF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0x80, 0x3F, 0xF0, 0x00, 0x70, 0x03, 0xC7, 0x80, 0x0F, 0x00, 0x78, 0x38,
  0x01, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x07,
  0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x1C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x70,
  0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x1E,
  0x1E, 0x00, 0x0F, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x1C, 0x3C, 0x3E, 0x07,
  0x01, 0xC7, 0x8F, 0xF8, 0x78, 0x3C, 0x79, 0xFF, 0x87, 0x83, 0xCF, 0x1E,
  0x3C, 0x3C, 0xF8, 0xE3, 0xC1, 0xE1, 0xFF, 0x1E, 0x38, 0x1E, 0x0F, 0xE1,
  0xC3, 0x80, 0xE0, 0x78, 0x3C, 0x78, 0x0E, 0x00, 0x03, 0x87, 0x80, 0xE0,
  0x00, 0x78, 0x78, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x78,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x3C,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x38, 0x1E, 0x00, 0x78, 0x03, 0xC1, 0xE0,
  0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x0F,
  0xF8, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7C, 0x3F, 0x3F,
  0x00, 0x78, 0x7E, 0x1F, 0x80, 0x78, 0x7C, 0x0F, 0xC0, 0x78, 0xF8, 0x07,
  0xE0, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0xF0, 0x00, 0xF9, 0xF0, 0xF0, 0x00,
  0x7F, 0xE0, 0xF0, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x1F, 0xC0, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0x87,
  0xFD, 0xF0, 0x3F, 0xFF, 0xF0, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFD, 0xEF, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x03, 0xE0,
  0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0xF8, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C,
  0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x03,
  0x80, 0xFE, 0x0E, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xC0,
  0xF0, 0x03, 0x01, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xF7, 0xFF, 0x7D, 0xF3, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xF8, 0x1F, 0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x78, 0x00,
  0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0xC7, 0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x07, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF1, 0xFF, 0x9F, 0xBF, 0xF1, 0xEF, 0x0F, 0x70, 0x79, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xE0, 0x3F, 0x07, 0x00, 0x1F, 0x0C, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0x86, 0x00, 0x1F,
  0x08, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xB0, 0x00, 0x3E,
  0x7E, 0x03, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x7B, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F,
  0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFB, 0x00,
  0x0F, 0xCF, 0x80, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x0F, 0xF8, 0x3C, 0xFF, 0xF8, 0xF7, 0xFF, 0xF3,
  0xFC, 0x07, 0xCF, 0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x7C, 0xF0, 0x01, 0xE3,
  0xE0, 0x0F, 0x87, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1F,
  0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1,
  0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x3E, 0x03, 0xF1, 0xF8, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7E,
  0x3F, 0x81, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x1F, 0x80, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x07,
  0xC0, 0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x7C, 0x01,
  0xFC, 0xFE, 0x0F, 0x78, 0xFF, 0xFC, 0xF0, 0xFF, 0xF3, 0xE0, 0x7F, 0x87,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x08, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x7D, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xF7, 0xFF, 0x7D, 0xF3, 0x80, 0x1F,
  0x1F, 0x3F, 0x3F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x80, 0xFC, 0x80, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x07, 0xF8, 0x07, 0x8F, 0x00, 0xFF,
  0xF8, 0x1C, 0xF0, 0x0F, 0xFF, 0xC0, 0xF7, 0x80, 0xF8, 0x1E, 0x07, 0xB8,
  0x0F, 0x80, 0xF0, 0x1F, 0xC0, 0xF8, 0x07, 0x80, 0xFE, 0x07, 0x80, 0x3C,
  0x07, 0xF0, 0x3C, 0x01, 0xE0, 0x3F, 0x01, 0xC0, 0x0F, 0x01, 0xF8, 0x1E,
  0x00, 0x78, 0x0F, 0xC0, 0xF0, 0x03, 0x80, 0x7E, 0x07, 0x80, 0x1C, 0x03,
  0xF0, 0x3C, 0x01, 0xE0, 0x3F, 0x80, 0xE0, 0x0F, 0x01, 0xDC, 0x07, 0x80,
  0x7C, 0x0E, 0xF0, 0x3C, 0x07, 0xE0, 0xF7, 0x80, 0xF8, 0xF7, 0x8F, 0x3C,
  0x03, 0xFF, 0x1F, 0xF0, 0xE0, 0x0F, 0xF0, 0x7F, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x80,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x01,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xF0, 0x01, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7E, 0xF0, 0x00,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0x83, 0xF0, 0x00, 0x41, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x1F, 0xF8, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x78, 0x1F, 0xFE, 0x0F, 0x00, 0x0F, 0xE1,
  0xE0, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x7E, 0x78, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xE1, 0xE0, 0x03, 0xF8,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC,
  0x07, 0xE0, 0xFE, 0x00, 0x06, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x3F, 0x00,
  0x00, 0xF1, 0xF8, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF0, 0x7F, 0xE0, 0x7F,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xDF, 0xFC, 0xFF, 0xE7,
  0xFE, 0x3F, 0xC0, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x1F,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x1F,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xCF,
  0x80, 0x01, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF8, 0x03,
  0xC0, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xF0,
  0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0xC3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xEF, 0x00, 0x00, 0x3F, 0xFB, 0xC0, 0x00, 0x1E,
  0xFE, 0xF8, 0x00, 0x07, 0xBF, 0xDE, 0x00, 0x01, 0xCF, 0xF7, 0x80, 0x00,
  0xF3, 0xFC, 0xF0, 0x00, 0x3C, 0xFF, 0x3C, 0x00, 0x1E, 0x3F, 0xCF, 0x00,
  0x07, 0x8F, 0xF1, 0xE0, 0x01, 0xE3, 0xFC, 0x78, 0x00, 0xF0, 0xFF, 0x1F,
  0x00, 0x3C, 0x3F, 0xC3, 0xC0, 0x0E, 0x0F, 0xF0, 0xF0, 0x07, 0x83, 0xFC,
  0x1E, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xE0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0E, 0x03, 0xFC, 0x0F, 0x07, 0x80, 0xFF, 0x03, 0xE1, 0xE0,
  0x3F, 0xC0, 0x78, 0xF0, 0x0F, 0xF0, 0x1E, 0x3C, 0x03, 0xFC, 0x03, 0xCF,
  0x00, 0xFF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0x80, 0x0F, 0xF0, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xF0,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x7F,
  0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x01, 0xFC, 0x7C, 0x00, 0x3F, 0xC7, 0xC0,
  0x07, 0xF8, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x03, 0xFC,
  0x1F, 0x00, 0x7F, 0x81, 0xF0, 0x0F, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xE0,
  0x3F, 0xC0, 0x3E, 0x07, 0xF8, 0x07, 0xC0, 0xFF, 0x00, 0x7C, 0x1F, 0xE0,
  0x07, 0xC3, 0xFC, 0x00, 0xF8, 0x7F, 0x80, 0x0F, 0x8F, 0xF0, 0x00, 0xF9,
  0xFE, 0x00, 0x1F, 0x3F, 0xC0, 0x01, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3C,
  0x1F, 0xFC, 0xF0, 0x03, 0xF3, 0xC0, 0x07, 0xEF, 0x00, 0x0F, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7C, 0xF0,
  0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01,
  0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xF0, 0x7F, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x80,
  0xF0, 0xF8, 0x00, 0x47, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xEE, 0x00, 0x1F,
  0xBF, 0x81, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF8, 0x3F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x1F, 0x00,
  0x1E, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xDE, 0x00, 0x3C, 0x3C, 0x00, 0xF3,
  0xC0, 0x0F, 0x87, 0xC0, 0x1E, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xC7, 0x80,
  0x3C, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x1E, 0x01, 0xF0,
  0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x01, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x3C,
  0x3E, 0x00, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x78, 0xF0,
  0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x03,
  0xCF, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x07, 0xF8,
  0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x78, 0x00, 0x1F, 0xE0, 0x00,
  0xEE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x03, 0xC0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0xC7, 0x00, 0x03, 0xC7, 0x80, 0x03, 0x83, 0x80, 0x07, 0x83, 0xC0, 0x07,
  0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0x70, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x78,
  0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x0F,
  0xE0, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x9F, 0xFF, 0x3C, 0xFC, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xBC, 0x01, 0xFD,
  0xF8, 0x1F, 0xEF, 0xFF, 0xEF, 0x3F, 0xFE, 0x38, 0x7F, 0xC1, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC3, 0xFC, 0x07, 0x9F, 0xFE, 0x0F, 0x7F, 0xFE,
  0x1F, 0xF8, 0xFE, 0x3F, 0x80, 0x3E, 0x7E, 0x00, 0x3C, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00,
  0x0F, 0xBF, 0x00, 0x1F, 0x7F, 0x00, 0x7C, 0xFF, 0x83, 0xF1, 0xEF, 0xFF,
  0xE3, 0xCF, 0xFF, 0x87, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xBF, 0x3E, 0x00, 0x9F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x13, 0xF8, 0x3C, 0x7F,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x3F, 0xC3,
  0xC3, 0xFF, 0xCF, 0x1F, 0xFF, 0xBC, 0xFE, 0x1F, 0xF3, 0xE0, 0x1F, 0xDF,
  0x00, 0x3F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x3F, 0x3F, 0x03,
  0xFC, 0x7F, 0xFE, 0x70, 0xFF, 0xF1, 0xC0, 0xFF, 0x87, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xF1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0,
  0x03, 0xC7, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x43, 0xFC, 0x0F,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x1C,
  0x3F, 0xFC, 0x71, 0xFF, 0xF9, 0xCF, 0xF3, 0xF7, 0x3E, 0x01, 0xFD, 0xF0,
  0x03, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xF3, 0xF0, 0x3F,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0x3C, 0x0F, 0xF8, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x20, 0x00, 0xF8, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xF8,
  0x3C, 0x7F, 0xF8, 0xF7, 0xFF, 0xF3, 0xDF, 0x1F, 0xCF, 0xE0, 0x0F, 0xBF,
  0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF7, 0xFF, 0xF7,
  0x00, 0x00, 0x07, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xEF,
  0xFC, 0xFF, 0xCF, 0xF0, 0x08, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7D, 0xE0,
  0x07, 0xCF, 0x00, 0x7C, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE0,
  0xF0, 0x3E, 0x07, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x3E,
  0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFE, 0xF8, 0x07,
  0xC7, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x78, 0x0F,
  0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xE7, 0x80, 0x1F, 0x3C,
  0x00, 0x7D, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x00, 0xFF, 0x87, 0x9F, 0xFE, 0x1F, 0xFE, 0x3D, 0xFF, 0xF9, 0xFF,
  0xF9, 0xEF, 0x8F, 0xFF, 0x8F, 0xEF, 0xE0, 0x1F, 0xE0, 0x1F, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x0F,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x00,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x03, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0xF0, 0xFF, 0x83, 0xC7, 0xFF, 0x8F, 0x7F, 0xFF, 0x3D, 0xF1, 0xFE, 0xFE,
  0x00, 0xFB, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE, 0x3F, 0x83,
  0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0xC0, 0x07,
  0xC7, 0xC0, 0x1F, 0x07, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0xF0, 0xFF, 0x01, 0xE7, 0xFF, 0x83, 0xDF, 0xFF, 0x87,
  0xFE, 0x3F, 0x8F, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x03,
  0xEF, 0xC0, 0x07, 0xDF, 0xC0, 0x1F, 0x3F, 0xE0, 0xFC, 0x7B, 0xFF, 0xF8,
  0xF3, 0xFF, 0xC1, 0xE1, 0xFF, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1C, 0x3F, 0xFC, 0x71, 0xFF,
  0xF9, 0xCF, 0xE1, 0xFF, 0x3E, 0x01, 0xFD, 0xF0, 0x03, 0xF7, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xF3, 0xF0, 0x3F, 0xC7, 0xFF, 0xEF, 0x0F,
  0xFF, 0x3C, 0x0F, 0xF8, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8, 0x1F,
  0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x07,
  0xC7, 0x80, 0x08, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xBE, 0x03, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFC, 0x20,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x7F, 0xDF, 0xFF, 0xEF, 0x3F,
  0xFF, 0x3C, 0x3F, 0xF0, 0xF0, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07,
  0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x1E, 0x78, 0x03, 0xFC, 0x01, 0xE7, 0x80, 0x3F,
  0xC0, 0x3E, 0x7C, 0x03, 0xBC, 0x03, 0xC3, 0xC0, 0x79, 0xC0, 0x3C, 0x3C,
  0x07, 0x9E, 0x03, 0xC3, 0xC0, 0x79, 0xE0, 0x7C, 0x3E, 0x0F, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0xF0, 0x78, 0x1E, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0,
  0xF0, 0xF8, 0x1F, 0x1E, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x78, 0xF0, 0x0F,
  0x1C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x39, 0xE0, 0x07, 0xBC, 0x03, 0xDE,
  0x00, 0x7B, 0x80, 0x3D, 0xE0, 0x07, 0xB8, 0x03, 0xDE, 0x00, 0x7F, 0x80,
  0x1D, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F,
  0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0x80, 0x01,
  0xEF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03,
  0xE7, 0x80, 0x07, 0xC3, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03,
  0xC3, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x00,
  0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x80,
  0xFF, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0,
  0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xF8, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x7F, 0xCF, 0xFF, 0xFE, 0x03, 0xFF, 0xD0, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 35, 13, 3, -34 },
  { 28, 13, 12, 20, 3, -34 },
  { 48, 29, 34, 31, 1, -34 },
  { 172, 22, 39, 27, 3, -36 },
  { 280, 36, 35, 40, 2, -35 },
  { 438, 32, 35, 35, 3, -35 },
  { 578, 5, 12, 11, 3, -34 },
  { 586, 11, 42, 14, 2, -34 },
  { 644, 11, 42, 14, 1, -34 },
  { 702, 22, 21, 26, 2, -36 },
  { 760, 23, 24, 27, 2, -29 },
  { 829, 7, 12, 13, 2, -6 },
  { 840, 12, 4, 15, 2, -15 },
  { 846, 6, 7, 13, 3, -6 },
  { 852, 17, 34, 18, 0, -34 },
  { 925, 23, 35, 27, 2, -35 },
  { 1026, 13, 34, 27, 4, -34 },
  { 1082, 23, 35, 27, 2, -35 },
  { 1183, 23, 35, 27, 2, -35 },
  { 1284, 26, 34, 27, 1, -34 },
  { 1395, 22, 34, 27, 3, -34 },
  { 1489, 22, 35, 27, 3, -35 },
  { 1586, 23, 34, 27, 2, -34 },
  { 1684, 23, 35, 27, 2, -35 },
  { 1785, 23, 35, 27, 2, -35 },
  { 1886, 6, 27, 13, 3, -26 },
  { 1907, 8, 32, 13, 1, -26 },
  { 1939, 23, 23, 27, 2, -29 },
  { 2006, 22, 13, 27, 3, -23 },
  { 2042, 23, 23, 27, 2, -29 },
  { 2109, 19, 36, 21, 1, -35 },
  { 2195, 37, 38, 43, 3, -34 },
  { 2371, 31, 34, 31, 0, -34 },
  { 2503, 24, 34, 31, 5, -34 },
  { 2605, 26, 35, 30, 3, -35 },
  { 2719, 27, 34, 35, 5, -34 },
  { 2834, 19, 34, 27, 5, -34 },
  { 2915, 19, 34, 25, 5, -34 },
  { 2996, 28, 35, 35, 3, -35 },
  { 3119, 26, 34, 36, 5, -34 },
  { 3230, 12, 34, 16, 2, -34 },
  { 3281, 13, 43, 13, -4, -34 },
  { 3351, 25, 34, 30, 5, -34 },
  { 3458, 19, 34, 25, 5, -34 },
  { 3539, 34, 34, 44, 5, -34 },
  { 3684, 27, 34, 36, 5, -34 },
  { 3799, 32, 35, 37, 3, -35 },
  { 3939, 22, 34, 29, 5, -34 },
  { 4033, 32, 43, 37, 3, -35 },
  { 4205, 24, 34, 30, 5, -34 },
  { 4307, 22, 35, 26, 2, -35 },
  { 4404, 26, 34, 27, 0, -34 },
  { 4515, 27, 34, 35, 4, -34 },
  { 4630, 29, 34, 29, 0, -34 },
  { 4754, 43, 34, 45, 1, -34 },
  { 4937, 28, 34, 28, 0, -34 },
  { 5056, 27, 34, 27, 0, -34 },
  { 5171, 24, 34, 27, 2, -34 },
  { 5273, 11, 42, 16, 4, -34 },
  { 5331, 17, 34, 18, 0, -34 },
  { 5404, 11, 42, 16, 1, -34 },
  { 5462, 24, 22, 27, 2, -35 },
  { 5528, 21, 3, 21, 0, 4 },
  { 5536, 10, 8, 13, 2, -37 },
  { 5546, 21, 26, 27, 2, -26 },
  { 5615, 23, 36, 30, 4, -36 },
  { 5719, 18, 26, 23, 3, -26 },
  { 5778, 22, 36, 30, 3, -36 },
  { 5877, 22, 26, 27, 3, -26 },
  { 5949, 18, 37, 17, 1, -37 },
  { 6033, 22, 38, 30, 3, -26 },
  { 6138, 22, 36, 30, 4, -36 },
  { 6237, 5, 35, 12, 4, -35 },
  { 6259, 12, 47, 12, -3, -35 },
  { 6330, 21, 36, 26, 4, -36 },
  { 6425, 4, 36, 12, 4, -36 },
  { 6443, 37, 26, 45, 4, -26 },
  { 6564, 22, 26, 30, 4, -26 },
  { 6636, 23, 26, 29, 3, -26 },
  { 6711, 23, 38, 30, 4, -26 },
  { 6821, 22, 38, 30, 3, -26 },
  { 6926, 15, 26, 20, 4, -26 },
  { 6975, 19, 26, 23, 2, -26 },
  { 7037, 15, 32, 17, 1, -32 },
  { 7097, 22, 26, 30, 4, -26 },
  { 7169, 24, 26, 24, 0, -26 },
  { 7247, 36, 26, 38, 1, -26 },
  { 7364, 24, 26, 25, 1, -26 },
  { 7442, 24, 38, 24, 0, -26 },
  { 7556, 19, 26, 23, 2, -26 },
  { 7618, 16, 42, 18, 1, -34 },
  { 7702, 4, 48, 26, 11, -36 },
  { 7726, 15, 42, 18, 2, -34 },
  { 7805, 23, 6, 27, 2, -20 },
};

const GFXfont NotoSans_Regular48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular48pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_REGULAR48PT7B_H_
