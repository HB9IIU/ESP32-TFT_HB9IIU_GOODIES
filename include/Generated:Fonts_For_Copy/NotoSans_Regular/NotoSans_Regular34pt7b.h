#ifndef _NOTOSANS_REGULAR34PT7B_H_
#define _NOTOSANS_REGULAR34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC6, 0x30,
  0x00, 0x07, 0x7F, 0xEE, 0xE3, 0xF8, 0x7E, 0x1B, 0x86, 0x61, 0x98, 0x66,
  0x19, 0x86, 0x61, 0x80, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0x83, 0x80,
  0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x30, 0x03, 0x87, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x30, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x06, 0x0E,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xC1,
  0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0x83, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xF0,
  0x3F, 0xFE, 0x7F, 0xFC, 0x71, 0x84, 0xE1, 0x80, 0xE1, 0x80, 0xE1, 0x80,
  0xF1, 0x80, 0x7D, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x01, 0x9E, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x8E, 0x81, 0x8E, 0xF9, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x1F, 0x80, 0x38, 0x1F, 0xE0, 0x18, 0x1C, 0x70, 0x1C,
  0x0E, 0x18, 0x1C, 0x06, 0x0E, 0x0E, 0x03, 0x07, 0x0E, 0x01, 0x83, 0x86,
  0x00, 0xC1, 0xC7, 0x00, 0x60, 0xE3, 0x00, 0x30, 0x73, 0x9E, 0x1C, 0x31,
  0x9F, 0xCE, 0x39, 0xDE, 0xF3, 0xFD, 0xCE, 0x38, 0xFC, 0xE6, 0x0C, 0x18,
  0xE3, 0x06, 0x00, 0x61, 0x83, 0x80, 0x70, 0xC1, 0xC0, 0x30, 0x60, 0xE0,
  0x38, 0x30, 0x70, 0x18, 0x18, 0x30, 0x1C, 0x0C, 0x18, 0x1C, 0x07, 0x1C,
  0x0E, 0x01, 0xFC, 0x0E, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0x1E,
  0x3C, 0x0E, 0x38, 0x3C, 0x3C, 0xE0, 0x3C, 0x71, 0xC0, 0x3D, 0xE3, 0x80,
  0x3F, 0x87, 0x00, 0x3E, 0x0E, 0x00, 0x3C, 0x1E, 0x01, 0xFC, 0x1F, 0x0F,
  0xBC, 0x1F, 0xFE, 0x3C, 0x1F, 0xF0, 0x3E, 0xFF, 0xF6, 0xDB, 0x60, 0x07,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38,
  0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0E,
  0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xF0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x61, 0x87, 0x7F, 0xBF, 0xFF,
  0xFF, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1E,
  0x3C, 0x0C, 0x18, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x3C,
  0xE3, 0x9E, 0x71, 0xC6, 0x38, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x38, 0x3C, 0x70, 0x1C, 0x70, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0x60, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x3C, 0x7C, 0x1F, 0xF8, 0x0F,
  0xE0, 0x03, 0x87, 0xC7, 0xE7, 0xFF, 0x3B, 0x1D, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x1F, 0xF0, 0x7F, 0xF8, 0xF0, 0x3C,
  0x60, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x3F, 0xF0, 0xFF, 0xF8,
  0xF0, 0x3C, 0x40, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x78, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x80, 0x1E, 0xF0, 0x7C, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x39, 0xC0,
  0x0C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x70, 0x70, 0x38,
  0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x3F, 0xFC, 0x7F, 0xFC, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x80, 0x1C, 0xF0, 0x7C, 0xFF, 0xF8,
  0x7F, 0xE0, 0x00, 0x38, 0x03, 0xFC, 0x0F, 0xFC, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE7, 0xF0,
  0xEF, 0xFC, 0xFC, 0x3E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C,
  0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1F, 0xF0, 0x3F,
  0xFC, 0x78, 0x3C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x0E, 0x70,
  0x1C, 0x78, 0x3C, 0x3E, 0x78, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0x78,
  0x7C, 0x70, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0E, 0x78, 0x3E, 0x3F, 0xFC, 0x1F, 0xF0, 0x03, 0x80, 0x1F,
  0xF0, 0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0x70, 0x1F, 0x7E,
  0xF7, 0x3F, 0xE6, 0x0F, 0x8E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x41, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x33,
  0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xDC, 0x10,
  0xE7, 0xDE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x39,
  0xE7, 0x1C, 0x71, 0x8E, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0x00, 0xFF, 0x8F,
  0xFF, 0x9C, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x07,
  0x0E, 0x03, 0xC0, 0x73, 0x81, 0xFF, 0x0E, 0x70, 0x7F, 0xE0, 0xCC, 0x1C,
  0x1C, 0x1B, 0x87, 0x03, 0x83, 0xF0, 0xE0, 0x70, 0x7E, 0x1C, 0x0E, 0x0F,
  0x83, 0x01, 0xC1, 0xB0, 0x60, 0x38, 0x36, 0x0E, 0x07, 0x06, 0xE1, 0xC1,
  0xE1, 0xDC, 0x3C, 0x3C, 0x33, 0x83, 0xFC, 0xFC, 0x30, 0x3F, 0x1F, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x80, 0x0F, 0xC1, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xDC, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1C, 0x00, 0xE0, 0x70,
  0x03, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x38, 0x1F,
  0xDC, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0x00, 0x7B,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x7E, 0x07, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x78, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xE0,
  0x7F, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00, 0x7C, 0xE0, 0x0F, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0xF0, 0xF8, 0x0E, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x80, 0x07, 0x3C, 0x00, 0x71, 0xE0,
  0x07, 0x0F, 0xE1, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xF1, 0xEF, 0xF7, 0xF0, 0xE0, 0x07, 0xF8, 0x03, 0xCE,
  0x00, 0xE3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x87,
  0x80, 0xE3, 0xC0, 0x39, 0xE0, 0x0E, 0xF0, 0x03, 0xBE, 0x00, 0xFF, 0xC0,
  0x3E, 0x70, 0x0E, 0x1E, 0x03, 0x83, 0xC0, 0xE0, 0x78, 0x38, 0x0E, 0x0E,
  0x03, 0xC3, 0x80, 0x78, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7B, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0x7E, 0xE0, 0x03, 0xBF, 0x70,
  0x01, 0xDF, 0xB8, 0x01, 0xCF, 0xCE, 0x00, 0xE7, 0xE7, 0x00, 0x63, 0xF1,
  0x80, 0x71, 0xF8, 0xE0, 0x38, 0xFC, 0x70, 0x18, 0x7E, 0x1C, 0x1C, 0x3F,
  0x0E, 0x0E, 0x1F, 0x87, 0x0E, 0x0F, 0xC1, 0xC7, 0x07, 0xE0, 0xE3, 0x03,
  0xF0, 0x3B, 0x81, 0xF8, 0x1D, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0, 0x38, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7E, 0xF0,
  0x07, 0xE7, 0x00, 0x7E, 0x78, 0x07, 0xE3, 0x80, 0x7E, 0x1C, 0x07, 0xE1,
  0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x87, 0xE0, 0x38, 0x7E,
  0x03, 0xC7, 0xE0, 0x1E, 0x7E, 0x00, 0xE7, 0xE0, 0x0F, 0x7E, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF0,
  0xE0, 0x01, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x00, 0x03, 0xDE, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xC1, 0xFC,
  0x7E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xE0,
  0xFE, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xE7,
  0x80, 0x03, 0x9C, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xDE,
  0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xC1, 0xFC, 0x7E, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0E, 0x0F, 0xE3, 0x80, 0x78, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x38,
  0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00,
  0x7B, 0x80, 0x0F, 0x01, 0x80, 0x3F, 0xF8, 0xFF, 0xF3, 0xC0, 0xEF, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xBE, 0x3F, 0x7F, 0xFC,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80,
  0x38, 0x7E, 0x3F, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x3C,
  0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xE0, 0x38, 0x0E, 0x07, 0x80,
  0xE0, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0,
  0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0xE0, 0x07, 0x80, 0x1D, 0xC0, 0x1F, 0x00, 0x73, 0xC0, 0x3E, 0x00, 0xE3,
  0x80, 0x6E, 0x01, 0xC7, 0x01, 0xDC, 0x07, 0x8E, 0x03, 0xB8, 0x0E, 0x1E,
  0x07, 0x38, 0x1C, 0x1C, 0x0C, 0x70, 0x38, 0x38, 0x38, 0xE0, 0xF0, 0x70,
  0x70, 0xE1, 0xC0, 0x70, 0xE1, 0xC3, 0x80, 0xE3, 0x83, 0x87, 0x01, 0xC7,
  0x07, 0x1E, 0x03, 0x8E, 0x07, 0x38, 0x03, 0x98, 0x0E, 0x70, 0x07, 0x70,
  0x1C, 0xE0, 0x0E, 0xE0, 0x1D, 0x80, 0x1D, 0xC0, 0x3F, 0x00, 0x1B, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE3, 0x80, 0x1C, 0x3C, 0x03,
  0x81, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x39,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x07, 0x0E, 0x00,
  0xE0, 0xF0, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x3C, 0x03, 0xC3, 0x80, 0x1C,
  0x70, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xEE, 0x00, 0x39, 0xE0, 0x0F,
  0x1C, 0x01, 0xC1, 0xC0, 0x78, 0x38, 0x0E, 0x03, 0x83, 0xC0, 0x70, 0x70,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xF0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x31, 0x80, 0x38, 0xE0,
  0x18, 0x30, 0x1C, 0x1C, 0x0C, 0x06, 0x0E, 0x03, 0x86, 0x00, 0xC7, 0x00,
  0x73, 0x80, 0x1B, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0x01, 0x00, 0x7F, 0xC3, 0xFF, 0x8C, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x07, 0xFC, 0xFF, 0xF7, 0xC1, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0xED, 0xFF, 0x33, 0xF8, 0xC0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x80, 0xE7, 0xF0, 0xFF, 0xFC, 0xF8, 0x3C, 0xF0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xFC, 0x3C,
  0xCF, 0xFC, 0xC7, 0xF0, 0x00, 0xC0, 0x7F, 0xCF, 0xFE, 0x78, 0x27, 0x80,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x38, 0xFF, 0xC3, 0xFE, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x03, 0x87, 0x1F, 0xE7, 0x3F, 0xFF, 0x7C, 0x1F, 0x70, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x3C, 0x3F, 0x3F,
  0xF7, 0x0F, 0xE3, 0x01, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xC1, 0xE7, 0x01,
  0xEE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3E, 0x0E, 0x3F,
  0xFC, 0x1F, 0xF0, 0x03, 0xF0, 0xFF, 0x0F, 0x71, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0xFF, 0xCF, 0xFC, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x01, 0x00, 0x1F, 0xE7, 0x3F, 0xF7,
  0x7C, 0x3F, 0x70, 0x0F, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F,
  0x78, 0x0F, 0x3C, 0x3F, 0x3F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x40, 0x1E, 0x7C, 0x7E, 0x7F, 0xFC, 0x1F, 0xF0,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x60, 0xE7, 0xF9, 0xFF, 0xFB, 0xE0, 0x7F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1C, 0xFF, 0xA0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x9E, 0xFE, 0xFC, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x3D, 0xC0, 0xF3, 0x83, 0xC7, 0x0F, 0x0E, 0x3C, 0x1C, 0xF0, 0x39, 0xC0,
  0x77, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xCE, 0x07, 0x1E, 0x0E, 0x1E, 0x1C,
  0x1C, 0x38, 0x1C, 0x70, 0x3C, 0xE0, 0x3D, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x10, 0x31, 0xFC,
  0x3F, 0xCF, 0xFF, 0x9F, 0xFB, 0xE0, 0xFE, 0x0E, 0xF0, 0x1F, 0x03, 0xF8,
  0x07, 0x80, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x07, 0xE0, 0x1C, 0x01,
  0xF8, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1C,
  0x01, 0xF8, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0,
  0x1C, 0x01, 0xF8, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x1C, 0x00, 0x81, 0x8F,
  0xF3, 0xFF, 0xF7, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x38, 0x01, 0xC0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x00, 0xF3, 0x80, 0x3B, 0x80, 0x1D,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x77, 0x80, 0x39, 0xC0, 0x1C, 0xF0, 0x1C, 0x3C, 0x3E, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0x01, 0x80, 0xC7, 0xF0, 0xFF, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xFC, 0x3C,
  0xEF, 0xF8, 0xE7, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1F, 0xE3,
  0x3F, 0xF7, 0x78, 0x1F, 0x70, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0x70, 0x0F, 0x78, 0x0F, 0x3C, 0x3F, 0x3F, 0xF7, 0x0F, 0xE7, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0xF8, 0xFB, 0xBF, 0x7F, 0x0F, 0x81, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x00, 0x06, 0x01, 0xFF, 0x9F, 0xFD, 0xE0, 0x6E,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0xE0, 0xF7, 0xFF, 0x1F, 0xF0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x0F, 0xFD, 0xFF, 0x8E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xFE, 0x1F, 0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFC,
  0x3F, 0x7F, 0xEE, 0x7F, 0x8C, 0xE0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCF,
  0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C,
  0x07, 0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0D,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x01, 0xDC,
  0x07, 0xC0, 0x77, 0x01, 0xF0, 0x1D, 0xC0, 0x6C, 0x0E, 0x38, 0x3B, 0x03,
  0x8E, 0x0E, 0xE0, 0xE3, 0x83, 0x38, 0x70, 0xE1, 0xC6, 0x1C, 0x1C, 0x71,
  0xC7, 0x07, 0x18, 0x71, 0xC1, 0xCE, 0x0C, 0xE0, 0x33, 0x83, 0xB8, 0x0E,
  0xE0, 0xEE, 0x03, 0xB0, 0x3B, 0x80, 0xFC, 0x06, 0xC0, 0x1F, 0x01, 0xF0,
  0x07, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x70, 0x1E, 0x38,
  0x1C, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x38, 0x38,
  0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x38,
  0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x1B,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0xFC, 0x1E, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE1, 0xF8, 0x38, 0x07, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1E,
  0x03, 0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0xC0,
  0x38, 0x3F, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0xF0, 0x7E, 0x0F, 0x00, 0x7E, 0x01, 0xFF, 0xC7,
  0xC7, 0xFF, 0x80, 0xFC,
};

const GFXglyph NotoSans_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 10, 9, 14, 2, -24 },
  { 28, 20, 24, 22, 1, -24 },
  { 88, 16, 28, 19, 2, -26 },
  { 144, 25, 25, 28, 2, -25 },
  { 223, 23, 25, 25, 2, -25 },
  { 295, 3, 9, 8, 2, -24 },
  { 299, 8, 29, 10, 1, -24 },
  { 328, 8, 29, 10, 1, -24 },
  { 357, 16, 15, 19, 1, -26 },
  { 387, 16, 16, 19, 2, -20 },
  { 419, 6, 8, 9, 1, -4 },
  { 425, 9, 2, 11, 1, -10 },
  { 428, 5, 4, 9, 2, -4 },
  { 431, 12, 24, 13, 0, -24 },
  { 467, 16, 25, 19, 2, -25 },
  { 517, 9, 24, 19, 3, -24 },
  { 544, 16, 25, 19, 2, -25 },
  { 594, 16, 25, 19, 2, -25 },
  { 644, 18, 24, 19, 1, -24 },
  { 698, 16, 24, 19, 2, -24 },
  { 746, 16, 25, 19, 2, -25 },
  { 796, 17, 24, 19, 1, -24 },
  { 847, 16, 25, 19, 2, -25 },
  { 897, 16, 25, 19, 2, -25 },
  { 947, 5, 19, 9, 2, -19 },
  { 959, 6, 23, 9, 1, -19 },
  { 977, 16, 17, 19, 2, -21 },
  { 1011, 15, 10, 19, 2, -17 },
  { 1030, 16, 17, 19, 2, -21 },
  { 1064, 14, 25, 15, 0, -25 },
  { 1108, 27, 27, 31, 2, -24 },
  { 1200, 22, 24, 22, 0, -24 },
  { 1266, 17, 24, 22, 3, -24 },
  { 1317, 18, 25, 21, 2, -25 },
  { 1374, 20, 24, 25, 3, -24 },
  { 1434, 14, 24, 19, 3, -24 },
  { 1476, 14, 24, 18, 3, -24 },
  { 1518, 20, 25, 25, 2, -25 },
  { 1581, 19, 24, 25, 3, -24 },
  { 1638, 9, 24, 12, 1, -24 },
  { 1665, 9, 30, 9, -3, -24 },
  { 1699, 18, 24, 21, 3, -24 },
  { 1753, 14, 24, 18, 3, -24 },
  { 1795, 25, 24, 31, 3, -24 },
  { 1870, 20, 24, 26, 3, -24 },
  { 1930, 22, 25, 27, 2, -25 },
  { 1999, 16, 24, 21, 3, -24 },
  { 2047, 22, 31, 27, 2, -25 },
  { 2133, 18, 24, 21, 3, -24 },
  { 2187, 15, 25, 19, 2, -25 },
  { 2234, 19, 24, 19, 0, -24 },
  { 2291, 19, 24, 25, 3, -24 },
  { 2348, 20, 24, 20, 0, -24 },
  { 2408, 31, 24, 32, 0, -24 },
  { 2501, 20, 24, 20, 0, -24 },
  { 2561, 19, 24, 19, 0, -24 },
  { 2618, 17, 24, 19, 1, -24 },
  { 2669, 7, 29, 11, 3, -24 },
  { 2695, 12, 24, 13, 0, -24 },
  { 2731, 7, 29, 11, 1, -24 },
  { 2757, 17, 15, 19, 1, -24 },
  { 2789, 15, 2, 15, 0, 3 },
  { 2793, 7, 5, 10, 1, -26 },
  { 2798, 14, 19, 19, 2, -19 },
  { 2832, 16, 26, 21, 3, -26 },
  { 2884, 13, 19, 16, 2, -19 },
  { 2915, 16, 26, 21, 2, -26 },
  { 2967, 15, 19, 19, 2, -19 },
  { 3003, 12, 26, 12, 1, -26 },
  { 3042, 16, 27, 21, 2, -19 },
  { 3096, 15, 26, 21, 3, -26 },
  { 3145, 3, 25, 9, 3, -25 },
  { 3155, 8, 33, 9, -2, -25 },
  { 3188, 15, 26, 18, 3, -26 },
  { 3237, 3, 26, 9, 3, -26 },
  { 3247, 26, 19, 32, 3, -19 },
  { 3309, 15, 19, 21, 3, -19 },
  { 3345, 17, 19, 21, 2, -19 },
  { 3386, 16, 27, 21, 3, -19 },
  { 3440, 16, 27, 21, 2, -19 },
  { 3494, 11, 19, 14, 3, -19 },
  { 3521, 13, 19, 16, 2, -19 },
  { 3552, 11, 22, 12, 1, -22 },
  { 3583, 15, 18, 21, 3, -18 },
  { 3617, 17, 18, 17, 0, -18 },
  { 3656, 26, 18, 27, 0, -18 },
  { 3715, 16, 18, 18, 1, -18 },
  { 3751, 17, 26, 17, 0, -18 },
  { 3807, 14, 18, 16, 1, -18 },
  { 3839, 11, 29, 13, 1, -24 },
  { 3879, 3, 34, 19, 8, -26 },
  { 3892, 11, 29, 13, 1, -24 },
  { 3932, 16, 4, 19, 2, -14 },
};

const GFXfont NotoSans_Regular34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular34pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_REGULAR34PT7B_H_
