#ifndef _NOTOSANS_REGULAR27PT7B_H_
#define _NOTOSANS_REGULAR27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDB, 0x6D, 0xB4, 0x80, 0xFF, 0x80, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x03, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x60, 0x18, 0x60, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x03, 0xFC,
  0x7F, 0xEE, 0x62, 0xC6, 0x0C, 0x60, 0xC6, 0x0F, 0x60, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x67, 0x06, 0x70, 0x63, 0x86, 0x7F, 0x7E, 0xFF, 0xC1, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x08, 0x00, 0x83, 0xE0, 0x30, 0x67, 0x03,
  0x06, 0x30, 0x60, 0xC3, 0x0E, 0x0C, 0x30, 0xC0, 0xC3, 0x18, 0x0C, 0x31,
  0x80, 0xC3, 0x31, 0xC6, 0x33, 0x7E, 0x67, 0x66, 0x63, 0xE6, 0xC3, 0x08,
  0xCC, 0x30, 0x1C, 0xC3, 0x01, 0x8C, 0x30, 0x30, 0xC3, 0x03, 0x0C, 0x30,
  0x60, 0x63, 0x06, 0x07, 0xE0, 0xC0, 0x3C, 0x03, 0x00, 0x01, 0xFC, 0x00,
  0x73, 0x80, 0x1C, 0x38, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x06, 0x18, 0x00,
  0xE7, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x7E, 0x07, 0x1C, 0xE0, 0xC7,
  0x0E, 0x38, 0xC0, 0xE6, 0x38, 0x0F, 0xC7, 0x00, 0xF0, 0x60, 0x1E, 0x0E,
  0x07, 0xE0, 0xFF, 0xCE, 0x0F, 0xE0, 0xF0, 0xFF, 0xFC, 0x1C, 0x63, 0x8C,
  0x71, 0x86, 0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x8E, 0x38, 0x61, 0x87, 0x0C,
  0x38, 0x61, 0xC0, 0xE1, 0x83, 0x0C, 0x38, 0x61, 0x87, 0x1C, 0x30, 0xC3,
  0x0C, 0x71, 0xC7, 0x18, 0x63, 0x8C, 0x71, 0x8E, 0x00, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x0C, 0x61, 0x7D, 0x7F, 0xFF, 0xE0, 0xE0, 0x0D, 0x80,
  0xEE, 0x0E, 0x30, 0x71, 0xC0, 0x88, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xE0, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x77, 0x66, 0x6C, 0xFF, 0xFC, 0xFF, 0x80,
  0x01, 0xC0, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x00,
  0x02, 0x00, 0xFE, 0x0F, 0x78, 0x60, 0xE7, 0x03, 0x30, 0x1D, 0x80, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xB0, 0x0D, 0x80,
  0xEC, 0x07, 0x70, 0x31, 0xC3, 0x87, 0xF8, 0x1F, 0x80, 0x07, 0x1F, 0x3F,
  0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x02, 0x01, 0xFE, 0x1F, 0xF8, 0xC0, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x06, 0x01, 0xFE, 0x3F, 0x78, 0x80, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0xFE, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xBF, 0xF8, 0xFF, 0x80, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xD8, 0x07, 0x60, 0x19, 0x80, 0xC6, 0x06, 0x18,
  0x38, 0x60, 0xC1, 0x86, 0x06, 0x38, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x7F, 0xE7, 0xFE, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0xC4, 0x1E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x80, 0xEF, 0xFC, 0xFF,
  0x80, 0x00, 0x60, 0x3F, 0x87, 0xC4, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x67, 0xC3, 0x7F, 0xBE, 0x1D, 0xE0, 0x7E, 0x01, 0xB0, 0x0D,
  0x80, 0x6C, 0x03, 0x70, 0x39, 0xC3, 0x87, 0xFC, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0xFF, 0x0F, 0x3C, 0xE0, 0x66,
  0x03, 0x30, 0x19, 0xC0, 0xC6, 0x0E, 0x3C, 0xE0, 0x7C, 0x07, 0xF0, 0x71,
  0xC7, 0x07, 0x30, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x3B, 0x81, 0x8F, 0xFC,
  0x3F, 0x80, 0x02, 0x00, 0xFE, 0x0F, 0x78, 0xE0, 0xE6, 0x03, 0x70, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x3B, 0x01, 0xDC, 0x3E, 0x7F, 0xB0, 0xF3, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x0F, 0xF0, 0x7E, 0x00, 0x7F,
  0xB0, 0x00, 0x00, 0x0F, 0xF8, 0x37, 0x76, 0x00, 0x00, 0x00, 0x00, 0x77,
  0x66, 0xCC, 0x00, 0x18, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x06, 0x1F, 0xF1,
  0xFF, 0x20, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0x00, 0x70, 0x70, 0x00, 0xC7,
  0x00, 0x07, 0x30, 0x7F, 0x1B, 0x07, 0xF8, 0xD8, 0x60, 0xC3, 0xC7, 0x06,
  0x1E, 0x30, 0x30, 0xF1, 0x81, 0x87, 0x8C, 0x1C, 0x2C, 0x60, 0xE3, 0x63,
  0x87, 0x1B, 0x0F, 0xFF, 0x98, 0x3C, 0x78, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x40, 0x3E, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x37, 0x00, 0x39, 0x80, 0x18, 0xC0,
  0x1C, 0x70, 0x0C, 0x18, 0x06, 0x0E, 0x07, 0x03, 0x03, 0xFF, 0x81, 0xFF,
  0xE1, 0xC0, 0x30, 0xC0, 0x18, 0xE0, 0x0E, 0x60, 0x03, 0x30, 0x01, 0xF8,
  0x00, 0x60, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x03, 0x60, 0x1B,
  0x00, 0xD8, 0x1C, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x77, 0xFF, 0x3F, 0xF0, 0x00, 0x80, 0x3F,
  0xF1, 0xFF, 0xCE, 0x01, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xF0, 0x11, 0xFF, 0x83, 0xFE, 0xFF, 0xC1, 0xFF, 0xE3,
  0x01, 0xE6, 0x01, 0xEC, 0x01, 0xD8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB0, 0x07,
  0x60, 0x1C, 0xC0, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x40, 0x07, 0xFE,
  0x1F, 0xFE, 0x3C, 0x02, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x3C, 0x07, 0x1F, 0xFF, 0x07, 0xFE,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0xFE, 0x78,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x39, 0xFF, 0xF8, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xBF, 0x7C,
  0xC0, 0x3B, 0x01, 0xCC, 0x0E, 0x30, 0x70, 0xC3, 0x83, 0x1C, 0x0C, 0xE0,
  0x33, 0x00, 0xDC, 0x03, 0xF8, 0x0E, 0x70, 0x31, 0xC0, 0xC3, 0x83, 0x07,
  0x0C, 0x1C, 0x30, 0x38, 0xC0, 0x73, 0x00, 0xEC, 0x03, 0xC0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0D, 0xFC, 0x01, 0xBD, 0x80, 0x7F, 0xB0, 0x0D,
  0xF7, 0x01, 0xBE, 0x60, 0x77, 0xCE, 0x0C, 0xF8, 0xC1, 0x9F, 0x18, 0x63,
  0xE3, 0x8C, 0x7C, 0x33, 0x8F, 0x86, 0x61, 0xF0, 0xEC, 0x3E, 0x0F, 0x07,
  0xC1, 0xE0, 0xF8, 0x1C, 0x1F, 0x03, 0x03, 0x80, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3D, 0xC0, 0x7B, 0x80, 0xF3, 0x81, 0xE3, 0x03, 0xC7,
  0x07, 0x87, 0x0F, 0x06, 0x1E, 0x0E, 0x3C, 0x0E, 0x78, 0x0C, 0xF0, 0x1D,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x38, 0x00, 0x80, 0x07, 0xFC,
  0x0F, 0xFF, 0x87, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0E, 0xC0, 0x06, 0x70, 0x07, 0x1C, 0x07, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x8F, 0xFE, 0xC0, 0xEC, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xEF, 0xFC, 0xFF, 0x8F, 0x80, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x07, 0xFC,
  0x0F, 0xFF, 0x87, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0E, 0xC0, 0x06, 0x70, 0x07, 0x1C, 0x07, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0xFF, 0x87, 0xFF, 0x30, 0x39, 0x80, 0xEC, 0x07, 0x60, 0x3B,
  0x01, 0xD8, 0x0E, 0xC0, 0xE7, 0xFE, 0x3F, 0xC1, 0x87, 0x0C, 0x18, 0x60,
  0xE3, 0x03, 0x98, 0x1C, 0xC0, 0x76, 0x01, 0xB0, 0x0E, 0x02, 0x00, 0xFF,
  0x8F, 0xFC, 0xE0, 0x26, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x36, 0x03, 0xBF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0xB8, 0x07,
  0x38, 0x1C, 0x7F, 0xF0, 0x3F, 0xC0, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x06,
  0x70, 0x0E, 0x30, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x18,
  0x0C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x70, 0x06, 0x60, 0x07, 0x60,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0xB0,
  0x0E, 0x01, 0x9C, 0x0F, 0x80, 0xCE, 0x06, 0xC0, 0xE3, 0x03, 0x60, 0x71,
  0x83, 0xB0, 0x30, 0xE1, 0xDC, 0x38, 0x70, 0xC6, 0x1C, 0x18, 0x63, 0x0C,
  0x0C, 0x71, 0xC6, 0x07, 0x30, 0x67, 0x03, 0x98, 0x33, 0x80, 0xDC, 0x1D,
  0x80, 0x6E, 0x06, 0xC0, 0x3E, 0x03, 0x60, 0x0F, 0x01, 0xF0, 0x07, 0x80,
  0xF0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x30, 0x0C,
  0x38, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x70, 0x0C, 0x30,
  0x18, 0x38, 0x38, 0x18, 0x30, 0x1C, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x18, 0xC0, 0x71, 0xC0, 0xC1, 0x83, 0x83, 0x86, 0x03, 0x1C, 0x07,
  0x30, 0x06, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0xFF,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x60, 0x1B, 0x01,
  0x8C, 0x0C, 0x60, 0xC1, 0x86, 0x0C, 0x30, 0x33, 0x01, 0x98, 0x07, 0x80,
  0x30, 0xFF, 0xFF, 0xFF, 0xE1, 0xC3, 0x06, 0x0C, 0x07, 0x83, 0xFE, 0x38,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x07, 0xF3, 0xFF, 0x78, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0xF7, 0xFB, 0x3F, 0x30, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9C, 0x1D, 0xFC, 0xF8, 0xF7, 0x81, 0xB8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xFC, 0x1D, 0xBF, 0xCC, 0xFC, 0x00, 0x07, 0x83, 0xFC, 0xF3, 0xB8, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x82,
  0x7F, 0xC3, 0xF8, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x1C, 0x63, 0xFB, 0x3C, 0xFB, 0x81, 0xDC, 0x0E, 0xC0, 0x36, 0x01,
  0xF0, 0x0F, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x81, 0xDC, 0x0E, 0x7F, 0xF1,
  0xF9, 0x80, 0x07, 0x80, 0xFF, 0x0E, 0x3C, 0xE0, 0x66, 0x03, 0xB0, 0x1D,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x81, 0x0F,
  0xF8, 0x3F, 0xC0, 0x03, 0x83, 0xF0, 0xE4, 0x70, 0x18, 0x06, 0x01, 0x83,
  0xFE, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x07, 0x00, 0xFE, 0xCE, 0x3E, 0xE0,
  0x76, 0x03, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06,
  0xE0, 0x77, 0x03, 0x9F, 0xFC, 0x7E, 0x60, 0x03, 0x00, 0x18, 0x00, 0xD0,
  0x0E, 0x7F, 0xE3, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x8E, 0x1D, 0xFC, 0xF8, 0xF7, 0x81, 0xB8, 0x0D, 0xC0,
  0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0x80, 0xDF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x18, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFB, 0xE0, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x0E, 0xE1, 0xCE, 0x38, 0xE7,
  0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0E, 0x70, 0xE3, 0x8E, 0x1C, 0xE1,
  0xCE, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x81, 0xC6, 0xFF, 0x3F, 0xBE, 0x3B, 0x1F, 0xE0, 0xF0, 0x7E, 0x07,
  0x01, 0xF0, 0x38, 0x0F, 0x81, 0xC0, 0x7C, 0x0E, 0x03, 0xE0, 0x70, 0x1F,
  0x03, 0x80, 0xF8, 0x1C, 0x07, 0xC0, 0xE0, 0x3E, 0x07, 0x01, 0xF0, 0x38,
  0x0F, 0x81, 0xC0, 0x60, 0x03, 0x86, 0x7F, 0x3E, 0x3D, 0xE0, 0x6E, 0x03,
  0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xE0, 0x07, 0x80, 0x7F, 0x83, 0xC7, 0x1C, 0x0E,
  0x70, 0x19, 0x80, 0x76, 0x01, 0xF8, 0x07, 0x60, 0x1D, 0x80, 0x76, 0x01,
  0xDC, 0x06, 0x38, 0x38, 0x7F, 0xC0, 0xFE, 0x00, 0x03, 0x06, 0x7F, 0x3E,
  0x3D, 0xE0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0x7F, 0xF3, 0xBF, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xFE, 0xCF, 0x3E,
  0xE0, 0x77, 0x03, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8,
  0x06, 0xE0, 0x77, 0x03, 0x9F, 0xFC, 0x7E, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x03, 0xE7, 0xF7, 0xBE, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x0F,
  0x07, 0xF9, 0xC3, 0x70, 0x0E, 0x00, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x0D, 0xFF, 0x9F, 0xE0, 0x18, 0x0C, 0x06, 0x07,
  0x0F, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x60, 0x30, 0x1F, 0x87, 0xC0, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x76, 0x07, 0x7F,
  0xF3, 0xF3, 0xE0, 0x1D, 0x80, 0xE7, 0x03, 0x9C, 0x0C, 0x30, 0x70, 0xE1,
  0x81, 0x86, 0x06, 0x38, 0x1C, 0xC0, 0x33, 0x00, 0xDC, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x70, 0x3B, 0x03, 0x81, 0xD8, 0x1E, 0x0C, 0xE1,
  0xB0, 0x67, 0x0D, 0x87, 0x18, 0x6C, 0x38, 0xC7, 0x31, 0x87, 0x31, 0x8C,
  0x39, 0x8C, 0xE0, 0xCC, 0x76, 0x06, 0xC1, 0xB0, 0x3E, 0x0D, 0x80, 0xF0,
  0x7C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x3C, 0xE0, 0xC1, 0x86,
  0x03, 0x38, 0x0F, 0xC0, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xC0, 0x33,
  0x81, 0xC6, 0x0E, 0x1C, 0x30, 0x3B, 0xC0, 0x70, 0xE0, 0x1D, 0x80, 0xE7,
  0x03, 0x8C, 0x0C, 0x30, 0x70, 0xE1, 0xC1, 0x86, 0x07, 0x38, 0x0C, 0xC0,
  0x33, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x0B, 0xC0, 0x3E, 0x00, 0x7F, 0xC0, 0x18, 0x07, 0x01,
  0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xF0, 0xC0, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C,
  0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0xE0, 0x70, 0xF0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x87, 0x83, 0x80, 0x7E,
  0x0F, 0xFF, 0xE0, 0xFC,
};

const GFXglyph NotoSans_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 11, 2, -19 },
  { 16, 16, 19, 17, 1, -19 },
  { 54, 12, 23, 15, 2, -21 },
  { 89, 20, 20, 22, 1, -20 },
  { 139, 19, 20, 20, 1, -20 },
  { 187, 2, 7, 6, 2, -19 },
  { 189, 6, 23, 8, 1, -19 },
  { 207, 6, 23, 8, 1, -19 },
  { 225, 13, 13, 15, 1, -21 },
  { 247, 13, 13, 15, 1, -16 },
  { 269, 4, 6, 7, 1, -3 },
  { 272, 7, 2, 9, 1, -8 },
  { 274, 3, 3, 7, 2, -3 },
  { 276, 10, 19, 10, 0, -19 },
  { 300, 13, 20, 15, 1, -20 },
  { 333, 8, 19, 15, 2, -19 },
  { 352, 13, 20, 15, 1, -20 },
  { 385, 13, 20, 15, 1, -20 },
  { 418, 14, 19, 15, 1, -19 },
  { 452, 12, 19, 15, 2, -19 },
  { 481, 13, 20, 15, 1, -20 },
  { 514, 13, 19, 15, 1, -19 },
  { 545, 13, 20, 15, 1, -20 },
  { 578, 13, 20, 15, 1, -20 },
  { 611, 3, 15, 7, 2, -15 },
  { 617, 4, 18, 7, 1, -15 },
  { 626, 13, 13, 15, 1, -16 },
  { 648, 12, 7, 15, 2, -13 },
  { 659, 13, 13, 15, 1, -16 },
  { 681, 11, 20, 12, 0, -20 },
  { 709, 21, 21, 24, 2, -19 },
  { 765, 17, 19, 17, 0, -19 },
  { 806, 13, 19, 18, 3, -19 },
  { 837, 14, 20, 17, 2, -20 },
  { 872, 15, 19, 20, 3, -19 },
  { 908, 10, 19, 15, 3, -19 },
  { 932, 10, 19, 14, 3, -19 },
  { 956, 16, 20, 20, 2, -20 },
  { 996, 14, 19, 20, 3, -19 },
  { 1030, 7, 19, 9, 1, -19 },
  { 1047, 7, 24, 7, -2, -19 },
  { 1068, 14, 19, 17, 3, -19 },
  { 1102, 10, 19, 14, 3, -19 },
  { 1126, 19, 19, 24, 3, -19 },
  { 1172, 15, 19, 21, 3, -19 },
  { 1208, 17, 20, 21, 2, -20 },
  { 1251, 12, 19, 16, 3, -19 },
  { 1280, 17, 25, 21, 2, -20 },
  { 1334, 13, 19, 17, 3, -19 },
  { 1365, 13, 20, 15, 1, -20 },
  { 1398, 15, 19, 15, 0, -19 },
  { 1434, 15, 19, 20, 2, -19 },
  { 1470, 16, 19, 16, 0, -19 },
  { 1508, 25, 19, 25, 0, -19 },
  { 1568, 16, 19, 16, 0, -19 },
  { 1606, 15, 19, 15, 0, -19 },
  { 1642, 13, 19, 15, 1, -19 },
  { 1673, 6, 23, 9, 2, -19 },
  { 1691, 10, 19, 10, 0, -19 },
  { 1715, 6, 23, 9, 1, -19 },
  { 1733, 13, 12, 15, 1, -19 },
  { 1753, 12, 2, 12, 0, 2 },
  { 1756, 6, 5, 8, 1, -21 },
  { 1760, 12, 15, 15, 1, -15 },
  { 1783, 13, 21, 17, 2, -21 },
  { 1818, 11, 15, 13, 1, -15 },
  { 1839, 13, 21, 17, 1, -21 },
  { 1874, 13, 15, 15, 1, -15 },
  { 1899, 10, 21, 9, 0, -21 },
  { 1926, 13, 21, 17, 1, -15 },
  { 1961, 13, 21, 17, 2, -21 },
  { 1996, 3, 20, 7, 2, -20 },
  { 2004, 6, 26, 7, -1, -20 },
  { 2024, 12, 21, 14, 2, -21 },
  { 2056, 3, 21, 7, 2, -21 },
  { 2064, 21, 15, 25, 2, -15 },
  { 2104, 13, 15, 17, 2, -15 },
  { 2129, 14, 15, 16, 1, -15 },
  { 2156, 13, 21, 17, 2, -15 },
  { 2191, 13, 21, 17, 1, -15 },
  { 2226, 9, 15, 11, 2, -15 },
  { 2243, 11, 15, 13, 1, -15 },
  { 2264, 9, 18, 10, 0, -18 },
  { 2285, 12, 14, 17, 2, -14 },
  { 2306, 14, 14, 14, 0, -14 },
  { 2331, 21, 15, 21, 0, -15 },
  { 2371, 14, 14, 14, 0, -14 },
  { 2396, 14, 20, 14, 0, -14 },
  { 2431, 11, 14, 13, 1, -14 },
  { 2451, 8, 23, 10, 1, -19 },
  { 2474, 2, 28, 15, 6, -21 },
  { 2481, 9, 23, 10, 1, -19 },
  { 2507, 13, 3, 15, 1, -11 },
};

const GFXfont NotoSans_Regular27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular27pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_REGULAR27PT7B_H_
