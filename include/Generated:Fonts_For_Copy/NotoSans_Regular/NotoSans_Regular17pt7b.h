#ifndef _NOTOSANS_REGULAR17PT7B_H_
#define _NOTOSANS_REGULAR17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x55, 0x4F, 0xDE, 0xF7, 0x10, 0x08, 0x81, 0x10, 0x26, 0x3F,
  0xF7, 0xFE, 0x22, 0x04, 0x47, 0xFE, 0x12, 0x06, 0x40, 0x88, 0x11, 0x00,
  0x10, 0x10, 0x7E, 0xD0, 0xD0, 0xD0, 0x78, 0x1E, 0x13, 0x13, 0x92, 0xFC,
  0x10, 0x10, 0x70, 0xC9, 0x88, 0x89, 0x88, 0x90, 0x8B, 0x09, 0xAF, 0x75,
  0x90, 0x59, 0x09, 0x91, 0x99, 0x10, 0x93, 0x0E, 0x3C, 0x0C, 0xC1, 0x88,
  0x33, 0x03, 0xC0, 0x70, 0x1B, 0x1E, 0x32, 0x83, 0xD8, 0x33, 0x0F, 0x3F,
  0x30, 0xFE, 0x36, 0x4C, 0x88, 0x88, 0x88, 0xCC, 0x46, 0x30, 0x89, 0xB2,
  0x49, 0x25, 0xB5, 0xA0, 0x10, 0x10, 0x91, 0xFF, 0x18, 0x28, 0x6E, 0x24,
  0x10, 0x10, 0x10, 0xFF, 0xFF, 0x10, 0x10, 0x10, 0xFE, 0xF0, 0xF0, 0x0C,
  0x30, 0x86, 0x10, 0x43, 0x08, 0x61, 0x84, 0x30, 0x7C, 0x46, 0xC2, 0xC3,
  0x83, 0x83, 0x83, 0x83, 0xC3, 0xC2, 0x66, 0x3C, 0x37, 0x91, 0x11, 0x11,
  0x11, 0x11, 0x7C, 0xC6, 0x02, 0x02, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0xFF, 0x7C, 0x86, 0x02, 0x02, 0x06, 0x38, 0x0E, 0x03, 0x03, 0x03,
  0x86, 0xFC, 0x03, 0x03, 0x83, 0xC3, 0x61, 0x31, 0x99, 0x8C, 0x86, 0xFF,
  0x81, 0x80, 0xC0, 0x60, 0x7E, 0x40, 0x40, 0x40, 0xC0, 0xFE, 0x02, 0x03,
  0x03, 0x03, 0x86, 0xFC, 0x3E, 0x60, 0x40, 0xC0, 0xD8, 0xBE, 0xC3, 0x83,
  0xC3, 0xC3, 0x66, 0x3C, 0xFF, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x7E, 0xC2, 0xC2, 0xC2, 0x66, 0x38, 0x6E, 0xC3,
  0x83, 0x83, 0xC2, 0x7C, 0x7C, 0xC6, 0xC2, 0x83, 0x83, 0xC3, 0x7F, 0x03,
  0x02, 0x06, 0x0C, 0x78, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE8, 0x03, 0x0E,
  0x38, 0xE0, 0xE0, 0x38, 0x0E, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x70,
  0x1C, 0x07, 0x07, 0x1C, 0xE0, 0x80, 0xFD, 0x0C, 0x08, 0x30, 0x41, 0x04,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x0F, 0xC1, 0x81, 0x98, 0x04, 0x8F, 0x1C,
  0xCC, 0xC4, 0x46, 0x62, 0x33, 0x11, 0x88, 0xDE, 0x7B, 0x90, 0x00, 0xC0,
  0x03, 0xFC, 0x01, 0x00, 0x0C, 0x01, 0xC0, 0x28, 0x0D, 0x81, 0x30, 0x22,
  0x0C, 0x61, 0xFC, 0x60, 0x8C, 0x19, 0x01, 0x60, 0x30, 0xFC, 0x86, 0x83,
  0x83, 0x82, 0xFC, 0x86, 0x83, 0x83, 0x83, 0x87, 0xFC, 0x1F, 0xB8, 0x58,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x23, 0xF0, 0xFC,
  0x43, 0xA0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xA1, 0xDF,
  0x80, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08,
  0x20, 0x83, 0xFF, 0xE0, 0x82, 0x08, 0x20, 0x1F, 0xCC, 0x16, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0x01, 0xC0, 0x58, 0x13, 0x04, 0x7F, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1F, 0xFE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0xF6, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x13, 0xE0, 0x83, 0x43, 0x23, 0x13, 0x0B, 0x07, 0x83, 0x61, 0x30, 0x8C,
  0x43, 0x20, 0x90, 0x70, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x3F, 0xC0, 0x7E, 0x07, 0xE0, 0x7A, 0x0F, 0xB0, 0xB9, 0x1B, 0x91, 0x39,
  0x93, 0x8B, 0x38, 0xE3, 0x8E, 0x38, 0x43, 0xC0, 0xE0, 0x78, 0x36, 0x19,
  0x0C, 0xC6, 0x33, 0x09, 0x86, 0xC1, 0xE0, 0x70, 0x30, 0x3F, 0x8E, 0x19,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x6C, 0x09, 0xC7,
  0x0F, 0xC0, 0xFD, 0x0E, 0x0C, 0x18, 0x30, 0xFF, 0x40, 0x81, 0x02, 0x04,
  0x00, 0x3F, 0x8E, 0x19, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x6C, 0x09, 0xC7, 0x0F, 0xC0, 0x30, 0x03, 0x00, 0x38, 0xFC, 0x86,
  0x82, 0x82, 0x82, 0x8E, 0xF8, 0x8C, 0x8C, 0x86, 0x82, 0x83, 0x7E, 0xC2,
  0xC0, 0xC0, 0xE0, 0x78, 0x1E, 0x06, 0x03, 0x02, 0x86, 0xFC, 0xFF, 0x84,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF8,
  0xCF, 0xC0, 0xC0, 0xD0, 0x36, 0x09, 0x86, 0x21, 0x8C, 0x43, 0x30, 0x48,
  0x1A, 0x07, 0x80, 0xC0, 0x30, 0xC1, 0x83, 0x41, 0x82, 0x43, 0x86, 0x62,
  0xC6, 0x62, 0x44, 0x26, 0x44, 0x26, 0x6C, 0x34, 0x6C, 0x34, 0x28, 0x1C,
  0x28, 0x18, 0x38, 0x18, 0x10, 0xC0, 0xD8, 0x63, 0x30, 0x48, 0x1E, 0x03,
  0x00, 0xC0, 0x58, 0x33, 0x08, 0x46, 0x1B, 0x03, 0xC0, 0xD8, 0x66, 0x10,
  0xCC, 0x12, 0x07, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0, 0xFF, 0xFC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0x06, 0x08, 0x20, 0xC1,
  0x04, 0x18, 0x20, 0xC1, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0,
  0x10, 0x38, 0x2C, 0x24, 0x46, 0x42, 0x83, 0xFF, 0xC8, 0x80, 0x7C, 0x8C,
  0x08, 0x17, 0xF8, 0x60, 0xE3, 0x7A, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xE7,
  0x1B, 0x05, 0x82, 0xC1, 0xE0, 0xB0, 0x5C, 0x6D, 0xE0, 0x3E, 0xC3, 0x06,
  0x08, 0x18, 0x30, 0x31, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x7D, 0x43, 0xC3,
  0xC3, 0x81, 0xC3, 0xC3, 0x63, 0x7D, 0x3C, 0x46, 0xC3, 0xC3, 0xFF, 0xC0,
  0xC0, 0x61, 0x3E, 0x1E, 0x60, 0x81, 0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x7D, 0x43, 0xC3, 0xC3, 0x81, 0xC1, 0xC3, 0x63, 0x3D,
  0x01, 0x03, 0x46, 0x7C, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xE3, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x70, 0xFF, 0xFF, 0xC0, 0x13, 0x00, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xE0, 0xC0, 0xC0, 0xC0, 0xC1, 0xC6, 0xCC,
  0xD8, 0xD0, 0xF8, 0xC8, 0xCC, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0xFB, 0x8E, 0x2C, 0x30, 0xB0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0,
  0xC3, 0xC3, 0x0C, 0xDE, 0xE3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0x3E, 0x43, 0xC3, 0xC1, 0x81, 0xC1, 0xC3, 0x63, 0x3E, 0xDE, 0x71, 0xB0,
  0x58, 0x2C, 0x1E, 0x0B, 0x05, 0xC6, 0xDE, 0x60, 0x30, 0x18, 0x0C, 0x00,
  0x7D, 0x43, 0xC3, 0xC3, 0x81, 0xC3, 0xC3, 0x63, 0x3D, 0x01, 0x01, 0x01,
  0x01, 0xDF, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x7E, 0x18, 0x38, 0x38,
  0x30, 0x61, 0xF8, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0x83, 0xC0,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0x43, 0x7D, 0xC1, 0xA1, 0x98,
  0xCC, 0x42, 0x61, 0xB0, 0x50, 0x38, 0x18, 0x00, 0xC3, 0x1A, 0x38, 0xD1,
  0x44, 0xCB, 0x26, 0xCB, 0x14, 0x58, 0xA3, 0x87, 0x1C, 0x18, 0x60, 0xE3,
  0x91, 0x0D, 0x83, 0x81, 0x80, 0xA0, 0xD8, 0xC6, 0xC1, 0x80, 0xC1, 0xA1,
  0x98, 0xCC, 0x42, 0x61, 0xB0, 0x50, 0x38, 0x18, 0x04, 0x06, 0x06, 0x0E,
  0x00, 0xFC, 0x30, 0x84, 0x31, 0x84, 0x30, 0xFC, 0x0C, 0x61, 0x04, 0x10,
  0x43, 0x38, 0x30, 0x41, 0x04, 0x10, 0x70, 0xC0, 0xFF, 0xFF, 0x80, 0xC3,
  0x18, 0xC6, 0x30, 0xC3, 0x23, 0x18, 0xC6, 0x62, 0x00, 0xF1, 0x9F,
};

const GFXglyph NotoSans_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 5, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 11, 12, 11, 0, -12 },
  { 24, 8, 14, 10, 1, -13 },
  { 38, 12, 12, 14, 1, -12 },
  { 56, 11, 12, 12, 1, -12 },
  { 73, 2, 4, 4, 1, -12 },
  { 74, 4, 15, 5, 1, -12 },
  { 82, 3, 15, 5, 1, -12 },
  { 88, 8, 8, 9, 1, -13 },
  { 96, 8, 8, 10, 1, -10 },
  { 104, 2, 4, 5, 1, -2 },
  { 105, 4, 1, 5, 1, -5 },
  { 106, 2, 2, 5, 1, -2 },
  { 107, 6, 12, 6, 0, -12 },
  { 116, 8, 12, 10, 1, -12 },
  { 128, 4, 12, 10, 2, -12 },
  { 134, 8, 12, 10, 1, -12 },
  { 146, 8, 12, 10, 1, -12 },
  { 158, 9, 12, 10, 0, -12 },
  { 172, 8, 12, 10, 1, -12 },
  { 184, 8, 12, 10, 1, -12 },
  { 196, 8, 12, 10, 1, -12 },
  { 208, 8, 12, 10, 1, -12 },
  { 220, 8, 12, 10, 1, -12 },
  { 232, 2, 9, 5, 1, -9 },
  { 235, 2, 11, 5, 1, -9 },
  { 238, 8, 8, 10, 1, -10 },
  { 246, 8, 4, 10, 1, -8 },
  { 250, 8, 8, 10, 1, -10 },
  { 258, 7, 12, 7, 0, -12 },
  { 269, 13, 14, 15, 1, -12 },
  { 292, 11, 12, 11, 0, -12 },
  { 309, 8, 12, 11, 2, -12 },
  { 321, 9, 12, 11, 1, -12 },
  { 335, 9, 12, 12, 2, -12 },
  { 349, 6, 12, 9, 2, -12 },
  { 358, 6, 12, 9, 2, -12 },
  { 367, 10, 12, 12, 1, -12 },
  { 382, 9, 12, 13, 2, -12 },
  { 396, 4, 12, 6, 1, -12 },
  { 402, 4, 15, 5, -1, -12 },
  { 410, 9, 12, 11, 2, -12 },
  { 424, 6, 12, 9, 2, -12 },
  { 433, 12, 12, 15, 2, -12 },
  { 451, 9, 12, 13, 2, -12 },
  { 465, 11, 12, 13, 1, -12 },
  { 482, 7, 12, 10, 2, -12 },
  { 493, 11, 15, 13, 1, -12 },
  { 514, 8, 12, 11, 2, -12 },
  { 526, 8, 12, 9, 1, -12 },
  { 538, 9, 12, 9, 0, -12 },
  { 552, 9, 12, 12, 2, -12 },
  { 566, 10, 12, 10, 0, -12 },
  { 581, 16, 12, 16, 0, -12 },
  { 605, 10, 12, 10, 0, -12 },
  { 620, 10, 12, 10, 0, -12 },
  { 635, 8, 12, 10, 1, -12 },
  { 647, 4, 15, 6, 1, -12 },
  { 655, 6, 12, 6, 0, -12 },
  { 664, 4, 15, 6, 0, -12 },
  { 672, 8, 7, 10, 1, -12 },
  { 679, 8, 1, 8, 0, 2 },
  { 680, 3, 3, 5, 1, -13 },
  { 682, 7, 9, 10, 1, -9 },
  { 690, 9, 13, 10, 1, -13 },
  { 705, 7, 9, 8, 1, -9 },
  { 713, 8, 13, 10, 1, -13 },
  { 726, 8, 9, 10, 1, -9 },
  { 735, 7, 13, 6, 0, -13 },
  { 747, 8, 13, 10, 1, -9 },
  { 760, 8, 13, 11, 1, -13 },
  { 773, 2, 13, 4, 1, -13 },
  { 777, 4, 17, 4, -1, -13 },
  { 786, 8, 13, 9, 1, -13 },
  { 799, 2, 13, 4, 1, -13 },
  { 803, 14, 9, 16, 1, -9 },
  { 819, 8, 9, 11, 1, -9 },
  { 828, 8, 9, 10, 1, -9 },
  { 837, 9, 13, 10, 1, -9 },
  { 852, 8, 13, 10, 1, -9 },
  { 865, 6, 9, 7, 1, -9 },
  { 872, 6, 9, 8, 1, -9 },
  { 879, 6, 11, 6, 0, -11 },
  { 888, 8, 9, 11, 1, -9 },
  { 897, 9, 9, 9, 0, -9 },
  { 908, 13, 9, 13, 0, -9 },
  { 923, 9, 9, 9, 0, -9 },
  { 934, 9, 13, 9, 0, -9 },
  { 949, 6, 9, 8, 1, -9 },
  { 956, 6, 15, 6, 0, -12 },
  { 968, 1, 17, 9, 4, -13 },
  { 971, 5, 15, 6, 1, -12 },
  { 981, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_Regular17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular17pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_REGULAR17PT7B_H_
