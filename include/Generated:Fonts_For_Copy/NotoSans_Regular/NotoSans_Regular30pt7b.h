#ifndef _NOTOSANS_REGULAR30PT7B_H_
#define _NOTOSANS_REGULAR30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x04, 0xFF, 0xF0,
  0xE7, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0x03, 0x86, 0x00, 0xC1, 0x80,
  0x30, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x07, 0xFF, 0xFD, 0xFF,
  0xFF, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x38,
  0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0x70, 0xC0, 0x18, 0x30, 0x06, 0x1C, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x38, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x3F, 0xE7, 0xFF, 0xF9, 0x9B, 0x8C, 0x18, 0x60, 0xE3, 0x07, 0x18, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x0C, 0xE0, 0x63, 0x03, 0x18, 0x18,
  0xE0, 0xCF, 0xFF, 0xEF, 0xFE, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x20, 0xFC, 0x03, 0x07, 0x30, 0x1C, 0x18, 0x60, 0x60, 0x61,
  0x83, 0x01, 0x86, 0x0C, 0x0E, 0x18, 0x60, 0x38, 0x63, 0x80, 0x61, 0x8C,
  0x01, 0x86, 0x73, 0xC6, 0x19, 0x9F, 0x9C, 0xCE, 0xE7, 0x3F, 0x33, 0x0C,
  0x31, 0x8C, 0x30, 0x06, 0x30, 0xC0, 0x30, 0xC3, 0x01, 0xC3, 0x0C, 0x06,
  0x0C, 0x30, 0x38, 0x30, 0xC0, 0xC0, 0xC3, 0x07, 0x01, 0xF8, 0x38, 0x03,
  0xE0, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00, 0x30,
  0x30, 0x03, 0x03, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x1D, 0xE0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x0E, 0x79, 0xC0, 0xCF, 0x0E, 0x1C,
  0xE0, 0x71, 0xCC, 0x03, 0xB8, 0xC0, 0x1F, 0x0C, 0x00, 0xF0, 0xE0, 0x1F,
  0x0F, 0x07, 0xF8, 0x7F, 0xF1, 0xC3, 0xFE, 0x0F, 0xFF, 0xFD, 0xB0, 0x0E,
  0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0xE0, 0xE0,
  0xC1, 0xC1, 0x83, 0x87, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x18, 0x70, 0xE1, 0x87, 0x0E, 0x38, 0x61, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x83, 0x07, 0xEC, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x3B, 0x00, 0xCE, 0x07, 0x1C, 0x38, 0x70, 0x21, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x3B, 0x9C, 0xE6, 0x33, 0x00, 0xFF, 0xFC, 0x4F, 0xFF,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x7F, 0xC1, 0xC1,
  0xC7, 0x01, 0xCE, 0x03, 0x9C, 0x03, 0x30, 0x06, 0x60, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEC, 0x01, 0xD8, 0x03, 0xB0, 0x06, 0x70,
  0x1C, 0xE0, 0x38, 0xC0, 0x61, 0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x0F,
  0x1F, 0x3F, 0xF7, 0xE7, 0x47, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x03, 0x80, 0x3F, 0xE1,
  0xFF, 0xE3, 0x81, 0xC2, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0xFF, 0xCF, 0xFF, 0x98, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0xFC, 0x03, 0xFC, 0x00,
  0x78, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xF8,
  0x0E, 0xFF, 0xF9, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xB0, 0x03, 0xB0, 0x07, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x1C,
  0x30, 0x18, 0x30, 0x38, 0x30, 0x70, 0x30, 0x60, 0x30, 0xC0, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x7F, 0xF3, 0xFF, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xFF, 0xC7, 0xFF, 0x10, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xF0, 0x3D, 0xFF, 0xC7, 0xFC, 0x00,
  0x01, 0xF0, 0x3F, 0xC1, 0xFB, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x3F, 0x8D, 0xFF, 0x3C, 0x0E, 0xE0, 0x1B, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x67, 0x03, 0x9E, 0x1E, 0x3F,
  0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFB,
  0xE3, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x18, 0x0E, 0x38, 0x38,
  0x3D, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xC7, 0x8E, 0x07, 0x9C, 0x07, 0x30,
  0x07, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x73, 0xC1, 0xE3, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0xC1, 0xC7, 0x01, 0xCC, 0x03,
  0x98, 0x03, 0x70, 0x06, 0x60, 0x0E, 0xC0, 0x1D, 0xC0, 0x79, 0xC3, 0xF3,
  0xFE, 0xC1, 0xF1, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x83, 0xFE, 0x07, 0xF0, 0x00, 0x4F, 0xFF, 0x40, 0x00, 0x00,
  0x00, 0x04, 0xFF, 0xF0, 0x23, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xCE, 0x73, 0x39, 0x8C, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x1C, 0x00, 0x20, 0x00, 0x00, 0x07, 0x0F, 0xFC, 0x7F, 0xE4, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3C, 0x01, 0xC0, 0xE0,
  0x01, 0xC3, 0x80, 0x01, 0xCE, 0x03, 0x01, 0x98, 0x3F, 0xE3, 0xB0, 0xF1,
  0xC3, 0xC1, 0x83, 0x87, 0x87, 0x07, 0x0F, 0x0C, 0x0C, 0x1E, 0x18, 0x18,
  0x3C, 0x30, 0x30, 0x78, 0x60, 0x60, 0xF0, 0xE1, 0xC3, 0x61, 0xC7, 0xCE,
  0xE1, 0xFD, 0xF8, 0xC0, 0xE0, 0xC1, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x04, 0x01, 0xF0, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07,
  0x70, 0x00, 0xE6, 0x00, 0x18, 0xE0, 0x07, 0x1C, 0x00, 0xE1, 0x80, 0x38,
  0x38, 0x07, 0x07, 0x00, 0xC0, 0x60, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xC0,
  0x1C, 0x38, 0x03, 0x86, 0x00, 0x31, 0xC0, 0x07, 0x38, 0x00, 0xE6, 0x00,
  0x0F, 0xC0, 0x01, 0xC0, 0xFF, 0xF1, 0xFF, 0xF3, 0x80, 0xF7, 0x00, 0xEE,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0C, 0xE0, 0x79, 0xFF, 0xC3, 0xFF,
  0xC7, 0x01, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3B, 0x81, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0x1F, 0xFF, 0x3C, 0x02, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3E, 0x02,
  0x0F, 0xFE, 0x07, 0xFE, 0xFF, 0xF0, 0x7F, 0xFC, 0x38, 0x0F, 0x1C, 0x01,
  0xCE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x0F, 0x70, 0x0F, 0x38, 0x3F, 0x1F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x78, 0x04, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x73, 0xC0, 0x1C,
  0x7C, 0x07, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xFF, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0xFF, 0xFB, 0xC0, 0xE0, 0x1E,
  0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x80,
  0xE7, 0x00, 0xEE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0xE3, 0x80,
  0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xB0, 0x01, 0xBD, 0xC0,
  0x1D, 0xE6, 0x00, 0xCF, 0x38, 0x06, 0x79, 0xC0, 0x73, 0xC6, 0x03, 0x1E,
  0x38, 0x18, 0xF1, 0xC1, 0xC7, 0x86, 0x0C, 0x3C, 0x38, 0xE1, 0xE0, 0xC6,
  0x0F, 0x07, 0x30, 0x78, 0x3B, 0x83, 0xC0, 0xD8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0x80, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xC0, 0x3E, 0x70, 0x1F, 0x38, 0x0F, 0x8E,
  0x07, 0xC3, 0x83, 0xE1, 0xC1, 0xF0, 0x70, 0xF8, 0x1C, 0x7C, 0x0E, 0x3E,
  0x03, 0x9F, 0x00, 0xEF, 0x80, 0x77, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xC0, 0x78, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x1C, 0x38, 0x03, 0xC3, 0xE0, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0xE3, 0xFF, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x06, 0xE0, 0x3B, 0x81, 0xEF, 0xFF, 0x3F, 0xF0, 0xFF, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xC0, 0x78, 0x78,
  0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x03,
  0xC3, 0xE0, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0xFF, 0xE1, 0xFF,
  0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0C,
  0xE0, 0x39, 0xC1, 0xE3, 0xFF, 0x87, 0xFC, 0x0E, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0x73, 0x80, 0x77, 0x00, 0xEE, 0x00,
  0xE0, 0x07, 0x81, 0xFF, 0xDF, 0xFD, 0xE0, 0x2E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x78,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x81, 0xEF, 0xFE, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x0F,
  0xF0, 0xE0, 0x01, 0xD8, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x03, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x06, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0C,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xE0, 0x0F, 0x00, 0xF7, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x00, 0xE7,
  0x01, 0xF0, 0x0C, 0x30, 0x1B, 0x81, 0xC3, 0x81, 0xB8, 0x1C, 0x38, 0x39,
  0x81, 0xC3, 0x83, 0x9C, 0x18, 0x18, 0x31, 0xC3, 0x81, 0xC3, 0x0C, 0x38,
  0x1C, 0x70, 0xE3, 0x80, 0xC7, 0x0E, 0x30, 0x0C, 0x60, 0x67, 0x00, 0xEE,
  0x06, 0x70, 0x0E, 0xE0, 0x77, 0x00, 0x6C, 0x07, 0x60, 0x06, 0xC0, 0x36,
  0x00, 0x6C, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0x83, 0x81, 0x80,
  0xE1, 0xC0, 0x71, 0xC0, 0x1C, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x37, 0x00, 0x39, 0xC0, 0x38, 0xE0, 0x18,
  0x38, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x01, 0xCE, 0x00, 0xFE, 0x00, 0x38,
  0xE0, 0x03, 0xB8, 0x03, 0x8C, 0x01, 0x87, 0x01, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFC,
  0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF,
  0xF0, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x6C, 0x01, 0x9C,
  0x03, 0x18, 0x0C, 0x38, 0x18, 0x30, 0x60, 0x70, 0xC0, 0x63, 0x80, 0xE6,
  0x00, 0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x86, 0x0C,
  0x1F, 0xE1, 0xFF, 0x84, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x07, 0xE3,
  0xFF, 0x7C, 0x1B, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xB8, 0x3D, 0xFF,
  0x67, 0xF3, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x33, 0xF8, 0xDF, 0xF3, 0xC1, 0xEE, 0x03, 0xB8, 0x06, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xB8,
  0x0E, 0xF0, 0x73, 0x7F, 0xCC, 0xFC, 0x00, 0x1F, 0xE7, 0xFD, 0xE0, 0xF8,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x4F, 0xF8, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xF7, 0x3F, 0xFD, 0xC1, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0x70, 0x7C, 0xFF, 0xF1, 0xFC, 0xC0, 0x1F, 0xC1,
  0xFF, 0x9C, 0x1C, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x0C, 0xFF, 0xE1, 0xFE,
  0x03, 0xF0, 0x7E, 0x0E, 0x20, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0xFC,
  0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x1F,
  0xCC, 0xFF, 0xB7, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xC1, 0xF3,
  0xFF, 0xC7, 0xF7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x60, 0x79,
  0xFF, 0xC3, 0xFE, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x19, 0xFC, 0xDF, 0xF7, 0x83, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x7D, 0x80, 0x1B, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xC0, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x01, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x1C, 0x3F, 0xEF, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x0E, 0xC0, 0xE6, 0x0E, 0x30, 0xE1, 0x8E,
  0x0C, 0xE0, 0x6E, 0x03, 0xF0, 0x1F, 0xC0, 0xE7, 0x06, 0x3C, 0x30, 0xE1,
  0x83, 0x8C, 0x0E, 0x60, 0x7B, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xCF, 0xC3, 0xF9, 0xBF, 0xCF, 0xFB, 0xC1, 0xF0, 0x77, 0x03, 0xC0,
  0x6E, 0x03, 0x80, 0xF8, 0x07, 0x01, 0xF0, 0x0C, 0x03, 0xE0, 0x18, 0x07,
  0xC0, 0x30, 0x0F, 0x80, 0x60, 0x1F, 0x00, 0xC0, 0x3E, 0x01, 0x80, 0x7C,
  0x03, 0x00, 0xF8, 0x06, 0x01, 0xF0, 0x0C, 0x03, 0xE0, 0x18, 0x07, 0xCF,
  0xE6, 0xFF, 0xBC, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x1F, 0xE0, 0x7F, 0xE1, 0xE0, 0xE7, 0x00, 0xEE, 0x01, 0xDC, 0x01,
  0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x1B, 0x80, 0x37, 0x00, 0xE7,
  0x01, 0xCF, 0x0F, 0x0F, 0xFC, 0x07, 0xF0, 0xCF, 0xE3, 0x7F, 0xCF, 0x07,
  0xB8, 0x0E, 0xE0, 0x3B, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x0E, 0xE0, 0x3B, 0xC1, 0xCD, 0xFF, 0x33, 0xF0, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0xCC, 0xFF, 0xB7, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xC1,
  0xF3, 0xFF, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0xCF, 0xEF, 0xFE, 0x1E, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x3F,
  0xFF, 0xFB, 0x81, 0x60, 0x0C, 0x01, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0xC0,
  0x78, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xFF, 0xF7, 0xFC, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x7F, 0xFF, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xFC, 0x3F, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x3D, 0xC1, 0xF7, 0xFE,
  0xC7, 0xF3, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x73, 0x80, 0xE3, 0x01, 0xC7,
  0x07, 0x0E, 0x0E, 0x0E, 0x18, 0x1C, 0x70, 0x18, 0xE0, 0x39, 0x80, 0x77,
  0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0xC0,
  0x78, 0x1D, 0xC0, 0xF0, 0x3B, 0x83, 0xE0, 0x63, 0x06, 0xE1, 0xC7, 0x0C,
  0xC3, 0x8E, 0x39, 0x86, 0x1C, 0x63, 0x8C, 0x18, 0xC7, 0x38, 0x3B, 0x86,
  0x70, 0x76, 0x0C, 0xC0, 0x6C, 0x1D, 0x80, 0xD8, 0x1F, 0x01, 0xF0, 0x3C,
  0x03, 0xC0, 0x78, 0x03, 0x80, 0x70, 0xE0, 0x1D, 0xC0, 0xE3, 0x87, 0x0E,
  0x1C, 0x1C, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x01,
  0xCC, 0x07, 0x38, 0x38, 0x71, 0xC0, 0xE7, 0x03, 0xB8, 0x07, 0xE0, 0x0E,
  0xC0, 0x1D, 0xC0, 0x33, 0x80, 0xE3, 0x81, 0xC7, 0x07, 0x06, 0x0E, 0x0E,
  0x18, 0x1C, 0x70, 0x18, 0xE0, 0x39, 0x80, 0x37, 0x00, 0x6E, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0x87, 0xC3, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0x0E, 0x07, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1F, 0x07, 0x80, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3E, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x3E, 0x03,
  0xC1, 0xF0, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC3, 0xE0, 0xF0, 0x30, 0x00, 0x18, 0x02, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xE0,
};

const GFXglyph NotoSans_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 8, 7, 12, 2, -21 },
  { 19, 18, 21, 19, 1, -21 },
  { 67, 13, 25, 17, 2, -23 },
  { 108, 22, 22, 25, 1, -22 },
  { 169, 20, 22, 22, 2, -22 },
  { 224, 3, 7, 7, 2, -21 },
  { 227, 7, 26, 9, 1, -21 },
  { 250, 7, 26, 9, 1, -21 },
  { 273, 14, 14, 17, 1, -23 },
  { 298, 15, 15, 17, 1, -18 },
  { 327, 5, 7, 8, 1, -3 },
  { 332, 7, 2, 10, 1, -9 },
  { 334, 4, 4, 8, 2, -4 },
  { 336, 11, 21, 11, 0, -21 },
  { 365, 15, 22, 17, 1, -22 },
  { 407, 8, 21, 17, 3, -21 },
  { 428, 15, 22, 17, 1, -22 },
  { 470, 14, 22, 17, 1, -22 },
  { 509, 16, 22, 17, 1, -22 },
  { 553, 13, 21, 17, 2, -21 },
  { 588, 14, 22, 17, 2, -22 },
  { 627, 15, 21, 17, 1, -21 },
  { 667, 15, 22, 17, 1, -22 },
  { 709, 15, 22, 17, 1, -22 },
  { 751, 4, 17, 8, 2, -17 },
  { 760, 5, 21, 8, 1, -17 },
  { 774, 15, 15, 17, 1, -18 },
  { 803, 13, 8, 17, 2, -15 },
  { 816, 15, 15, 17, 1, -18 },
  { 845, 12, 22, 13, 0, -22 },
  { 878, 23, 24, 27, 2, -21 },
  { 947, 19, 22, 19, 0, -22 },
  { 1000, 15, 21, 20, 3, -21 },
  { 1040, 16, 22, 19, 2, -22 },
  { 1084, 17, 21, 22, 3, -21 },
  { 1129, 12, 21, 17, 3, -21 },
  { 1161, 12, 21, 16, 3, -21 },
  { 1193, 18, 22, 22, 2, -22 },
  { 1243, 16, 21, 22, 3, -21 },
  { 1285, 8, 21, 10, 1, -21 },
  { 1306, 7, 27, 8, -2, -21 },
  { 1330, 16, 21, 19, 3, -21 },
  { 1372, 12, 21, 16, 3, -21 },
  { 1404, 21, 21, 27, 3, -21 },
  { 1460, 17, 21, 23, 3, -21 },
  { 1505, 20, 22, 23, 2, -22 },
  { 1560, 14, 21, 18, 3, -21 },
  { 1597, 20, 27, 23, 2, -22 },
  { 1665, 15, 21, 19, 3, -21 },
  { 1705, 13, 22, 16, 2, -22 },
  { 1741, 16, 21, 17, 0, -21 },
  { 1783, 16, 21, 22, 3, -21 },
  { 1825, 18, 21, 18, 0, -21 },
  { 1873, 28, 21, 28, 0, -21 },
  { 1947, 17, 21, 18, 0, -21 },
  { 1992, 17, 21, 17, 0, -21 },
  { 2037, 15, 21, 17, 1, -21 },
  { 2077, 7, 26, 10, 2, -21 },
  { 2100, 11, 21, 11, 0, -21 },
  { 2129, 6, 26, 10, 1, -21 },
  { 2149, 15, 14, 17, 1, -22 },
  { 2176, 13, 2, 13, 0, 3 },
  { 2180, 6, 5, 8, 1, -23 },
  { 2184, 13, 16, 17, 1, -16 },
  { 2210, 14, 23, 18, 3, -23 },
  { 2251, 11, 16, 14, 2, -16 },
  { 2273, 14, 23, 18, 2, -23 },
  { 2314, 13, 16, 17, 2, -16 },
  { 2340, 12, 23, 10, 0, -23 },
  { 2375, 14, 23, 18, 2, -16 },
  { 2416, 13, 23, 19, 3, -23 },
  { 2454, 3, 22, 8, 2, -22 },
  { 2463, 7, 29, 8, -2, -22 },
  { 2489, 13, 23, 16, 3, -23 },
  { 2527, 2, 23, 8, 3, -23 },
  { 2533, 23, 16, 28, 3, -16 },
  { 2579, 13, 16, 19, 3, -16 },
  { 2605, 15, 16, 18, 2, -16 },
  { 2635, 14, 23, 18, 3, -16 },
  { 2676, 14, 23, 18, 2, -16 },
  { 2717, 9, 16, 12, 3, -16 },
  { 2735, 11, 16, 14, 2, -16 },
  { 2757, 10, 20, 11, 0, -20 },
  { 2782, 14, 16, 19, 2, -16 },
  { 2810, 15, 16, 15, 0, -16 },
  { 2840, 23, 16, 24, 0, -16 },
  { 2886, 14, 16, 16, 1, -16 },
  { 2914, 15, 23, 15, 0, -16 },
  { 2958, 12, 16, 14, 1, -16 },
  { 2982, 9, 26, 11, 1, -21 },
  { 3012, 2, 30, 17, 7, -23 },
  { 3020, 10, 26, 11, 1, -21 },
  { 3053, 15, 4, 17, 1, -13 },
};

const GFXfont NotoSans_Regular30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular30pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_REGULAR30PT7B_H_
