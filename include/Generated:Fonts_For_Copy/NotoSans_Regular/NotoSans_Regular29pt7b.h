#ifndef _NOTOSANS_REGULAR29PT7B_H_
#define _NOTOSANS_REGULAR29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x04, 0xFF, 0xE0,
  0xE7, 0xE7, 0xC7, 0xC7, 0xC3, 0xC3, 0xC2, 0xC2, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x30, 0xC1, 0xFF, 0xFE, 0xFF,
  0xFF, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x07,
  0xFF, 0xFB, 0xFF, 0xFC, 0x30, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18,
  0x03, 0x0C, 0x03, 0x0E, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x7F, 0xE7,
  0xFF, 0x73, 0x0B, 0x18, 0x18, 0xC0, 0xE6, 0x07, 0xB0, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x03, 0x78, 0x18, 0xE0, 0xC7, 0x06, 0x3C, 0x31, 0xFF, 0xFD,
  0xFF, 0xC0, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0xFC,
  0x06, 0x06, 0x30, 0x38, 0x18, 0x60, 0xC0, 0x61, 0x87, 0x03, 0x86, 0x18,
  0x0E, 0x18, 0xC0, 0x38, 0x63, 0x00, 0x61, 0x98, 0xC1, 0x8E, 0x6F, 0xC6,
  0x33, 0x33, 0x8F, 0xDD, 0xC6, 0x1E, 0x66, 0x18, 0x03, 0x98, 0x70, 0x0C,
  0x60, 0xC0, 0x61, 0x83, 0x01, 0x86, 0x1C, 0x0C, 0x18, 0x60, 0x30, 0x31,
  0x81, 0x80, 0xFE, 0x0E, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0xE3,
  0x80, 0x18, 0x38, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x18, 0x01, 0xCF,
  0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3D, 0xC0, 0xEF, 0x1C,
  0x19, 0xC1, 0xC7, 0x30, 0x1E, 0xE6, 0x01, 0xF8, 0xC0, 0x1E, 0x1C, 0x03,
  0xE3, 0xC1, 0xFE, 0x3F, 0xF9, 0xE3, 0xFC, 0x1E, 0xFF, 0x6D, 0xB6, 0x0E,
  0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0xC1, 0x83, 0x87, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0xC0, 0xC1,
  0xC1, 0x83, 0x83, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xE1, 0xC3, 0x06,
  0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0xE3, 0x1B, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F,
  0x80, 0x33, 0x01, 0xCE, 0x0E, 0x1C, 0x08, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7B, 0x9C, 0xC6,
  0x73, 0x00, 0xFF, 0xFC, 0x4F, 0xFE, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x07,
  0xC0, 0x7F, 0x83, 0xC7, 0x0C, 0x0E, 0x70, 0x19, 0x80, 0x76, 0x01, 0xD8,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x76,
  0x01, 0xD8, 0x07, 0x70, 0x18, 0xC0, 0xE3, 0x87, 0x87, 0xFC, 0x0F, 0xE0,
  0x06, 0x1C, 0xFB, 0xBE, 0x78, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x0F, 0xC0, 0xFF, 0xC7, 0x87,
  0x18, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC1, 0xFF, 0xCF,
  0x07, 0x90, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x7F, 0x81, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x7C, 0x07, 0xBF, 0xFC, 0x7F, 0xE0, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x66, 0x01, 0x8C, 0x07, 0x18,
  0x0C, 0x30, 0x30, 0x60, 0xE0, 0xC3, 0x81, 0x86, 0x03, 0x18, 0x06, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xEF, 0x07, 0xFE, 0x1C, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xB0, 0x3D, 0xFF, 0xCF, 0xF8, 0x00,
  0x03, 0xF0, 0x7F, 0x8F, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC7, 0xC6, 0xFF, 0x3E, 0x1D, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x3B, 0x01, 0xDC, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x06, 0x70, 0x19, 0xC0, 0x67, 0x01,
  0x8E, 0x0E, 0x3C, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0x7C, 0x38, 0x39, 0xC0,
  0x76, 0x01, 0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x77, 0x03, 0x8F, 0xFE, 0x1F,
  0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0x8F, 0x1C, 0x0E, 0x60, 0x19, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0x60, 0x1D, 0xC0, 0x77, 0x03, 0xCF, 0xFF, 0x1F, 0xDC,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x0F, 0xF0,
  0x3F, 0x80, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFE, 0x33, 0xDE,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x67, 0x31, 0x80, 0x00,
  0x04, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x1F, 0x8F, 0xFC, 0x70, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0E, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x3E, 0x07, 0x80,
  0x1C, 0x38, 0x00, 0x38, 0xC0, 0x00, 0x66, 0x07, 0xF1, 0xD8, 0x7F, 0xC3,
  0xC1, 0x83, 0x0F, 0x0C, 0x0C, 0x3C, 0x30, 0x30, 0xF0, 0xC0, 0xC3, 0xC7,
  0x07, 0x0F, 0x0C, 0x1C, 0x3C, 0x30, 0x70, 0xF0, 0xE3, 0xC6, 0xC1, 0xF9,
  0xF3, 0x83, 0xC3, 0x86, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x80,
  0x7E, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x00, 0xCE,
  0x00, 0x38, 0xC0, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x30, 0x06, 0x07,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xC0, 0x18, 0x30, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x07, 0x30, 0x00, 0xEE, 0x00, 0x0E, 0xFF, 0x03,
  0xFF, 0xCF, 0xFF, 0xB0, 0x0E, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB0, 0x0E,
  0xC0, 0x3B, 0xFF, 0x8F, 0xFE, 0x30, 0x3E, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xBF, 0xFC, 0xFF, 0xE0, 0x03,
  0xF8, 0x1F, 0xFC, 0x7C, 0x79, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF8, 0x18, 0xFF,
  0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xC0, 0x3C, 0xC0,
  0x0E, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xC0,
  0x0E, 0xC0, 0x3C, 0xC0, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xC7,
  0xE3, 0xC7, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x01, 0xCF, 0x80, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF0, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC3, 0x87, 0xFD, 0xF1, 0x00, 0xC0, 0x1F, 0x80, 0x3B, 0x00,
  0xE6, 0x03, 0x8C, 0x0E, 0x18, 0x38, 0x30, 0xE0, 0x63, 0x80, 0xCE, 0x01,
  0xBC, 0x03, 0xF8, 0x07, 0xB8, 0x0E, 0x38, 0x18, 0x70, 0x30, 0x70, 0x60,
  0x70, 0xC0, 0x71, 0x80, 0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x01, 0xE0, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x7F, 0xFF, 0xFE, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xD8, 0x01, 0xBD, 0xC0, 0x1B, 0xCC, 0x03, 0xBC, 0xC0, 0x33,
  0xCE, 0x03, 0x3C, 0x60, 0x63, 0xC7, 0x06, 0x3C, 0x70, 0xE3, 0xC3, 0x0C,
  0x3C, 0x38, 0xC3, 0xC1, 0x9C, 0x3C, 0x19, 0x83, 0xC1, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x60, 0x30, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xDC, 0x03, 0xDC, 0x03, 0xCE, 0x03, 0xCE,
  0x03, 0xC7, 0x03, 0xC3, 0x83, 0xC3, 0x83, 0xC1, 0xC3, 0xC0, 0xE3, 0xC0,
  0xE3, 0xC0, 0x73, 0xC0, 0x3B, 0xC0, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xF8, 0x7C, 0x1C, 0x01,
  0xC7, 0x00, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x37, 0x00, 0x0E, 0x70, 0x01, 0xCF, 0x00, 0x70, 0xF0, 0x3C,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFE, 0x07, 0xFF, 0x3F, 0xFD, 0x80, 0xEC,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xB0, 0xFD, 0xFF,
  0xCF, 0xF0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xF8, 0x7C, 0x1C,
  0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x37, 0x00, 0x0E, 0x70, 0x01, 0xCF, 0x00, 0x70, 0xF0,
  0x3C, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC6,
  0x03, 0xCC, 0x03, 0x98, 0x07, 0x30, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80,
  0xE3, 0xFF, 0x87, 0xFC, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x38, 0x60, 0x70,
  0xC0, 0x71, 0x80, 0x63, 0x00, 0xE6, 0x00, 0xEC, 0x01, 0xE0, 0x0F, 0xE0,
  0xFF, 0xE3, 0xC7, 0x9C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x18, 0x00, 0xEE, 0x07, 0xBF, 0xFC, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0x78, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0xE0,
  0x01, 0xF0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x38,
  0xE0, 0x38, 0x30, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x03, 0x07, 0x01, 0xC3,
  0x00, 0xE3, 0x80, 0x31, 0xC0, 0x1C, 0xC0, 0x0E, 0xE0, 0x03, 0x70, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xEC,
  0x01, 0xC0, 0x19, 0xC0, 0x78, 0x07, 0x38, 0x0F, 0x80, 0xE7, 0x01, 0xB0,
  0x18, 0x60, 0x36, 0x03, 0x0E, 0x0E, 0xE0, 0xE1, 0xC1, 0x9C, 0x1C, 0x18,
  0x31, 0x83, 0x03, 0x0E, 0x38, 0x60, 0x71, 0xC7, 0x1C, 0x0E, 0x30, 0x63,
  0x80, 0xCE, 0x0C, 0x60, 0x19, 0xC1, 0xDC, 0x03, 0xB0, 0x3B, 0x80, 0x76,
  0x03, 0x70, 0x07, 0xC0, 0x6C, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x70, 0x07, 0x38, 0x03, 0x8E,
  0x03, 0x83, 0x01, 0x81, 0xC1, 0xC0, 0x71, 0xC0, 0x18, 0xC0, 0x0E, 0xE0,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B,
  0x80, 0x38, 0xE0, 0x18, 0x30, 0x1C, 0x1C, 0x1C, 0x07, 0x0C, 0x03, 0x8E,
  0x00, 0xEE, 0x00, 0x38, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0E, 0x38, 0x0E,
  0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x07, 0x60,
  0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0E, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x0C, 0x00, 0x78, 0x01, 0xE0, 0x0C, 0xC0, 0x33, 0x01, 0x86, 0x06,
  0x1C, 0x30, 0x30, 0xC0, 0xE7, 0x01, 0x98, 0x07, 0xE0, 0x0C, 0xFF, 0xF8,
  0xF1, 0xC3, 0x87, 0x07, 0xC1, 0xFF, 0x8F, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE3, 0xFF, 0x3F, 0x3B, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xB8, 0x3D, 0xFF, 0x67, 0xF3, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x3C, 0x3B, 0xFC, 0xFC, 0xFB, 0xC0, 0xEF, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7F, 0x01, 0xFE, 0x0E, 0xFF, 0xF3, 0x1F, 0x80, 0x0F, 0x87, 0xFD, 0xF3,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x4F, 0xF8, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x3C, 0x67, 0xFB, 0x78, 0xFF, 0x81, 0xF8, 0x0F,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xF8,
  0x0E, 0xE0, 0xF3, 0xFD, 0x8F, 0xCC, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0,
  0xEE, 0x03, 0x60, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x3C, 0x08, 0xFF, 0xC3, 0xFE, 0x07, 0xE1, 0xFC, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xF7, 0xFE, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x0F, 0x19, 0xFE, 0xDE, 0x3E, 0xE0, 0x7E, 0x03, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x03,
  0xB8, 0x3C, 0xFF, 0x63, 0xF3, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x76,
  0x0F, 0x3F, 0xF0, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x3C, 0x3B, 0xFC, 0xFC, 0x7B, 0xC0, 0xEF, 0x01,
  0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0xFD, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x1C, 0x18, 0x00, 0x01, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1F, 0xF7, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0xFC, 0x0E, 0xE0, 0xE7, 0x0E, 0x38, 0xE1, 0xCE,
  0x0E, 0xE0, 0x7F, 0x03, 0xFC, 0x1E, 0xE0, 0xE3, 0x87, 0x0E, 0x38, 0x39,
  0xC1, 0xCE, 0x07, 0x70, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE3, 0xC1, 0xF1, 0xDF, 0xE7, 0xF3, 0xF3, 0xDC, 0xF7, 0x81,
  0xE0, 0x6F, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C,
  0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0,
  0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07,
  0xE3, 0xC3, 0xBF, 0xCF, 0xC7, 0xBC, 0x0E, 0xF0, 0x1B, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0x0F, 0x80, 0xFF, 0x87, 0xCF, 0x1C, 0x0E, 0xE0,
  0x1B, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0x39, 0xC1, 0xE3, 0xFF, 0x07, 0xF0, 0xE3, 0xC3, 0xBF, 0xCF,
  0xCF, 0xBC, 0x0E, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xEF, 0xFF, 0x39, 0xF8,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x0F, 0x19, 0xFE, 0xDE, 0x3E, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xB8, 0x3C,
  0xFF, 0x63, 0xF3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0xE3, 0xFB, 0xEF, 0xEB, 0xE0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0F,
  0x83, 0xFE, 0x70, 0xE6, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x74, 0x0E, 0x7F, 0xE7, 0xF8, 0x08,
  0x06, 0x01, 0x80, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0xF0, 0xFC, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xB8, 0x3D, 0xFF, 0x67,
  0xF3, 0xE0, 0x0F, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xE3, 0x01, 0x87, 0x07,
  0x0E, 0x0C, 0x0C, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x33, 0x80, 0x77, 0x00,
  0x6C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x38, 0x0D, 0x80, 0xE0,
  0x36, 0x07, 0x81, 0xDC, 0x1F, 0x07, 0x70, 0x6C, 0x18, 0xC3, 0xB0, 0x63,
  0x8E, 0xE3, 0x8E, 0x31, 0x8E, 0x19, 0xC6, 0x30, 0x67, 0x1D, 0xC1, 0xD8,
  0x77, 0x07, 0x60, 0xD8, 0x0F, 0x83, 0x60, 0x3C, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0xE0, 0x1D, 0x80, 0xE7, 0x07, 0x0E, 0x18, 0x18, 0xE0,
  0x77, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x3E, 0x01, 0xDC, 0x07, 0x38,
  0x38, 0x61, 0xC1, 0xC6, 0x03, 0xB8, 0x07, 0xE0, 0x0F, 0xC0, 0x19, 0xC0,
  0x73, 0x80, 0xE3, 0x01, 0x87, 0x07, 0x0E, 0x0E, 0x0C, 0x38, 0x1C, 0x70,
  0x18, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0x83, 0xC3, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x0F, 0x07, 0x80, 0xE0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1F, 0x07, 0x80, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x78, 0x1E, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x78, 0x3C, 0x38, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x61, 0xF0, 0xF0, 0x40, 0x00, 0x3E,
  0x07, 0xFF, 0x7C, 0x3F, 0xE0, 0x18,
};

const GFXglyph NotoSans_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 8, 8, 12, 2, -21 },
  { 20, 17, 21, 19, 1, -21 },
  { 65, 13, 24, 17, 2, -22 },
  { 104, 22, 21, 24, 1, -21 },
  { 162, 19, 21, 21, 2, -21 },
  { 212, 3, 8, 7, 2, -21 },
  { 215, 7, 26, 9, 1, -21 },
  { 238, 7, 26, 9, 1, -21 },
  { 261, 14, 13, 16, 1, -22 },
  { 284, 14, 14, 17, 1, -17 },
  { 309, 5, 7, 8, 1, -3 },
  { 314, 7, 2, 9, 1, -9 },
  { 316, 4, 4, 8, 2, -4 },
  { 318, 11, 21, 11, 0, -21 },
  { 347, 14, 21, 17, 1, -21 },
  { 384, 7, 21, 17, 3, -21 },
  { 403, 14, 21, 17, 1, -21 },
  { 440, 14, 21, 17, 1, -21 },
  { 477, 15, 21, 17, 1, -21 },
  { 517, 13, 21, 17, 2, -21 },
  { 552, 13, 21, 17, 2, -21 },
  { 587, 14, 21, 17, 1, -21 },
  { 624, 14, 21, 17, 1, -21 },
  { 661, 14, 21, 17, 1, -21 },
  { 698, 4, 16, 8, 2, -16 },
  { 706, 5, 20, 8, 1, -16 },
  { 719, 14, 15, 17, 1, -18 },
  { 746, 13, 8, 17, 2, -14 },
  { 759, 14, 15, 17, 1, -18 },
  { 786, 12, 21, 13, 0, -21 },
  { 818, 22, 24, 26, 2, -21 },
  { 884, 19, 21, 19, 0, -21 },
  { 934, 14, 21, 19, 3, -21 },
  { 971, 15, 21, 18, 2, -21 },
  { 1011, 16, 21, 21, 3, -21 },
  { 1053, 11, 21, 16, 3, -21 },
  { 1082, 11, 21, 15, 3, -21 },
  { 1111, 17, 21, 21, 2, -21 },
  { 1156, 16, 21, 21, 3, -21 },
  { 1198, 8, 21, 10, 1, -21 },
  { 1219, 7, 27, 8, -2, -21 },
  { 1243, 15, 21, 18, 3, -21 },
  { 1283, 11, 21, 15, 3, -21 },
  { 1312, 20, 21, 26, 3, -21 },
  { 1365, 16, 21, 22, 3, -21 },
  { 1407, 19, 21, 23, 2, -21 },
  { 1457, 13, 21, 18, 3, -21 },
  { 1492, 19, 26, 23, 2, -21 },
  { 1554, 15, 21, 18, 3, -21 },
  { 1594, 14, 21, 16, 1, -21 },
  { 1631, 16, 21, 16, 0, -21 },
  { 1673, 16, 21, 21, 3, -21 },
  { 1715, 17, 21, 17, 0, -21 },
  { 1760, 27, 21, 27, 0, -21 },
  { 1831, 17, 21, 17, 0, -21 },
  { 1876, 16, 21, 16, 0, -21 },
  { 1918, 14, 21, 17, 1, -21 },
  { 1955, 7, 26, 10, 2, -21 },
  { 1978, 11, 21, 11, 0, -21 },
  { 2007, 6, 26, 10, 1, -21 },
  { 2027, 14, 13, 17, 1, -21 },
  { 2050, 13, 1, 13, 0, 3 },
  { 2052, 6, 4, 8, 1, -22 },
  { 2055, 13, 16, 16, 1, -16 },
  { 2081, 14, 22, 18, 2, -22 },
  { 2120, 11, 16, 14, 2, -16 },
  { 2142, 13, 22, 18, 2, -22 },
  { 2178, 13, 16, 16, 2, -16 },
  { 2204, 11, 22, 10, 0, -22 },
  { 2235, 13, 23, 18, 2, -16 },
  { 2273, 14, 22, 18, 2, -22 },
  { 2312, 3, 21, 7, 2, -21 },
  { 2320, 7, 28, 7, -2, -21 },
  { 2345, 13, 22, 15, 2, -22 },
  { 2381, 3, 22, 7, 2, -22 },
  { 2390, 23, 16, 27, 2, -16 },
  { 2436, 14, 16, 18, 2, -16 },
  { 2464, 14, 16, 18, 2, -16 },
  { 2492, 14, 23, 18, 2, -16 },
  { 2533, 13, 23, 18, 2, -16 },
  { 2571, 10, 16, 12, 2, -16 },
  { 2591, 12, 16, 14, 1, -16 },
  { 2615, 10, 19, 10, 0, -19 },
  { 2639, 13, 16, 18, 2, -16 },
  { 2665, 15, 16, 15, 0, -16 },
  { 2695, 22, 16, 23, 0, -16 },
  { 2739, 14, 16, 15, 1, -16 },
  { 2767, 15, 23, 15, 0, -16 },
  { 2811, 12, 16, 14, 1, -16 },
  { 2835, 9, 26, 11, 1, -21 },
  { 2865, 2, 29, 16, 7, -22 },
  { 2873, 9, 26, 11, 1, -21 },
  { 2903, 14, 4, 17, 1, -12 },
};

const GFXfont NotoSans_Regular29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular29pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_REGULAR29PT7B_H_
