#ifndef _NOTOSANS_REGULAR41PT7B_H_
#define _NOTOSANS_REGULAR41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0x90, 0xF1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0xE0, 0xDC, 0x18, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x60, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x01, 0xC1,
  0xC0, 0x01, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0xE7, 0xFF, 0xFB, 0xC7, 0x04, 0xE1, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x3F, 0x70, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0x1F, 0x01, 0xC3,
  0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x0F, 0x81, 0xC3, 0xFC, 0x77, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x80, 0xFF, 0x00, 0x1C, 0x03,
  0xFC, 0x00, 0x70, 0x1C, 0x38, 0x03, 0x80, 0x70, 0xE0, 0x1E, 0x03, 0x81,
  0xC0, 0x70, 0x0E, 0x07, 0x03, 0xC0, 0x38, 0x1C, 0x0E, 0x00, 0xE0, 0x70,
  0x70, 0x03, 0x81, 0xC1, 0xC0, 0x0E, 0x07, 0x0E, 0x00, 0x38, 0x1C, 0x38,
  0x00, 0xE0, 0x71, 0xC3, 0xC3, 0x81, 0xCF, 0x3F, 0xC7, 0x0E, 0x39, 0xFF,
  0x9C, 0x39, 0xE7, 0x0E, 0x3F, 0xC7, 0x3C, 0x38, 0x7F, 0x38, 0xE0, 0x70,
  0xF0, 0xE3, 0x81, 0xC0, 0x07, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x1C, 0x00,
  0xE0, 0xE0, 0x70, 0x07, 0x83, 0x81, 0xC0, 0x1C, 0x0E, 0x07, 0x00, 0xF0,
  0x38, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x07,
  0x9E, 0x03, 0x80, 0x0F, 0xF0, 0x1E, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x3C, 0x1F, 0x7C, 0x03, 0xC3, 0xC3, 0xE0, 0x3C,
  0x78, 0x1F, 0x03, 0x87, 0x80, 0xF8, 0x78, 0xF0, 0x07, 0xC7, 0x0F, 0x00,
  0x3E, 0xF0, 0xF0, 0x01, 0xFE, 0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x7C,
  0x07, 0x80, 0x0F, 0xE0, 0x7C, 0x03, 0xFF, 0x03, 0xFF, 0xFC, 0xF8, 0x1F,
  0xFF, 0x87, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0x07,
  0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0,
  0x3C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0x01,
  0xC0, 0x7C, 0x38, 0x77, 0xF6, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xE0, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0xF0,
  0xF8, 0x3E, 0x0F, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xE3, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x90, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xCF, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0E, 0x70,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0xC0,
  0x0E, 0x78, 0x03, 0xC7, 0x80, 0x78, 0xF8, 0x1E, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0xF7, 0xDF, 0xF3,
  0xFC, 0x7B, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xFC, 0x7F, 0x9F, 0xC7, 0x80, 0x78, 0x40, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x03, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7F, 0x9F, 0xC7, 0x00, 0x7C, 0x80, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7B, 0x80, 0x1F,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEE,
  0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00,
  0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0,
  0x38, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xE0, 0x0E, 0x0F, 0x00, 0x38,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC2,
  0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x80, 0x07,
  0xB0, 0x07, 0xCF, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0x08, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x71, 0xFE, 0x0F, 0x7F, 0xF8, 0xF7, 0xFF, 0xCF,
  0xE0, 0x3C, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E,
  0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x01,
  0xE3, 0xC0, 0x1E, 0x1E, 0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x87, 0xC7, 0xC0, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x78, 0xF0, 0x0F,
  0x1F, 0x03, 0xC1, 0xF9, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0x3F, 0x07, 0xC1, 0xF1, 0xE0, 0x0F, 0x38, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x3D,
  0xF0, 0x0F, 0x1F, 0xDF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0xE0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xCF, 0x87, 0xC0, 0x78, 0xF0, 0x07,
  0x9C, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x7F,
  0x3F, 0xFE, 0xE3, 0xFF, 0x9C, 0x1F, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x27, 0xFF,
  0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFF,
  0xE4, 0x08, 0x7C, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE1,
  0xC7, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xEF, 0xE6, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x07, 0xFE, 0x0E, 0x38,
  0x0F, 0xFF, 0x07, 0x38, 0x1E, 0x1E, 0x07, 0x70, 0x3C, 0x0E, 0x07, 0x70,
  0x78, 0x0E, 0x07, 0x70, 0x70, 0x0E, 0x03, 0x70, 0x70, 0x0E, 0x03, 0xE0,
  0x70, 0x0E, 0x03, 0xE0, 0x70, 0x0E, 0x07, 0xE0, 0x70, 0x0E, 0x07, 0xE0,
  0x70, 0x0E, 0x07, 0xE0, 0x70, 0x1E, 0x07, 0x70, 0x78, 0x1E, 0x0E, 0x70,
  0x3C, 0x3F, 0x1E, 0x70, 0x3F, 0xF3, 0xFC, 0x70, 0x1F, 0xE3, 0xF8, 0x38,
  0x01, 0x00, 0x40, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x07, 0xF0, 0x0F, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x03, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x00, 0x7E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xFF, 0x8F,
  0x00, 0xFC, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC,
  0x01, 0x83, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x30, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x80,
  0x3F, 0x8F, 0x00, 0x1F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0,
  0x03, 0xF1, 0xE0, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFC,
  0x00, 0x60, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xFF,
  0x70, 0x01, 0xFF, 0xB8, 0x00, 0xFF, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x8F, 0xC0, 0x03, 0xC3, 0xF8, 0x01, 0xE0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1C, 0xFF, 0xFF, 0xF3, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x87, 0xFB, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xF7, 0xEF,
  0xFB, 0xFC, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x3C, 0x00, 0xF1,
  0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07,
  0x80, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x0F,
  0x78, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0xF8, 0xF0,
  0x07, 0x87, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x1F,
  0x3C, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0xE0, 0x00,
  0x3B, 0xF7, 0x80, 0x01, 0xDF, 0xBC, 0x00, 0x1E, 0xFC, 0xE0, 0x00, 0xE7,
  0xE7, 0x80, 0x0F, 0x3F, 0x1C, 0x00, 0x71, 0xF8, 0xE0, 0x03, 0x8F, 0xC7,
  0x80, 0x3C, 0x7E, 0x1C, 0x01, 0xC3, 0xF0, 0xF0, 0x0E, 0x1F, 0x87, 0x80,
  0xE0, 0xFC, 0x1C, 0x07, 0x07, 0xE0, 0xF0, 0x78, 0x3F, 0x03, 0x83, 0x81,
  0xF8, 0x1C, 0x1C, 0x0F, 0xC0, 0xF1, 0xE0, 0x7E, 0x03, 0x8E, 0x03, 0xF0,
  0x1E, 0xF0, 0x1F, 0x80, 0xF7, 0x00, 0xFC, 0x03, 0xB8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0x70, 0x03, 0x80, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFD, 0xE0, 0x01, 0xFB, 0xE0,
  0x03, 0xF3, 0xC0, 0x07, 0xE3, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x87, 0x80,
  0x3F, 0x07, 0x80, 0x7E, 0x0F, 0x00, 0xFC, 0x0F, 0x01, 0xF8, 0x0F, 0x03,
  0xF0, 0x1E, 0x07, 0xE0, 0x1E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3C, 0x3F,
  0x00, 0x3C, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0x79, 0xF8, 0x00, 0x7B, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x78, 0x0F, 0xCF,
  0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x1F, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xE0, 0x1F, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x0F, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0xF8,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xC0, 0x18, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xD0, 0x00, 0x7B, 0x80, 0x3E, 0x7F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xDE, 0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0xB8, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x3C, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x03, 0xE0, 0x01, 0xE7, 0x80,
  0x0F, 0xC0, 0x07, 0x9E, 0x00, 0x3F, 0x00, 0x1E, 0x3C, 0x00, 0xFC, 0x00,
  0x70, 0xF0, 0x07, 0xF8, 0x03, 0xC3, 0xC0, 0x1D, 0xE0, 0x0F, 0x07, 0x00,
  0x73, 0x80, 0x3C, 0x1E, 0x03, 0xCE, 0x00, 0xE0, 0x78, 0x0F, 0x3C, 0x07,
  0x81, 0xE0, 0x38, 0x70, 0x1E, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x0F, 0x07,
  0x87, 0x83, 0xC0, 0x3C, 0x1C, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x38, 0x3C,
  0x01, 0xC3, 0xC0, 0xF0, 0xE0, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x1E, 0x38,
  0x07, 0x1E, 0x00, 0x78, 0xE0, 0x1C, 0x78, 0x00, 0xE7, 0x80, 0x79, 0xC0,
  0x03, 0xDC, 0x00, 0xEF, 0x00, 0x0F, 0x70, 0x03, 0xBC, 0x00, 0x1D, 0xC0,
  0x0E, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7,
  0x80, 0x01, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x81,
  0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xC0,
  0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x7F, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xB8, 0x00, 0x73, 0x80, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x38, 0x03, 0x83, 0x80,
  0x3C, 0x70, 0x01, 0xC7, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x60, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF,
  0x0F, 0x7C, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0xFD, 0xFF, 0xF7, 0x7F, 0xF9, 0xC7, 0xF8, 0x70,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x1F,
  0xE0, 0xF7, 0xFF, 0x0F, 0xFF, 0xF8, 0xFE, 0x07, 0xCF, 0xC0, 0x1E, 0xF8,
  0x01, 0xEF, 0x80, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xEF, 0x80, 0x1E, 0xFC, 0x01, 0xEF, 0xE0, 0x3C, 0xFF, 0xFF,
  0xCE, 0x7F, 0xF8, 0xE1, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3E, 0x02, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x01, 0x1F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x7F, 0x8F, 0x0F, 0xFE, 0xF1, 0xFF, 0xFF, 0x3E, 0x07, 0xF7, 0xC0,
  0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x3F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xE7, 0x07, 0xF8, 0x70, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0x03, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0x9E, 0x00,
  0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x03, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xF3, 0xFF, 0xE7, 0xFF, 0xC1,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x07, 0xF8, 0x70, 0xFF, 0xE7, 0x1F, 0xFF, 0xF3, 0xE0, 0x7F, 0x3C, 0x01,
  0xF7, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x03, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFE, 0xF0, 0x7F, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE2, 0x00, 0x3E, 0x3E, 0x0F,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x3F, 0xC3, 0xDF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xE0, 0x3D, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x7F, 0xF7,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0xFF, 0xFB, 0xF9, 0xF0, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFB, 0xC0, 0x3E,
  0x78, 0x0F, 0x8F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0x87, 0x80,
  0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFB, 0xC0, 0x3E, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xC0, 0x78, 0x78, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x00, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xFE, 0x07, 0xF8, 0xF7, 0xFF, 0x1F, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFE, 0x07, 0xF8, 0x1E, 0xFC, 0x03, 0xE0, 0x0F,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xE1, 0xFF, 0x1E, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0x01, 0xEF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x07, 0xC3,
  0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00,
  0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x39, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0, 0x0F,
  0x0F, 0x80, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xF1,
  0xFE, 0x0F, 0x7F, 0xF8, 0xFF, 0xFF, 0xCF, 0xE0, 0x7C, 0xFC, 0x03, 0xEF,
  0x80, 0x1E, 0xF8, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0xC0, 0x3E, 0xFE, 0x07, 0xCF, 0xFF,
  0xF8, 0xF7, 0xFF, 0x8F, 0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x70, 0xFF, 0xE7,
  0x1F, 0xFF, 0xF3, 0xE0, 0x7F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x00,
  0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x03, 0xF1, 0xFF, 0xFF, 0x0F, 0xFE, 0xF0,
  0x7F, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0x9F, 0xFD, 0xFF, 0xFE, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x00, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0xF0, 0x04, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x1E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xEF,
  0x00, 0x7D, 0xF0, 0x1F, 0xBF, 0xFF, 0xF3, 0xFF, 0xCE, 0x1F, 0xE1, 0xC0,
  0xF0, 0x00, 0x7B, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0x80,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0x70, 0x1C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x38, 0x00, 0x73, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x78, 0x03, 0xE0, 0x0E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07,
  0xE0, 0x1E, 0x38, 0x07, 0xF0, 0x1E, 0x3C, 0x0F, 0x70, 0x1C, 0x3C, 0x0E,
  0x70, 0x3C, 0x1C, 0x0E, 0x70, 0x3C, 0x1C, 0x1E, 0x78, 0x38, 0x1E, 0x1E,
  0x38, 0x38, 0x1E, 0x1C, 0x38, 0x78, 0x0E, 0x1C, 0x3C, 0x78, 0x0E, 0x3C,
  0x1C, 0x70, 0x0F, 0x38, 0x1C, 0x70, 0x0F, 0x38, 0x1E, 0xF0, 0x07, 0x78,
  0x1E, 0xE0, 0x07, 0x70, 0x0E, 0xE0, 0x07, 0xF0, 0x0E, 0xE0, 0x03, 0xF0,
  0x0F, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x3C, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x3C,
  0x07, 0x87, 0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0x7B,
  0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0x70, 0x07, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x03,
  0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x0E, 0x38,
  0x00, 0x79, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x03, 0xE0, 0xFE, 0x07, 0x80, 0x3F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF8, 0x0F,
  0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xC0,
  0x7E, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0xFE, 0x07,
  0xF0, 0x3E, 0x00, 0x3F, 0x80, 0x2F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xF8,
};

const GFXglyph NotoSans_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 30, 11, 3, -29 },
  { 20, 11, 10, 17, 3, -29 },
  { 34, 24, 29, 26, 1, -29 },
  { 121, 18, 33, 23, 3, -31 },
  { 196, 30, 30, 34, 2, -30 },
  { 309, 28, 30, 30, 2, -30 },
  { 414, 4, 10, 9, 3, -29 },
  { 419, 9, 35, 12, 2, -29 },
  { 459, 10, 35, 12, 1, -29 },
  { 503, 19, 18, 23, 2, -31 },
  { 546, 19, 19, 23, 2, -24 },
  { 592, 6, 10, 11, 2, -5 },
  { 600, 10, 4, 13, 2, -13 },
  { 605, 5, 6, 11, 3, -5 },
  { 609, 15, 29, 15, 0, -29 },
  { 664, 19, 30, 23, 2, -30 },
  { 736, 11, 29, 23, 4, -29 },
  { 776, 19, 30, 23, 2, -30 },
  { 848, 19, 30, 23, 2, -30 },
  { 920, 22, 29, 23, 1, -29 },
  { 1000, 18, 29, 23, 3, -29 },
  { 1066, 20, 30, 23, 2, -30 },
  { 1141, 19, 29, 23, 2, -29 },
  { 1210, 19, 30, 23, 2, -30 },
  { 1282, 19, 30, 23, 2, -30 },
  { 1354, 5, 24, 11, 3, -23 },
  { 1369, 7, 28, 11, 1, -23 },
  { 1394, 19, 20, 23, 2, -25 },
  { 1442, 19, 11, 23, 2, -20 },
  { 1469, 19, 20, 23, 2, -25 },
  { 1517, 17, 31, 18, 0, -30 },
  { 1583, 32, 33, 37, 2, -29 },
  { 1715, 26, 29, 26, 0, -29 },
  { 1810, 20, 29, 27, 4, -29 },
  { 1883, 23, 30, 26, 2, -30 },
  { 1970, 23, 29, 30, 4, -29 },
  { 2054, 16, 29, 23, 4, -29 },
  { 2112, 16, 29, 21, 4, -29 },
  { 2170, 25, 30, 30, 2, -30 },
  { 2264, 22, 29, 30, 4, -29 },
  { 2344, 10, 29, 14, 2, -29 },
  { 2381, 10, 37, 11, -3, -29 },
  { 2428, 21, 29, 25, 4, -29 },
  { 2505, 16, 29, 21, 4, -29 },
  { 2563, 29, 29, 37, 4, -29 },
  { 2669, 23, 29, 31, 4, -29 },
  { 2753, 28, 30, 32, 2, -30 },
  { 2858, 19, 29, 25, 4, -29 },
  { 2927, 28, 37, 32, 2, -30 },
  { 3057, 21, 29, 26, 4, -29 },
  { 3134, 19, 30, 23, 2, -30 },
  { 3206, 22, 29, 23, 0, -29 },
  { 3286, 22, 29, 30, 4, -29 },
  { 3366, 25, 29, 25, 0, -29 },
  { 3457, 38, 29, 38, 0, -29 },
  { 3595, 24, 29, 24, 0, -29 },
  { 3682, 23, 29, 23, 0, -29 },
  { 3766, 20, 29, 23, 2, -29 },
  { 3839, 9, 35, 13, 3, -29 },
  { 3879, 15, 29, 15, 0, -29 },
  { 3934, 9, 35, 13, 1, -29 },
  { 3974, 20, 18, 23, 2, -29 },
  { 4019, 18, 2, 18, 0, 4 },
  { 4024, 8, 6, 12, 2, -31 },
  { 4030, 18, 22, 23, 2, -22 },
  { 4080, 20, 31, 25, 3, -31 },
  { 4158, 16, 22, 20, 2, -22 },
  { 4202, 20, 31, 25, 2, -31 },
  { 4280, 19, 22, 23, 2, -22 },
  { 4333, 15, 31, 14, 1, -31 },
  { 4392, 20, 32, 25, 2, -22 },
  { 4472, 19, 31, 25, 3, -31 },
  { 4546, 4, 30, 11, 3, -30 },
  { 4561, 9, 40, 11, -2, -30 },
  { 4606, 19, 31, 22, 3, -31 },
  { 4680, 4, 31, 11, 3, -31 },
  { 4696, 32, 22, 38, 3, -22 },
  { 4784, 19, 22, 25, 3, -22 },
  { 4837, 21, 22, 25, 2, -22 },
  { 4895, 20, 32, 25, 3, -22 },
  { 4975, 20, 32, 25, 2, -22 },
  { 5055, 13, 22, 17, 3, -22 },
  { 5091, 16, 22, 20, 2, -22 },
  { 5135, 13, 27, 15, 1, -27 },
  { 5179, 19, 22, 25, 3, -22 },
  { 5232, 21, 22, 21, 0, -22 },
  { 5290, 32, 22, 32, 0, -22 },
  { 5378, 20, 22, 22, 1, -22 },
  { 5433, 21, 32, 21, 0, -22 },
  { 5517, 16, 22, 19, 2, -22 },
  { 5561, 13, 35, 16, 1, -29 },
  { 5618, 3, 41, 23, 10, -31 },
  { 5634, 13, 35, 16, 1, -29 },
  { 5691, 19, 5, 23, 2, -17 },
};

const GFXfont NotoSans_Regular41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular41pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_REGULAR41PT7B_H_
