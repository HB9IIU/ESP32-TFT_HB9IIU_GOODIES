#ifndef _NOTOSANS_REGULAR11PT7B_H_
#define _NOTOSANS_REGULAR11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x14, 0x49, 0xF9, 0x42, 0x9F, 0x92, 0x24, 0x26,
  0xA9, 0x83, 0x16, 0xCC, 0x20, 0xC4, 0xA8, 0xA8, 0xB6, 0xD9, 0x29, 0x29,
  0x46, 0x71, 0x23, 0x43, 0x0A, 0x72, 0xA2, 0x7B, 0xE0, 0x29, 0x29, 0x12,
  0x44, 0xC8, 0x92, 0x4A, 0x50, 0x31, 0x7B, 0x1E, 0x30, 0x21, 0x09, 0xF2,
  0x10, 0x70, 0xE0, 0x80, 0x12, 0x22, 0x44, 0x48, 0x74, 0xA3, 0x18, 0xC6,
  0x4E, 0x3C, 0x92, 0x49, 0xF4, 0x84, 0x22, 0x22, 0x1F, 0x79, 0x20, 0x8E,
  0x08, 0x10, 0xFE, 0x08, 0x62, 0x8A, 0x4B, 0xF0, 0x82, 0xF4, 0x21, 0xE1,
  0x04, 0x7E, 0x74, 0x21, 0xE8, 0xC6, 0x2E, 0xFC, 0x20, 0x82, 0x10, 0x42,
  0x18, 0xF4, 0xA4, 0xEF, 0x46, 0x3E, 0x74, 0xA3, 0x3E, 0x84, 0x5C, 0x84,
  0x40, 0x18, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x3E, 0x86, 0x0C, 0x3E, 0x40,
  0xF1, 0x11, 0x24, 0x06, 0x3C, 0x42, 0x9D, 0xA5, 0xA5, 0xA5, 0x9A, 0x80,
  0x7C, 0x10, 0x50, 0xA1, 0x44, 0x4F, 0x91, 0x41, 0xF2, 0x28, 0xBE, 0x8A,
  0x38, 0xBE, 0x7F, 0x08, 0x20, 0x82, 0x0C, 0x1E, 0xF2, 0x38, 0x61, 0x86,
  0x18, 0xFE, 0xF8, 0x8F, 0x88, 0x8F, 0xF8, 0x88, 0xF8, 0x88, 0x3F, 0x08,
  0x20, 0x9E, 0x1C, 0x5F, 0x86, 0x18, 0x7F, 0x86, 0x18, 0x61, 0xE9, 0x24,
  0x97, 0x24, 0x92, 0x49, 0x38, 0x8E, 0x4B, 0x28, 0xE2, 0x48, 0xA3, 0x88,
  0x88, 0x88, 0x8F, 0xC3, 0xC3, 0xC5, 0xA5, 0xA5, 0x99, 0x99, 0x99, 0x87,
  0x1A, 0x69, 0x96, 0x38, 0xE1, 0x79, 0x8A, 0x0C, 0x18, 0x30, 0x61, 0x3C,
  0xF4, 0x63, 0x1F, 0x42, 0x10, 0x79, 0x8A, 0x0C, 0x18, 0x30, 0x61, 0x3C,
  0x08, 0x0C, 0xF2, 0x28, 0xA2, 0xF2, 0x48, 0xA3, 0xF4, 0x21, 0x83, 0x0C,
  0x5E, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x5E, 0x87, 0x89, 0x12, 0x42, 0x85, 0x0C, 0x08, 0x8C, 0x73, 0x14, 0xC9,
  0x2A, 0x52, 0x8C, 0xA3, 0x10, 0x84, 0xC5, 0x22, 0x8C, 0x30, 0xA4, 0xA1,
  0x85, 0x24, 0x8C, 0x30, 0x41, 0x04, 0x7C, 0x20, 0x84, 0x20, 0x84, 0x3F,
  0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0x3C, 0x10,
  0xC2, 0x92, 0xC4, 0xF8, 0xE0, 0x78, 0x4E, 0x9C, 0xBC, 0x84, 0x3D, 0x18,
  0xC6, 0x3E, 0x78, 0x88, 0x8F, 0x08, 0x5F, 0x18, 0xC6, 0x3F, 0x74, 0xBF,
  0x08, 0x38, 0x74, 0xF4, 0x44, 0x44, 0x7C, 0x63, 0x18, 0xFC, 0x33, 0x60,
  0x84, 0x3D, 0x18, 0xC6, 0x31, 0xBF, 0x20, 0x92, 0x49, 0x27, 0x00, 0x84,
  0x27, 0x4C, 0x52, 0xD3, 0xFF, 0xF7, 0x89, 0x89, 0x89, 0x89, 0x89, 0xF4,
  0x63, 0x18, 0xC4, 0x74, 0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10,
  0x80, 0x7C, 0x63, 0x18, 0xFC, 0x21, 0x08, 0xF2, 0x49, 0x00, 0xF8, 0xC3,
  0x1E, 0x4F, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xFC, 0x8D, 0x24, 0x94,
  0x30, 0xC0, 0x89, 0xCC, 0x95, 0x4A, 0xA6, 0x61, 0x10, 0xCD, 0x63, 0x0C,
  0x4B, 0x30, 0x8D, 0x24, 0x94, 0x30, 0xC2, 0x08, 0xC0, 0x78, 0x88, 0x44,
  0x7C, 0x32, 0x22, 0xC4, 0x22, 0x21, 0xFF, 0xE0, 0xC4, 0x22, 0x32, 0x22,
  0x4C, 0xCD, 0x80,
};

const GFXglyph NotoSans_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 1, -8 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 5, 9, 6, 1, -8 },
  { 17, 8, 8, 9, 1, -8 },
  { 25, 7, 8, 8, 1, -8 },
  { 32, 1, 3, 2, 1, -8 },
  { 33, 3, 10, 3, 0, -8 },
  { 37, 3, 10, 3, 0, -8 },
  { 41, 6, 5, 6, 0, -8 },
  { 45, 5, 6, 6, 1, -7 },
  { 49, 2, 2, 3, 0, -1 },
  { 50, 3, 1, 4, 0, -3 },
  { 51, 1, 1, 3, 1, -1 },
  { 52, 4, 8, 4, 0, -8 },
  { 56, 5, 8, 6, 1, -8 },
  { 61, 3, 8, 6, 1, -8 },
  { 64, 5, 8, 6, 1, -8 },
  { 69, 6, 8, 6, 0, -8 },
  { 75, 6, 8, 6, 0, -8 },
  { 81, 5, 8, 6, 1, -8 },
  { 86, 5, 8, 6, 1, -8 },
  { 91, 6, 8, 6, 0, -8 },
  { 97, 5, 8, 6, 1, -8 },
  { 102, 5, 8, 6, 1, -8 },
  { 107, 1, 6, 3, 1, -6 },
  { 108, 2, 7, 3, 0, -6 },
  { 110, 5, 6, 6, 1, -7 },
  { 114, 5, 3, 6, 1, -5 },
  { 116, 5, 6, 6, 1, -7 },
  { 120, 4, 8, 5, 0, -8 },
  { 124, 8, 9, 10, 1, -8 },
  { 133, 7, 8, 7, 0, -8 },
  { 140, 6, 8, 7, 1, -8 },
  { 146, 6, 8, 7, 1, -8 },
  { 152, 6, 8, 8, 1, -8 },
  { 158, 4, 8, 6, 1, -8 },
  { 162, 4, 8, 6, 1, -8 },
  { 166, 6, 8, 8, 1, -8 },
  { 172, 6, 8, 8, 1, -8 },
  { 178, 3, 8, 4, 0, -8 },
  { 181, 3, 10, 3, -1, -8 },
  { 185, 6, 8, 7, 1, -8 },
  { 191, 4, 8, 6, 1, -8 },
  { 195, 8, 8, 10, 1, -8 },
  { 203, 6, 8, 8, 1, -8 },
  { 209, 7, 8, 9, 1, -8 },
  { 216, 5, 8, 7, 1, -8 },
  { 221, 7, 10, 9, 1, -8 },
  { 230, 6, 8, 7, 1, -8 },
  { 236, 5, 8, 6, 1, -8 },
  { 241, 6, 8, 6, 0, -8 },
  { 247, 6, 8, 8, 1, -8 },
  { 253, 7, 8, 7, 0, -8 },
  { 260, 10, 8, 10, 0, -8 },
  { 270, 6, 8, 6, 0, -8 },
  { 276, 6, 8, 6, 0, -8 },
  { 282, 6, 8, 6, 0, -8 },
  { 288, 2, 10, 4, 1, -8 },
  { 291, 4, 8, 4, 0, -8 },
  { 295, 3, 10, 4, 0, -8 },
  { 299, 6, 5, 6, 0, -8 },
  { 303, 5, 1, 5, 0, 1 },
  { 304, 3, 1, 3, 0, -8 },
  { 305, 5, 6, 6, 0, -6 },
  { 309, 5, 8, 7, 1, -8 },
  { 314, 4, 6, 5, 1, -6 },
  { 317, 5, 8, 7, 1, -8 },
  { 322, 5, 6, 6, 1, -6 },
  { 326, 4, 8, 4, 0, -8 },
  { 330, 5, 9, 7, 1, -6 },
  { 336, 5, 8, 7, 1, -8 },
  { 341, 1, 8, 3, 1, -8 },
  { 342, 3, 11, 3, -1, -8 },
  { 347, 5, 8, 6, 1, -8 },
  { 352, 1, 8, 3, 1, -8 },
  { 353, 8, 6, 10, 1, -6 },
  { 359, 5, 6, 7, 1, -6 },
  { 363, 5, 6, 7, 1, -6 },
  { 367, 5, 9, 7, 1, -6 },
  { 373, 5, 9, 7, 1, -6 },
  { 379, 3, 6, 5, 1, -6 },
  { 382, 4, 6, 5, 1, -6 },
  { 385, 4, 7, 4, 0, -7 },
  { 389, 5, 6, 7, 1, -6 },
  { 393, 6, 6, 6, 0, -6 },
  { 398, 9, 6, 9, 0, -6 },
  { 405, 6, 6, 6, 0, -6 },
  { 410, 6, 9, 6, 0, -6 },
  { 417, 5, 6, 5, 0, -6 },
  { 421, 4, 10, 4, 0, -8 },
  { 426, 1, 11, 6, 3, -8 },
  { 428, 4, 10, 4, 0, -8 },
  { 433, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_Regular11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular11pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_REGULAR11PT7B_H_
