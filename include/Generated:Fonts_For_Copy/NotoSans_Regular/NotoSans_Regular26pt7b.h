#ifndef _NOTOSANS_REGULAR26PT7B_H_
#define _NOTOSANS_REGULAR26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE9, 0x24, 0x80, 0xFF, 0x80, 0xCF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x00, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x31, 0x80,
  0x63, 0x01, 0x86, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x60, 0x18, 0xC0, 0x21,
  0x80, 0xC3, 0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x08, 0x60, 0x30, 0xC0,
  0x61, 0x80, 0xC6, 0x00, 0x04, 0x00, 0x80, 0x10, 0x3F, 0xFF, 0xFD, 0x88,
  0x31, 0x06, 0x20, 0xE4, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x4E, 0x08, 0xC1,
  0x18, 0x23, 0xE5, 0xFF, 0xF8, 0xF8, 0x02, 0x00, 0x40, 0x08, 0x00, 0x1C,
  0x03, 0x0F, 0xC0, 0xC1, 0x98, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC1, 0x86,
  0x30, 0x30, 0xC6, 0x06, 0x19, 0x80, 0x43, 0x67, 0xCC, 0xCD, 0xDD, 0xFB,
  0x31, 0x8E, 0x66, 0x30, 0x18, 0xC6, 0x03, 0x18, 0xC0, 0xC3, 0x18, 0x18,
  0x63, 0x06, 0x0C, 0x61, 0xC1, 0xDC, 0x30, 0x1F, 0x00, 0x07, 0x80, 0x07,
  0xF0, 0x03, 0x8E, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0E, 0x18, 0x01, 0x8E,
  0x00, 0x77, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xB8, 0x39, 0xC7, 0x0C,
  0x60, 0xE3, 0x38, 0x1D, 0x8E, 0x03, 0xE3, 0x80, 0x70, 0x70, 0x3E, 0x1F,
  0xFD, 0xC1, 0xFC, 0x3C, 0xFF, 0xFC, 0x0C, 0x63, 0x8C, 0x71, 0x86, 0x38,
  0xE3, 0x0C, 0x30, 0xC3, 0x0E, 0x38, 0x61, 0x87, 0x0C, 0x30, 0x61, 0xC0,
  0xC1, 0x86, 0x0C, 0x30, 0xE1, 0x86, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC6,
  0x18, 0x63, 0x8C, 0x71, 0x8C, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xE6, 0x7F, 0xFF, 0x1F, 0x80, 0xF0, 0x1D, 0x81, 0x9C, 0x38, 0xE1, 0x08,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xE0,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x77, 0x66, 0xEC, 0xFF,
  0xF0, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38,
  0x00, 0x0F, 0x00, 0xFE, 0x0E, 0x38, 0xE0, 0xE6, 0x03, 0x30, 0x1B, 0x80,
  0xDC, 0x06, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x0E, 0x30, 0x61, 0xFF, 0x07, 0xE0, 0x06, 0x1C, 0x7B, 0xBE,
  0x68, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x0F, 0x01, 0xFE, 0x3C, 0x38, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0xFC, 0xF0,
  0xE4, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x1F, 0xC1, 0xF8, 0x03,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x7F, 0xFE, 0x7F,
  0x80, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x06, 0xC0, 0x7E, 0x03, 0x70, 0x33,
  0x83, 0x1C, 0x18, 0xE1, 0x87, 0x18, 0x39, 0xC1, 0xCC, 0x0E, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xCF, 0xF9, 0xFF,
  0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x80, 0xDF, 0xFB, 0xFC, 0x00, 0x03,
  0xE0, 0x7F, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x70,
  0x6F, 0xE7, 0xC7, 0xBC, 0x0D, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0x80, 0xEE,
  0x06, 0x30, 0x71, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x38, 0xC0, 0xE6, 0x03, 0x30, 0x19, 0xC1,
  0xC7, 0x1C, 0x1F, 0xC0, 0x7C, 0x0E, 0x78, 0xE0, 0xE6, 0x03, 0x70, 0x1F,
  0x80, 0xFC, 0x06, 0x60, 0x73, 0xFF, 0x07, 0xF0, 0x0F, 0x01, 0xFE, 0x1E,
  0x38, 0xC0, 0xEE, 0x03, 0x70, 0x1B, 0x80, 0xDC, 0x06, 0x60, 0x3B, 0x83,
  0x8F, 0xFC, 0x3E, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x01, 0xC1,
  0xFC, 0x0F, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x77, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x66, 0xEC, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xE0, 0x08, 0x00,
  0x00, 0x1F, 0x1F, 0xF1, 0x87, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0x07, 0x81,
  0x80, 0x1C, 0x30, 0x00, 0xC6, 0x02, 0x06, 0x61, 0xFC, 0x6C, 0x38, 0xC3,
  0xC7, 0x0C, 0x3C, 0x60, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC3, 0x86, 0x0C,
  0x28, 0x61, 0xC6, 0xC3, 0xF6, 0xCC, 0x3E, 0x78, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x02, 0x01, 0xF3, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x19, 0xC0,
  0x1C, 0x60, 0x0C, 0x38, 0x06, 0x0C, 0x07, 0x06, 0x03, 0xFF, 0x81, 0xFF,
  0xC1, 0x80, 0x60, 0xC0, 0x38, 0xE0, 0x0C, 0x60, 0x07, 0x30, 0x01, 0xB8,
  0x00, 0xE0, 0xFC, 0x07, 0xFE, 0x30, 0xF9, 0x80, 0xEC, 0x07, 0x60, 0x3B,
  0x01, 0xD8, 0x0C, 0xFF, 0xC7, 0xFC, 0x30, 0x79, 0x80, 0xEC, 0x03, 0x60,
  0x1F, 0x00, 0xD8, 0x0E, 0xC0, 0xF7, 0xFF, 0x3F, 0xE0, 0x03, 0xE0, 0x7F,
  0xF3, 0xE3, 0x9E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x08, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x0C, 0x3F,
  0x30, 0x1E, 0xC0, 0x3B, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xB0, 0x0E, 0xC0,
  0xF3, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xEF, 0xFB, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0xF8, 0x73, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0xFF,
  0x01, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB8, 0x03, 0x38,
  0x06, 0x3F, 0xFC, 0x3F, 0xF0, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xC0, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xFB, 0xF8, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE3, 0xBF, 0x78, 0xC0, 0x3E, 0x03, 0xB0, 0x39, 0x83, 0x8C,
  0x38, 0x61, 0x83, 0x18, 0x19, 0x80, 0xD8, 0x07, 0xE0, 0x3B, 0x81, 0x8E,
  0x0C, 0x30, 0x61, 0xC3, 0x07, 0x18, 0x1C, 0xC0, 0xE6, 0x03, 0xB0, 0x0E,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x06, 0xF6,
  0x01, 0xBD, 0x80, 0xCF, 0x70, 0x33, 0xCC, 0x0C, 0xF3, 0x06, 0x3C, 0x61,
  0x8F, 0x18, 0xE3, 0xC7, 0x30, 0xF0, 0xCC, 0x3C, 0x36, 0x0F, 0x0F, 0x83,
  0xC1, 0xE0, 0xF0, 0x70, 0x3C, 0x0C, 0x0C, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0x60, 0x3D, 0xC0, 0xF3, 0x83, 0xC6, 0x0F, 0x1C,
  0x3C, 0x38, 0xF0, 0x63, 0xC1, 0xCF, 0x03, 0xBC, 0x06, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x0F, 0x0E,
  0x01, 0xC6, 0x00, 0x77, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x37, 0x00, 0x1B, 0x80,
  0x1C, 0xE0, 0x0C, 0x38, 0x1E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0x1F,
  0xF3, 0x1F, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x7B,
  0xFE, 0x7E, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x0F, 0x0E, 0x01, 0xC6, 0x00, 0x77,
  0x00, 0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x1C, 0xE0, 0x0C, 0x38,
  0x1E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0xFC, 0x07, 0xFC, 0x31, 0xF1, 0x81, 0xCC, 0x06, 0x60, 0x33,
  0x01, 0x98, 0x0C, 0xC0, 0xE7, 0xFE, 0x3F, 0xC1, 0x86, 0x0C, 0x38, 0x60,
  0xC3, 0x07, 0x18, 0x1C, 0xC0, 0x66, 0x03, 0xB0, 0x0E, 0x0F, 0x83, 0xFF,
  0x78, 0x66, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x3E, 0x01, 0xF8,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x07, 0x80, 0x6F, 0xFE,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xD8, 0x03, 0x38, 0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0x3F, 0x80,
  0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x30, 0x1C,
  0x38, 0x18, 0x18, 0x18, 0x18, 0x38, 0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x70,
  0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0xE0, 0x18, 0x07, 0x60, 0x3C, 0x07, 0x60, 0x3C, 0x06, 0x70,
  0x3C, 0x06, 0x70, 0x3C, 0x0E, 0x30, 0x66, 0x0E, 0x30, 0x66, 0x0C, 0x38,
  0x66, 0x0C, 0x38, 0xE7, 0x1C, 0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x1C,
  0xC3, 0x98, 0x1D, 0x81, 0xB8, 0x0D, 0x81, 0xB0, 0x0D, 0x81, 0xB0, 0x0D,
  0x80, 0xB0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0xE0,
  0x0E, 0xE0, 0x18, 0xC0, 0x61, 0xC1, 0xC1, 0xC3, 0x01, 0x8C, 0x03, 0xB8,
  0x03, 0x60, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x36, 0x00, 0xE6, 0x01,
  0x8E, 0x06, 0x0C, 0x1C, 0x1C, 0x30, 0x1C, 0xE0, 0x1B, 0x80, 0x38, 0xE0,
  0x0E, 0xC0, 0x19, 0xC0, 0x71, 0x80, 0xC3, 0x83, 0x83, 0x0E, 0x07, 0x18,
  0x06, 0x70, 0x0E, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0,
  0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x1A, 0x00, 0x98, 0x0C, 0x40, 0x63,
  0x06, 0x0C, 0x30, 0x63, 0x01, 0x98, 0x0D, 0x80, 0x30, 0xFF, 0xFF, 0xFF,
  0xE3, 0x8C, 0x30, 0x1F, 0xC7, 0xFC, 0x81, 0x80, 0x30, 0x06, 0x00, 0xC7,
  0xFB, 0xC3, 0x60, 0x7C, 0x0F, 0x81, 0xF0, 0x77, 0xFE, 0x7E, 0x40, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x3F, 0x1B, 0xFC,
  0xF0, 0x77, 0x01, 0xB8, 0x0D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xDC,
  0x06, 0xE0, 0x37, 0x83, 0xB7, 0xF9, 0x9F, 0x80, 0x0F, 0xE7, 0xF8, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x13, 0xFC, 0x3F, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x7E, 0x67, 0xFB, 0x70, 0x7B, 0x81, 0xD8, 0x0E, 0xC0, 0x7E,
  0x03, 0xF0, 0x0D, 0x80, 0xEC, 0x07, 0x60, 0x3B, 0x83, 0xCF, 0xF6, 0x3F,
  0x30, 0x0F, 0xC3, 0xFE, 0x30, 0x66, 0x03, 0x60, 0x36, 0x03, 0xFF, 0xFE,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x01, 0x3F, 0xF0, 0xFE, 0x07, 0xC3,
  0xF1, 0xC0, 0x60, 0x18, 0x06, 0x07, 0xFB, 0xFE, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F,
  0x99, 0xFE, 0xDC, 0x1E, 0xE0, 0x76, 0x03, 0xB0, 0x1F, 0x80, 0x7C, 0x03,
  0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xE0, 0xF3, 0xFD, 0x8F, 0xCC, 0x00, 0xE0,
  0x07, 0x00, 0x32, 0x03, 0x8F, 0xF8, 0x7F, 0x80, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xCF, 0xCD, 0xFE, 0xF0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xDD, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x70,
  0x80, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x61, 0xBE, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0xEC, 0x1C, 0xC3, 0x8C, 0x70, 0xCE, 0x0C, 0xC0, 0xDC,
  0x0F, 0xE0, 0xE6, 0x0C, 0x30, 0xC3, 0x8C, 0x1C, 0xC0, 0xEC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xCF, 0xC7, 0xCD, 0xFF, 0xFE,
  0xF0, 0xF8, 0x7E, 0x07, 0x03, 0xE0, 0x70, 0x3E, 0x06, 0x03, 0xE0, 0x60,
  0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06,
  0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03, 0xCF, 0xCD, 0xFE, 0xF0, 0x7E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0x0F, 0xC1, 0xFF, 0x0C, 0x1C, 0xE0, 0x76, 0x01, 0xB0,
  0x0F, 0x80, 0x7C, 0x03, 0x60, 0x1B, 0x00, 0xDC, 0x0E, 0x60, 0xE3, 0xFE,
  0x07, 0xE0, 0xCF, 0xC6, 0xFF, 0x3C, 0x1D, 0xC0, 0xEE, 0x03, 0x70, 0x1B,
  0x80, 0xFC, 0x07, 0xE0, 0x37, 0x01, 0xB8, 0x1D, 0xE0, 0xED, 0xFE, 0x67,
  0xE3, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F,
  0x99, 0xFE, 0xDC, 0x1E, 0xE0, 0x76, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xE0, 0xF3, 0xFD, 0x8F, 0xDC, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0xCF, 0xDF, 0xD8, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x9F,
  0xFE, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x30, 0x0E,
  0x03, 0xFF, 0xDF, 0xC0, 0x18, 0x0C, 0x06, 0x0F, 0xFF, 0xF9, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x3F, 0x0F, 0x80,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0x7F, 0xB3, 0xF3, 0xE0, 0x1B, 0x01,
  0xD8, 0x0C, 0xE0, 0x63, 0x07, 0x18, 0x30, 0xE3, 0x83, 0x18, 0x18, 0xC0,
  0x6E, 0x03, 0x60, 0x1B, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x70, 0x36, 0x07,
  0x07, 0x60, 0xF0, 0x67, 0x0F, 0x86, 0x30, 0xD8, 0x63, 0x19, 0x8E, 0x31,
  0x98, 0xC3, 0x98, 0xCC, 0x1B, 0x0C, 0xC1, 0xB0, 0xDC, 0x1B, 0x07, 0x81,
  0xB0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x70, 0x39, 0x83, 0x8E, 0x18,
  0x39, 0xC0, 0xDC, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x0F, 0x80, 0x66, 0x06,
  0x38, 0x70, 0xC3, 0x03, 0x70, 0x1C, 0xE0, 0x1B, 0x01, 0xD8, 0x0C, 0xE0,
  0x63, 0x07, 0x1C, 0x30, 0x63, 0x83, 0x18, 0x1C, 0xC0, 0x6E, 0x03, 0x60,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x3F,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0,
  0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0x0F, 0x1E,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xE0, 0xF0, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0xF0, 0x70, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x1C, 0x07, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0xF0, 0xE0, 0x3C, 0x0F, 0xF9, 0xF1, 0xFD, 0x00, 0x80,
};

const GFXglyph NotoSans_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 11, 2, -19 },
  { 16, 15, 19, 17, 1, -19 },
  { 52, 11, 22, 15, 2, -20 },
  { 83, 19, 19, 22, 1, -19 },
  { 129, 18, 19, 19, 1, -19 },
  { 172, 2, 7, 6, 2, -19 },
  { 174, 6, 23, 8, 1, -19 },
  { 192, 6, 23, 8, 1, -19 },
  { 210, 12, 12, 14, 1, -20 },
  { 228, 13, 12, 15, 1, -15 },
  { 248, 4, 6, 7, 1, -3 },
  { 251, 6, 2, 8, 1, -8 },
  { 253, 3, 3, 7, 2, -3 },
  { 255, 9, 19, 10, 0, -19 },
  { 277, 13, 19, 15, 1, -19 },
  { 308, 7, 19, 15, 2, -19 },
  { 325, 13, 19, 15, 1, -19 },
  { 356, 12, 19, 15, 1, -19 },
  { 385, 13, 19, 15, 1, -19 },
  { 416, 11, 19, 15, 2, -19 },
  { 443, 13, 19, 15, 1, -19 },
  { 474, 13, 19, 15, 1, -19 },
  { 505, 13, 19, 15, 1, -19 },
  { 536, 13, 19, 15, 1, -19 },
  { 567, 3, 14, 7, 2, -14 },
  { 573, 4, 17, 7, 1, -14 },
  { 582, 13, 13, 15, 1, -16 },
  { 604, 12, 7, 15, 1, -13 },
  { 615, 13, 13, 15, 1, -16 },
  { 637, 11, 19, 11, 0, -19 },
  { 664, 20, 21, 23, 2, -19 },
  { 717, 17, 19, 17, 0, -19 },
  { 758, 13, 19, 17, 3, -19 },
  { 789, 14, 19, 16, 2, -19 },
  { 823, 14, 19, 19, 3, -19 },
  { 857, 10, 19, 14, 3, -19 },
  { 881, 10, 19, 14, 3, -19 },
  { 905, 15, 19, 19, 2, -19 },
  { 941, 14, 19, 19, 3, -19 },
  { 975, 7, 19, 9, 1, -19 },
  { 992, 7, 24, 7, -2, -19 },
  { 1013, 13, 19, 16, 3, -19 },
  { 1044, 10, 19, 14, 3, -19 },
  { 1068, 18, 19, 24, 3, -19 },
  { 1111, 14, 19, 20, 3, -19 },
  { 1145, 17, 19, 20, 2, -19 },
  { 1186, 11, 19, 16, 3, -19 },
  { 1213, 17, 23, 20, 2, -19 },
  { 1262, 13, 19, 16, 3, -19 },
  { 1293, 12, 19, 14, 1, -19 },
  { 1322, 14, 19, 14, 0, -19 },
  { 1356, 15, 19, 19, 2, -19 },
  { 1392, 16, 19, 16, 0, -19 },
  { 1430, 24, 19, 24, 0, -19 },
  { 1487, 15, 19, 15, 0, -19 },
  { 1523, 15, 19, 15, 0, -19 },
  { 1559, 13, 19, 15, 1, -19 },
  { 1590, 6, 23, 9, 2, -19 },
  { 1608, 9, 19, 10, 0, -19 },
  { 1630, 5, 23, 9, 1, -19 },
  { 1645, 13, 12, 15, 1, -19 },
  { 1665, 12, 2, 12, 0, 2 },
  { 1668, 5, 4, 7, 1, -20 },
  { 1671, 11, 14, 15, 1, -14 },
  { 1691, 13, 20, 16, 2, -20 },
  { 1724, 11, 14, 12, 1, -14 },
  { 1744, 13, 20, 16, 1, -20 },
  { 1777, 12, 14, 15, 1, -14 },
  { 1798, 10, 20, 9, 0, -20 },
  { 1823, 13, 20, 16, 1, -14 },
  { 1856, 12, 20, 16, 2, -20 },
  { 1886, 3, 19, 7, 2, -19 },
  { 1894, 6, 25, 7, -1, -19 },
  { 1913, 12, 20, 14, 2, -20 },
  { 1943, 3, 20, 7, 2, -20 },
  { 1951, 20, 14, 24, 2, -14 },
  { 1986, 12, 14, 16, 2, -14 },
  { 2007, 13, 14, 16, 1, -14 },
  { 2030, 13, 20, 16, 2, -14 },
  { 2063, 13, 20, 16, 1, -14 },
  { 2096, 8, 14, 11, 2, -14 },
  { 2110, 10, 14, 12, 1, -14 },
  { 2128, 9, 17, 9, 0, -17 },
  { 2148, 12, 14, 16, 2, -14 },
  { 2169, 13, 14, 13, 0, -14 },
  { 2192, 20, 14, 20, 0, -14 },
  { 2227, 13, 14, 14, 0, -14 },
  { 2250, 13, 20, 13, 0, -14 },
  { 2283, 10, 14, 12, 1, -14 },
  { 2301, 8, 23, 10, 1, -19 },
  { 2324, 2, 26, 14, 6, -20 },
  { 2331, 8, 23, 10, 1, -19 },
  { 2354, 13, 4, 15, 1, -11 },
};

const GFXfont NotoSans_Regular26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular26pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_REGULAR26PT7B_H_
