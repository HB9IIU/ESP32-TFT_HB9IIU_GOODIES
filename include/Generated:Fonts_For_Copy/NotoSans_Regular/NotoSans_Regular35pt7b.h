#ifndef _NOTOSANS_REGULAR35PT7B_H_
#define _NOTOSANS_REGULAR35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x00, 0x0E,
  0xFF, 0xF0, 0xF1, 0xFC, 0x7E, 0x1D, 0x87, 0x61, 0xD8, 0x76, 0x1D, 0x86,
  0x61, 0x80, 0x00, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x83,
  0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x0C, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0x60,
  0x03, 0x83, 0x00, 0x18, 0x38, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x83, 0x83, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00,
  0x70, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x7D, 0x9E, 0xF1, 0x80,
  0xE1, 0x80, 0xE1, 0x80, 0xE1, 0x80, 0x71, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xBE, 0x01, 0x8F, 0x01, 0x87, 0x01, 0x87,
  0x01, 0x87, 0x81, 0x8F, 0xFD, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x00, 0x38, 0x3F, 0xC0, 0x38,
  0x18, 0xE0, 0x18, 0x1C, 0x38, 0x1C, 0x0C, 0x1C, 0x0C, 0x06, 0x0E, 0x0E,
  0x03, 0x07, 0x06, 0x01, 0x83, 0x87, 0x00, 0xC1, 0xC7, 0x00, 0x60, 0xE3,
  0x80, 0x38, 0x73, 0x9F, 0x9C, 0x39, 0x9F, 0xE6, 0x39, 0xCE, 0x33, 0xFC,
  0xCE, 0x1C, 0xFC, 0xE7, 0x06, 0x00, 0x63, 0x83, 0x00, 0x71, 0xC1, 0x80,
  0x70, 0xE0, 0xC0, 0x38, 0x70, 0x60, 0x38, 0x38, 0x30, 0x18, 0x1C, 0x18,
  0x1C, 0x06, 0x1C, 0x0C, 0x03, 0x8E, 0x0E, 0x01, 0xFE, 0x0E, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xE0, 0x1C, 0x3C, 0xF0, 0x1C, 0x78, 0x78, 0x38, 0xF0, 0x3C,
  0x38, 0xE0, 0x1E, 0x78, 0xE0, 0x0F, 0x70, 0xE0, 0x07, 0xF0, 0xE0, 0x03,
  0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x0F, 0xF0, 0x7E, 0x7F, 0x78, 0x3F, 0xFC,
  0x3C, 0x1F, 0xF8, 0x1F, 0xFF, 0xE6, 0x66, 0x66, 0x60, 0x07, 0x0E, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C,
  0x1E, 0x0E, 0x07, 0x03, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x02, 0x0E, 0x09,
  0xE3, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0xDC, 0x00, 0xEE,
  0x00, 0xE3, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x08, 0x30, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3C, 0xE3, 0x8E, 0x71, 0xC7,
  0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xEF, 0xFF, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x7C, 0x78, 0x1E, 0x70, 0x0E, 0x70,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3E, 0x7C, 0x1F,
  0xF8, 0x0F, 0xF0, 0x03, 0x83, 0xC3, 0xE7, 0xB7, 0xBF, 0x9D, 0x8E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x1F, 0xF0, 0x7F, 0xF8,
  0xFC, 0x7C, 0x60, 0x1E, 0x40, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0,
  0x7F, 0xF8, 0xF8, 0x7C, 0x60, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x1E, 0xF0, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0xE0, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x30, 0x7E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x80, 0x1E, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F, 0xE0, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0x82, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0xC0, 0xE7, 0xF8, 0xEF, 0xFE, 0xFC,
  0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x38, 0x0E, 0x3E, 0x3E, 0x1F, 0xFC, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7C, 0x3E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3E, 0xFC, 0x78, 0x3E, 0x70, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78,
  0x3E, 0x3F, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7C, 0x7C, 0x70,
  0x1E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1F, 0x3F, 0xF7, 0x1F, 0xE7, 0x07,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x41, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xEF, 0xFF, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xFF, 0xF0, 0x39, 0xF7, 0xCF, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x39, 0xE7, 0x1C, 0x71, 0x8E, 0x30, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x3F, 0xE3, 0xFF, 0xE7, 0xCF, 0x90, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xE1, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0xFF, 0x07,
  0x70, 0x3F, 0xF0, 0xEE, 0x0E, 0x0E, 0x0D, 0x83, 0x81, 0xC1, 0xF0, 0x60,
  0x38, 0x3E, 0x1C, 0x07, 0x07, 0xC3, 0x80, 0xE0, 0xF8, 0x70, 0x18, 0x1F,
  0x0E, 0x03, 0x03, 0xE1, 0xC0, 0xE0, 0xFC, 0x38, 0x1E, 0x1B, 0x83, 0x86,
  0xC7, 0x30, 0x3F, 0xDF, 0xC7, 0x03, 0xE1, 0xF0, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xB8,
  0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x07, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x07,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0xE0, 0x00, 0x1C, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0,
  0x07, 0xBC, 0x01, 0xCF, 0x03, 0xE3, 0xFF, 0xE0, 0xFF, 0xFC, 0x3C, 0x07,
  0xCF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0x9F, 0x0F, 0x80, 0x23,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF9, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x00, 0xF8,
  0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC3, 0xFC, 0xFC, 0x3E, 0x00, 0x63, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0xC0, 0x03, 0x8F, 0x80, 0x1C, 0x3F, 0xC7, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xC7, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0xFF, 0xFF, 0x80, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x7F, 0xFB, 0xF8, 0xF0, 0xF0,
  0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xE0,
  0x70, 0x3C, 0x1C, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xDE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3C, 0x78, 0x07, 0x87,
  0x80, 0xF0, 0x70, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00,
  0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0xE0, 0x01, 0xFF, 0x70,
  0x00, 0xDF, 0xB8, 0x00, 0xEF, 0xCE, 0x00, 0x77, 0xE7, 0x00, 0x73, 0xF1,
  0xC0, 0x39, 0xF8, 0xE0, 0x1C, 0xFC, 0x70, 0x1C, 0x7E, 0x1C, 0x0E, 0x3F,
  0x0E, 0x06, 0x1F, 0x87, 0x87, 0x0F, 0xC1, 0xC3, 0x87, 0xE0, 0xE3, 0x83,
  0xF0, 0x39, 0xC1, 0xF8, 0x1C, 0xE0, 0xFC, 0x0E, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x3C, 0x07, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7E, 0xF0, 0x07, 0xE7, 0x00, 0x7E, 0x78, 0x07, 0xE3, 0xC0,
  0x7E, 0x1C, 0x07, 0xE1, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xF0, 0x7E, 0x07,
  0x87, 0xE0, 0x38, 0x7E, 0x03, 0xC7, 0xE0, 0x1E, 0x7E, 0x00, 0xE7, 0xE0,
  0x0F, 0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0x9F, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x73,
  0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x83, 0xC0, 0x1F, 0x03, 0xF9, 0xFC, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x1E, 0xF1, 0xFE, 0xFF, 0xF8, 0xFF, 0xF0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0x9F, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0x73, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x83, 0xC0, 0x1F, 0x03, 0xF9,
  0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F,
  0x3C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xCF,
  0x00, 0xF3, 0xC0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xC1,
  0xC0, 0xF0, 0x38, 0x3C, 0x0F, 0x0F, 0x01, 0xC3, 0xC0, 0x78, 0xF0, 0x0F,
  0x3C, 0x01, 0xCF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0x0F, 0xFC,
  0x3F, 0xFE, 0x7F, 0x7C, 0x70, 0x04, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x80, 0x1E, 0xFC, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77,
  0x80, 0x1E, 0x78, 0x07, 0x8F, 0xE7, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0xE0, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x01, 0xE3, 0x80,
  0x0E, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0,
  0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xF0, 0x78, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x70, 0x03,
  0xC0, 0x0F, 0x70, 0x03, 0xE0, 0x0E, 0x78, 0x07, 0xE0, 0x0E, 0x38, 0x07,
  0xE0, 0x0E, 0x38, 0x07, 0x60, 0x1E, 0x38, 0x07, 0x70, 0x1C, 0x3C, 0x0E,
  0x70, 0x1C, 0x1C, 0x0E, 0x70, 0x1C, 0x1C, 0x0E, 0x38, 0x3C, 0x1C, 0x1C,
  0x38, 0x38, 0x1E, 0x1C, 0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x38, 0x0E, 0x1C,
  0x1C, 0x78, 0x0E, 0x38, 0x1C, 0x70, 0x07, 0x38, 0x1C, 0x70, 0x07, 0x38,
  0x0E, 0x70, 0x07, 0x70, 0x0E, 0xE0, 0x07, 0x70, 0x0E, 0xE0, 0x03, 0xF0,
  0x06, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00,
  0xF3, 0x80, 0x0E, 0x3C, 0x01, 0xC1, 0xC0, 0x3C, 0x0E, 0x03, 0x80, 0xF0,
  0x70, 0x07, 0x0F, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x39, 0xC0, 0x03, 0x8E, 0x00, 0x70, 0xF0, 0x0F, 0x07, 0x00, 0xE0, 0x78,
  0x1C, 0x03, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xC3, 0x80, 0x1C, 0x3C,
  0x03, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x00, 0xE0, 0xF0, 0x07, 0x0E, 0x00,
  0x71, 0xE0, 0x03, 0x9C, 0x00, 0x3B, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x01, 0xCC, 0x00, 0x63, 0x80,
  0x38, 0x60, 0x0C, 0x1C, 0x07, 0x03, 0x01, 0x80, 0xE0, 0xE0, 0x1C, 0x30,
  0x07, 0x1C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xC0, 0x0F, 0xF0, 0x7F, 0xF0, 0xF9, 0xF1,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0xFE, 0x7F,
  0xFD, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xF0, 0xFE, 0xFF, 0xDC, 0xFE, 0x38, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE3,
  0xF0, 0x77, 0xFE, 0x3F, 0xFF, 0x9F, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3B,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x3D, 0xF0, 0x1C, 0xFE, 0x3E, 0x77,
  0xFE, 0x31, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0x9E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x38, 0x7F, 0xE0,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xE7, 0x8F, 0xF9, 0xCF,
  0xFE, 0xEF, 0x01, 0xF7, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3D, 0xC0, 0x1E, 0xF0, 0x1F, 0x3E, 0x3B, 0x8F, 0xFD, 0xC3, 0xF8, 0xE0,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0x7C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x01, 0x3F, 0x1E, 0x1F, 0xFE,
  0x07, 0xFC, 0x01, 0xE8, 0x3F, 0x83, 0xFC, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3F, 0xE7, 0xFF, 0x3F, 0xF8, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x07, 0xE3,
  0x8F, 0xF9, 0xCF, 0xFE, 0xEF, 0x01, 0xF7, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x1F, 0x3E, 0x3F, 0x8F, 0xFD,
  0xC3, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x80,
  0x1E, 0x78, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE3, 0xF0, 0xEF, 0xFC, 0xFF, 0x7E, 0xF8, 0x0E, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x5F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x06, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x8F, 0xFE, 0xFC, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x1F, 0xC0, 0x7B, 0x81, 0xE7, 0x07, 0x8E, 0x1E, 0x1C, 0x78,
  0x39, 0xE0, 0x77, 0x80, 0xEE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0x9E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x38, 0x3C, 0x70, 0x3C, 0xE0, 0x39, 0xC0, 0x3B, 0x80,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE3, 0xF0, 0x3F, 0x1D, 0xFF, 0x1F, 0xF3, 0xFF, 0xF7, 0xFF, 0x7C, 0x0F,
  0xC0, 0xEF, 0x01, 0xF0, 0x1F, 0xE0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F,
  0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38,
  0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8,
  0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0,
  0x1F, 0x80, 0x38, 0x03, 0x80, 0xE3, 0xF8, 0xEF, 0xFC, 0xFF, 0x7E, 0xF8,
  0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xDF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x3D, 0xC0, 0x1C, 0xF0, 0x1E, 0x3E, 0x1E, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0xE3, 0xF0, 0x77, 0xFE, 0x3F, 0xFF, 0x9F, 0x03, 0xCF, 0x00, 0xF7, 0x80,
  0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x3D, 0xF0, 0x1C, 0xFC, 0x3E,
  0x77, 0xFE, 0x39, 0xFC, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x07, 0xE3,
  0x8F, 0xF9, 0xCF, 0xFE, 0xEF, 0x01, 0xF7, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x1F, 0x3E, 0x3B, 0x8F, 0xFD,
  0xC3, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0xE3, 0xFC, 0xFF, 0xBF,
  0xFE, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x1F,
  0xE3, 0xFF, 0xFF, 0x7D, 0xC0, 0x2E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0xE0, 0xFF, 0xFF, 0x9F, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x07,
  0xFF, 0xFF, 0xFF, 0xF9, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xE2, 0x3F,
  0xC3, 0xF8, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0x78, 0x7F,
  0x7F, 0xF7, 0x1F, 0xC7, 0xE0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E,
  0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x77, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xEE, 0x01, 0xE0, 0x1D, 0xC0, 0x7C, 0x07, 0xB8, 0x0F, 0x80,
  0xE3, 0x81, 0xB8, 0x1C, 0x70, 0x77, 0x03, 0x8E, 0x0E, 0x60, 0xE1, 0xC1,
  0xCE, 0x1C, 0x1C, 0x71, 0xC3, 0x83, 0x8E, 0x38, 0x70, 0x71, 0xC3, 0x9C,
  0x0E, 0x30, 0x73, 0x80, 0xEE, 0x0E, 0x70, 0x1D, 0xC0, 0xCC, 0x03, 0xB0,
  0x1F, 0x80, 0x36, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xB8, 0x07, 0x8E, 0x03, 0x87, 0x83,
  0x81, 0xC3, 0xC0, 0x73, 0xC0, 0x3D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0x71, 0xC0, 0x70, 0xF0,
  0x78, 0x38, 0x78, 0x0E, 0x38, 0x07, 0xB8, 0x01, 0xE0, 0xE0, 0x03, 0xDC,
  0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x1C, 0xF0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x3B, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x7C, 0x1F,
  0x83, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x3E, 0x07, 0x80, 0xFC, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7E,
  0x03, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F,
  0x00, 0xF8, 0x0F, 0x07, 0xE1, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0x0F, 0xC1, 0xF0, 0x20, 0x00,
  0x1C, 0x01, 0x7F, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 25, 9, 3, -25 },
  { 14, 10, 9, 14, 2, -25 },
  { 26, 21, 25, 23, 1, -25 },
  { 92, 16, 29, 20, 2, -27 },
  { 150, 25, 25, 29, 2, -25 },
  { 229, 24, 25, 26, 2, -25 },
  { 304, 4, 9, 8, 2, -25 },
  { 309, 8, 31, 11, 1, -25 },
  { 340, 8, 31, 11, 1, -25 },
  { 371, 17, 16, 19, 1, -27 },
  { 405, 16, 17, 20, 2, -21 },
  { 439, 6, 9, 9, 1, -4 },
  { 446, 9, 3, 11, 1, -11 },
  { 450, 4, 4, 9, 3, -4 },
  { 452, 13, 25, 13, 0, -25 },
  { 493, 16, 25, 20, 2, -25 },
  { 543, 9, 25, 20, 3, -25 },
  { 572, 16, 25, 20, 2, -25 },
  { 622, 16, 25, 20, 2, -25 },
  { 672, 18, 25, 20, 1, -25 },
  { 729, 16, 25, 20, 2, -25 },
  { 779, 16, 25, 20, 2, -25 },
  { 829, 16, 25, 20, 2, -25 },
  { 879, 16, 25, 20, 2, -25 },
  { 929, 16, 25, 20, 2, -25 },
  { 979, 4, 19, 9, 3, -19 },
  { 989, 6, 24, 9, 1, -19 },
  { 1007, 16, 17, 20, 2, -21 },
  { 1041, 16, 9, 20, 2, -17 },
  { 1059, 16, 17, 20, 2, -21 },
  { 1093, 14, 25, 15, 0, -25 },
  { 1137, 27, 28, 31, 2, -25 },
  { 1232, 22, 25, 22, 0, -25 },
  { 1301, 18, 25, 23, 3, -25 },
  { 1358, 19, 25, 22, 2, -25 },
  { 1418, 20, 25, 26, 3, -25 },
  { 1481, 14, 25, 19, 3, -25 },
  { 1525, 14, 25, 18, 3, -25 },
  { 1569, 21, 25, 25, 2, -25 },
  { 1635, 20, 25, 26, 3, -25 },
  { 1698, 9, 25, 12, 1, -25 },
  { 1727, 9, 32, 10, -3, -25 },
  { 1763, 19, 25, 22, 3, -25 },
  { 1823, 14, 25, 18, 3, -25 },
  { 1867, 25, 25, 32, 3, -25 },
  { 1946, 20, 25, 27, 3, -25 },
  { 2009, 23, 25, 27, 2, -25 },
  { 2081, 16, 25, 21, 3, -25 },
  { 2131, 23, 31, 27, 2, -25 },
  { 2221, 18, 25, 22, 3, -25 },
  { 2278, 16, 25, 19, 2, -25 },
  { 2328, 19, 25, 19, 0, -25 },
  { 2388, 19, 25, 26, 3, -25 },
  { 2448, 21, 25, 21, 0, -25 },
  { 2514, 32, 25, 33, 0, -25 },
  { 2614, 20, 25, 21, 0, -25 },
  { 2677, 20, 25, 20, 0, -25 },
  { 2740, 18, 25, 20, 1, -25 },
  { 2797, 8, 31, 12, 3, -25 },
  { 2828, 13, 25, 13, 0, -25 },
  { 2869, 8, 31, 12, 1, -25 },
  { 2900, 18, 16, 20, 1, -25 },
  { 2936, 16, 2, 16, 0, 3 },
  { 2940, 7, 6, 10, 1, -27 },
  { 2946, 15, 19, 20, 2, -19 },
  { 2982, 17, 27, 22, 3, -27 },
  { 3040, 14, 19, 17, 2, -19 },
  { 3074, 17, 27, 22, 2, -27 },
  { 3132, 16, 19, 20, 2, -19 },
  { 3170, 13, 27, 12, 1, -27 },
  { 3214, 17, 27, 22, 2, -19 },
  { 3272, 16, 27, 22, 3, -27 },
  { 3326, 3, 26, 9, 3, -26 },
  { 3336, 8, 34, 9, -2, -26 },
  { 3370, 15, 27, 19, 3, -27 },
  { 3421, 3, 27, 9, 3, -27 },
  { 3432, 27, 19, 33, 3, -19 },
  { 3497, 16, 19, 22, 3, -19 },
  { 3535, 17, 19, 21, 2, -19 },
  { 3576, 17, 27, 22, 3, -19 },
  { 3634, 17, 27, 22, 2, -19 },
  { 3692, 11, 19, 14, 3, -19 },
  { 3719, 13, 19, 17, 2, -19 },
  { 3750, 11, 23, 13, 1, -23 },
  { 3782, 16, 19, 22, 3, -19 },
  { 3820, 18, 19, 18, 0, -19 },
  { 3863, 27, 19, 28, 0, -19 },
  { 3928, 17, 19, 19, 1, -19 },
  { 3969, 18, 27, 18, 0, -19 },
  { 4030, 14, 19, 16, 1, -19 },
  { 4064, 11, 31, 13, 1, -25 },
  { 4107, 3, 35, 19, 8, -27 },
  { 4121, 11, 31, 13, 1, -25 },
  { 4164, 16, 5, 20, 2, -15 },
};

const GFXfont NotoSans_Regular35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular35pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_REGULAR35PT7B_H_
