#ifndef _NOTOSANS_REGULAR28PT7B_H_
#define _NOTOSANS_REGULAR28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x6D, 0xB6, 0xC0, 0x1F, 0xF0, 0xC7, 0xC7, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC6, 0x03, 0x0C, 0x03, 0x0C, 0x07, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x06, 0x00, 0x60, 0x1F,
  0xC7, 0xFF, 0xF6, 0xEC, 0x60, 0xC6, 0x0C, 0x60, 0xE6, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x67, 0x06, 0x30, 0x63, 0x86, 0x7F, 0xFF, 0xFF,
  0xC0, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3E, 0x01, 0x83, 0xB8, 0x18,
  0x18, 0xC0, 0xC0, 0xC6, 0x0C, 0x0C, 0x18, 0x60, 0x60, 0xC6, 0x03, 0x06,
  0x70, 0x18, 0x33, 0x00, 0x63, 0x3B, 0xE3, 0x19, 0xBF, 0x9F, 0xD9, 0x8C,
  0x7C, 0xCC, 0x30, 0x0C, 0x61, 0x80, 0x63, 0x0C, 0x06, 0x18, 0x60, 0x70,
  0xC3, 0x03, 0x06, 0x18, 0x38, 0x31, 0x81, 0x80, 0xFC, 0x18, 0x07, 0xC0,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x61, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x00,
  0x30, 0x60, 0x07, 0x1C, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0xFF, 0x03, 0x1C, 0xF0, 0xE7, 0x0F, 0x18, 0xC0, 0xF7, 0x38, 0x0F, 0xE3,
  0x00, 0xF8, 0x70, 0x0F, 0x0F, 0x07, 0xF0, 0xFF, 0xE7, 0x0F, 0xF0, 0x70,
  0xFF, 0xFC, 0x0E, 0x38, 0xE1, 0x83, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xC1, 0xC3, 0x83, 0x07, 0x06, 0x07, 0xE1,
  0x87, 0x0C, 0x38, 0x61, 0xC7, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1C,
  0x71, 0x8E, 0x38, 0xC7, 0x38, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x0F,
  0x33, 0xFF, 0xFC, 0x3E, 0x00, 0xF0, 0x0D, 0xC0, 0xE6, 0x0E, 0x38, 0x30,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x77, 0x76, 0x6C, 0xC0, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x70, 0x39, 0x80, 0x66, 0x01,
  0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80,
  0x66, 0x01, 0x9C, 0x0E, 0x70, 0x38, 0xE1, 0xC1, 0xFE, 0x03, 0xF0, 0x07,
  0x0F, 0x1F, 0x7B, 0xE3, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0xC1, 0xFF, 0x87, 0x07,
  0x10, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0x98, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x03, 0xE0, 0xFC, 0x07, 0xFC,
  0x00, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3E, 0x03, 0xFF,
  0xFC, 0xFF, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0x70,
  0x19, 0xC0, 0xE7, 0x03, 0x1C, 0x18, 0x70, 0xE1, 0xC3, 0x07, 0x18, 0x1C,
  0xE0, 0x73, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x78, 0x0E, 0xFF, 0xCF, 0xF8, 0x07, 0xE0, 0xFF, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x60, 0xDF, 0xC7, 0xEF,
  0x38, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x33,
  0x83, 0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x03, 0x9C, 0x0E, 0x60,
  0x19, 0xC0, 0xE7, 0x03, 0x8E, 0x1C, 0x1F, 0xE0, 0x3E, 0x01, 0xFE, 0x0E,
  0x1C, 0x70, 0x39, 0x80, 0x6E, 0x01, 0xF8, 0x07, 0x60, 0x19, 0xC0, 0xE3,
  0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0xFF, 0x87, 0x07, 0x1C, 0x0E, 0x60, 0x1B,
  0x80, 0x6E, 0x01, 0xB8, 0x07, 0x60, 0x1D, 0xC0, 0xF3, 0xCF, 0x87, 0xF6,
  0x02, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x83, 0xFC,
  0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x77, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x77, 0x66, 0xEC, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x3F, 0x9F, 0xF9, 0x83,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x18, 0x30,
  0x00, 0x31, 0xC0, 0x60, 0xE6, 0x0F, 0xE1, 0xB0, 0x71, 0x86, 0xC3, 0x06,
  0x1B, 0x0C, 0x18, 0x3C, 0x70, 0x60, 0xF1, 0x81, 0x86, 0xC6, 0x06, 0x1B,
  0x1C, 0x18, 0x6C, 0x30, 0xE3, 0x30, 0xFE, 0xFC, 0xC0, 0xF1, 0xE1, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x20, 0x1F, 0x9F, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0x70,
  0x00, 0xCC, 0x00, 0x73, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x87, 0x00,
  0xC0, 0xC0, 0x70, 0x38, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0x80, 0x70, 0xC0,
  0x0C, 0x70, 0x03, 0x1C, 0x00, 0xE6, 0x00, 0x1B, 0x80, 0x07, 0xFF, 0xC3,
  0xFF, 0xCC, 0x0F, 0x30, 0x0E, 0xC0, 0x3B, 0x00, 0xEC, 0x03, 0xB0, 0x0C,
  0xC3, 0xE3, 0xFE, 0x0F, 0xFF, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3B, 0x01, 0xEF, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0x3F,
  0xFC, 0xF0, 0x33, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x08, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0xF0, 0xC0, 0xF8, 0xC0, 0x3C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x3C, 0xC0, 0xF8, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEC,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x03,
  0xFE, 0x0F, 0xFF, 0x3E, 0x06, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0x70, 0x03, 0x78, 0x03, 0x3C, 0x03, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x70, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x73, 0xFF, 0xF0, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0xFE, 0xF8, 0xC0, 0x1F, 0x00,
  0xEC, 0x07, 0x30, 0x38, 0xC1, 0xC3, 0x0E, 0x0C, 0x70, 0x33, 0x80, 0xDC,
  0x03, 0x78, 0x0F, 0xE0, 0x39, 0xC0, 0xC3, 0x83, 0x07, 0x0C, 0x1C, 0x30,
  0x38, 0xC0, 0x73, 0x01, 0xEC, 0x03, 0xB0, 0x07, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xD8, 0x03,
  0xFD, 0xC0, 0x37, 0xDC, 0x07, 0x7C, 0xC0, 0x67, 0xCE, 0x06, 0x7C, 0x60,
  0xE7, 0xC6, 0x0C, 0x7C, 0x70, 0xC7, 0xC3, 0x18, 0x7C, 0x39, 0x87, 0xC3,
  0xB8, 0x7C, 0x1B, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xE0, 0x7C,
  0x0E, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xDC, 0x07,
  0xDC, 0x07, 0xCE, 0x07, 0xC6, 0x07, 0xC7, 0x07, 0xC3, 0x87, 0xC3, 0x87,
  0xC1, 0xC7, 0xC0, 0xE7, 0xC0, 0xE7, 0xC0, 0x77, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xC0,
  0xF1, 0xC0, 0x1E, 0x70, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x19, 0xC0, 0x0E, 0x70, 0x07, 0x0F, 0x03, 0xC1, 0xFF,
  0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0x30, 0x7D, 0x80, 0xEC, 0x03, 0x60,
  0x1F, 0x00, 0xD8, 0x06, 0xC0, 0x76, 0x07, 0x3F, 0xF9, 0xFF, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0xF1, 0xC0, 0x1E, 0x70, 0x03, 0xB8,
  0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x19, 0xC0, 0x0E,
  0x70, 0x07, 0x8F, 0x03, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0x83, 0xFF,
  0x8C, 0x1F, 0x30, 0x1C, 0xC0, 0x33, 0x00, 0xEC, 0x03, 0x30, 0x0C, 0xC0,
  0x73, 0x0F, 0x8F, 0xFC, 0x3F, 0xE0, 0xC1, 0x83, 0x07, 0x0C, 0x0E, 0x30,
  0x38, 0xC0, 0x73, 0x00, 0xCC, 0x03, 0xB0, 0x07, 0x1F, 0xF9, 0xFF, 0x9E,
  0x0C, 0xE0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x3E,
  0x03, 0xBF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x1C, 0xE0, 0x78, 0xFF, 0xE0, 0xFF, 0x00, 0xE0, 0x03, 0xB0,
  0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x00, 0x61, 0xC0, 0x70, 0xE0, 0x30,
  0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x0C, 0x03, 0x0E, 0x01, 0xC7, 0x00, 0xE3,
  0x00, 0x33, 0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x01, 0xD8, 0x07, 0x80, 0x67, 0x01,
  0xE0, 0x39, 0xC0, 0x78, 0x0E, 0x30, 0x3F, 0x03, 0x0C, 0x0C, 0xC0, 0xC3,
  0x83, 0x30, 0x70, 0xE1, 0xCC, 0x1C, 0x18, 0x73, 0x86, 0x06, 0x18, 0x61,
  0x81, 0xC6, 0x18, 0xE0, 0x73, 0x87, 0x38, 0x0C, 0xC0, 0xCC, 0x03, 0x30,
  0x33, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x07, 0x80, 0x78, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x70,
  0x0E, 0x38, 0x0C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x07,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x06, 0x70, 0x0E,
  0x70, 0x0C, 0x38, 0x1C, 0x18, 0x38, 0x1C, 0x30, 0x0E, 0x70, 0x06, 0xE0,
  0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x18, 0x1C,
  0x38, 0x1C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x03, 0x00, 0x1C, 0x00,
  0x78, 0x03, 0x60, 0x0C, 0xC0, 0x63, 0x01, 0x86, 0x0E, 0x18, 0x30, 0x31,
  0xC0, 0xC6, 0x01, 0x98, 0x06, 0xC0, 0x0C, 0xFF, 0xF0, 0xF1, 0xC3, 0x87,
  0x1F, 0xE3, 0xFF, 0x10, 0x70, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xF3, 0xFF,
  0x70, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xF7, 0xFF, 0x3F, 0x10, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0xFE, 0x3F,
  0xFC, 0xF0, 0x7B, 0xC0, 0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1B, 0xC0, 0xEF, 0x07, 0xBF, 0xFC, 0xCF, 0xE0,
  0x1F, 0xE7, 0xF9, 0xC1, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x07, 0x04, 0x7F, 0x87, 0xF0, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7E, 0xEF, 0xFB, 0x70, 0x7F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xDC, 0x1E, 0xFF, 0xB1, 0xF9, 0x80, 0x1F, 0x83, 0xFE, 0x70,
  0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x13, 0xFF, 0x1F, 0xE0, 0x07, 0xE1, 0xF8, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x1F, 0xE7, 0xFC, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x1F, 0x9B, 0xFE, 0xDC, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x77, 0x07, 0xBF, 0xFC, 0x7E,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1C, 0xE3, 0xE7, 0xFE, 0x0F, 0x80,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0x9F,
  0xFE, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0x80, 0x5F,
  0xA0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x1C, 0x38, 0x20, 0x00,
  0x03, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x3B, 0xF3, 0x80, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xDC, 0x1C, 0xE1, 0xC7, 0x1C,
  0x39, 0xC1, 0xDC, 0x0F, 0xC0, 0x7F, 0x03, 0xDC, 0x1C, 0x70, 0xE3, 0x87,
  0x0E, 0x38, 0x39, 0xC0, 0xEE, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xCF, 0xC3, 0xF3, 0xFF, 0x9F, 0xEF, 0x07, 0xC1, 0xFC,
  0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C,
  0x07, 0xE0, 0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07,
  0xE0, 0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xC0, 0xCF, 0xE7, 0xFF,
  0xBE, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x60, 0x1F, 0xC1,
  0xFF, 0x1C, 0x1D, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0x77, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0xCF,
  0xE3, 0xFF, 0xCF, 0x07, 0xBC, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xBC, 0x0E, 0xF8, 0x7B, 0xFF, 0xCE,
  0xFE, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x1F, 0x9B, 0xFE, 0xDC, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x77, 0x07, 0xBF,
  0xFC, 0x7E, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0xC7, 0xF7, 0xFE, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x3F, 0xCF, 0xFD, 0x81, 0x70,
  0x0E, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x0F, 0xFF, 0x9F, 0xE0, 0x18, 0x0C, 0x06, 0x0F, 0xFF, 0xF8, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1F, 0x87,
  0xC0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x77, 0x07, 0xBF, 0xEC,
  0xFE, 0x60, 0xE0, 0x1D, 0x80, 0x77, 0x01, 0x9C, 0x0E, 0x30, 0x38, 0xE0,
  0xC3, 0x87, 0x06, 0x18, 0x1C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x1D, 0x81, 0xE0, 0x67, 0x07,
  0x81, 0x9C, 0x1E, 0x0E, 0x30, 0xDC, 0x30, 0xC3, 0x30, 0xC3, 0x8C, 0xC7,
  0x0E, 0x73, 0x9C, 0x19, 0x86, 0x60, 0x66, 0x19, 0x81, 0xF8, 0x7E, 0x07,
  0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x3C, 0x00, 0x70,
  0x1C, 0xE0, 0xE1, 0x83, 0x07, 0x1C, 0x0E, 0xE0, 0x1B, 0x00, 0x78, 0x00,
  0xE0, 0x07, 0xC0, 0x3B, 0x00, 0xCE, 0x07, 0x1C, 0x38, 0x38, 0xC0, 0xEF,
  0x01, 0xC0, 0xE0, 0x1D, 0x80, 0x77, 0x01, 0x9C, 0x0E, 0x30, 0x38, 0xE0,
  0xC1, 0x87, 0x07, 0x18, 0x1C, 0x60, 0x33, 0x80, 0xEC, 0x01, 0xB0, 0x07,
  0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0xFC, 0x03, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0x87, 0xC3, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x1E, 0x0E, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07,
  0x01, 0xF0, 0x78, 0x70, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC3, 0xE1, 0xE0, 0x1C, 0x05, 0xFC, 0x3E, 0x7F, 0xE0, 0x3C,
};

const GFXglyph NotoSans_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 20, 8, 2, -20 },
  { 9, 8, 7, 11, 2, -20 },
  { 16, 16, 20, 18, 1, -20 },
  { 56, 12, 23, 16, 2, -21 },
  { 91, 21, 20, 23, 1, -20 },
  { 144, 19, 20, 21, 1, -20 },
  { 192, 2, 7, 6, 2, -20 },
  { 194, 7, 24, 8, 1, -20 },
  { 215, 6, 24, 8, 1, -20 },
  { 233, 13, 12, 15, 1, -21 },
  { 253, 14, 14, 16, 1, -17 },
  { 278, 4, 7, 8, 1, -3 },
  { 282, 7, 3, 9, 1, -9 },
  { 285, 3, 3, 8, 2, -3 },
  { 287, 10, 20, 10, 0, -20 },
  { 312, 14, 20, 16, 1, -20 },
  { 347, 8, 20, 16, 2, -20 },
  { 367, 14, 20, 16, 1, -20 },
  { 402, 13, 20, 16, 1, -20 },
  { 435, 14, 20, 16, 1, -20 },
  { 470, 12, 20, 16, 2, -20 },
  { 500, 13, 20, 16, 2, -20 },
  { 533, 14, 20, 16, 1, -20 },
  { 568, 14, 20, 16, 1, -20 },
  { 603, 14, 20, 16, 1, -20 },
  { 638, 3, 15, 8, 2, -15 },
  { 644, 4, 19, 8, 1, -15 },
  { 654, 14, 14, 16, 1, -17 },
  { 679, 12, 8, 16, 2, -14 },
  { 691, 14, 14, 16, 1, -17 },
  { 716, 11, 20, 12, 0, -20 },
  { 744, 22, 22, 25, 2, -20 },
  { 805, 18, 20, 18, 0, -20 },
  { 850, 14, 20, 18, 3, -20 },
  { 885, 15, 20, 18, 2, -20 },
  { 923, 16, 20, 20, 3, -20 },
  { 963, 11, 20, 16, 3, -20 },
  { 991, 11, 20, 15, 3, -20 },
  { 1019, 16, 20, 20, 2, -20 },
  { 1059, 15, 20, 21, 3, -20 },
  { 1097, 7, 20, 9, 1, -20 },
  { 1115, 7, 25, 8, -2, -20 },
  { 1137, 14, 20, 17, 3, -20 },
  { 1172, 11, 20, 15, 3, -20 },
  { 1200, 20, 20, 25, 3, -20 },
  { 1250, 16, 20, 21, 3, -20 },
  { 1290, 18, 20, 22, 2, -20 },
  { 1335, 13, 20, 17, 3, -20 },
  { 1368, 18, 25, 22, 2, -20 },
  { 1425, 14, 20, 17, 3, -20 },
  { 1460, 13, 20, 15, 1, -20 },
  { 1493, 15, 20, 16, 0, -20 },
  { 1531, 15, 20, 20, 3, -20 },
  { 1569, 17, 20, 17, 0, -20 },
  { 1612, 26, 20, 26, 0, -20 },
  { 1677, 16, 20, 16, 0, -20 },
  { 1717, 16, 20, 16, 0, -20 },
  { 1757, 14, 20, 16, 1, -20 },
  { 1792, 7, 24, 9, 2, -20 },
  { 1813, 10, 20, 10, 0, -20 },
  { 1838, 6, 24, 9, 1, -20 },
  { 1856, 14, 13, 16, 1, -20 },
  { 1879, 12, 1, 12, 0, 3 },
  { 1881, 6, 4, 8, 1, -21 },
  { 1884, 12, 15, 16, 1, -15 },
  { 1907, 14, 21, 17, 2, -21 },
  { 1944, 11, 15, 13, 2, -15 },
  { 1965, 13, 21, 17, 2, -21 },
  { 2000, 12, 15, 16, 2, -15 },
  { 2023, 11, 21, 10, 0, -21 },
  { 2052, 13, 22, 17, 2, -15 },
  { 2088, 13, 21, 17, 2, -21 },
  { 2123, 3, 21, 7, 2, -21 },
  { 2131, 7, 28, 7, -2, -21 },
  { 2156, 13, 21, 15, 2, -21 },
  { 2191, 3, 21, 7, 2, -21 },
  { 2199, 22, 15, 26, 2, -15 },
  { 2241, 13, 15, 17, 2, -15 },
  { 2266, 13, 15, 17, 2, -15 },
  { 2291, 14, 22, 17, 2, -15 },
  { 2330, 13, 22, 17, 2, -15 },
  { 2366, 9, 15, 12, 2, -15 },
  { 2383, 11, 15, 13, 1, -15 },
  { 2404, 9, 18, 10, 0, -18 },
  { 2425, 13, 15, 17, 2, -15 },
  { 2450, 14, 15, 14, 0, -15 },
  { 2477, 22, 15, 22, 0, -15 },
  { 2519, 14, 15, 15, 0, -15 },
  { 2546, 14, 22, 14, 0, -15 },
  { 2585, 11, 15, 13, 1, -15 },
  { 2606, 9, 24, 11, 1, -20 },
  { 2633, 2, 28, 15, 7, -21 },
  { 2640, 9, 24, 11, 1, -20 },
  { 2667, 14, 4, 16, 1, -12 },
};

const GFXfont NotoSans_Regular28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular28pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_REGULAR28PT7B_H_
