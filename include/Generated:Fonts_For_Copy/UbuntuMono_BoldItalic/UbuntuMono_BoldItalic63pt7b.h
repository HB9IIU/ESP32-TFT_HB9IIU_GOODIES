#ifndef _UBUNTUMONO_BOLDITALIC63PT7B_H_
#define _UBUNTUMONO_BOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0xC1, 0xFE, 0x7F, 0x87,
  0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE7, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F,
  0x9F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0x80,
  0x7F, 0xC0, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x81, 0xC0, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x1F, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x7C,
  0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x7C, 0x00,
  0x0F, 0x87, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F,
  0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0xF8, 0x00,
  0x01, 0xFF, 0xE3, 0xE0, 0x00, 0x03, 0xFF, 0xCF, 0xC0, 0x00, 0x03, 0xFF,
  0x3F, 0x00, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x7F, 0x80, 0x00, 0x01, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xFF,
  0x00, 0x00, 0x1F, 0x9F, 0xFF, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xFC, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE1,
  0xF0, 0x00, 0x3F, 0x07, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x3E, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0x1F, 0x80, 0xF8,
  0xFC, 0x00, 0x7E, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFD, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0xFF, 0xFC, 0x1F, 0x87, 0xFF, 0xF8,
  0x7E, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x1F, 0xCF, 0xC7, 0xF0, 0x7F, 0xFF,
  0x1F, 0xC0, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0x0F,
  0xE0, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8,
  0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xC3,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0xE7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x0C, 0x0F, 0xC0, 0xC3, 0xC3, 0xF0, 0xF1, 0xF8, 0xF8, 0xFC,
  0x7F, 0xBE, 0x7F, 0x9F, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF8, 0x1F, 0xE1, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x3C, 0x0E,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFF, 0xFC, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xCF, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFF,
  0x3F, 0xC3, 0xC3, 0xFC, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x9F,
  0xE3, 0xF8, 0xFE, 0x7F, 0x8F, 0xC3, 0xF9, 0xFC, 0x1E, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x3F, 0xC0,
  0x3E, 0x1F, 0xC0, 0x1C, 0x1F, 0xE0, 0x08, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0x81, 0xFF, 0x80, 0x18, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x60, 0x00, 0x7F, 0xC0, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x20, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x7F, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x01, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x00, 0xFF,
  0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x0F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFB, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0x81, 0xFF, 0x18,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0,
  0x1F, 0xFF, 0x0F, 0xC0, 0x7F, 0xFF, 0x1F, 0x80, 0xFF, 0xFF, 0x1F, 0x83,
  0xFF, 0xFE, 0x1F, 0x83, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFE, 0x3F, 0x0F,
  0xF0, 0xFE, 0x3F, 0x0F, 0xE0, 0xFE, 0x3E, 0x1F, 0xC0, 0xFC, 0x7E, 0x1F,
  0xC1, 0xFC, 0x7E, 0x1F, 0x81, 0xFC, 0x7E, 0x1F, 0x81, 0xFC, 0x7E, 0x3F,
  0x81, 0xF8, 0x7E, 0x3F, 0x83, 0xF8, 0x7C, 0x3F, 0x83, 0xF8, 0x7C, 0x3F,
  0x03, 0xF8, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F,
  0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0xE0, 0x7E, 0x03,
  0xFF, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x02, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF8,
  0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0x00,
  0xFF, 0x80, 0x08, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x10, 0x07, 0xFE, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x83, 0xFF, 0x00, 0x7F,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x87,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x3E, 0x01,
  0xFF, 0x80, 0x08, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x83, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0x00,
  0x1E, 0x00, 0xFF, 0x80, 0x1F, 0x81, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F,
  0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xDE, 0x0F, 0xFE, 0x00, 0xFD, 0xE0,
  0xFF, 0xE0, 0x0F, 0xDE, 0x1F, 0x7E, 0x00, 0xFD, 0xE1, 0xF7, 0xC0, 0x1F,
  0x9E, 0x3E, 0xFC, 0x01, 0xF9, 0xF3, 0xCF, 0xC0, 0x1F, 0x9F, 0x7C, 0xFC,
  0x01, 0xF9, 0xF7, 0x8F, 0xC0, 0x3F, 0x1F, 0xF9, 0xF8, 0x03, 0xF1, 0xFF,
  0x1F, 0x80, 0x3F, 0x1F, 0xF1, 0xF8, 0x07, 0xF1, 0xFE, 0x1F, 0x80, 0x7F,
  0x1F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC3, 0xF0,
  0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x7F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x80,
  0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xF0, 0x3F,
  0x80, 0x3F, 0xBE, 0x07, 0xF0, 0x07, 0xF7, 0xC0, 0xFE, 0x01, 0xFC, 0xFC,
  0x1F, 0x80, 0x3F, 0x9F, 0x87, 0xF0, 0x07, 0xF1, 0xF0, 0xFE, 0x00, 0xFE,
  0x3E, 0x1F, 0xC0, 0x1F, 0x87, 0xE3, 0xF0, 0x07, 0xF0, 0xFC, 0xFE, 0x00,
  0xFE, 0x1F, 0x9F, 0xC0, 0x1F, 0xC1, 0xF3, 0xF8, 0x03, 0xF0, 0x3F, 0x7E,
  0x00, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xF8, 0x03, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xF8, 0x03, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFC,
  0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x00, 0x1C, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00,
  0x1F, 0xE0, 0x1C, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x07,
  0xE1, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x83, 0xF0, 0x0F, 0xE3, 0xF8, 0x7F,
  0x00, 0xFC, 0x3F, 0x87, 0xF0, 0x0F, 0xC7, 0xF8, 0x7E, 0x00, 0xFC, 0x7F,
  0x87, 0xE0, 0x1F, 0xCF, 0xFC, 0x7E, 0x01, 0xF8, 0xFF, 0xCF, 0xC0, 0x1F,
  0x9F, 0x7C, 0xFC, 0x01, 0xF9, 0xF7, 0xCF, 0xC0, 0x1F, 0xBE, 0x7C, 0xFC,
  0x01, 0xF3, 0xE7, 0xDF, 0x80, 0x3F, 0x7C, 0x7D, 0xF8, 0x03, 0xF7, 0xC7,
  0xDF, 0x80, 0x3F, 0xF8, 0x7D, 0xF0, 0x03, 0xEF, 0x83, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x87, 0xF0, 0x03, 0xFC,
  0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xC3, 0xFC,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x0F, 0xF3, 0xE0, 0x00, 0x7F, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x87, 0xFF,
  0x07, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF,
  0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xE0, 0x3F, 0xF8,
  0x7F, 0x00, 0x7F, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xF8, 0x00, 0x3F, 0x81, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF1,
  0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x07, 0xFE,
  0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x01, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x06, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x20, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0x00, 0x0F, 0xF8,
  0x00, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x0C, 0x01, 0xFF, 0x00, 0x3C, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x0E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFF, 0xF3, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x3F,
  0x07, 0xF0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F,
  0x07, 0xE1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x3F, 0xF0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x06,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x18, 0x00,
  0x7F, 0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x07, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0x01, 0xFF, 0xC7, 0xF8, 0x07, 0xF0,
  0x30, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFB, 0xFC, 0x00,
  0x3F, 0xBF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x7F,
  0x07, 0xE0, 0xFC, 0x7F, 0x07, 0xE0, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7E,
  0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0xE1, 0xF8, 0x7E,
  0x1F, 0xE3, 0xF0, 0x7E, 0x3F, 0xE3, 0xF0, 0x7E, 0x3F, 0xE3, 0xF0, 0x7C,
  0x7F, 0xE7, 0xE0, 0x7C, 0x7F, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC,
  0xF9, 0xE7, 0xC0, 0xFD, 0xF1, 0xEF, 0xC0, 0xFF, 0xF1, 0xEF, 0x80, 0xFF,
  0xE1, 0xEF, 0x80, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x60, 0x0F, 0xFC, 0x03, 0xF0, 0xFF, 0xF8, 0x0F, 0xC7, 0xFF,
  0xF8, 0x7F, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xC3, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0xC3, 0xF0, 0x07, 0xFE,
  0x00, 0xC0, 0x07, 0xE0, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 18, 40, 32, 10, -39 },
  { 91, 23, 18, 32, 12, -43 },
  { 143, 34, 39, 32, 2, -39 },
  { 309, 31, 50, 32, 3, -44 },
  { 503, 39, 41, 32, 0, -40 },
  { 703, 30, 41, 32, 3, -40 },
  { 857, 11, 19, 32, 18, -43 },
  { 884, 25, 56, 32, 9, -45 },
  { 1059, 25, 56, 32, 3, -45 },
  { 1234, 26, 24, 32, 8, -39 },
  { 1312, 28, 28, 32, 4, -31 },
  { 1410, 15, 20, 32, 6, -10 },
  { 1448, 19, 8, 32, 9, -20 },
  { 1467, 11, 11, 32, 10, -10 },
  { 1483, 38, 54, 32, -1, -44 },
  { 1740, 30, 41, 32, 4, -40 },
  { 1894, 25, 39, 32, 4, -39 },
  { 2016, 30, 40, 32, 3, -40 },
  { 2166, 31, 41, 32, 2, -40 },
  { 2325, 31, 39, 32, 3, -39 },
  { 2477, 33, 40, 32, 2, -39 },
  { 2642, 30, 40, 32, 5, -39 },
  { 2792, 30, 39, 32, 7, -39 },
  { 2939, 30, 41, 32, 4, -40 },
  { 3093, 31, 40, 32, 3, -40 },
  { 3248, 16, 30, 32, 10, -29 },
  { 3308, 20, 39, 32, 6, -29 },
  { 3406, 29, 27, 32, 5, -30 },
  { 3504, 31, 18, 32, 3, -26 },
  { 3574, 29, 27, 32, 3, -30 },
  { 3672, 23, 41, 32, 10, -40 },
  { 3790, 32, 49, 32, 3, -40 },
  { 3986, 30, 39, 32, 0, -39 },
  { 4133, 32, 40, 32, 2, -39 },
  { 4293, 30, 41, 32, 6, -40 },
  { 4447, 31, 41, 32, 2, -40 },
  { 4606, 33, 39, 32, 3, -39 },
  { 4767, 33, 39, 32, 4, -39 },
  { 4928, 31, 41, 32, 5, -40 },
  { 5087, 35, 39, 32, 2, -39 },
  { 5258, 34, 39, 32, 2, -39 },
  { 5424, 33, 40, 32, 2, -39 },
  { 5589, 36, 39, 32, 2, -39 },
  { 5765, 26, 39, 32, 3, -39 },
  { 5892, 36, 39, 32, 0, -39 },
  { 6068, 35, 39, 32, 2, -39 },
  { 6239, 30, 41, 32, 4, -40 },
  { 6393, 33, 39, 32, 2, -39 },
  { 6554, 30, 51, 32, 4, -40 },
  { 6746, 32, 39, 32, 2, -39 },
  { 6902, 32, 41, 32, 2, -40 },
  { 7066, 30, 39, 32, 8, -39 },
  { 7213, 32, 40, 32, 4, -39 },
  { 7373, 30, 39, 32, 9, -39 },
  { 7520, 36, 39, 32, 2, -39 },
  { 7696, 38, 39, 32, 0, -39 },
  { 7882, 30, 39, 32, 9, -39 },
  { 8029, 34, 39, 32, 2, -39 },
  { 8195, 30, 54, 32, 6, -44 },
  { 8398, 12, 54, 32, 13, -44 },
  { 8479, 31, 54, 32, 1, -44 },
  { 8689, 29, 23, 32, 5, -39 },
  { 8773, 30, 6, 32, -2, 4 },
  { 8796, 14, 12, 32, 15, -44 },
  { 8817, 29, 32, 32, 4, -31 },
  { 8933, 29, 45, 32, 3, -44 },
  { 9097, 28, 32, 32, 5, -31 },
  { 9209, 33, 45, 32, 4, -44 },
  { 9395, 28, 32, 32, 5, -31 },
  { 9507, 39, 55, 32, -2, -44 },
  { 9776, 34, 42, 32, 0, -31 },
  { 9955, 28, 44, 32, 3, -44 },
  { 10109, 22, 45, 32, 7, -44 },
  { 10233, 30, 55, 32, 0, -44 },
  { 10440, 33, 44, 32, 3, -44 },
  { 10622, 20, 44, 32, 9, -43 },
  { 10732, 32, 30, 32, 1, -30 },
  { 10852, 28, 31, 32, 3, -31 },
  { 10961, 28, 32, 32, 4, -31 },
  { 11073, 32, 41, 32, 0, -31 },
  { 11237, 29, 41, 32, 5, -31 },
  { 11386, 30, 31, 32, 4, -31 },
  { 11503, 29, 32, 32, 3, -31 },
  { 11619, 26, 40, 32, 7, -39 },
  { 11749, 28, 31, 32, 5, -30 },
  { 11858, 28, 30, 32, 7, -30 },
  { 11963, 32, 30, 32, 4, -30 },
  { 12083, 34, 30, 32, 1, -30 },
  { 12211, 38, 41, 32, -3, -30 },
  { 12406, 30, 30, 32, 3, -30 },
  { 12519, 30, 54, 32, 6, -44 },
  { 12722, 21, 54, 32, 8, -44 },
  { 12864, 30, 54, 32, 0, -44 },
  { 13067, 30, 11, 32, 3, -22 },
};

const GFXfont UbuntuMono_BoldItalic63pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic63pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic63pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _UBUNTUMONO_BOLDITALIC63PT7B_H_
