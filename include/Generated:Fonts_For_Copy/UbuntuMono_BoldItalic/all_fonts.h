#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/UbuntuMono_BoldItalic
// Headers: 67

#include "UbuntuMono_BoldItalic6pt7b.h"
#include "UbuntuMono_BoldItalic7pt7b.h"
#include "UbuntuMono_BoldItalic8pt7b.h"
#include "UbuntuMono_BoldItalic9pt7b.h"
#include "UbuntuMono_BoldItalic10pt7b.h"
#include "UbuntuMono_BoldItalic11pt7b.h"
#include "UbuntuMono_BoldItalic12pt7b.h"
#include "UbuntuMono_BoldItalic13pt7b.h"
#include "UbuntuMono_BoldItalic14pt7b.h"
#include "UbuntuMono_BoldItalic15pt7b.h"
#include "UbuntuMono_BoldItalic16pt7b.h"
#include "UbuntuMono_BoldItalic17pt7b.h"
#include "UbuntuMono_BoldItalic18pt7b.h"
#include "UbuntuMono_BoldItalic19pt7b.h"
#include "UbuntuMono_BoldItalic20pt7b.h"
#include "UbuntuMono_BoldItalic21pt7b.h"
#include "UbuntuMono_BoldItalic22pt7b.h"
#include "UbuntuMono_BoldItalic23pt7b.h"
#include "UbuntuMono_BoldItalic24pt7b.h"
#include "UbuntuMono_BoldItalic25pt7b.h"
#include "UbuntuMono_BoldItalic26pt7b.h"
#include "UbuntuMono_BoldItalic27pt7b.h"
#include "UbuntuMono_BoldItalic28pt7b.h"
#include "UbuntuMono_BoldItalic29pt7b.h"
#include "UbuntuMono_BoldItalic30pt7b.h"
#include "UbuntuMono_BoldItalic31pt7b.h"
#include "UbuntuMono_BoldItalic32pt7b.h"
#include "UbuntuMono_BoldItalic33pt7b.h"
#include "UbuntuMono_BoldItalic34pt7b.h"
#include "UbuntuMono_BoldItalic35pt7b.h"
#include "UbuntuMono_BoldItalic36pt7b.h"
#include "UbuntuMono_BoldItalic37pt7b.h"
#include "UbuntuMono_BoldItalic38pt7b.h"
#include "UbuntuMono_BoldItalic39pt7b.h"
#include "UbuntuMono_BoldItalic40pt7b.h"
#include "UbuntuMono_BoldItalic41pt7b.h"
#include "UbuntuMono_BoldItalic42pt7b.h"
#include "UbuntuMono_BoldItalic43pt7b.h"
#include "UbuntuMono_BoldItalic44pt7b.h"
#include "UbuntuMono_BoldItalic45pt7b.h"
#include "UbuntuMono_BoldItalic46pt7b.h"
#include "UbuntuMono_BoldItalic47pt7b.h"
#include "UbuntuMono_BoldItalic48pt7b.h"
#include "UbuntuMono_BoldItalic49pt7b.h"
#include "UbuntuMono_BoldItalic50pt7b.h"
#include "UbuntuMono_BoldItalic51pt7b.h"
#include "UbuntuMono_BoldItalic52pt7b.h"
#include "UbuntuMono_BoldItalic53pt7b.h"
#include "UbuntuMono_BoldItalic54pt7b.h"
#include "UbuntuMono_BoldItalic55pt7b.h"
#include "UbuntuMono_BoldItalic56pt7b.h"
#include "UbuntuMono_BoldItalic57pt7b.h"
#include "UbuntuMono_BoldItalic58pt7b.h"
#include "UbuntuMono_BoldItalic59pt7b.h"
#include "UbuntuMono_BoldItalic60pt7b.h"
#include "UbuntuMono_BoldItalic61pt7b.h"
#include "UbuntuMono_BoldItalic62pt7b.h"
#include "UbuntuMono_BoldItalic63pt7b.h"
#include "UbuntuMono_BoldItalic64pt7b.h"
#include "UbuntuMono_BoldItalic65pt7b.h"
#include "UbuntuMono_BoldItalic66pt7b.h"
#include "UbuntuMono_BoldItalic67pt7b.h"
#include "UbuntuMono_BoldItalic68pt7b.h"
#include "UbuntuMono_BoldItalic69pt7b.h"
#include "UbuntuMono_BoldItalic70pt7b.h"
#include "UbuntuMono_BoldItalic71pt7b.h"
#include "UbuntuMono_BoldItalic72pt7b.h"
