#ifndef _UBUNTUMONO_BOLDITALIC15PT7B_H_
#define _UBUNTUMONO_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x30, 0x0C, 0x60, 0xDE, 0xF7, 0x20, 0x09, 0x05,
  0x8F, 0xCF, 0xE3, 0x63, 0xF9, 0xF8, 0xD0, 0x58, 0x00, 0x0C, 0x71, 0xFB,
  0x07, 0x87, 0xA3, 0x7E, 0xF8, 0x41, 0x80, 0x39, 0x94, 0x9E, 0x86, 0x80,
  0x80, 0xB8, 0xD4, 0xD6, 0xC6, 0x00, 0x1C, 0x79, 0x91, 0x67, 0x9E, 0xE7,
  0x7E, 0xFC, 0x7B, 0x60, 0x04, 0x63, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C,
  0x18, 0x20, 0x10, 0x61, 0x82, 0x0C, 0x30, 0x86, 0x18, 0xC6, 0x30, 0x80,
  0x33, 0xFF, 0xCC, 0x79, 0x20, 0x18, 0x30, 0x47, 0xFF, 0xC6, 0x0C, 0x10,
  0x37, 0x32, 0xE0, 0xFF, 0x80, 0x7D, 0x80, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x00, 0x1C, 0x7D, 0x9A,
  0xBD, 0x78, 0xF3, 0x7E, 0x70, 0x0C, 0xF7, 0x86, 0x18, 0x63, 0x3F, 0xFC,
  0x3C, 0xFC, 0x18, 0x31, 0xC6, 0x10, 0x7E, 0xFC, 0x1E, 0x1F, 0x03, 0x1E,
  0x1C, 0x06, 0x06, 0x7E, 0x7C, 0x06, 0x1C, 0x51, 0x64, 0xDF, 0xFF, 0x84,
  0x18, 0x1F, 0x1F, 0x10, 0x3C, 0x3E, 0x06, 0x06, 0x7E, 0x7C, 0x0E, 0x7D,
  0xC3, 0xEF, 0xD8, 0xF1, 0x7E, 0x78, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x18,
  0x60, 0xC0, 0x3C, 0x7D, 0x9B, 0x33, 0x99, 0xB3, 0x7E, 0x78, 0x3C, 0xFD,
  0x9A, 0x37, 0xE1, 0xC7, 0x7C, 0xE0, 0x33, 0x30, 0x06, 0xE6, 0x18, 0xC6,
  0x00, 0x19, 0xC6, 0x27, 0x00, 0x02, 0x3D, 0xE6, 0x0F, 0x87, 0x83, 0x00,
  0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x40, 0xF0, 0xF8, 0x67, 0xDE, 0x20, 0x00,
  0x79, 0xF0, 0xC6, 0x31, 0x80, 0x18, 0xE0, 0x1E, 0x45, 0x0E, 0x79, 0x76,
  0xED, 0xDA, 0x9D, 0x81, 0xE0, 0x0E, 0x1C, 0x78, 0xB3, 0x67, 0xDF, 0xA3,
  0xC6, 0x3C, 0xFD, 0x9B, 0xE7, 0xD8, 0xF3, 0x7E, 0xF8, 0x1E, 0x3E, 0x70,
  0x60, 0xC0, 0xC0, 0xC0, 0x7C, 0x7C, 0x1E, 0x3F, 0x33, 0x33, 0x23, 0x63,
  0x66, 0x7C, 0x78, 0x3E, 0x3E, 0x60, 0x60, 0x7C, 0x7C, 0xC0, 0xFC, 0xFC,
  0x3F, 0x3F, 0x60, 0x60, 0x7C, 0x7C, 0xC0, 0xC0, 0xC0, 0x1E, 0x3E, 0x70,
  0x60, 0xC6, 0xCC, 0xCC, 0xFC, 0x7C, 0x11, 0x99, 0x8C, 0xC7, 0xE3, 0xF3,
  0x11, 0x98, 0xCC, 0x46, 0x00, 0x3F, 0x7E, 0x18, 0x18, 0x18, 0x30, 0x30,
  0xFC, 0xFC, 0x3E, 0x7C, 0x18, 0x20, 0xC1, 0xA3, 0x7C, 0xF0, 0x11, 0x99,
  0x8D, 0x87, 0x83, 0x83, 0x61, 0xB0, 0xCC, 0x46, 0x00, 0x30, 0x86, 0x18,
  0x61, 0x0C, 0x3F, 0xFC, 0x11, 0x9D, 0x8E, 0xC5, 0xA6, 0xF3, 0x59, 0x08,
  0x84, 0xC6, 0x00, 0x31, 0x9C, 0x8E, 0x45, 0x66, 0xB3, 0x71, 0x98, 0x8C,
  0x46, 0x00, 0x1C, 0xFD, 0x9E, 0x3C, 0x78, 0xF3, 0x7E, 0x78, 0x3C, 0xFD,
  0x9B, 0x37, 0xFF, 0x30, 0x60, 0xC0, 0x1C, 0x7D, 0x9E, 0x3C, 0x78, 0xF3,
  0x7E, 0x78, 0x40, 0xE0, 0xC0, 0x3C, 0xFD, 0x9B, 0x37, 0xDF, 0x36, 0x66,
  0x8C, 0x1F, 0x3F, 0x30, 0x38, 0x1E, 0x0E, 0x46, 0x7E, 0x7C, 0xFF, 0xFC,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x40, 0x63, 0x66, 0x66, 0x46, 0xC6, 0xCC,
  0xCC, 0xFC, 0x78, 0xC7, 0x8F, 0x36, 0x6D, 0x9B, 0x3C, 0x70, 0xE0, 0x63,
  0x63, 0x42, 0x5A, 0xDE, 0xEE, 0xEC, 0xCC, 0xCC, 0x31, 0x8D, 0x87, 0x81,
  0x80, 0xC0, 0xE0, 0xD8, 0xCC, 0xC6, 0x00, 0xC7, 0x99, 0x33, 0xC7, 0x0C,
  0x18, 0x30, 0x60, 0x1F, 0x1F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFC,
  0x7E, 0x00, 0x1F, 0x1E, 0x18, 0x10, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x78, 0xF8, 0xDB, 0x64, 0x9B, 0x6D, 0xB0, 0x1E, 0x1E, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0xF8, 0xF8, 0x0C, 0x38, 0xF3, 0x3C, 0x60,
  0x7E, 0x99, 0x00, 0x3E, 0xFF, 0x96, 0x6C, 0xDF, 0x9F, 0x00, 0x30, 0x61,
  0x83, 0xE7, 0xCC, 0xF1, 0x66, 0xFD, 0xE0, 0x1E, 0xFD, 0x86, 0x0C, 0x1F,
  0x9F, 0x00, 0x03, 0x06, 0x06, 0x3E, 0x7E, 0xE4, 0xCC, 0xCC, 0xFC, 0x7C,
  0x3C, 0xFF, 0x1F, 0xEC, 0x1F, 0x9E, 0x00, 0x03, 0xC1, 0xE0, 0x60, 0x7E,
  0x1F, 0x83, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x07, 0x81, 0xC0, 0x1F, 0x3F,
  0x62, 0x66, 0x7E, 0x3E, 0x0C, 0xFC, 0xF8, 0x30, 0xC6, 0x1F, 0x7D, 0x94,
  0xF3, 0xCF, 0x20, 0x31, 0x81, 0xEE, 0x31, 0x8C, 0x7B, 0xC0, 0x06, 0x0C,
  0x01, 0xF3, 0xE0, 0x83, 0x06, 0x0D, 0x33, 0xE7, 0x80, 0x30, 0x30, 0x30,
  0x66, 0x6C, 0x78, 0x70, 0xD8, 0xCC, 0xCC, 0xF7, 0x8C, 0x46, 0x31, 0x88,
  0x7B, 0xC0, 0x3F, 0x3F, 0x6B, 0x6B, 0x62, 0x42, 0xC6, 0x7D, 0xF6, 0x53,
  0xCF, 0x3C, 0x80, 0x3C, 0xFB, 0x1E, 0x2C, 0xDF, 0x9C, 0x00, 0x3E, 0x3E,
  0x33, 0x62, 0x66, 0x7E, 0x78, 0xC0, 0xC0, 0x3E, 0xFF, 0x96, 0x6C, 0xDF,
  0x9E, 0x0C, 0x18, 0x3E, 0xFD, 0x83, 0x06, 0x18, 0x30, 0x00, 0x3C, 0xF9,
  0x81, 0xC8, 0xDF, 0xBE, 0x00, 0x30, 0x8F, 0xFF, 0x61, 0x0C, 0x3E, 0x78,
  0x66, 0xCD, 0x36, 0x6C, 0xDF, 0x9F, 0x00, 0xCF, 0x3D, 0xB6, 0xF3, 0x8E,
  0x00, 0xC3, 0xD2, 0xD6, 0xF4, 0xBC, 0xDC, 0xC8, 0x33, 0x36, 0x1C, 0x18,
  0x3C, 0x64, 0x66, 0x19, 0x8C, 0xC6, 0xC3, 0x41, 0xE0, 0x60, 0x60, 0xF0,
  0xE0, 0x00, 0x7E, 0xFC, 0x31, 0x86, 0x1F, 0xBE, 0x00, 0x0F, 0x0E, 0x18,
  0x18, 0x10, 0x70, 0x60, 0x30, 0x20, 0x60, 0x78, 0x38, 0x18, 0x8C, 0x63,
  0x11, 0x8C, 0x62, 0x31, 0x80, 0x1C, 0x38, 0x10, 0x60, 0xC1, 0xC3, 0x8C,
  0x18, 0x33, 0xC7, 0x80, 0x77, 0xFA, 0x70,
};

const GFXglyph UbuntuMono_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 9, 8, 2, -9 },
  { 7, 5, 4, 8, 3, -10 },
  { 10, 9, 9, 8, 0, -9 },
  { 21, 7, 11, 8, 1, -10 },
  { 31, 9, 9, 8, 0, -9 },
  { 42, 7, 9, 8, 1, -9 },
  { 50, 3, 4, 8, 4, -10 },
  { 52, 6, 13, 8, 2, -11 },
  { 62, 6, 13, 8, 1, -11 },
  { 72, 6, 6, 8, 2, -9 },
  { 77, 7, 8, 8, 1, -7 },
  { 84, 4, 5, 8, 1, -3 },
  { 87, 5, 2, 8, 2, -5 },
  { 89, 3, 3, 8, 2, -3 },
  { 91, 9, 12, 8, 0, -10 },
  { 105, 7, 9, 8, 1, -9 },
  { 113, 6, 9, 8, 1, -9 },
  { 120, 7, 9, 8, 1, -9 },
  { 128, 8, 9, 8, 0, -9 },
  { 137, 7, 9, 8, 1, -9 },
  { 145, 8, 9, 8, 0, -9 },
  { 154, 7, 9, 8, 1, -9 },
  { 162, 7, 9, 8, 2, -9 },
  { 170, 7, 9, 8, 1, -9 },
  { 178, 7, 9, 8, 1, -9 },
  { 186, 4, 8, 8, 2, -8 },
  { 190, 5, 10, 8, 1, -8 },
  { 197, 7, 7, 8, 1, -7 },
  { 204, 7, 5, 8, 1, -6 },
  { 209, 7, 7, 8, 1, -7 },
  { 216, 6, 9, 8, 2, -9 },
  { 223, 7, 11, 8, 1, -9 },
  { 233, 7, 9, 8, 0, -9 },
  { 241, 7, 9, 8, 1, -9 },
  { 249, 8, 9, 8, 1, -9 },
  { 258, 8, 9, 8, 0, -9 },
  { 267, 8, 9, 8, 1, -9 },
  { 276, 8, 9, 8, 1, -9 },
  { 285, 8, 9, 8, 1, -9 },
  { 294, 9, 9, 8, 0, -9 },
  { 305, 8, 9, 8, 1, -9 },
  { 314, 7, 9, 8, 1, -9 },
  { 322, 9, 9, 8, 0, -9 },
  { 333, 6, 9, 8, 1, -9 },
  { 340, 9, 9, 8, 0, -9 },
  { 351, 9, 9, 8, 0, -9 },
  { 362, 7, 9, 8, 1, -9 },
  { 370, 7, 9, 8, 1, -9 },
  { 378, 7, 12, 8, 1, -9 },
  { 389, 7, 9, 8, 1, -9 },
  { 397, 8, 9, 8, 0, -9 },
  { 406, 7, 9, 8, 2, -9 },
  { 414, 8, 9, 8, 1, -9 },
  { 423, 7, 9, 8, 2, -9 },
  { 431, 8, 9, 8, 1, -9 },
  { 440, 9, 9, 8, 0, -9 },
  { 451, 7, 9, 8, 2, -9 },
  { 459, 9, 9, 8, 0, -9 },
  { 470, 8, 12, 8, 1, -10 },
  { 482, 3, 12, 8, 3, -10 },
  { 487, 8, 12, 8, 0, -10 },
  { 499, 7, 5, 8, 1, -9 },
  { 504, 8, 1, 8, -1, 1 },
  { 505, 3, 3, 8, 4, -10 },
  { 507, 7, 7, 8, 1, -7 },
  { 514, 7, 10, 8, 1, -10 },
  { 523, 7, 7, 8, 1, -7 },
  { 530, 8, 10, 8, 1, -10 },
  { 540, 7, 7, 8, 1, -7 },
  { 547, 10, 12, 8, -1, -10 },
  { 562, 8, 9, 8, 0, -7 },
  { 571, 6, 10, 8, 1, -10 },
  { 579, 5, 10, 8, 2, -10 },
  { 586, 7, 12, 8, 0, -10 },
  { 597, 8, 10, 8, 1, -10 },
  { 607, 5, 10, 8, 2, -10 },
  { 614, 8, 7, 8, 0, -7 },
  { 621, 6, 7, 8, 1, -7 },
  { 627, 7, 7, 8, 1, -7 },
  { 634, 8, 9, 8, 0, -7 },
  { 643, 7, 9, 8, 1, -7 },
  { 651, 7, 7, 8, 1, -7 },
  { 658, 7, 7, 8, 1, -7 },
  { 665, 6, 9, 8, 2, -9 },
  { 672, 7, 7, 8, 1, -7 },
  { 679, 6, 7, 8, 2, -7 },
  { 685, 8, 7, 8, 1, -7 },
  { 692, 8, 7, 8, 0, -7 },
  { 699, 9, 9, 8, -1, -7 },
  { 710, 7, 7, 8, 1, -7 },
  { 717, 8, 12, 8, 1, -10 },
  { 729, 5, 12, 8, 2, -10 },
  { 737, 7, 12, 8, 0, -10 },
  { 748, 7, 3, 8, 1, -5 },
};

const GFXfont UbuntuMono_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic15pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _UBUNTUMONO_BOLDITALIC15PT7B_H_
