#ifndef _UBUNTUMONO_BOLDITALIC28PT7B_H_
#define _UBUNTUMONO_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0x80,
  0x00, 0x3C, 0x78, 0xE0, 0x79, 0xCF, 0x39, 0xCF, 0x39, 0xE7, 0x38, 0xC7,
  0x38, 0xE7, 0x18, 0x01, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x39, 0xC3, 0xFF,
  0xE7, 0xFF, 0xDF, 0xFF, 0x07, 0x38, 0x1C, 0x60, 0x39, 0xC3, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0x8E, 0x30, 0x1C, 0xE0, 0x31, 0x80, 0xE7, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0xFE, 0x0F, 0xFC, 0x3F, 0xE1, 0xE0, 0x87,
  0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x60, 0xF1, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x87, 0xC3, 0x87, 0x63, 0x83, 0x31,
  0x81, 0x99, 0x80, 0xDD, 0x80, 0x7D, 0xC0, 0x3D, 0xC0, 0x01, 0xC0, 0x01,
  0xDE, 0x00, 0xDF, 0x00, 0xCD, 0xC0, 0xCC, 0xE0, 0xE6, 0x60, 0xE3, 0x30,
  0xE1, 0xF0, 0x60, 0x70, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0x9C,
  0x0C, 0x30, 0x71, 0xC0, 0xCE, 0x03, 0xF0, 0x1F, 0x90, 0xFC, 0x67, 0xBB,
  0x9C, 0xFE, 0xE1, 0xF3, 0xC3, 0x8F, 0xFF, 0x1F, 0xFC, 0x3E, 0x70, 0x7B,
  0xBD, 0xEE, 0x73, 0x98, 0x00, 0x40, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x01,
  0xC0, 0x10, 0x00, 0x01, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80,
  0x40, 0x00, 0x07, 0x00, 0x70, 0x67, 0x27, 0xEF, 0x7F, 0xF3, 0xFC, 0x0F,
  0x01, 0xF8, 0x3D, 0xC3, 0x9C, 0x08, 0x80, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x00, 0x1C, 0xF3, 0xCF, 0x3C, 0x77, 0xBC, 0xC0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFC, 0x78,
  0xF3, 0x83, 0xBC, 0x1D, 0xCC, 0xEE, 0xE7, 0xF7, 0x7F, 0x03, 0xB8, 0x1D,
  0xC1, 0xEE, 0x0E, 0x78, 0xF1, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0x00, 0xE0,
  0x7C, 0x3F, 0x1F, 0xE3, 0xFC, 0x67, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x3F, 0xE1, 0xFF, 0xC3, 0x0F, 0x08, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0xE0, 0xFF, 0x83, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x7F, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x71, 0x07, 0xCF, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x1C, 0xE0, 0xE7, 0x87, 0x1C,
  0x38, 0x71, 0xC1, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x08, 0x1E, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80,
  0x00, 0x7C, 0x0F, 0xE0, 0xFF, 0x87, 0xE0, 0x3C, 0x00, 0xE0, 0x07, 0x7C,
  0x1F, 0xF8, 0xFF, 0xF3, 0xC3, 0xCE, 0x07, 0x38, 0x1C, 0xF0, 0xF3, 0xC3,
  0x87, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0x9C, 0x1C, 0x73, 0xC3,
  0xFC, 0x1F, 0xC3, 0xCF, 0x3C, 0x39, 0xC1, 0xEE, 0x0F, 0x78, 0xF3, 0xFF,
  0x8F, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x70, 0xF7, 0x87,
  0xB8, 0x1D, 0xC0, 0xEF, 0x0F, 0x7F, 0xF9, 0xFF, 0x87, 0xBC, 0x01, 0xC0,
  0x1E, 0x07, 0xE3, 0xFE, 0x1F, 0xC0, 0xF8, 0x00, 0x1C, 0x78, 0xF1, 0xE3,
  0x80, 0x00, 0x00, 0x71, 0xE3, 0xC7, 0x8E, 0x00, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE1,
  0xE1, 0xE0, 0xC0, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xE7, 0xF8,
  0x3E, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x80,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x9F, 0xFC, 0xFF, 0xF0, 0x10, 0x00, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7C, 0x03, 0xE0, 0xFF, 0x3F, 0xC3, 0xF0, 0x1E, 0x00, 0x80, 0x00,
  0x1F, 0x8F, 0xF8, 0xFF, 0x90, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x1F,
  0x03, 0xC0, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xC0, 0x70, 0x00,
  0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xC7, 0xF7, 0x3F,
  0xB9, 0xFE, 0xEF, 0x3B, 0xB8, 0xEC, 0xE7, 0x33, 0x9C, 0xCE, 0x73, 0x3F,
  0xCC, 0x7E, 0x38, 0xF8, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3B, 0x81, 0xDC, 0x1C,
  0xE1, 0xE7, 0x0E, 0x38, 0xF1, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF, 0xBC, 0x1D,
  0xC0, 0xEE, 0x07, 0xF0, 0x38, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F,
  0x1C, 0x1C, 0x70, 0xE1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xE1, 0xE3, 0x83,
  0x9E, 0x0E, 0x70, 0x79, 0xC3, 0xC7, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0x01,
  0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x87,
  0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0x8E,
  0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x3C, 0xE0, 0xE7, 0x87,
  0x9E, 0x1E, 0x70, 0xF1, 0xC7, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC7, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x87, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3,
  0xE3, 0x87, 0xFE, 0x1F, 0xF8, 0x1F, 0x80, 0x0E, 0x0E, 0x1C, 0x1C, 0x78,
  0x78, 0xE0, 0xF1, 0xC1, 0xC3, 0x87, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8,
  0x70, 0x71, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x3C, 0x3C, 0x78,
  0x78, 0xE0, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x0C,
  0x3C, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0x00, 0x0E, 0x0F, 0x0E, 0x1E, 0x1E,
  0x3C, 0x1E, 0x78, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3B, 0x80, 0x7B, 0xC0, 0x79, 0xE0, 0x71, 0xE0, 0x70, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xE0, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0x07, 0x07, 0x07, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1F, 0x0F, 0x9E, 0x1D, 0xB6, 0x1D, 0xBE, 0x1D, 0xEE, 0x19,
  0xEE, 0x39, 0xCC, 0x39, 0xDC, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x38, 0x0E, 0x0E, 0x3C, 0x1C, 0x7C, 0x38, 0xF8,
  0xF1, 0xF1, 0xC3, 0xE3, 0x8E, 0xE7, 0x1D, 0xCE, 0x39, 0xB8, 0x73, 0x71,
  0xC7, 0xE3, 0x8F, 0xC7, 0x0F, 0x0E, 0x1E, 0x38, 0x3C, 0x70, 0x78, 0xE0,
  0xE0, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1D, 0xC1, 0xEE, 0x0E, 0x78, 0xF3,
  0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0xF1,
  0xE1, 0xE1, 0xE3, 0x83, 0x87, 0x07, 0x1E, 0x3E, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1D, 0xC1, 0xEE, 0x0E, 0x78, 0xF3,
  0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x01,
  0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1C, 0x3C, 0x70, 0xF1,
  0xC3, 0xCF, 0x1E, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x1E, 0x70, 0x79, 0xE1,
  0xC3, 0x87, 0x0F, 0x3C, 0x3C, 0xE0, 0x70, 0x03, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC7, 0x82, 0x1C, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x71, 0x83, 0xCF, 0xFE, 0x3F, 0xF8, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0E,
  0x38, 0x39, 0xE1, 0xE7, 0x87, 0x9C, 0x1C, 0x70, 0x73, 0xC3, 0xCF, 0x0F,
  0x38, 0x38, 0xE1, 0xE3, 0xC7, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0xE0,
  0x7F, 0x03, 0xF8, 0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x78,
  0xE3, 0x87, 0x3C, 0x39, 0xC1, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x0F,
  0x00, 0x78, 0x00, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x39, 0x9C, 0x3B, 0x9C, 0x33, 0x9C, 0x77, 0xD8, 0x76,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0,
  0xE0, 0x0F, 0x07, 0x83, 0x87, 0x81, 0xE3, 0x80, 0x73, 0x80, 0x3B, 0xC0,
  0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xFC,
  0x01, 0xEE, 0x00, 0xE7, 0x00, 0xF3, 0xC0, 0xF1, 0xE0, 0xF0, 0x70, 0xF0,
  0x38, 0x00, 0xE0, 0x7F, 0x03, 0xBC, 0x3C, 0xE1, 0xC7, 0x1C, 0x39, 0xE1,
  0xCE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xE7, 0x39,
  0xCE, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7B, 0xDE, 0xF3, 0x9C,
  0xE7, 0x38, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xC0,
  0x1F, 0x01, 0xF8, 0x1F, 0xC1, 0xEF, 0x0E, 0x78, 0xF1, 0xCF, 0x0F, 0xF0,
  0x79, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x43, 0x8F, 0x9F, 0x18,
  0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0xF8, 0xE7, 0x0F, 0x78, 0x7B, 0x83, 0x9C,
  0x1C, 0xE1, 0xE7, 0x8F, 0x3F, 0xF8, 0xFF, 0xC3, 0xCE, 0x00, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0x83, 0xFE, 0x3F,
  0xF9, 0xE3, 0xCF, 0x0E, 0x70, 0x77, 0x87, 0xBC, 0x3D, 0xC1, 0xCE, 0x3E,
  0x7F, 0xE7, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0xCF, 0xFC, 0xF8, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0xFF,
  0xC1, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xF1, 0xF1, 0xC7, 0x0F, 0x3C, 0x38,
  0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x3C, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xCE,
  0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0xF8, 0xF7, 0x07, 0x78, 0x7B, 0xFF,
  0x9F, 0xF0, 0xF0, 0x07, 0x80, 0x1F, 0xF8, 0xFF, 0xC1, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xF0,
  0xE1, 0xC1, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1C, 0x3C, 0x78, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7B, 0x80, 0x0F, 0x00, 0x1E, 0x10, 0x78, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFE, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x7F, 0x83, 0xFE, 0x1F, 0xF9, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0x87,
  0x1C, 0x39, 0xE1, 0xCF, 0x1E, 0x70, 0xE3, 0x87, 0x3C, 0x38, 0x07, 0x03,
  0xE0, 0xF8, 0x1C, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0xFE, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3F, 0xC7, 0xF0, 0xF8, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x84, 0x3C, 0x7F, 0xC3, 0xFC, 0x0F,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC3, 0x8F, 0x1E, 0x3C, 0xE0, 0xE7, 0x03, 0xB8, 0x1F, 0xC0, 0x7F, 0x01,
  0xDE, 0x07, 0x38, 0x3C, 0xF0, 0xF1, 0xC3, 0x87, 0x8E, 0x1E, 0x00, 0x7F,
  0x7F, 0x3F, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xF1, 0x7F, 0xBF, 0xCF, 0xC0, 0x1F, 0x78, 0xFF,
  0xF3, 0xFF, 0xCE, 0xE7, 0x3B, 0x9D, 0xCE, 0x67, 0x3B, 0x9C, 0xCE, 0x70,
  0x3B, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x70, 0x0F, 0xE0, 0xFF, 0x87,
  0xFE, 0x38, 0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0xC7,
  0x9C, 0x38, 0xE1, 0xCF, 0x1E, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0x8F,
  0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEF, 0x1E, 0xFF, 0xC7, 0xF8,
  0x3E, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1E, 0x1C, 0x70,
  0x71, 0xC1, 0xCF, 0x0F, 0x3C, 0x78, 0xE3, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F,
  0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0xFF, 0xCF, 0xFE, 0xF8, 0xE7, 0x87, 0x78, 0x7B, 0xC3, 0xDC, 0x1C, 0xE1,
  0xE7, 0x8F, 0x3F, 0xF8, 0xFF, 0x83, 0xDC, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x00, 0x07, 0xF8, 0xFF, 0xC7, 0xFC, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0xC7, 0xFC, 0x3C, 0x21, 0xC0, 0x0F, 0x80,
  0x3F, 0x80, 0x7C, 0x00, 0xF3, 0x07, 0x9F, 0xF9, 0xFF, 0x83, 0xF8, 0x00,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xE1, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x84, 0x7F, 0xC3, 0xFC,
  0x1F, 0x80, 0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x0F, 0x38, 0x73,
  0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3F, 0xF8, 0xFF, 0xC3, 0xCE, 0x00,
  0xF0, 0x77, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0x1E, 0x79, 0xE1, 0xCE, 0x0E,
  0xF0, 0x77, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0x80, 0x00, 0x70, 0x1D,
  0xC0, 0x7E, 0x03, 0xB9, 0xCE, 0xE7, 0x3B, 0xBC, 0xCE, 0xF7, 0x3F, 0xDC,
  0xDB, 0x63, 0xEF, 0x8F, 0x3C, 0x38, 0xF0, 0xE1, 0x80, 0x1E, 0x1E, 0x1C,
  0x38, 0x3C, 0xF0, 0x3B, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xF0,
  0x0F, 0xE0, 0x3D, 0xE0, 0x71, 0xC1, 0xC3, 0xC7, 0x87, 0x80, 0x0F, 0x07,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x3C,
  0x07, 0x38, 0x07, 0x78, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x81, 0xF8, 0x0F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x78, 0x07, 0xE0, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x1E, 0x18, 0xFC, 0x77, 0xFF, 0x9C,
  0xFC, 0x61, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 17, 14, 5, -17 },
  { 16, 11, 8, 14, 5, -19 },
  { 27, 15, 17, 14, 1, -17 },
  { 59, 14, 23, 14, 1, -20 },
  { 100, 17, 17, 14, 0, -17 },
  { 137, 14, 17, 14, 1, -17 },
  { 167, 5, 8, 14, 8, -19 },
  { 172, 11, 25, 14, 4, -20 },
  { 207, 11, 25, 14, 1, -20 },
  { 242, 12, 11, 14, 3, -17 },
  { 259, 12, 13, 14, 2, -14 },
  { 279, 6, 9, 14, 3, -5 },
  { 286, 8, 3, 14, 4, -9 },
  { 289, 4, 5, 14, 5, -5 },
  { 292, 16, 25, 14, 0, -20 },
  { 342, 13, 17, 14, 2, -17 },
  { 370, 11, 17, 14, 2, -17 },
  { 394, 14, 17, 14, 1, -17 },
  { 424, 14, 17, 14, 1, -17 },
  { 454, 14, 17, 14, 1, -17 },
  { 484, 15, 17, 14, 1, -17 },
  { 516, 14, 17, 14, 2, -17 },
  { 546, 14, 17, 14, 3, -17 },
  { 576, 13, 17, 14, 2, -17 },
  { 604, 13, 17, 14, 2, -17 },
  { 632, 7, 13, 14, 5, -13 },
  { 644, 9, 17, 14, 3, -13 },
  { 664, 13, 12, 14, 2, -13 },
  { 684, 14, 9, 14, 1, -12 },
  { 700, 13, 12, 14, 1, -13 },
  { 720, 11, 17, 14, 4, -17 },
  { 744, 14, 21, 14, 2, -17 },
  { 781, 13, 17, 14, 0, -17 },
  { 809, 14, 17, 14, 1, -17 },
  { 839, 14, 17, 14, 2, -17 },
  { 869, 14, 17, 14, 1, -17 },
  { 899, 15, 17, 14, 1, -17 },
  { 931, 14, 17, 14, 2, -17 },
  { 961, 14, 17, 14, 2, -17 },
  { 991, 15, 17, 14, 1, -17 },
  { 1023, 15, 17, 14, 1, -17 },
  { 1055, 15, 17, 14, 1, -17 },
  { 1087, 16, 17, 14, 1, -17 },
  { 1121, 12, 17, 14, 1, -17 },
  { 1147, 16, 17, 14, 0, -17 },
  { 1181, 15, 17, 14, 1, -17 },
  { 1213, 13, 17, 14, 2, -17 },
  { 1241, 15, 17, 14, 1, -17 },
  { 1273, 13, 22, 14, 2, -17 },
  { 1309, 14, 17, 14, 1, -17 },
  { 1339, 14, 17, 14, 1, -17 },
  { 1369, 13, 17, 14, 4, -17 },
  { 1397, 14, 17, 14, 2, -17 },
  { 1427, 13, 17, 14, 4, -17 },
  { 1455, 16, 17, 14, 1, -17 },
  { 1489, 17, 17, 14, 0, -17 },
  { 1526, 13, 17, 14, 4, -17 },
  { 1554, 15, 17, 14, 1, -17 },
  { 1586, 14, 25, 14, 2, -20 },
  { 1630, 5, 25, 14, 6, -20 },
  { 1646, 14, 25, 14, 0, -20 },
  { 1690, 13, 10, 14, 2, -17 },
  { 1707, 13, 3, 14, -1, 2 },
  { 1712, 6, 5, 14, 7, -19 },
  { 1716, 13, 13, 14, 2, -13 },
  { 1738, 13, 19, 14, 1, -19 },
  { 1769, 13, 13, 14, 2, -13 },
  { 1791, 14, 19, 14, 2, -19 },
  { 1825, 13, 13, 14, 2, -13 },
  { 1847, 18, 24, 14, -1, -19 },
  { 1901, 15, 18, 14, 0, -13 },
  { 1935, 13, 19, 14, 1, -19 },
  { 1966, 10, 19, 14, 3, -19 },
  { 1990, 13, 24, 14, 0, -19 },
  { 2029, 14, 19, 14, 2, -19 },
  { 2063, 9, 19, 14, 4, -19 },
  { 2085, 14, 13, 14, 1, -13 },
  { 2108, 13, 13, 14, 1, -13 },
  { 2130, 12, 13, 14, 2, -13 },
  { 2150, 14, 18, 14, 0, -13 },
  { 2182, 13, 18, 14, 2, -13 },
  { 2212, 13, 13, 14, 2, -13 },
  { 2234, 13, 13, 14, 1, -13 },
  { 2256, 12, 17, 14, 3, -17 },
  { 2282, 13, 13, 14, 2, -13 },
  { 2304, 13, 13, 14, 3, -13 },
  { 2326, 14, 13, 14, 2, -13 },
  { 2349, 15, 13, 14, 0, -13 },
  { 2374, 16, 18, 14, -1, -13 },
  { 2410, 14, 13, 14, 1, -13 },
  { 2433, 13, 25, 14, 3, -20 },
  { 2474, 10, 25, 14, 3, -20 },
  { 2506, 14, 25, 14, 0, -20 },
  { 2550, 14, 5, 14, 1, -10 },
};

const GFXfont UbuntuMono_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic28pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUMONO_BOLDITALIC28PT7B_H_
