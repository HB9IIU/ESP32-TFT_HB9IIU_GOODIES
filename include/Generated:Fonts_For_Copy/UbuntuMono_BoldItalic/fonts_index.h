#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &UbuntuMono_BoldItalic6pt7b, 6, "UbuntuMono_BoldItalic6pt7b" },
  { &UbuntuMono_BoldItalic7pt7b, 7, "UbuntuMono_BoldItalic7pt7b" },
  { &UbuntuMono_BoldItalic8pt7b, 8, "UbuntuMono_BoldItalic8pt7b" },
  { &UbuntuMono_BoldItalic9pt7b, 9, "UbuntuMono_BoldItalic9pt7b" },
  { &UbuntuMono_BoldItalic10pt7b, 10, "UbuntuMono_BoldItalic10pt7b" },
  { &UbuntuMono_BoldItalic11pt7b, 11, "UbuntuMono_BoldItalic11pt7b" },
  { &UbuntuMono_BoldItalic12pt7b, 12, "UbuntuMono_BoldItalic12pt7b" },
  { &UbuntuMono_BoldItalic13pt7b, 13, "UbuntuMono_BoldItalic13pt7b" },
  { &UbuntuMono_BoldItalic14pt7b, 14, "UbuntuMono_BoldItalic14pt7b" },
  { &UbuntuMono_BoldItalic15pt7b, 15, "UbuntuMono_BoldItalic15pt7b" },
  { &UbuntuMono_BoldItalic16pt7b, 16, "UbuntuMono_BoldItalic16pt7b" },
  { &UbuntuMono_BoldItalic17pt7b, 17, "UbuntuMono_BoldItalic17pt7b" },
  { &UbuntuMono_BoldItalic18pt7b, 18, "UbuntuMono_BoldItalic18pt7b" },
  { &UbuntuMono_BoldItalic19pt7b, 19, "UbuntuMono_BoldItalic19pt7b" },
  { &UbuntuMono_BoldItalic20pt7b, 20, "UbuntuMono_BoldItalic20pt7b" },
  { &UbuntuMono_BoldItalic21pt7b, 21, "UbuntuMono_BoldItalic21pt7b" },
  { &UbuntuMono_BoldItalic22pt7b, 22, "UbuntuMono_BoldItalic22pt7b" },
  { &UbuntuMono_BoldItalic23pt7b, 23, "UbuntuMono_BoldItalic23pt7b" },
  { &UbuntuMono_BoldItalic24pt7b, 24, "UbuntuMono_BoldItalic24pt7b" },
  { &UbuntuMono_BoldItalic25pt7b, 25, "UbuntuMono_BoldItalic25pt7b" },
  { &UbuntuMono_BoldItalic26pt7b, 26, "UbuntuMono_BoldItalic26pt7b" },
  { &UbuntuMono_BoldItalic27pt7b, 27, "UbuntuMono_BoldItalic27pt7b" },
  { &UbuntuMono_BoldItalic28pt7b, 28, "UbuntuMono_BoldItalic28pt7b" },
  { &UbuntuMono_BoldItalic29pt7b, 29, "UbuntuMono_BoldItalic29pt7b" },
  { &UbuntuMono_BoldItalic30pt7b, 30, "UbuntuMono_BoldItalic30pt7b" },
  { &UbuntuMono_BoldItalic31pt7b, 31, "UbuntuMono_BoldItalic31pt7b" },
  { &UbuntuMono_BoldItalic32pt7b, 32, "UbuntuMono_BoldItalic32pt7b" },
  { &UbuntuMono_BoldItalic33pt7b, 33, "UbuntuMono_BoldItalic33pt7b" },
  { &UbuntuMono_BoldItalic34pt7b, 34, "UbuntuMono_BoldItalic34pt7b" },
  { &UbuntuMono_BoldItalic35pt7b, 35, "UbuntuMono_BoldItalic35pt7b" },
  { &UbuntuMono_BoldItalic36pt7b, 36, "UbuntuMono_BoldItalic36pt7b" },
  { &UbuntuMono_BoldItalic37pt7b, 37, "UbuntuMono_BoldItalic37pt7b" },
  { &UbuntuMono_BoldItalic38pt7b, 38, "UbuntuMono_BoldItalic38pt7b" },
  { &UbuntuMono_BoldItalic39pt7b, 39, "UbuntuMono_BoldItalic39pt7b" },
  { &UbuntuMono_BoldItalic40pt7b, 40, "UbuntuMono_BoldItalic40pt7b" },
  { &UbuntuMono_BoldItalic41pt7b, 41, "UbuntuMono_BoldItalic41pt7b" },
  { &UbuntuMono_BoldItalic42pt7b, 42, "UbuntuMono_BoldItalic42pt7b" },
  { &UbuntuMono_BoldItalic43pt7b, 43, "UbuntuMono_BoldItalic43pt7b" },
  { &UbuntuMono_BoldItalic44pt7b, 44, "UbuntuMono_BoldItalic44pt7b" },
  { &UbuntuMono_BoldItalic45pt7b, 45, "UbuntuMono_BoldItalic45pt7b" },
  { &UbuntuMono_BoldItalic46pt7b, 46, "UbuntuMono_BoldItalic46pt7b" },
  { &UbuntuMono_BoldItalic47pt7b, 47, "UbuntuMono_BoldItalic47pt7b" },
  { &UbuntuMono_BoldItalic48pt7b, 48, "UbuntuMono_BoldItalic48pt7b" },
  { &UbuntuMono_BoldItalic49pt7b, 49, "UbuntuMono_BoldItalic49pt7b" },
  { &UbuntuMono_BoldItalic50pt7b, 50, "UbuntuMono_BoldItalic50pt7b" },
  { &UbuntuMono_BoldItalic51pt7b, 51, "UbuntuMono_BoldItalic51pt7b" },
  { &UbuntuMono_BoldItalic52pt7b, 52, "UbuntuMono_BoldItalic52pt7b" },
  { &UbuntuMono_BoldItalic53pt7b, 53, "UbuntuMono_BoldItalic53pt7b" },
  { &UbuntuMono_BoldItalic54pt7b, 54, "UbuntuMono_BoldItalic54pt7b" },
  { &UbuntuMono_BoldItalic55pt7b, 55, "UbuntuMono_BoldItalic55pt7b" },
  { &UbuntuMono_BoldItalic56pt7b, 56, "UbuntuMono_BoldItalic56pt7b" },
  { &UbuntuMono_BoldItalic57pt7b, 57, "UbuntuMono_BoldItalic57pt7b" },
  { &UbuntuMono_BoldItalic58pt7b, 58, "UbuntuMono_BoldItalic58pt7b" },
  { &UbuntuMono_BoldItalic59pt7b, 59, "UbuntuMono_BoldItalic59pt7b" },
  { &UbuntuMono_BoldItalic60pt7b, 60, "UbuntuMono_BoldItalic60pt7b" },
  { &UbuntuMono_BoldItalic61pt7b, 61, "UbuntuMono_BoldItalic61pt7b" },
  { &UbuntuMono_BoldItalic62pt7b, 62, "UbuntuMono_BoldItalic62pt7b" },
  { &UbuntuMono_BoldItalic63pt7b, 63, "UbuntuMono_BoldItalic63pt7b" },
  { &UbuntuMono_BoldItalic64pt7b, 64, "UbuntuMono_BoldItalic64pt7b" },
  { &UbuntuMono_BoldItalic65pt7b, 65, "UbuntuMono_BoldItalic65pt7b" },
  { &UbuntuMono_BoldItalic66pt7b, 66, "UbuntuMono_BoldItalic66pt7b" },
  { &UbuntuMono_BoldItalic67pt7b, 67, "UbuntuMono_BoldItalic67pt7b" },
  { &UbuntuMono_BoldItalic68pt7b, 68, "UbuntuMono_BoldItalic68pt7b" },
  { &UbuntuMono_BoldItalic69pt7b, 69, "UbuntuMono_BoldItalic69pt7b" },
  { &UbuntuMono_BoldItalic70pt7b, 70, "UbuntuMono_BoldItalic70pt7b" },
  { &UbuntuMono_BoldItalic71pt7b, 71, "UbuntuMono_BoldItalic71pt7b" },
  { &UbuntuMono_BoldItalic72pt7b, 72, "UbuntuMono_BoldItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
