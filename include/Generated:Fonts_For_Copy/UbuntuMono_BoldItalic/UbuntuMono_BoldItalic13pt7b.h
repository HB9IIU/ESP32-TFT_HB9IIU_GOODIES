#ifndef _UBUNTUMONO_BOLDITALIC13PT7B_H_
#define _UBUNTUMONO_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x40, 0xCC, 0xFB, 0xBA, 0x1A, 0x2D, 0xF9, 0x22, 0xCF,
  0xD6, 0x28, 0x18, 0xE7, 0xD0, 0x70, 0xE0, 0xBE, 0x71, 0x80, 0x33, 0x52,
  0x54, 0x68, 0x16, 0x2A, 0x4A, 0xCC, 0x39, 0xA4, 0x9C, 0xFE, 0x69, 0xBA,
  0xFA, 0x09, 0x98, 0x8C, 0x42, 0x10, 0xC6, 0x10, 0x21, 0x86, 0x31, 0x8C,
  0x46, 0x66, 0x20, 0x25, 0xFE, 0xE5, 0x00, 0x10, 0xCF, 0x88, 0x20, 0x6D,
  0xE0, 0xFE, 0xF0, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60,
  0x40, 0xC0, 0x39, 0xF4, 0xFF, 0xBE, 0x6F, 0x9C, 0x1B, 0xD4, 0x23, 0x1B,
  0xFF, 0x39, 0xF4, 0xC2, 0x31, 0x0F, 0xBE, 0x3C, 0x7C, 0x18, 0xE1, 0x80,
  0x9F, 0x3C, 0x0C, 0x72, 0x92, 0xFF, 0xF1, 0x04, 0x1E, 0x3C, 0xC1, 0xC3,
  0xC0, 0x9F, 0x7C, 0x1C, 0xF6, 0x3E, 0xFB, 0x3F, 0x9C, 0xFF, 0xE1, 0x8C,
  0x61, 0x0C, 0x20, 0x39, 0xF4, 0x5E, 0x5A, 0x2F, 0xBC, 0x39, 0xFC, 0xF3,
  0x7C, 0x6F, 0x38, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x6C, 0x04, 0xEC,
  0x1C, 0x08, 0xFC, 0x0F, 0x80, 0x40, 0xC0, 0x9C, 0x80, 0x70, 0xC6, 0xE4,
  0x03, 0x18, 0x3D, 0x95, 0xED, 0xAE, 0xBA, 0xAE, 0xC1, 0xC0, 0x0C, 0x71,
  0x4D, 0x25, 0xF7, 0xF1, 0x3C, 0x7C, 0x99, 0xE6, 0x48, 0xDF, 0x3C, 0x1D,
  0xF6, 0x30, 0xC3, 0x0F, 0x9E, 0x3C, 0x7C, 0x9B, 0x36, 0x69, 0x9F, 0x7C,
  0x7D, 0xF6, 0x1E, 0x7B, 0x0F, 0xBE, 0x3E, 0xF9, 0x83, 0x07, 0x9F, 0x30,
  0x60, 0x3D, 0xF6, 0x33, 0xCB, 0x2F, 0x9E, 0x33, 0x26, 0x3E, 0x7E, 0x66,
  0x44, 0x4C, 0xCC, 0x3E, 0x7C, 0x20, 0xC1, 0x82, 0x1F, 0x3E, 0x1E, 0x3C,
  0x18, 0x20, 0x41, 0x9F, 0x3C, 0x32, 0x36, 0x2C, 0x78, 0x78, 0x68, 0x4C,
  0x4C, 0x63, 0x10, 0x8C, 0x63, 0xFF, 0x32, 0x6C, 0xDB, 0xD5, 0xE8, 0xF1,
  0x62, 0x32, 0x32, 0x32, 0x7E, 0x6E, 0x4C, 0x4C, 0xCC, 0x39, 0xF6, 0xF3,
  0xCF, 0x6F, 0x9C, 0x3C, 0x7C, 0x89, 0xF7, 0xCC, 0x10, 0x20, 0x39, 0xFC,
  0xF3, 0xCF, 0x6F, 0x9C, 0x60, 0xC1, 0x00, 0x3C, 0x7C, 0x99, 0xF7, 0xCD,
  0x13, 0x26, 0x1C, 0x7C, 0x81, 0xC1, 0xC0, 0x9F, 0x3C, 0xFF, 0xF2, 0x18,
  0x61, 0x04, 0x30, 0x64, 0x89, 0x36, 0x6C, 0x93, 0x3E, 0x78, 0x8E, 0x29,
  0xA4, 0xB2, 0x8E, 0x30, 0x23, 0x23, 0x62, 0x7A, 0x5E, 0x6C, 0x6C, 0x4C,
  0x33, 0x36, 0x14, 0x18, 0x18, 0x3C, 0x6C, 0xC4, 0x8F, 0x2D, 0xBC, 0x61,
  0x04, 0x30, 0x3E, 0x7C, 0x10, 0x41, 0x04, 0x1F, 0x3E, 0x1C, 0xC3, 0x0C,
  0x20, 0x86, 0x18, 0x41, 0x0F, 0x00, 0xAB, 0xFF, 0xD4, 0x1C, 0x08, 0x30,
  0x60, 0x81, 0x06, 0x0C, 0x10, 0x23, 0xC0, 0x18, 0xE6, 0xB3, 0x0C, 0xFC,
  0x4C, 0x3D, 0xFC, 0xA6, 0xFB, 0xA0, 0x61, 0x86, 0x1E, 0xFB, 0x3C, 0xBE,
  0xF0, 0x3D, 0xFC, 0x30, 0xF9, 0xE0, 0x04, 0x08, 0x31, 0xE7, 0xD9, 0x26,
  0x7C, 0xE8, 0x39, 0xFC, 0xFC, 0xC1, 0xE0, 0x0F, 0x0E, 0x18, 0x3E, 0x3E,
  0x10, 0x30, 0x30, 0x30, 0xE0, 0xE0, 0x1E, 0x7D, 0x93, 0x27, 0xC7, 0xA6,
  0x78, 0x23, 0x18, 0xF4, 0xE7, 0x3B, 0x98, 0x11, 0x80, 0xEF, 0x10, 0x8F,
  0x38, 0x0C, 0x30, 0x0F, 0x3C, 0x30, 0x86, 0x1B, 0xC6, 0x00, 0x21, 0x86,
  0x1B, 0x59, 0xCF, 0x36, 0x98, 0xEE, 0x66, 0x44, 0xCF, 0x70, 0x3E, 0xFD,
  0xEA, 0xA4, 0x58, 0x80, 0x7A, 0x73, 0x9D, 0xCC, 0x39, 0xEC, 0xE2, 0xFB,
  0xC0, 0x3C, 0x7D, 0x9B, 0x24, 0xCF, 0x30, 0x60, 0x3D, 0xFC, 0xB6, 0xFB,
  0xE1, 0x04, 0x7D, 0xF4, 0x10, 0xC3, 0x00, 0x39, 0x07, 0x0E, 0x1B, 0xC0,
  0x30, 0xC7, 0xDF, 0x61, 0x87, 0x8C, 0x4D, 0x2C, 0xB6, 0xDB, 0xE0, 0xCF,
  0x35, 0x94, 0x71, 0x80, 0xC5, 0x6A, 0xF7, 0xCD, 0x92, 0x00, 0x26, 0x78,
  0x61, 0xC6, 0x89, 0x80, 0x33, 0x13, 0x12, 0x16, 0x1C, 0x18, 0x78, 0x60,
  0x7D, 0xE1, 0x08, 0xFB, 0xE0, 0x1C, 0x20, 0x41, 0x83, 0x18, 0x08, 0x30,
  0x60, 0xC1, 0xC0, 0x33, 0x26, 0x66, 0x4C, 0xCC, 0x80, 0x38, 0x30, 0x82,
  0x08, 0x31, 0x04, 0x10, 0xCE, 0x00, 0x67, 0xE9, 0x80,
};

const GFXglyph UbuntuMono_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 8, 7, 2, -8 },
  { 5, 4, 4, 7, 3, -9 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 6, 10, 7, 1, -9 },
  { 22, 8, 8, 7, 0, -8 },
  { 30, 6, 8, 7, 1, -8 },
  { 36, 2, 4, 7, 4, -9 },
  { 37, 5, 11, 7, 2, -9 },
  { 44, 5, 11, 7, 1, -9 },
  { 51, 5, 5, 7, 2, -8 },
  { 55, 6, 5, 7, 1, -6 },
  { 59, 3, 4, 7, 1, -2 },
  { 61, 4, 2, 7, 2, -4 },
  { 62, 2, 2, 7, 2, -2 },
  { 63, 8, 11, 7, 0, -9 },
  { 74, 6, 8, 7, 1, -8 },
  { 80, 5, 8, 7, 1, -8 },
  { 85, 6, 8, 7, 1, -8 },
  { 91, 7, 8, 7, 0, -8 },
  { 98, 6, 8, 7, 1, -8 },
  { 104, 7, 8, 7, 0, -8 },
  { 111, 6, 8, 7, 1, -8 },
  { 117, 6, 8, 7, 2, -8 },
  { 123, 6, 8, 7, 1, -8 },
  { 129, 6, 8, 7, 1, -8 },
  { 135, 3, 6, 7, 2, -6 },
  { 138, 4, 8, 7, 1, -6 },
  { 142, 6, 5, 7, 1, -6 },
  { 146, 6, 3, 7, 1, -5 },
  { 149, 6, 5, 7, 1, -6 },
  { 153, 5, 8, 7, 2, -8 },
  { 158, 6, 10, 7, 1, -8 },
  { 166, 6, 8, 7, 0, -8 },
  { 172, 7, 8, 7, 0, -8 },
  { 179, 6, 8, 7, 1, -8 },
  { 185, 7, 8, 7, 0, -8 },
  { 192, 6, 8, 7, 1, -8 },
  { 198, 7, 8, 7, 1, -8 },
  { 205, 6, 8, 7, 1, -8 },
  { 211, 8, 8, 7, 0, -8 },
  { 219, 7, 8, 7, 0, -8 },
  { 226, 7, 8, 7, 0, -8 },
  { 233, 8, 8, 7, 0, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 7, 8, 7, 0, -8 },
  { 253, 8, 8, 7, 0, -8 },
  { 261, 6, 8, 7, 1, -8 },
  { 267, 7, 8, 7, 0, -8 },
  { 274, 6, 11, 7, 1, -8 },
  { 283, 7, 8, 7, 0, -8 },
  { 290, 7, 8, 7, 0, -8 },
  { 297, 6, 8, 7, 2, -8 },
  { 303, 7, 8, 7, 1, -8 },
  { 310, 6, 8, 7, 2, -8 },
  { 316, 8, 8, 7, 0, -8 },
  { 324, 8, 8, 7, 0, -8 },
  { 332, 6, 8, 7, 2, -8 },
  { 338, 7, 8, 7, 0, -8 },
  { 345, 6, 11, 7, 1, -9 },
  { 354, 2, 11, 7, 3, -9 },
  { 357, 7, 11, 7, 0, -9 },
  { 367, 6, 5, 7, 1, -8 },
  { 371, 6, 1, 7, 0, 1 },
  { 372, 3, 2, 7, 3, -9 },
  { 373, 6, 6, 7, 1, -6 },
  { 378, 6, 9, 7, 1, -9 },
  { 385, 6, 6, 7, 1, -6 },
  { 390, 7, 9, 7, 1, -9 },
  { 398, 6, 6, 7, 1, -6 },
  { 403, 8, 11, 7, 0, -9 },
  { 414, 7, 8, 7, 0, -6 },
  { 421, 5, 9, 7, 1, -9 },
  { 427, 5, 9, 7, 1, -9 },
  { 433, 6, 11, 7, 0, -9 },
  { 442, 6, 9, 7, 1, -9 },
  { 449, 4, 9, 7, 2, -9 },
  { 454, 7, 6, 7, 0, -6 },
  { 460, 5, 6, 7, 1, -6 },
  { 464, 6, 6, 7, 1, -6 },
  { 469, 7, 8, 7, 0, -6 },
  { 476, 6, 8, 7, 1, -6 },
  { 482, 6, 6, 7, 1, -6 },
  { 487, 6, 6, 7, 1, -6 },
  { 492, 6, 8, 7, 1, -8 },
  { 498, 6, 6, 7, 1, -6 },
  { 503, 6, 6, 7, 1, -6 },
  { 508, 7, 6, 7, 1, -6 },
  { 514, 7, 6, 7, 0, -6 },
  { 520, 8, 8, 7, -1, -6 },
  { 528, 6, 6, 7, 1, -6 },
  { 533, 7, 11, 7, 1, -9 },
  { 543, 4, 11, 7, 2, -9 },
  { 549, 6, 11, 7, 0, -9 },
  { 558, 6, 3, 7, 1, -5 },
};

const GFXfont UbuntuMono_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic13pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUMONO_BOLDITALIC13PT7B_H_
