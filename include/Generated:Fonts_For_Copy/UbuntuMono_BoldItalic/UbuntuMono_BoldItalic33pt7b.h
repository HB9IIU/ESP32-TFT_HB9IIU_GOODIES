#ifndef _UBUNTUMONO_BOLDITALIC33PT7B_H_
#define _UBUNTUMONO_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x0F,
  0xC1, 0xE0, 0x7C, 0xF7, 0x8F, 0x79, 0xF7, 0x9E, 0x79, 0xE7, 0x1E, 0xF1,
  0xCE, 0x1C, 0xE1, 0x80, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07,
  0x1C, 0x03, 0xCF, 0x0F, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0x1C,
  0x03, 0xCF, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xE0, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xCF,
  0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x1F, 0x04, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x60, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x7C, 0x0E, 0x0F, 0xE1,
  0xC0, 0xEE, 0x38, 0x1C, 0xE7, 0x01, 0xCE, 0xE0, 0x1D, 0xCE, 0x01, 0xFD,
  0xC0, 0x1F, 0xB8, 0x00, 0xF7, 0x00, 0x00, 0xEF, 0x00, 0x1D, 0xF8, 0x01,
  0xDF, 0x80, 0x3B, 0x98, 0x07, 0x31, 0x80, 0xE3, 0x38, 0x1C, 0x73, 0x83,
  0x83, 0xF0, 0x70, 0x3F, 0x07, 0x01, 0xC0, 0x00, 0xF8, 0x03, 0xFC, 0x07,
  0xFE, 0x07, 0x9E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x78, 0x07,
  0xF0, 0x07, 0xC6, 0x1F, 0xC7, 0x3D, 0xEF, 0x79, 0xEE, 0x70, 0xFE, 0x70,
  0x7C, 0xF0, 0x78, 0x78, 0xFC, 0x7F, 0xFC, 0x7F, 0xDE, 0x1F, 0x1E, 0x7D,
  0xF7, 0x9E, 0x79, 0xCF, 0x3C, 0xE3, 0x80, 0x00, 0x10, 0x00, 0xE0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0x00, 0x08, 0x00, 0x07, 0x80, 0x1E,
  0x06, 0x79, 0x9D, 0xCE, 0xFB, 0xFB, 0xFF, 0xF3, 0xFF, 0x01, 0xE0, 0x1F,
  0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x38, 0x08, 0x40, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x1F, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x1F, 0x1F, 0x0E, 0x1E, 0xFC, 0xF8, 0xC0,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0x39, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x79, 0xCF, 0x7B,
  0xCE, 0x73, 0x9E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x38, 0x07,
  0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x73, 0xC2, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x83, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC1, 0xE1, 0xE0, 0x40, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0x80, 0x01, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x06, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x60, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x38, 0x0F, 0x3C, 0x0F, 0x1E,
  0x0F, 0x0F, 0x0F, 0x07, 0x0F, 0x07, 0x87, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF,
  0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x60, 0x7C,
  0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x03,
  0xFF, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x3D, 0xF0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70,
  0x1C, 0x78, 0x3C, 0x7C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1F, 0x1E, 0x0F, 0xFC, 0x07, 0xF0, 0x1F,
  0xF0, 0x3C, 0xF8, 0x78, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8,
  0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x1E, 0x3E, 0x3C, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x7C,
  0x0F, 0x3C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0x9C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x0F,
  0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F,
  0x8F, 0xC7, 0xE1, 0xF0, 0xF0, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0xF8, 0x0E, 0x03, 0xC3, 0xF0, 0x7C, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x78, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0x3F, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x00, 0x04,
  0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x10, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x7E,
  0x07, 0xFC, 0xFF, 0xE3, 0xFE, 0x07, 0xF0, 0x0F, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0xC3, 0xFF, 0x0F, 0xFC, 0x61, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x03,
  0xFE, 0x0F, 0xFF, 0x1F, 0x0F, 0x1E, 0x07, 0x3C, 0x07, 0x38, 0x7F, 0x71,
  0xFF, 0x73, 0xFF, 0xF3, 0xCF, 0xE7, 0x8E, 0xE7, 0x8E, 0xE7, 0x1E, 0xE7,
  0x1E, 0xE7, 0x1C, 0xE7, 0x9C, 0xE7, 0xFC, 0xE3, 0xFC, 0xF1, 0xF8, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xEE, 0x01, 0xEE, 0x01, 0xCE, 0x03,
  0xCE, 0x07, 0x8E, 0x07, 0x8E, 0x0F, 0x0E, 0x0F, 0x0F, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF,
  0x87, 0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x78, 0xF0, 0x3C, 0x78,
  0x3E, 0x3F, 0xFE, 0x3F, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0x0F, 0xFE, 0x1F, 0x06, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x30, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x1F, 0x3C, 0x1E, 0x78, 0x3E, 0x78, 0x7C, 0x78, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x0F, 0xFE,
  0x1F, 0x06, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0xF8, 0xF8, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0x83,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC1, 0xE1,
  0xE0, 0x78, 0x78, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0,
  0x7C, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0x78, 0x3C,
  0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x70, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x07,
  0x83, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x1E, 0xF8, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF8, 0x78, 0x1F, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x03, 0xC1,
  0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x1D, 0x9F,
  0x83, 0xB3, 0x70, 0x76, 0xEE, 0x1E, 0xDB, 0xC3, 0x9F, 0x70, 0x73, 0xCE,
  0x0E, 0x79, 0xC3, 0xCE, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x38,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x00, 0x07, 0x01,
  0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0E, 0x0F, 0xC3, 0x87, 0xF1, 0xE1,
  0xFC, 0x78, 0x7F, 0x1C, 0x1C, 0xE7, 0x0F, 0x3B, 0xC3, 0xCE, 0xF0, 0xF3,
  0xBC, 0x38, 0x6E, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x70, 0x7C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x07,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x0F, 0x87, 0xFF, 0x87, 0xFF,
  0x83, 0xFE, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x0E, 0x00,
  0x0F, 0x80, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x7C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x0F, 0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xE7, 0x81, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F,
  0x1E, 0x07, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF0, 0x60,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x70, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE3, 0xE0,
  0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E,
  0x0F, 0x0F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF8, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xE0, 0x7B, 0xC0, 0x7B,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xE0,
  0x3C, 0x38, 0x07, 0x87, 0x00, 0xE1, 0xE7, 0x1C, 0x3C, 0xE7, 0x87, 0x3C,
  0xE0, 0xE7, 0x9C, 0x1D, 0xF3, 0x87, 0xF6, 0xF0, 0xEE, 0xFC, 0x1F, 0x9F,
  0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x1C,
  0x00, 0x07, 0x81, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7B, 0xC0,
  0x0F, 0x9E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E,
  0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x0F,
  0x8E, 0x1E, 0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0x7F, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0x71, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3,
  0x8F, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFF, 0x83, 0xEF, 0x0F, 0x9E, 0x1E, 0x1E, 0x78, 0x3D,
  0xE0, 0x7B, 0xC0, 0x79, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x20, 0xE3, 0xE3, 0xF1, 0xE0, 0x80, 0x01, 0xFC, 0x0F, 0xFC, 0x7F, 0xF9,
  0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x8F, 0x8F, 0xFF, 0x1F, 0xFE, 0x0F, 0x9C,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E,
  0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xFC,
  0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x81, 0x0F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0x87, 0x87, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0xF1,
  0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0x1F, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x7C, 0xE0, 0x01, 0xF8, 0x0F, 0xF8, 0x7F, 0xF8, 0xF0,
  0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x0F, 0xBF, 0xFE, 0x7F, 0xF9, 0xFF, 0x83,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x87, 0xFF, 0x0F, 0xFE, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x3E, 0x1E, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x07, 0x87, 0xC1,
  0xE1, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x18, 0x3E, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x78, 0x78, 0xF0, 0xF1,
  0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x79, 0xF0,
  0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x1E, 0x00, 0x03, 0x80, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x9F, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1F,
  0x01, 0xFE, 0x3F, 0xC3, 0xF8, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x41, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x1E, 0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x9F,
  0x07, 0xDE, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7B,
  0xE0, 0x3C, 0xF0, 0x1E, 0x7C, 0x0F, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC3,
  0xC1, 0xF0, 0xFF, 0xBF, 0xEF, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE1, 0x7F, 0xCF, 0xF1, 0xF8, 0x0F, 0xDE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1C, 0xE7, 0x3C, 0xE7, 0x38, 0xE7, 0x39, 0xE7, 0x39, 0xCF, 0x79,
  0xCE, 0x79, 0xCE, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xF0, 0xF1,
  0xE1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x8F, 0x8F, 0xFE, 0x0F,
  0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE0,
  0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07,
  0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC7, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x1F, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E,
  0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0x78,
  0x78, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xF0, 0x41, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xC6, 0x0F, 0x9F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xE1, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x3C, 0x3D, 0xF0, 0xF7, 0x83,
  0xDE, 0x1F, 0x78, 0x7B, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xFF, 0xCF, 0xFF, 0x0F, 0x98, 0x78,
  0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x3C,
  0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC0, 0xEF, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0xBC, 0x03, 0xDC, 0x01, 0xCE,
  0x38, 0xE7, 0x1C, 0xF3, 0x9E, 0x71, 0xCF, 0x39, 0xEF, 0x9C, 0xE6, 0xDC,
  0x77, 0x6E, 0x3B, 0x37, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xC3,
  0xC1, 0xE1, 0xC0, 0x0F, 0x03, 0xC3, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x7C,
  0x03, 0xDE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0x83, 0xC1,
  0xE1, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x08, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x1E, 0x0C, 0x7F, 0x1D, 0xFF, 0xFF,
  0xFF, 0xEE, 0x3F, 0x8C, 0x1E, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 10, 20, 17, 5, -20 },
  { 26, 12, 9, 17, 6, -22 },
  { 40, 18, 20, 17, 1, -20 },
  { 85, 16, 26, 17, 2, -23 },
  { 137, 20, 20, 17, 0, -20 },
  { 187, 16, 20, 17, 1, -20 },
  { 227, 6, 10, 17, 9, -22 },
  { 235, 14, 28, 17, 4, -23 },
  { 284, 14, 28, 17, 1, -23 },
  { 333, 14, 13, 17, 4, -20 },
  { 356, 15, 15, 17, 2, -16 },
  { 385, 8, 11, 17, 3, -6 },
  { 396, 10, 4, 17, 5, -10 },
  { 401, 6, 6, 17, 5, -6 },
  { 406, 19, 28, 17, 0, -23 },
  { 473, 16, 20, 17, 2, -20 },
  { 513, 13, 20, 17, 2, -20 },
  { 546, 17, 20, 17, 1, -20 },
  { 589, 16, 20, 17, 1, -20 },
  { 629, 17, 20, 17, 1, -20 },
  { 672, 17, 20, 17, 1, -20 },
  { 715, 16, 20, 17, 2, -20 },
  { 755, 16, 20, 17, 4, -20 },
  { 795, 16, 20, 17, 2, -20 },
  { 835, 16, 20, 17, 2, -20 },
  { 875, 9, 16, 17, 5, -16 },
  { 893, 11, 21, 17, 3, -16 },
  { 922, 15, 14, 17, 3, -16 },
  { 949, 17, 9, 17, 1, -14 },
  { 969, 15, 14, 17, 2, -16 },
  { 996, 13, 20, 17, 5, -20 },
  { 1029, 16, 24, 17, 2, -20 },
  { 1077, 16, 20, 17, 0, -20 },
  { 1117, 17, 20, 17, 1, -20 },
  { 1160, 16, 20, 17, 3, -20 },
  { 1200, 16, 20, 17, 1, -20 },
  { 1240, 17, 20, 17, 2, -20 },
  { 1283, 17, 20, 17, 2, -20 },
  { 1326, 16, 20, 17, 3, -20 },
  { 1366, 18, 20, 17, 1, -20 },
  { 1411, 18, 20, 17, 1, -20 },
  { 1456, 17, 20, 17, 1, -20 },
  { 1499, 19, 20, 17, 1, -20 },
  { 1547, 14, 20, 17, 1, -20 },
  { 1582, 19, 20, 17, 0, -20 },
  { 1630, 18, 20, 17, 1, -20 },
  { 1675, 16, 20, 17, 2, -20 },
  { 1715, 17, 20, 17, 1, -20 },
  { 1758, 16, 25, 17, 2, -20 },
  { 1808, 17, 20, 17, 1, -20 },
  { 1851, 17, 20, 17, 1, -20 },
  { 1894, 16, 20, 17, 4, -20 },
  { 1934, 17, 20, 17, 2, -20 },
  { 1977, 16, 20, 17, 4, -20 },
  { 2017, 19, 20, 17, 1, -20 },
  { 2065, 20, 20, 17, 0, -20 },
  { 2115, 15, 20, 17, 5, -20 },
  { 2153, 18, 20, 17, 1, -20 },
  { 2198, 16, 28, 17, 3, -23 },
  { 2254, 6, 28, 17, 7, -23 },
  { 2275, 17, 28, 17, 0, -23 },
  { 2335, 15, 12, 17, 3, -20 },
  { 2358, 15, 3, 17, -1, 2 },
  { 2364, 7, 6, 17, 8, -23 },
  { 2370, 15, 16, 17, 2, -16 },
  { 2400, 16, 23, 17, 1, -23 },
  { 2446, 15, 16, 17, 3, -16 },
  { 2476, 17, 23, 17, 2, -23 },
  { 2525, 15, 16, 17, 2, -16 },
  { 2555, 21, 28, 17, -1, -23 },
  { 2629, 18, 21, 17, 0, -16 },
  { 2677, 15, 23, 17, 1, -23 },
  { 2721, 11, 23, 17, 4, -23 },
  { 2753, 16, 28, 17, 0, -23 },
  { 2809, 17, 23, 17, 2, -23 },
  { 2858, 10, 23, 17, 5, -23 },
  { 2887, 16, 16, 17, 1, -16 },
  { 2919, 15, 16, 17, 1, -16 },
  { 2949, 15, 16, 17, 2, -16 },
  { 2979, 17, 21, 17, 0, -16 },
  { 3024, 16, 21, 17, 2, -16 },
  { 3066, 16, 16, 17, 2, -16 },
  { 3098, 15, 16, 17, 2, -16 },
  { 3128, 13, 21, 17, 4, -21 },
  { 3163, 14, 16, 17, 3, -16 },
  { 3191, 15, 16, 17, 3, -16 },
  { 3221, 17, 16, 17, 2, -16 },
  { 3255, 18, 16, 17, 0, -16 },
  { 3291, 19, 21, 17, -1, -16 },
  { 3341, 15, 16, 17, 2, -16 },
  { 3371, 16, 28, 17, 3, -23 },
  { 3427, 11, 28, 17, 4, -23 },
  { 3466, 16, 28, 17, 0, -23 },
  { 3522, 15, 6, 17, 2, -12 },
};

const GFXfont UbuntuMono_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic33pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _UBUNTUMONO_BOLDITALIC33PT7B_H_
