#ifndef _UBUNTUMONO_BOLDITALIC12PT7B_H_
#define _UBUNTUMONO_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA1, 0xB0, 0x5E, 0xA4, 0x16, 0x29, 0xF9, 0x47, 0xCA, 0x14,
  0x00, 0x13, 0xD0, 0x87, 0x0C, 0x7E, 0x40, 0x32, 0xA9, 0xA0, 0x82, 0xCA,
  0xB3, 0x00, 0x32, 0x54, 0xEE, 0xCB, 0xE0, 0x5E, 0x13, 0x6C, 0xC8, 0x88,
  0x8C, 0x40, 0x23, 0x11, 0x11, 0x32, 0x6C, 0x80, 0x33, 0x5E, 0x65, 0x80,
  0x31, 0x3E, 0x46, 0x00, 0x6D, 0xC0, 0xE0, 0xF0, 0x06, 0x08, 0x30, 0xC1,
  0x06, 0x08, 0x30, 0x41, 0x80, 0x3A, 0x73, 0x58, 0xCF, 0xC0, 0x13, 0x8C,
  0x62, 0x13, 0xC0, 0x3C, 0x90, 0x46, 0x31, 0x87, 0x80, 0x3C, 0x10, 0x4E,
  0x0C, 0x3F, 0x80, 0x0C, 0x38, 0xF3, 0x67, 0xC1, 0x06, 0x00, 0x1E, 0x60,
  0x81, 0xC0, 0xC1, 0xBE, 0x00, 0x1D, 0x8C, 0x3E, 0x8A, 0x67, 0x00, 0x7C,
  0x21, 0x0C, 0x61, 0x04, 0x00, 0x3A, 0x52, 0xE9, 0xCF, 0xC0, 0x7E, 0x72,
  0xF1, 0x9B, 0x80, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x68, 0x0B, 0xB0,
  0xE1, 0x00, 0xF8, 0x3E, 0x43, 0x86, 0xE8, 0x00, 0xF1, 0x36, 0x40, 0xC0,
  0x39, 0x19, 0xEA, 0xAA, 0xAB, 0xA0, 0x70, 0x18, 0x63, 0xCB, 0x7D, 0x3C,
  0xC0, 0x3C, 0x92, 0x5E, 0x65, 0x37, 0x80, 0x3D, 0x8C, 0x30, 0xC3, 0x07,
  0x80, 0x3C, 0x92, 0x59, 0x4D, 0x2F, 0x00, 0x7D, 0x04, 0x1E, 0xC3, 0x0F,
  0x00, 0x7D, 0x84, 0x1E, 0xC3, 0x08, 0x00, 0x3D, 0x8C, 0x32, 0x9B, 0x67,
  0x00, 0x26, 0x4D, 0x93, 0xE4, 0xC9, 0xB2, 0x00, 0x3E, 0x30, 0x60, 0x81,
  0x06, 0x1E, 0x00, 0x1E, 0x08, 0x10, 0x60, 0xC1, 0x1C, 0x00, 0x36, 0x58,
  0xE3, 0x85, 0x89, 0x13, 0x00, 0x64, 0x4C, 0xC8, 0xF0, 0x36, 0x6D, 0xF2,
  0xE5, 0x48, 0xB3, 0x00, 0x32, 0x6D, 0xD3, 0xA4, 0xC9, 0xB2, 0x00, 0x3A,
  0x73, 0x18, 0xCF, 0xC0, 0x3C, 0x4C, 0x9B, 0x27, 0x88, 0x10, 0x00, 0x3A,
  0x73, 0x18, 0xCF, 0xCC, 0x30, 0x3C, 0x92, 0x5F, 0x59, 0x24, 0xC0, 0x3E,
  0x40, 0x81, 0xC0, 0xC1, 0xBE, 0x00, 0xFB, 0x18, 0x84, 0x63, 0x00, 0x4D,
  0x3C, 0xB2, 0x9A, 0x4F, 0x00, 0x8C, 0xE5, 0x6A, 0x73, 0x00, 0x22, 0x45,
  0xDA, 0xA6, 0xCD, 0x92, 0x00, 0x26, 0x68, 0x60, 0xC2, 0x8D, 0x33, 0x00,
  0x8C, 0xBD, 0xC4, 0x63, 0x00, 0x3E, 0x18, 0x20, 0x83, 0x0C, 0x3E, 0x00,
  0x3C, 0xC2, 0x08, 0x61, 0x84, 0x10, 0xC3, 0xC0, 0x49, 0x24, 0x9B, 0x6C,
  0x1C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x33, 0xC0, 0x11, 0xDB, 0x90, 0xF8,
  0x90, 0x7E, 0x67, 0x39, 0x7C, 0x30, 0x83, 0xCB, 0x65, 0x34, 0x9C, 0x3A,
  0x31, 0x0C, 0x38, 0x0C, 0x37, 0xB2, 0x9A, 0x69, 0x3E, 0x3A, 0x67, 0xEC,
  0x38, 0x0E, 0x30, 0xF0, 0x83, 0x06, 0x0C, 0x10, 0x21, 0x80, 0x1C, 0x96,
  0xD3, 0x68, 0xE1, 0xBC, 0x63, 0x1E, 0xBD, 0xEE, 0x52, 0x31, 0x80, 0xE2,
  0x11, 0x8C, 0x38, 0x0C, 0x30, 0x0F, 0x08, 0x21, 0x86, 0x10, 0x4E, 0x00,
  0x61, 0x84, 0x96, 0xF3, 0xC9, 0x26, 0xED, 0x2D, 0xB7, 0x3D, 0x55, 0x55,
  0x4F, 0x20, 0x7A, 0xF7, 0xB9, 0x48, 0x76, 0xE3, 0x39, 0x70, 0x39, 0x96,
  0x5B, 0x49, 0xCC, 0x30, 0x3A, 0x77, 0x39, 0x78, 0xC6, 0x7A, 0x11, 0x8C,
  0x40, 0x7A, 0x18, 0x61, 0x78, 0x31, 0x3E, 0xC6, 0x21, 0x0E, 0x4E, 0x77,
  0x29, 0x7C, 0xCB, 0x2D, 0x94, 0x61, 0x80, 0x86, 0xAA, 0xBA, 0xD2, 0x40,
  0x24, 0x78, 0xE1, 0xC6, 0x89, 0x00, 0x32, 0x32, 0x16, 0x14, 0x1C, 0x18,
  0x10, 0x60, 0x78, 0xCC, 0xCC, 0x78, 0x1C, 0x43, 0x08, 0xC1, 0x86, 0x10,
  0x41, 0xC0, 0x11, 0x33, 0x22, 0x66, 0x44, 0x38, 0x20, 0x86, 0x0C, 0x41,
  0x0C, 0x23, 0x80, 0xED, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 7, 6, 2, -7 },
  { 4, 5, 3, 6, 2, -8 },
  { 6, 7, 7, 6, 0, -7 },
  { 13, 5, 9, 6, 1, -8 },
  { 19, 7, 7, 6, 0, -7 },
  { 26, 5, 7, 6, 1, -7 },
  { 31, 2, 4, 6, 3, -8 },
  { 32, 4, 11, 6, 2, -9 },
  { 38, 4, 11, 6, 1, -9 },
  { 44, 5, 5, 6, 1, -7 },
  { 48, 5, 5, 6, 1, -6 },
  { 52, 3, 4, 6, 1, -2 },
  { 54, 3, 1, 6, 2, -4 },
  { 55, 2, 2, 6, 2, -2 },
  { 56, 7, 10, 6, 0, -8 },
  { 65, 5, 7, 6, 1, -7 },
  { 70, 5, 7, 6, 1, -7 },
  { 75, 6, 7, 6, 0, -7 },
  { 81, 6, 7, 6, 0, -7 },
  { 87, 7, 7, 6, 0, -7 },
  { 94, 7, 7, 6, 0, -7 },
  { 101, 6, 7, 6, 1, -7 },
  { 107, 6, 7, 6, 1, -7 },
  { 113, 5, 7, 6, 1, -7 },
  { 118, 5, 7, 6, 1, -7 },
  { 123, 3, 6, 6, 2, -6 },
  { 126, 4, 8, 6, 1, -6 },
  { 130, 5, 5, 6, 1, -6 },
  { 134, 5, 3, 6, 1, -5 },
  { 136, 5, 5, 6, 1, -6 },
  { 140, 4, 7, 6, 2, -7 },
  { 144, 6, 9, 6, 1, -7 },
  { 151, 6, 7, 6, 0, -7 },
  { 157, 6, 7, 6, 0, -7 },
  { 163, 6, 7, 6, 1, -7 },
  { 169, 6, 7, 6, 0, -7 },
  { 175, 6, 7, 6, 1, -7 },
  { 181, 6, 7, 6, 1, -7 },
  { 187, 6, 7, 6, 1, -7 },
  { 193, 7, 7, 6, 0, -7 },
  { 200, 7, 7, 6, 0, -7 },
  { 207, 7, 7, 6, 0, -7 },
  { 214, 7, 7, 6, 0, -7 },
  { 221, 4, 7, 6, 1, -7 },
  { 225, 7, 7, 6, 0, -7 },
  { 232, 7, 7, 6, 0, -7 },
  { 239, 5, 7, 6, 1, -7 },
  { 244, 7, 7, 6, 0, -7 },
  { 251, 5, 9, 6, 1, -7 },
  { 257, 6, 7, 6, 0, -7 },
  { 263, 7, 7, 6, 0, -7 },
  { 270, 5, 7, 6, 2, -7 },
  { 275, 6, 7, 6, 1, -7 },
  { 281, 5, 7, 6, 2, -7 },
  { 286, 7, 7, 6, 0, -7 },
  { 293, 7, 7, 6, 0, -7 },
  { 300, 5, 7, 6, 2, -7 },
  { 305, 7, 7, 6, 0, -7 },
  { 312, 6, 10, 6, 1, -8 },
  { 320, 3, 10, 6, 2, -8 },
  { 324, 6, 10, 6, 0, -8 },
  { 332, 5, 4, 6, 1, -7 },
  { 335, 5, 1, 6, 0, 1 },
  { 336, 2, 2, 6, 3, -8 },
  { 337, 5, 6, 6, 1, -6 },
  { 341, 6, 8, 6, 0, -8 },
  { 347, 5, 6, 6, 1, -6 },
  { 351, 6, 8, 6, 1, -8 },
  { 357, 5, 6, 6, 1, -6 },
  { 361, 7, 10, 6, 0, -8 },
  { 370, 6, 8, 6, 0, -6 },
  { 376, 5, 8, 6, 1, -8 },
  { 381, 5, 9, 6, 1, -9 },
  { 387, 6, 11, 6, 0, -9 },
  { 396, 6, 8, 6, 1, -8 },
  { 402, 3, 8, 6, 2, -8 },
  { 405, 6, 6, 6, 0, -6 },
  { 410, 5, 6, 6, 1, -6 },
  { 414, 5, 6, 6, 1, -6 },
  { 418, 6, 8, 6, 0, -6 },
  { 424, 5, 8, 6, 1, -6 },
  { 429, 5, 6, 6, 1, -6 },
  { 433, 5, 6, 6, 1, -6 },
  { 437, 5, 8, 6, 1, -8 },
  { 442, 5, 6, 6, 1, -6 },
  { 446, 6, 6, 6, 1, -6 },
  { 451, 6, 6, 6, 1, -6 },
  { 456, 7, 6, 6, 0, -6 },
  { 462, 8, 8, 6, -1, -6 },
  { 470, 5, 6, 6, 1, -6 },
  { 474, 6, 10, 6, 1, -8 },
  { 482, 4, 10, 6, 1, -8 },
  { 487, 6, 10, 6, 0, -8 },
  { 495, 5, 2, 6, 1, -4 },
};

const GFXfont UbuntuMono_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic12pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUMONO_BOLDITALIC12PT7B_H_
