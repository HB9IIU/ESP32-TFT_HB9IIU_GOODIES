#ifndef _UBUNTUMONO_BOLDITALIC10PT7B_H_
#define _UBUNTUMONO_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x5E, 0x20, 0xAA, 0xA0, 0x18, 0xA7, 0xFE, 0x52, 0x80, 0x11, 0xD8,
  0x61, 0x8F, 0xC4, 0x65, 0xA7, 0x0E, 0x5A, 0x60, 0x39, 0x4C, 0xFD, 0x34,
  0xA8, 0x13, 0x64, 0xCC, 0xC4, 0x40, 0x11, 0x11, 0x11, 0x36, 0x40, 0x2B,
  0x76, 0x50, 0x22, 0xF4, 0x40, 0x5C, 0x60, 0xC0, 0x0C, 0x21, 0x84, 0x20,
  0x84, 0x10, 0x80, 0x7D, 0xB9, 0xBE, 0x3E, 0x22, 0x6F, 0x38, 0x46, 0x64,
  0x3C, 0x38, 0x4C, 0x31, 0xF8, 0x08, 0xCA, 0xB7, 0x88, 0x38, 0x87, 0x06,
  0x1B, 0xC0, 0x32, 0x3D, 0x29, 0x70, 0xF8, 0x88, 0xC4, 0x60, 0x7D, 0x7B,
  0x9E, 0x79, 0x9F, 0x3C, 0xF2, 0x80, 0x6C, 0x25, 0x80, 0x1E, 0xE3, 0x78,
  0x1E, 0xC7, 0x78, 0xE5, 0xC1, 0x00, 0x76, 0x6D, 0xAF, 0x43, 0x80, 0x11,
  0x4A, 0x97, 0xC4, 0x3B, 0x5C, 0x94, 0xF8, 0x3A, 0x21, 0x08, 0x78, 0x3B,
  0x52, 0x95, 0xF8, 0x7A, 0x3D, 0x08, 0x78, 0x7A, 0x3D, 0x08, 0x40, 0x7E,
  0x21, 0x2B, 0x70, 0x2D, 0xA7, 0x92, 0x5B, 0x40, 0x3C, 0x41, 0x0C, 0x23,
  0xC0, 0x38, 0x20, 0x86, 0x11, 0xC0, 0x2D, 0xE7, 0x1C, 0x53, 0x60, 0x21,
  0x18, 0x84, 0x38, 0x2D, 0xB7, 0x9E, 0xCA, 0x20, 0x25, 0xA5, 0x96, 0x5A,
  0x40, 0x7D, 0x99, 0xBE, 0x38, 0xB4, 0x9E, 0x41, 0x00, 0x7D, 0x99, 0xBE,
  0x46, 0x3B, 0x52, 0xE5, 0x6C, 0x3B, 0x1C, 0x31, 0xF8, 0xF9, 0x08, 0xC4,
  0x20, 0x5E, 0xA5, 0x2B, 0x70, 0xCE, 0xB5, 0xC6, 0x20, 0x65, 0x15, 0x9E,
  0x5B, 0x40, 0x2C, 0xA3, 0x0C, 0x73, 0x60, 0xCA, 0x9C, 0xC4, 0x20, 0x3C,
  0x21, 0x08, 0x43, 0xC0, 0x39, 0x18, 0x84, 0x23, 0x10, 0xE0, 0xAB, 0xD5,
  0x40, 0x38, 0xC4, 0x21, 0x08, 0xC4, 0xE0, 0x25, 0xD1, 0xF0, 0x48, 0x79,
  0x9B, 0xF0, 0x21, 0x1E, 0x94, 0xAF, 0xC0, 0x7C, 0x88, 0xF0, 0x18, 0x9D,
  0x29, 0x5B, 0xC0, 0x79, 0xF8, 0xF0, 0x1C, 0x47, 0x88, 0x20, 0x82, 0x18,
  0xC0, 0x3A, 0x52, 0xB7, 0x0B, 0x80, 0x21, 0x1E, 0x94, 0xAD, 0x40, 0x20,
  0xE6, 0x44, 0x70, 0x18, 0x1E, 0x21, 0x08, 0x44, 0xE0, 0x42, 0x15, 0xCE,
  0x52, 0xC0, 0x62, 0x64, 0x44, 0x70, 0x7A, 0xDA, 0x98, 0x80, 0x7A, 0x52,
  0xB5, 0x00, 0x79, 0x9B, 0xE0, 0x7A, 0x52, 0xB7, 0x42, 0x00, 0x79, 0x9B,
  0xE2, 0x20, 0x7C, 0x88, 0x80, 0x3B, 0x0C, 0x37, 0x00, 0x6F, 0x44, 0x47,
  0xD9, 0xBA, 0xF0, 0x94, 0xA9, 0xC4, 0x00, 0x8D, 0xBD, 0x6A, 0x00, 0x68,
  0xC3, 0x1C, 0x58, 0x4A, 0x5E, 0x62, 0x13, 0x00, 0x38, 0xCC, 0xC7, 0x00,
  0x39, 0x08, 0xC8, 0x21, 0x08, 0x60, 0x22, 0x22, 0x64, 0x44, 0xC0, 0x30,
  0x84, 0x21, 0x90, 0x84, 0xC0, 0x6A, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 4, 3, 5, 2, -7 },
  { 5, 6, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 6, 5, 0, -6 },
  { 20, 5, 6, 5, 0, -6 },
  { 24, 2, 3, 5, 3, -7 },
  { 25, 4, 9, 5, 1, -7 },
  { 30, 4, 9, 5, 0, -7 },
  { 35, 4, 5, 5, 1, -6 },
  { 38, 4, 5, 5, 1, -5 },
  { 41, 2, 3, 5, 1, -2 },
  { 42, 3, 1, 5, 1, -3 },
  { 43, 1, 2, 5, 2, -2 },
  { 44, 6, 9, 5, 0, -7 },
  { 51, 4, 6, 5, 1, -6 },
  { 54, 4, 6, 5, 1, -6 },
  { 57, 5, 6, 5, 0, -6 },
  { 61, 5, 6, 5, 0, -6 },
  { 65, 5, 6, 5, 0, -6 },
  { 69, 6, 6, 5, 0, -6 },
  { 74, 5, 6, 5, 1, -6 },
  { 78, 5, 6, 5, 1, -6 },
  { 82, 4, 6, 5, 1, -6 },
  { 85, 4, 6, 5, 1, -6 },
  { 88, 2, 5, 5, 2, -5 },
  { 90, 3, 6, 5, 1, -5 },
  { 93, 4, 4, 5, 1, -5 },
  { 95, 5, 3, 5, 0, -4 },
  { 97, 4, 4, 5, 1, -5 },
  { 99, 3, 6, 5, 2, -6 },
  { 102, 5, 7, 5, 1, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 5, 6, 5, 1, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 5, 6, 5, 1, -6 },
  { 127, 5, 6, 5, 1, -6 },
  { 131, 5, 6, 5, 1, -6 },
  { 135, 6, 6, 5, 0, -6 },
  { 140, 6, 6, 5, 0, -6 },
  { 145, 6, 6, 5, 0, -6 },
  { 150, 6, 6, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 6, 6, 5, 0, -6 },
  { 164, 6, 6, 5, 0, -6 },
  { 169, 4, 6, 5, 1, -6 },
  { 172, 6, 6, 5, 0, -6 },
  { 177, 4, 8, 5, 1, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 5, 6, 5, 0, -6 },
  { 189, 5, 6, 5, 1, -6 },
  { 193, 5, 6, 5, 1, -6 },
  { 197, 5, 6, 5, 1, -6 },
  { 201, 6, 6, 5, 0, -6 },
  { 206, 6, 6, 5, 0, -6 },
  { 211, 5, 6, 5, 1, -6 },
  { 215, 6, 6, 5, 0, -6 },
  { 220, 5, 9, 5, 1, -7 },
  { 226, 2, 9, 5, 2, -7 },
  { 229, 5, 9, 5, 0, -7 },
  { 235, 4, 4, 5, 1, -6 },
  { 237, 4, 1, 5, 0, 1 },
  { 238, 3, 2, 5, 2, -7 },
  { 239, 4, 5, 5, 1, -5 },
  { 242, 5, 7, 5, 0, -7 },
  { 247, 4, 5, 5, 1, -5 },
  { 250, 5, 7, 5, 1, -7 },
  { 255, 4, 5, 5, 1, -5 },
  { 258, 6, 9, 5, 0, -7 },
  { 265, 5, 7, 5, 0, -5 },
  { 270, 5, 7, 5, 0, -7 },
  { 275, 4, 7, 5, 1, -7 },
  { 279, 5, 9, 5, 0, -7 },
  { 285, 5, 7, 5, 1, -7 },
  { 290, 4, 7, 5, 1, -7 },
  { 294, 5, 5, 5, 0, -5 },
  { 298, 5, 5, 5, 0, -5 },
  { 302, 4, 5, 5, 1, -5 },
  { 305, 5, 7, 5, 0, -5 },
  { 310, 4, 7, 5, 1, -5 },
  { 314, 4, 5, 5, 1, -5 },
  { 317, 5, 5, 5, 0, -5 },
  { 321, 4, 6, 5, 1, -6 },
  { 324, 4, 5, 5, 1, -5 },
  { 327, 5, 5, 5, 1, -5 },
  { 331, 5, 5, 5, 1, -5 },
  { 335, 6, 5, 5, 0, -5 },
  { 339, 5, 7, 5, 0, -5 },
  { 344, 5, 5, 5, 0, -5 },
  { 348, 5, 9, 5, 1, -7 },
  { 354, 4, 9, 5, 1, -7 },
  { 359, 5, 9, 5, 0, -7 },
  { 365, 5, 2, 5, 0, -4 },
};

const GFXfont UbuntuMono_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic10pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUMONO_BOLDITALIC10PT7B_H_
