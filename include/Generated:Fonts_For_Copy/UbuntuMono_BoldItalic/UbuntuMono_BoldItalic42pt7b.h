#ifndef _UBUNTUMONO_BOLDITALIC42PT7B_H_
#define _UBUNTUMONO_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x3E, 0xFC, 0x7D, 0xF1, 0xFB,
  0xE3, 0xF7, 0xC7, 0xCF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3C, 0xF8, 0x79, 0xE1,
  0xE3, 0xC3, 0xC7, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x1E, 0x07, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0x8F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC7, 0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x81, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3E,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xE0, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x80, 0x3F, 0x0F, 0x03, 0xF0, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x70, 0x1E, 0xF0, 0x3C,
  0x07, 0x1C, 0x1E, 0x03, 0xCF, 0x0F, 0x00, 0xE3, 0xC7, 0x80, 0x38, 0xE3,
  0xC0, 0x0E, 0x38, 0xE0, 0x03, 0x9E, 0x78, 0x00, 0xFF, 0x3C, 0x00, 0x1F,
  0x9E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xF8, 0x00, 0x3C, 0xFF, 0x00, 0x1E, 0x79,
  0xC0, 0x0F, 0x1C, 0x70, 0x03, 0x87, 0x1C, 0x01, 0xE3, 0xC7, 0x00, 0xF0,
  0xE3, 0xC0, 0x78, 0x38, 0xE0, 0x3C, 0x0F, 0x78, 0x1E, 0x03, 0xFC, 0x07,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE3, 0xC0, 0x7C, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x9F, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x0F, 0x0F, 0xF0, 0xF1, 0xFF, 0x9E, 0x3E, 0xF9,
  0xE7, 0xC7, 0xFE, 0x78, 0x7F, 0xCF, 0x83, 0xF8, 0xF8, 0x1F, 0x8F, 0x01,
  0xF0, 0xF8, 0x1F, 0x8F, 0xC7, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xE7, 0xC1, 0xF8, 0x00, 0x7E, 0xFD, 0xF3, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9,
  0xE3, 0xC7, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x02, 0x1E, 0x33, 0xCE, 0x79, 0xFF,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xFE, 0x01, 0xEF, 0x81,
  0xF3, 0xE1, 0xF9, 0xF0, 0x38, 0x70, 0x08, 0x20, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x3F, 0x07, 0x83, 0xE7, 0xF3, 0xF8, 0xF8, 0x38, 0x00, 0x7F, 0xF3, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xC7, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xF3,
  0xE0, 0x1E, 0x7C, 0x01, 0xE7, 0xC7, 0x1E, 0x7C, 0xF3, 0xE7, 0x9F, 0x3E,
  0xF8, 0xE3, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x07, 0xC7,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0x7C, 0x0E, 0x7E, 0x04, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC3, 0xF0, 0x60, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x1C, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x0F, 0x03, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x80, 0x1F, 0x03, 0x81, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFE, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xF8,
  0x7E, 0x1F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x03, 0xF7, 0xF0, 0x7C, 0x1F,
  0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xC3, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x3E, 0x00, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xF0, 0x1F, 0x1F, 0x83,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x03, 0xC0, 0x3E, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x0C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFF, 0x38, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xF0, 0xF8, 0x3F, 0x01, 0xE0, 0xF8, 0x07, 0xC7, 0xC0,
  0x1E, 0x1E, 0x0F, 0xF8, 0xF0, 0x7F, 0xE3, 0xC3, 0xFF, 0x8F, 0x1F, 0xFE,
  0x78, 0xF8, 0xF9, 0xE3, 0xC3, 0xC7, 0x9F, 0x0F, 0x1E, 0x78, 0x7C, 0x71,
  0xE1, 0xF3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE3,
  0xE3, 0xC7, 0xCF, 0x0F, 0x1F, 0xFC, 0x3C, 0x3F, 0xF0, 0x78, 0x7F, 0xC1,
  0xE0, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7D, 0xE0, 0x07, 0xDE, 0x00, 0xF9, 0xE0, 0x0F, 0x9E, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7C, 0x3F, 0x03, 0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x1E,
  0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03,
  0xE3, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xE0, 0xE1, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x60, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3E,
  0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0,
  0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F,
  0xC0, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xE1, 0xF8, 0x7F,
  0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x07, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x10,
  0x1F, 0x81, 0xE1, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xE0,
  0x07, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03,
  0xF8, 0xEE, 0x07, 0xB8, 0xFE, 0x07, 0xB9, 0xDE, 0x07, 0xB9, 0xDE, 0x07,
  0xBB, 0x9E, 0x0F, 0x3B, 0xBC, 0x0F, 0x3F, 0x3C, 0x0F, 0x3F, 0x3C, 0x1F,
  0x3E, 0x3C, 0x1E, 0x3E, 0x7C, 0x1E, 0x3C, 0x78, 0x1E, 0x00, 0x78, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x03,
  0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x3E, 0x07,
  0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xF8, 0x7C, 0x07, 0xF8, 0x7C, 0x0F,
  0xF8, 0x7C, 0x0F, 0xB8, 0x78, 0x0F, 0x3C, 0xF8, 0x0F, 0x3C, 0xF8, 0x1F,
  0x3C, 0xF8, 0x1F, 0x1C, 0xF0, 0x1E, 0x1E, 0xF0, 0x1E, 0x1F, 0xF0, 0x3E,
  0x1F, 0xF0, 0x3E, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x7C,
  0x0F, 0xE0, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C,
  0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF8,
  0xF8, 0x1F, 0x0F, 0xC7, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0,
  0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC7,
  0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0,
  0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0xC7, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3E, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x0F, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0x1F,
  0x01, 0xF8, 0xF8, 0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xF0, 0x70, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x82, 0x00, 0x7C, 0x0F, 0x03, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xF8, 0x03,
  0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F,
  0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9E, 0x00, 0xFB, 0xE0, 0x0F, 0xBC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E,
  0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C,
  0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x3E, 0x3C, 0x78, 0x3E, 0x7C, 0xF8,
  0x3C, 0x7C, 0xF0, 0x3C, 0xFC, 0xF0, 0x3C, 0xFC, 0xF0, 0x7D, 0xDC, 0xF0,
  0x79, 0xDD, 0xE0, 0x7B, 0x9D, 0xE0, 0x7B, 0x9D, 0xE0, 0x7F, 0x1D, 0xC0,
  0x77, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0x7C, 0x0F, 0x87, 0xC1,
  0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x03, 0xE7, 0xC0, 0x3E,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80,
  0x7C, 0xFC, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xE7, 0xE0, 0x3E,
  0xFC, 0x03, 0xE3, 0x80, 0x3C, 0x18, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x20, 0x18, 0x1F, 0x1F,
  0xC7, 0xF0, 0xFC, 0x1C, 0x06, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xF1, 0xF8, 0x7C, 0x7E, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x7E,
  0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF9,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x8F, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFE, 0xF8, 0x3F, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF7, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0x7C, 0x0F, 0xDF, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xF3,
  0xF0, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFE, 0x04,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x61, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0x81,
  0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xBE, 0x01, 0xF8, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xF8, 0x7E, 0x7E, 0x07, 0xCF, 0x80, 0xFB,
  0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x03, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x61, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xE1, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83,
  0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7D, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x70, 0x3F,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFB, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x00,
  0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x11, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x04, 0x07,
  0xC0, 0x70, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x0F,
  0xC3, 0xF0, 0x3E, 0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0xBE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF8,
  0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3F,
  0x00, 0x7F, 0xF3, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x4F, 0xFE, 0x7F, 0xF1, 0xFF,
  0x87, 0xF0, 0x03, 0xF1, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xF3, 0xE7, 0x8F, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x1F,
  0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE7, 0xC0,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x07, 0xE7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0xCF, 0x81, 0xF7, 0xE0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x3F,
  0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x1F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xE1, 0xF8, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xF8,
  0x7E, 0x7E, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x81,
  0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xFC, 0x1F, 0x1F, 0x87, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xF8, 0x04, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFC, 0x0C, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x8E, 0x03, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x10, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFC,
  0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xF7,
  0xC1, 0xF8, 0xC0, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x07,
  0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E,
  0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF0,
  0x01, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0xFB, 0xE3, 0xC7, 0x9E, 0x3E, 0x3C,
  0xF1, 0xF1, 0xC7, 0x9F, 0x9E, 0x3C, 0xFC, 0xF1, 0xEF, 0xE7, 0x0F, 0x77,
  0x78, 0x7F, 0xBF, 0xC3, 0xF9, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x3F, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFB, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xC3, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x07, 0x80, 0xC1, 0xFE, 0x0F, 0x3F, 0xF1, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0x8F, 0xFC, 0xF0, 0x7F, 0x83, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 12, 27, 21, 7, -26 },
  { 42, 15, 12, 21, 8, -28 },
  { 65, 23, 26, 21, 1, -26 },
  { 140, 21, 33, 21, 2, -29 },
  { 227, 26, 28, 21, 0, -27 },
  { 318, 20, 28, 21, 2, -27 },
  { 388, 7, 13, 21, 12, -28 },
  { 400, 17, 38, 21, 6, -30 },
  { 481, 17, 38, 21, 2, -30 },
  { 562, 17, 16, 21, 5, -26 },
  { 596, 19, 18, 21, 3, -20 },
  { 639, 10, 14, 21, 4, -7 },
  { 657, 13, 5, 21, 6, -13 },
  { 666, 7, 8, 21, 7, -7 },
  { 673, 24, 36, 21, 0, -29 },
  { 781, 20, 28, 21, 3, -27 },
  { 851, 17, 26, 21, 3, -26 },
  { 907, 20, 27, 21, 2, -27 },
  { 975, 21, 28, 21, 1, -27 },
  { 1049, 21, 26, 21, 2, -26 },
  { 1118, 22, 27, 21, 1, -26 },
  { 1193, 20, 27, 21, 3, -26 },
  { 1261, 20, 26, 21, 5, -26 },
  { 1326, 20, 28, 21, 3, -27 },
  { 1396, 20, 27, 21, 2, -27 },
  { 1464, 10, 21, 21, 7, -20 },
  { 1491, 13, 27, 21, 4, -20 },
  { 1535, 19, 18, 21, 3, -20 },
  { 1578, 20, 12, 21, 2, -17 },
  { 1608, 19, 18, 21, 2, -20 },
  { 1651, 16, 28, 21, 6, -27 },
  { 1707, 22, 33, 21, 2, -27 },
  { 1798, 20, 26, 21, 0, -26 },
  { 1863, 21, 27, 21, 2, -26 },
  { 1934, 20, 28, 21, 4, -27 },
  { 2004, 21, 28, 21, 1, -27 },
  { 2078, 22, 26, 21, 2, -26 },
  { 2150, 23, 26, 21, 2, -26 },
  { 2225, 21, 28, 21, 3, -27 },
  { 2299, 24, 26, 21, 1, -26 },
  { 2377, 23, 26, 21, 1, -26 },
  { 2452, 21, 27, 21, 2, -26 },
  { 2523, 24, 26, 21, 1, -26 },
  { 2601, 17, 26, 21, 2, -26 },
  { 2657, 24, 26, 21, 0, -26 },
  { 2735, 24, 26, 21, 1, -26 },
  { 2813, 20, 28, 21, 3, -27 },
  { 2883, 21, 26, 21, 2, -26 },
  { 2952, 20, 35, 21, 3, -27 },
  { 3040, 21, 26, 21, 1, -26 },
  { 3109, 22, 28, 21, 1, -27 },
  { 3186, 20, 26, 21, 5, -26 },
  { 3251, 21, 27, 21, 3, -26 },
  { 3322, 20, 26, 21, 6, -26 },
  { 3387, 24, 26, 21, 2, -26 },
  { 3465, 26, 26, 21, 0, -26 },
  { 3550, 20, 26, 21, 6, -26 },
  { 3615, 23, 26, 21, 1, -26 },
  { 3690, 20, 36, 21, 4, -29 },
  { 3780, 8, 36, 21, 9, -29 },
  { 3816, 20, 36, 21, 1, -29 },
  { 3906, 20, 15, 21, 3, -26 },
  { 3944, 19, 5, 21, -1, 2 },
  { 3956, 9, 8, 21, 10, -29 },
  { 3965, 19, 22, 21, 3, -21 },
  { 4018, 19, 31, 21, 2, -30 },
  { 4092, 19, 22, 21, 3, -21 },
  { 4145, 22, 31, 21, 3, -30 },
  { 4231, 19, 22, 21, 3, -21 },
  { 4284, 26, 38, 21, -1, -30 },
  { 4408, 22, 29, 21, 0, -21 },
  { 4488, 19, 30, 21, 2, -30 },
  { 4560, 14, 30, 21, 5, -29 },
  { 4613, 20, 37, 21, 0, -29 },
  { 4706, 22, 30, 21, 2, -30 },
  { 4789, 13, 30, 21, 6, -29 },
  { 4838, 21, 20, 21, 1, -20 },
  { 4891, 19, 21, 21, 2, -21 },
  { 4941, 18, 22, 21, 3, -21 },
  { 4991, 21, 28, 21, 0, -21 },
  { 5065, 19, 28, 21, 3, -21 },
  { 5132, 19, 21, 21, 3, -21 },
  { 5182, 19, 22, 21, 2, -21 },
  { 5235, 17, 27, 21, 5, -26 },
  { 5293, 19, 21, 21, 3, -20 },
  { 5343, 19, 20, 21, 4, -20 },
  { 5391, 21, 20, 21, 3, -20 },
  { 5444, 23, 20, 21, 0, -20 },
  { 5502, 25, 28, 21, -2, -20 },
  { 5590, 20, 20, 21, 2, -20 },
  { 5640, 20, 36, 21, 4, -29 },
  { 5730, 14, 36, 21, 5, -29 },
  { 5793, 20, 36, 21, 0, -29 },
  { 5883, 20, 8, 21, 2, -15 },
};

const GFXfont UbuntuMono_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic42pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUMONO_BOLDITALIC42PT7B_H_
