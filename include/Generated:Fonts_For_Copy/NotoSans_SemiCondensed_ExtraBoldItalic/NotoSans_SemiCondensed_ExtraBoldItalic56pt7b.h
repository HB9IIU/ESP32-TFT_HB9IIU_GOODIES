#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xE3,
  0xFC, 0xFF, 0x1F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x9E, 0x1C, 0x07, 0xFC, 0xF0,
  0x20, 0x3F, 0xE7, 0x00, 0x01, 0xFF, 0x38, 0x00, 0x0F, 0xFB, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xE7, 0xFC, 0x00, 0x07, 0x3F, 0xE2, 0x00,
  0x79, 0xFE, 0x0C, 0x03, 0xCF, 0xF0, 0x78, 0x1E, 0x7F, 0x87, 0xF8, 0xEF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x00,
  0x7E, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC7,
  0xF0, 0x30, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F,
  0xF3, 0xFD, 0xFE, 0x7F, 0x3F, 0xFE, 0xFF, 0xFF, 0x3F, 0x9F, 0xFF, 0xDF,
  0xFF, 0x9F, 0xCF, 0xFF, 0xF7, 0xFF, 0xC7, 0xF3, 0xFD, 0xFC, 0xFF, 0xE3,
  0xF9, 0xFE, 0x7F, 0x1F, 0xF1, 0xFC, 0x7F, 0x0F, 0xC0, 0xC0, 0x7F, 0x1F,
  0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC7,
  0xF0, 0x03, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xE0, 0x7F, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF,
  0x87, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x87, 0xFE, 0x7F, 0xEF, 0xF8, 0x7F,
  0xC3, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F,
  0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x80, 0xFE, 0x00, 0xF0, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0xDF, 0x80, 0x3F, 0xFF, 0x83, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07,
  0xFD, 0xFC, 0x03, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3E, 0x1F, 0xE0,
  0x0E, 0x07, 0xF0, 0x01, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x8F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1,
  0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01,
  0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF,
  0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F,
  0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x1F, 0xF3, 0xFE,
  0x03, 0xFE, 0x7F, 0x80, 0xFF, 0xCF, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE,
  0x3F, 0xC0, 0xFF, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF1,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xF7, 0xFC, 0x7F, 0x9F, 0xE0, 0xFC, 0x7F, 0x83, 0xC3, 0xFE, 0x06, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xF0, 0x1F, 0xF0, 0x03, 0x80, 0x7F,
  0xC0, 0x0C, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xF8,
  0x3F, 0xF8, 0x07, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x10, 0x00, 0x1F,
  0xF8, 0xC0, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x7F, 0x3F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xF8, 0x7F, 0xC0, 0x1F, 0xC1, 0xFF,
  0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xEE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC2, 0x00, 0x07, 0xFC,
  0x18, 0x00, 0x7F, 0xE0, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x3F, 0xCF, 0xFE,
  0x03, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0x8F, 0xFE, 0x0F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x81,
  0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB,
  0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x7F,
  0xDF, 0xF0, 0x1F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xDF, 0xF0, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x10, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFE, 0x03, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x0C, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x03, 0xFE,
  0x38, 0x07, 0xFC, 0x40, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFF,
  0xF8, 0x7F, 0x0F, 0xC0, 0x7F, 0xFF, 0x0F, 0xC7, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF1, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0xFE, 0x0F, 0xFB, 0xF8, 0x3F, 0x3F,
  0x07, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0x83, 0xF7, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFD, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x7E, 0x1F, 0xC0, 0xFC,
  0x0F, 0xFF, 0x87, 0xE0, 0x3F, 0x07, 0xEF, 0xC1, 0xF8, 0x1F, 0xC1, 0xFB,
  0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0xBF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xCF, 0xC3, 0xF8, 0x3F, 0x87, 0xF3, 0xF0, 0xFE, 0x1F,
  0xE1, 0xF8, 0xFC, 0x3F, 0x8F, 0xF9, 0xFE, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC1, 0xFF, 0xEF, 0xFF, 0x83, 0xF8, 0x7F, 0xF3, 0xFF, 0xC0, 0xFE,
  0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03,
  0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xC1, 0xF0, 0x1F, 0xFE, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x40, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x06, 0x00,
  0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07,
  0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0,
  0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xC1, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x03,
  0xFF, 0x80, 0x0E, 0x03, 0xFF, 0x80, 0x01, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0xFF, 0x9F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0x03, 0xFF,
  0xF8, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03,
  0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x3F, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x77, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFB, 0xF0, 0x0F, 0xEF, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xBF, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFC, 0x07, 0xF7, 0xF8,
  0x07, 0xFB, 0xF0, 0x3F, 0x9F, 0xE0, 0x3F, 0xCF, 0xE0, 0xFE, 0xFF, 0x80,
  0xFF, 0x3F, 0x87, 0xFB, 0xFC, 0x03, 0xFC, 0xFE, 0x1F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xF8, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE3, 0xF9, 0xFF, 0x01, 0xFF,
  0x3F, 0x8F, 0xE7, 0xFC, 0x07, 0xF8, 0xFE, 0x7F, 0x1F, 0xE0, 0x1F, 0xE3,
  0xF9, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xEF, 0xE1, 0xFE, 0x01, 0xFE, 0x3F,
  0xBF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFF,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xFE,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFF, 0xC1,
  0xFE, 0x01, 0xFE, 0x0F, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x01,
  0xFF, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x7F,
  0x81, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0x03, 0xFD, 0xFE, 0x07, 0xF8,
  0x07, 0xFB, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x3F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF1, 0xFE,
  0x01, 0xFE, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x3F, 0xCF, 0xF8, 0x0F, 0xF0,
  0x7F, 0xDF, 0xE0, 0x1F, 0xE0, 0x7F, 0xBF, 0xC0, 0x3F, 0xC0, 0xFF, 0x7F,
  0x80, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFC,
  0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0x80,
  0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC7, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8,
  0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x87, 0xE0,
  0x1F, 0xF0, 0x06, 0x01, 0xFF, 0x80, 0x10, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0x3F, 0xE0, 0x78,
  0x03, 0xFF, 0x03, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0,
  0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF1, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xC3, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0xC0,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0xDF, 0xC3, 0xFE, 0x03,
  0xFC, 0x3F, 0xBF, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x7F, 0x1F, 0xF0, 0x0F,
  0xF1, 0xFC, 0xFE, 0x3F, 0xE0, 0x1F, 0xE7, 0xF9, 0xFC, 0x7F, 0x80, 0x3F,
  0xCF, 0xE3, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xC7, 0xF3, 0xFC, 0x00, 0xFF,
  0x7F, 0x8F, 0xE7, 0xF8, 0x01, 0xFE, 0xFE, 0x1F, 0xDF, 0xF0, 0x03, 0xFF,
  0xFC, 0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x80, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE7, 0xFC,
  0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x81, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x87, 0xF8,
  0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xDF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x9F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0xFF, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xDF, 0xE0, 0x1F, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xFB, 0xFF, 0x80, 0x7F,
  0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x01,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x07, 0xFE,
  0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0x3F, 0xFE, 0x03, 0xF9, 0xFF, 0xE0,
  0x3F, 0x83, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1C, 0x3F, 0xF8, 0x04, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x20, 0xFF, 0xC0, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0xFF, 0x80, 0x1F,
  0xF9, 0xFE, 0x00, 0x7F, 0xFB, 0xFC, 0x01, 0xFF, 0xF7, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC7,
  0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x7F, 0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x3F,
  0xF3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFC, 0x7F, 0xC0,
  0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFD, 0xFF,
  0x03, 0xFF, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x60, 0xFF, 0xE0, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x8C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xE3, 0xFC, 0x01,
  0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xF0, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x04, 0x00, 0x1F, 0xF0, 0x0E, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xF0, 0x0F, 0xFB, 0xFF,
  0xC0, 0x7F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE3, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0x7F, 0xFC, 0x7F, 0xF8, 0x07, 0xF3, 0xFF, 0xE7, 0xFF, 0xE0,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0x03,
  0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE3, 0xFF, 0x00, 0xFF, 0x7F, 0xFC, 0x07, 0xF3, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE3,
  0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC3, 0xFE, 0x3F, 0xF0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0xFF,
  0x80, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0,
  0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9,
  0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x9F, 0xF8, 0x00, 0x7F, 0xBF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF7, 0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF,
  0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF0, 0x20, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x87,
  0xF8, 0x07, 0xFE, 0x3F, 0x80, 0x7F, 0xF9, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0x1F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0xFF, 0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x30, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F,
  0xBF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF1, 0xF8,
  0x1F, 0xF0, 0x18, 0x0F, 0xF8, 0x04, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE2, 0x00,
  0x3F, 0xE1, 0xC0, 0x1F, 0xF0, 0xFF, 0x7F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0x40, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xCF, 0xE0, 0x1F, 0xFC, 0x7F, 0x00, 0x7F,
  0xC3, 0xF8, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x83,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0xC0,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF9,
  0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFB, 0xFE, 0x00, 0x3F, 0xBF, 0xC0,
  0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFB, 0xFE,
  0x07, 0xFE, 0x03, 0xFC, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF,
  0xE0, 0x7F, 0x8F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xFE, 0x0F,
  0xF0, 0xFF, 0x87, 0xFF, 0x83, 0xFC, 0x1F, 0xC3, 0xFF, 0xE1, 0xFF, 0x07,
  0xF0, 0xFD, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x7E, 0x3F, 0xE0, 0x7F, 0x1F,
  0xDF, 0x8F, 0xF0, 0x1F, 0xC7, 0xE7, 0xE7, 0xFC, 0x07, 0xF3, 0xF9, 0xF9,
  0xFE, 0x01, 0xFC, 0xFE, 0x7E, 0x7F, 0x80, 0x7F, 0x3F, 0x1F, 0xBF, 0xC0,
  0x1F, 0xDF, 0xC7, 0xEF, 0xF0, 0x07, 0xF7, 0xE1, 0xFB, 0xFC, 0x01, 0xFD,
  0xF8, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0xC0, 0x0F, 0xFF, 0x20, 0x00,
  0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 18, 41, 16, 0, -40 },
  { 94, 22, 14, 25, 5, -40 },
  { 133, 33, 40, 33, 1, -40 },
  { 298, 29, 46, 29, 1, -43 },
  { 465, 42, 42, 47, 3, -41 },
  { 686, 36, 42, 37, 1, -41 },
  { 875, 11, 14, 14, 5, -40 },
  { 895, 20, 50, 18, 2, -41 },
  { 1020, 21, 50, 18, -4, -41 },
  { 1152, 25, 26, 28, 4, -43 },
  { 1234, 26, 27, 30, 3, -33 },
  { 1322, 14, 14, 16, -3, -7 },
  { 1347, 16, 8, 18, 1, -19 },
  { 1363, 10, 10, 16, 0, -9 },
  { 1376, 31, 40, 24, -3, -40 },
  { 1531, 27, 42, 29, 2, -41 },
  { 1673, 22, 40, 29, 5, -40 },
  { 1783, 30, 41, 29, -2, -41 },
  { 1937, 29, 42, 29, 0, -41 },
  { 2090, 30, 40, 29, -1, -40 },
  { 2240, 29, 41, 29, 1, -40 },
  { 2389, 28, 42, 29, 2, -41 },
  { 2536, 30, 40, 29, 2, -40 },
  { 2686, 28, 42, 29, 1, -41 },
  { 2833, 27, 42, 29, 2, -41 },
  { 2975, 15, 32, 16, 0, -31 },
  { 3035, 18, 38, 16, -3, -31 },
  { 3121, 26, 29, 30, 3, -35 },
  { 3216, 26, 18, 30, 3, -29 },
  { 3275, 26, 29, 30, 3, -35 },
  { 3370, 23, 42, 24, 3, -41 },
  { 3491, 42, 45, 45, 2, -40 },
  { 3728, 33, 40, 33, -3, -40 },
  { 3893, 31, 40, 32, 1, -40 },
  { 4048, 31, 42, 31, 3, -41 },
  { 4211, 33, 40, 35, 1, -40 },
  { 4376, 29, 40, 28, 1, -40 },
  { 4521, 29, 40, 28, 1, -40 },
  { 4666, 33, 42, 36, 3, -41 },
  { 4840, 36, 40, 36, 1, -40 },
  { 5020, 27, 40, 21, -2, -40 },
  { 5155, 28, 52, 18, -9, -40 },
  { 5337, 37, 40, 33, 1, -40 },
  { 5522, 22, 40, 27, 1, -40 },
  { 5632, 46, 40, 46, 1, -40 },
  { 5862, 39, 40, 39, 1, -40 },
  { 6057, 33, 42, 37, 3, -41 },
  { 6231, 31, 40, 32, 1, -40 },
  { 6386, 33, 51, 37, 3, -41 },
  { 6597, 30, 40, 32, 1, -40 },
  { 6747, 29, 42, 28, 0, -41 },
  { 6900, 28, 40, 28, 4, -40 },
  { 7040, 34, 41, 36, 3, -40 },
  { 7215, 31, 40, 31, 5, -40 },
  { 7370, 47, 40, 47, 5, -40 },
  { 7605, 39, 40, 32, -3, -40 },
  { 7800, 30, 40, 30, 5, -40 },
  { 7950, 33, 40, 28, -2, -40 },
  { 8115, 24, 50, 18, -2, -41 },
  { 8265, 13, 40, 24, 6, -40 },
  { 8330, 24, 50, 18, -4, -41 },
  { 8480, 28, 26, 29, 0, -40 },
  { 8571, 23, 5, 22, -5, 4 },
  { 8586, 12, 9, 18, 8, -43 },
  { 8600, 29, 32, 31, 2, -31 },
  { 8716, 29, 44, 31, 0, -43 },
  { 8876, 24, 32, 25, 2, -31 },
  { 8972, 31, 44, 31, 2, -43 },
  { 9143, 26, 32, 29, 2, -31 },
  { 9247, 32, 56, 20, -6, -43 },
  { 9471, 31, 44, 31, 0, -31 },
  { 9642, 29, 43, 31, 0, -43 },
  { 9798, 18, 43, 16, 0, -43 },
  { 9895, 25, 56, 16, -7, -43 },
  { 10070, 33, 43, 30, 0, -43 },
  { 10248, 18, 43, 16, 0, -43 },
  { 10345, 45, 31, 47, 0, -31 },
  { 10520, 29, 31, 31, 0, -31 },
  { 10633, 27, 32, 31, 2, -31 },
  { 10741, 32, 44, 31, -3, -31 },
  { 10917, 29, 44, 31, 2, -31 },
  { 11077, 25, 31, 22, 0, -31 },
  { 11174, 25, 32, 25, 0, -31 },
  { 11274, 21, 38, 22, 2, -37 },
  { 11374, 29, 32, 31, 2, -31 },
  { 11490, 28, 31, 27, 3, -31 },
  { 11599, 42, 31, 42, 3, -31 },
  { 11762, 34, 31, 28, -3, -31 },
  { 11894, 35, 44, 28, -4, -31 },
  { 12087, 28, 31, 24, -2, -31 },
  { 12196, 24, 49, 20, 0, -40 },
  { 12343, 7, 56, 28, 10, -43 },
  { 12392, 23, 49, 20, -3, -40 },
  { 12533, 26, 10, 30, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC56PT7B_H_
