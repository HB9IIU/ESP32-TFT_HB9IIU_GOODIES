#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x7E, 0x7D, 0xF3, 0xF7, 0xCF, 0xFF,
  0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0,
  0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x7C, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x0F, 0x1E, 0x00, 0x3E,
  0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00,
  0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xB1, 0x83, 0xE6, 0x00, 0x7C, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x6F, 0xC8, 0x1D, 0xF9, 0x83, 0xBF, 0x3E, 0x6F,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3E, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF,
  0x81, 0xE0, 0x3E, 0x7C, 0x1F, 0x01, 0xF3, 0xE1, 0xF0, 0x0F, 0x1F, 0x0F,
  0x00, 0xF8, 0xF8, 0xF8, 0x07, 0xC7, 0xCF, 0x80, 0x3E, 0x3C, 0x78, 0x01,
  0xF3, 0xE7, 0xC7, 0x0F, 0x9F, 0x7C, 0xFE, 0x7D, 0xF3, 0xCF, 0xFB, 0xFF,
  0xBE, 0xFF, 0xCF, 0xFB, 0xE7, 0xDF, 0x3F, 0x9E, 0x7C, 0xF8, 0x61, 0xF3,
  0xC7, 0xC0, 0x1F, 0x3E, 0x3E, 0x00, 0xF1, 0xF1, 0xF0, 0x0F, 0x8F, 0x8F,
  0x00, 0xF8, 0x7C, 0xF8, 0x07, 0x83, 0xE7, 0xC0, 0x7C, 0x1F, 0x3C, 0x07,
  0xC0, 0xFF, 0xE0, 0x3C, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x3E, 0x00,
  0x7E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFC, 0x3F, 0xF0,
  0xFC, 0x3F, 0xFC, 0x7E, 0x3F, 0xFE, 0x7E, 0x3F, 0xBF, 0xBF, 0x1F, 0x8F,
  0xFF, 0x0F, 0xC3, 0xFF, 0x8F, 0xE1, 0xFF, 0x87, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7E, 0xF9, 0xF7, 0xEF, 0x9F, 0x3E,
  0x78, 0xF1, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x00, 0x01, 0xE8, 0x00, 0xF8, 0x00, 0x7C, 0x08, 0x3E, 0x07,
  0x1E, 0x03, 0xEF, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF,
  0xC3, 0xFB, 0xE3, 0xFE, 0x03, 0xFF, 0x03, 0xF7, 0xC0, 0xF1, 0xE0, 0x38,
  0xF8, 0x08, 0x78, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F,
  0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xFF, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xF3, 0xF0, 0xFC, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFD, 0xFC,
  0x1F, 0xBF, 0x07, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xF0,
  0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0x7C, 0xFC, 0x73,
  0xF0, 0xC7, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xC3, 0xF0, 0x30, 0x3F, 0x02, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x02, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC8,
  0x01, 0xF8, 0xC0, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F,
  0x9F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x80, 0x1F, 0x8C, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xEE,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x3C,
  0x03, 0xEF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xF1,
  0xF8, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x10, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x9F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xC7,
  0xE3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xE7, 0xF3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xCF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xEF, 0x87, 0xF7, 0xE0, 0x71, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x7F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFF, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xC3, 0xE0, 0xFF, 0x1F, 0x1E, 0x0F, 0xFC, 0x79, 0xF1, 0xFF, 0xE3,
  0xCF, 0x0F, 0x9F, 0x1E, 0xF8, 0xF8, 0xF0, 0xF7, 0x8F, 0x87, 0x87, 0xBC,
  0x78, 0x3C, 0x3D, 0xE3, 0xC3, 0xE3, 0xCF, 0x3E, 0x1E, 0x1E, 0xF9, 0xF0,
  0xF0, 0xF7, 0xCF, 0x8F, 0x8F, 0x3E, 0x7C, 0x7C, 0xF9, 0xF3, 0xFF, 0xFF,
  0x8F, 0x8F, 0xFF, 0xF8, 0x3C, 0x7F, 0x3F, 0x81, 0xE0, 0xF0, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x80, 0x07, 0xF8,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF8,
  0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE,
  0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE3, 0xF8,
  0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F,
  0x07, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0x81, 0x87, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x0C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0,
  0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x7F, 0x07, 0xE3, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFE, 0x03, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xFB, 0xF8, 0x7F, 0xEF, 0xE1, 0xFF,
  0x3F, 0x0F, 0xFC, 0xFC, 0x3F, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xF0, 0x7E, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFE, 0x07,
  0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xBE, 0x1F, 0x7C, 0x0F, 0xBE, 0x1F, 0xFC, 0x0F, 0xBE, 0x3E, 0xFC,
  0x0F, 0xBE, 0x3E, 0xF8, 0x1F, 0xBE, 0x7C, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8,
  0x1F, 0x3E, 0xF9, 0xF8, 0x1F, 0x3E, 0xF9, 0xF8, 0x3F, 0x3E, 0xF1, 0xF0,
  0x3F, 0x3F, 0xF3, 0xF0, 0x3F, 0x3F, 0xE3, 0xF0, 0x3E, 0x3F, 0xE3, 0xF0,
  0x3E, 0x3F, 0xC3, 0xF0, 0x7E, 0x3F, 0xC3, 0xE0, 0x7E, 0x3F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x87, 0xE0, 0x7C, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC0,
  0x03, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x83, 0xFE,
  0x03, 0xF0, 0x7F, 0xC0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x83, 0xF0,
  0x3F, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xF7, 0xE1, 0xF0, 0x3E, 0xFC,
  0x7E, 0x07, 0xCF, 0x8F, 0xC0, 0xF9, 0xF9, 0xF8, 0x3F, 0x3F, 0x3E, 0x07,
  0xE7, 0xE7, 0xC0, 0xF8, 0x7C, 0xF8, 0x1F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF,
  0xE0, 0xFC, 0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C,
  0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x1F, 0xE0, 0x7E, 0x03, 0xFC,
  0x0F, 0x80, 0x7F, 0x83, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xF8, 0x7F, 0x1F, 0xE0, 0x7E, 0x3F, 0x80, 0xFE, 0x7E, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC3, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x1F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFE, 0x0F, 0xDF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xF8, 0x7F, 0x1F, 0xE0, 0x7E, 0x3F, 0x80, 0xFE, 0x7E, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0xFE, 0x1F, 0x8F, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1,
  0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x81, 0xFC, 0x00, 0x0C, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xE0, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x84, 0x03, 0xF0, 0x70, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0x03, 0xF0,
  0x7C, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0,
  0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x3F, 0xE1,
  0xF8, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE1, 0xF0, 0xFC, 0x7F, 0xE3,
  0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7,
  0xE0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF,
  0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xFB, 0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0xFC, 0x1F, 0x87,
  0xE1, 0xFC, 0x1F, 0x0F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8,
  0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80,
  0xF9, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x80, 0xF3, 0xE0, 0x1E, 0xFC, 0x03, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x03, 0xF1, 0xF0, 0x7F,
  0xBF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x0F, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF,
  0xE0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFD, 0xF0, 0x1F, 0x9F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xCF, 0x80,
  0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC7, 0xF1,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xDF, 0xE0, 0xF8,
  0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFC, 0x10, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x10,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0xEF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE,
  0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xF7, 0xC0, 0x1F, 0x9E, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xCF, 0xCF, 0xC1, 0xF3, 0xF0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x7F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xC0,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x08, 0x7F, 0x0E, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x1F, 0xEF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x00, 0xF9, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xC0, 0x7E, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0xFD, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x1F, 0xC3,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0x80,
  0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xFE, 0x1F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF3, 0xF8, 0x07, 0xEF, 0xE0,
  0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x00, 0x07, 0x8F, 0xC3, 0xF0, 0x3E, 0x7F, 0x9F, 0xE0, 0xFB, 0xFE, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0x9F, 0xE3, 0xF1,
  0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x1F, 0x87, 0xE0, 0xFC, 0x7E,
  0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1, 0xF8, 0x7E, 0x3F, 0x07,
  0xE1, 0xF8, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0x9F, 0x83, 0xF0,
  0xFC, 0x7E, 0x0F, 0xC3, 0xF1, 0xF8, 0x3E, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F,
  0x1F, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x87, 0xE0, 0x07, 0x8F, 0xC0, 0xF9,
  0xFE, 0x0F, 0xBF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x1F,
  0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F,
  0x80, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xE3, 0xF3, 0xF0, 0xFD, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF8,
  0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x01, 0xE3, 0xE0, 0x0F, 0xBF, 0xC0, 0x3E, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xDF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF1, 0xF0, 0x7F, 0xBF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFB, 0xF0, 0x1F, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x07, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x03, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF8, 0xE1, 0xFC,
  0x10, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF9, 0x01, 0xFC, 0xF9, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF8, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xDF, 0x07, 0xF3, 0xE0, 0xFC, 0x0F, 0xFF, 0x81, 0xFB,
  0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x83,
  0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x3F, 0x87, 0xEF, 0xC3, 0xF8, 0x7E, 0xFC,
  0x7F, 0x87, 0xCF, 0xC7, 0xF8, 0xFC, 0xFC, 0xFF, 0x8F, 0x8F, 0xCF, 0x79,
  0xF8, 0xFC, 0xF7, 0x9F, 0x8F, 0xDF, 0x79, 0xF0, 0xFD, 0xE7, 0xBF, 0x07,
  0xFE, 0x7B, 0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80,
  0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80,
  0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC,
  0x07, 0xE1, 0xFC, 0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE3, 0xF0,
  0x03, 0xE3, 0xF0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00,
  0xF8, 0x00, 0x1C, 0x00, 0xBF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFE, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 27, 11, 0, -27 },
  { 42, 14, 10, 17, 4, -27 },
  { 60, 23, 27, 23, 0, -27 },
  { 138, 19, 31, 20, 1, -29 },
  { 212, 29, 28, 32, 2, -28 },
  { 314, 25, 28, 25, 0, -28 },
  { 402, 7, 10, 9, 4, -27 },
  { 411, 14, 34, 12, 1, -28 },
  { 471, 14, 34, 12, -3, -28 },
  { 531, 17, 18, 19, 3, -29 },
  { 570, 17, 19, 21, 2, -23 },
  { 611, 9, 10, 11, -2, -5 },
  { 623, 11, 5, 12, 0, -13 },
  { 630, 7, 6, 11, 0, -6 },
  { 636, 21, 27, 16, -2, -27 },
  { 707, 19, 28, 20, 1, -28 },
  { 774, 15, 27, 20, 3, -27 },
  { 825, 20, 28, 20, -1, -28 },
  { 895, 20, 28, 20, 0, -28 },
  { 965, 20, 27, 20, 0, -27 },
  { 1033, 20, 27, 20, 0, -27 },
  { 1101, 20, 28, 20, 1, -28 },
  { 1171, 21, 27, 20, 1, -27 },
  { 1242, 19, 28, 20, 1, -28 },
  { 1309, 18, 28, 20, 1, -28 },
  { 1372, 10, 21, 11, 0, -21 },
  { 1399, 12, 26, 11, -2, -21 },
  { 1438, 17, 20, 21, 2, -24 },
  { 1481, 17, 13, 21, 2, -20 },
  { 1509, 17, 20, 21, 2, -24 },
  { 1552, 16, 28, 16, 2, -28 },
  { 1608, 29, 30, 30, 1, -27 },
  { 1717, 22, 27, 23, -2, -27 },
  { 1792, 22, 27, 22, 0, -27 },
  { 1867, 21, 28, 21, 2, -28 },
  { 1941, 23, 27, 24, 0, -27 },
  { 2019, 20, 27, 19, 0, -27 },
  { 2087, 20, 27, 19, 0, -27 },
  { 2155, 22, 28, 24, 2, -28 },
  { 2232, 25, 27, 25, 0, -27 },
  { 2317, 18, 27, 14, -1, -27 },
  { 2378, 19, 35, 12, -6, -27 },
  { 2462, 26, 27, 22, 0, -27 },
  { 2550, 16, 27, 18, 0, -27 },
  { 2604, 32, 27, 32, 0, -27 },
  { 2712, 27, 27, 27, 0, -27 },
  { 2804, 23, 28, 25, 2, -28 },
  { 2885, 22, 27, 21, 0, -27 },
  { 2960, 23, 34, 25, 2, -28 },
  { 3058, 21, 27, 22, 0, -27 },
  { 3129, 20, 28, 19, 0, -28 },
  { 3199, 18, 27, 19, 3, -27 },
  { 3260, 23, 27, 24, 2, -27 },
  { 3338, 22, 27, 21, 3, -27 },
  { 3413, 32, 27, 32, 3, -27 },
  { 3521, 27, 27, 22, -2, -27 },
  { 3613, 21, 27, 20, 3, -27 },
  { 3684, 22, 27, 19, -1, -27 },
  { 3759, 16, 34, 12, -1, -28 },
  { 3827, 9, 27, 16, 4, -27 },
  { 3858, 16, 34, 12, -3, -28 },
  { 3926, 19, 17, 19, 0, -27 },
  { 3967, 16, 3, 15, -4, 3 },
  { 3973, 9, 6, 12, 5, -29 },
  { 3980, 20, 21, 21, 1, -21 },
  { 4033, 20, 29, 21, 0, -29 },
  { 4106, 17, 21, 17, 1, -21 },
  { 4151, 22, 29, 21, 1, -29 },
  { 4231, 18, 21, 20, 1, -21 },
  { 4279, 22, 38, 13, -4, -29 },
  { 4384, 21, 30, 21, 0, -21 },
  { 4463, 20, 29, 21, 0, -29 },
  { 4536, 12, 29, 11, 0, -29 },
  { 4580, 17, 38, 11, -5, -29 },
  { 4661, 23, 29, 21, 0, -29 },
  { 4745, 12, 29, 11, 0, -29 },
  { 4789, 30, 21, 32, 0, -21 },
  { 4868, 20, 21, 21, 0, -21 },
  { 4921, 18, 21, 21, 1, -21 },
  { 4969, 22, 30, 21, -2, -21 },
  { 5052, 20, 30, 21, 1, -21 },
  { 5127, 17, 21, 15, 0, -21 },
  { 5172, 17, 21, 17, 0, -21 },
  { 5217, 14, 25, 15, 2, -25 },
  { 5261, 19, 21, 21, 2, -21 },
  { 5311, 19, 21, 19, 2, -21 },
  { 5361, 28, 21, 28, 2, -21 },
  { 5435, 23, 21, 19, -2, -21 },
  { 5496, 24, 30, 19, -3, -21 },
  { 5586, 18, 21, 17, -1, -21 },
  { 5634, 16, 33, 13, 0, -27 },
  { 5700, 5, 38, 19, 7, -29 },
  { 5724, 15, 33, 13, -2, -27 },
  { 5786, 17, 7, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC38PT7B_H_
