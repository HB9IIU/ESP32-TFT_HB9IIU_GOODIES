#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x39, 0xCC, 0x03, 0x39, 0xC0, 0xEF, 0x7D, 0xB6,
  0x0C, 0xC3, 0x60, 0xD9, 0xFF, 0x7F, 0xC6, 0xC3, 0x33, 0xFE, 0xFF, 0x8D,
  0x86, 0x61, 0xB0, 0x02, 0x07, 0x8F, 0xE7, 0xE3, 0x41, 0xE0, 0xF8, 0x1E,
  0x0F, 0x45, 0xBF, 0xDF, 0xC1, 0x00, 0x80, 0x78, 0x63, 0xE6, 0x33, 0x31,
  0xBB, 0x0D, 0xB0, 0x6D, 0xFB, 0xDB, 0x61, 0xB3, 0x0D, 0x98, 0xCD, 0x8C,
  0x7C, 0xE1, 0xC0, 0x0F, 0x03, 0xF0, 0x66, 0x1D, 0xC1, 0xF0, 0x3D, 0xDF,
  0xBB, 0x7E, 0xE7, 0xDC, 0xF3, 0xFE, 0x3E, 0xE0, 0xFB, 0x60, 0x0E, 0x30,
  0xE1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x00,
  0x18, 0x70, 0xC3, 0x0C, 0x30, 0xC7, 0x1C, 0x63, 0x8C, 0x71, 0x8C, 0x00,
  0x0C, 0x4C, 0x68, 0xFF, 0x3F, 0x7C, 0x6E, 0x2C, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x77, 0x6E, 0x7F, 0xFE, 0x7F, 0x80, 0x01, 0x81,
  0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x00,
  0x1F, 0x1F, 0x8E, 0xEE, 0x77, 0x3B, 0x9D, 0x8C, 0xCE, 0xE7, 0x33, 0x1F,
  0x87, 0x80, 0x0E, 0x3D, 0xFF, 0x64, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1,
  0xC0, 0x0F, 0x8F, 0xE1, 0x9C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0xF3, 0xFC, 0x3F, 0x1F, 0xC8, 0xE0, 0x70, 0x70, 0xE0, 0xF8,
  0x0E, 0x07, 0x43, 0xBF, 0x9F, 0x80, 0x03, 0x83, 0x83, 0xC3, 0x61, 0xF1,
  0xB9, 0x99, 0xFE, 0xFF, 0x7F, 0x83, 0x81, 0x80, 0x1F, 0x8F, 0xCE, 0x06,
  0x03, 0xC3, 0xF8, 0xBC, 0x0E, 0x07, 0x47, 0xBF, 0x9F, 0x80, 0x1F, 0x3F,
  0x70, 0x60, 0xFC, 0xFE, 0xEE, 0xC6, 0xCE, 0xCE, 0xFC, 0x78, 0x3F, 0xCF,
  0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03,
  0xC0, 0x1F, 0x1F, 0xCC, 0xE6, 0x73, 0xF0, 0xF0, 0xF8, 0xEE, 0xE7, 0x73,
  0x9F, 0x8F, 0x80, 0x3E, 0x7E, 0xE7, 0xE7, 0xE7, 0xEF, 0xFE, 0x7E, 0x0E,
  0x1C, 0xF8, 0xF0, 0x39, 0xC8, 0x00, 0x01, 0x9C, 0xE0, 0x1C, 0x71, 0x00,
  0x00, 0x00, 0x1C, 0x71, 0x8E, 0x00, 0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0,
  0x3C, 0x0F, 0x0F, 0x7C, 0xF0, 0x80, 0xFC, 0xFD, 0x38, 0x71, 0xC7, 0x1C,
  0x30, 0x00, 0xC3, 0x87, 0x00, 0x0F, 0xC3, 0xCE, 0x30, 0x36, 0x7B, 0xCF,
  0x9D, 0x99, 0xD9, 0xB9, 0xB3, 0x9B, 0x6D, 0xDC, 0xC0, 0x06, 0x18, 0x3F,
  0x80, 0x03, 0x81, 0xE0, 0x78, 0x3F, 0x0D, 0xC7, 0x71, 0x9C, 0xFF, 0x3F,
  0xDC, 0x77, 0x1F, 0x87, 0x1F, 0x8F, 0xF3, 0x9C, 0xE7, 0x33, 0x8F, 0xC7,
  0xF1, 0xCE, 0x73, 0x99, 0xE7, 0xF3, 0xF8, 0x1F, 0x9F, 0xDE, 0x2E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0x3F, 0x8F, 0xC0, 0x1F, 0x0F, 0xF3,
  0x9C, 0xE7, 0x39, 0xCC, 0x77, 0x1D, 0xC7, 0x73, 0x99, 0xE7, 0xF3, 0xF0,
  0x1F, 0x9F, 0xCE, 0x07, 0x03, 0x81, 0xF9, 0xF8, 0xE0, 0x70, 0x30, 0x1F,
  0x9F, 0xC0, 0x1F, 0x9F, 0xCE, 0x07, 0x03, 0x81, 0xF9, 0xF8, 0xE0, 0x70,
  0x30, 0x18, 0x1C, 0x00, 0x1F, 0xCF, 0xE7, 0x89, 0xC0, 0xE0, 0x39, 0xEE,
  0xFB, 0x8E, 0xE3, 0x38, 0xC7, 0xF0, 0xFC, 0x1C, 0xE7, 0x1C, 0xE3, 0x9C,
  0x73, 0x8C, 0x7F, 0x9F, 0xF3, 0x8E, 0x71, 0x8C, 0x31, 0x8E, 0x71, 0xC0,
  0x1F, 0x8F, 0x83, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x1F,
  0x1F, 0x80, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x03, 0x81, 0xC7, 0xE3, 0xE1, 0xC0, 0x18, 0xE7, 0x38, 0xEE,
  0x1D, 0xC3, 0x70, 0x7C, 0x1F, 0x83, 0xB8, 0x77, 0x0C, 0xE1, 0x8C, 0x71,
  0xC0, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC1, 0xFF, 0xF0,
  0x1C, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x1F, 0x3E, 0xF8, 0xFB, 0x67, 0xEF,
  0x9D, 0xEE, 0x67, 0xB9, 0x9C, 0xC6, 0x73, 0x39, 0x9C, 0x1C, 0x33, 0xC7,
  0x3E, 0x73, 0xE6, 0x36, 0x63, 0x66, 0x77, 0xE7, 0x7E, 0x63, 0xC6, 0x3C,
  0x63, 0xCE, 0x3C, 0x1F, 0x8F, 0xE7, 0x1D, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x86, 0xE3, 0xB9, 0xEF, 0xF1, 0xF8, 0x1F, 0x0F, 0xE3, 0x9C, 0xE7, 0x39,
  0xCD, 0xE7, 0xF1, 0xF8, 0x70, 0x18, 0x06, 0x03, 0x80, 0x1F, 0x8F, 0xE7,
  0x9D, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE3, 0xB9, 0xEF, 0xF1, 0xF8,
  0x0E, 0x03, 0x80, 0x70, 0x1F, 0x0F, 0xE3, 0x9C, 0xE7, 0x3B, 0x8F, 0xE7,
  0xF1, 0xD8, 0x77, 0x19, 0xC6, 0x33, 0x8E, 0x1F, 0x9F, 0x8E, 0x46, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x06, 0x67, 0x3F, 0x9F, 0x80, 0x7F, 0xFF, 0x87,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x00, 0x31,
  0xDC, 0x77, 0x1D, 0xC6, 0x63, 0xB8, 0xEE, 0x3B, 0x8E, 0xE7, 0x39, 0xCF,
  0xE1, 0xF0, 0xE1, 0xD8, 0xE6, 0x39, 0x8C, 0x67, 0x19, 0x86, 0xE1, 0xB0,
  0x7C, 0x1E, 0x07, 0x81, 0xC0, 0xE3, 0x8F, 0xC7, 0x3B, 0x9E, 0x77, 0x3C,
  0xCE, 0xFB, 0x8D, 0xB6, 0x1B, 0x7C, 0x3C, 0xF8, 0x79, 0xE0, 0xF3, 0xC1,
  0xC7, 0x03, 0x8E, 0x00, 0x1C, 0x71, 0xCE, 0x0D, 0xC0, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x3B, 0x83, 0xB8, 0x73, 0x8E, 0x1C, 0xE3, 0xDC,
  0xE7, 0x71, 0xD8, 0x7E, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x1F, 0xC7, 0xF0, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x1C, 0x07, 0xF3, 0xFC, 0x0F, 0x1E, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30,
  0x30, 0x30, 0x70, 0x60, 0x60, 0x78, 0xF8, 0xCC, 0xCE, 0xE6, 0x66, 0x66,
  0x73, 0x1E, 0x3C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83,
  0x1E, 0x3C, 0x00, 0x06, 0x0E, 0x1E, 0x1E, 0x33, 0x73, 0x63, 0xC3, 0x7F,
  0xFE, 0xE7, 0x30, 0x10, 0x7B, 0x7F, 0xE7, 0xE7, 0xC6, 0xCE, 0xCE, 0xFE,
  0xFC, 0x1C, 0x0C, 0x0E, 0x07, 0x43, 0x71, 0xFD, 0xCE, 0xE7, 0x73, 0xB1,
  0x9D, 0xDF, 0xCD, 0xE0, 0x08, 0x7D, 0xF7, 0x0E, 0x18, 0x30, 0x72, 0xF8,
  0xF0, 0x03, 0x81, 0xC0, 0xE2, 0x67, 0xB3, 0xFB, 0x9D, 0xCC, 0xC6, 0x67,
  0x33, 0x9F, 0xCF, 0xC0, 0x08, 0x3E, 0x77, 0xE7, 0xFE, 0xFC, 0xC0, 0xC2,
  0xFC, 0x7C, 0x03, 0xC1, 0xE0, 0x60, 0x18, 0x1F, 0x87, 0xC0, 0xE0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x83, 0xC0, 0xF0, 0x00,
  0x08, 0x1E, 0xCF, 0xEE, 0x77, 0x3B, 0x19, 0x9C, 0xCE, 0x7F, 0x3B, 0x01,
  0x91, 0xCF, 0xC7, 0xC0, 0x1C, 0x0C, 0x0E, 0x07, 0x43, 0x79, 0xFD, 0xCE,
  0xE7, 0x73, 0xB9, 0x99, 0xDC, 0xEE, 0x70, 0x19, 0xC6, 0x03, 0x99, 0xCE,
  0x73, 0x99, 0xCE, 0x00, 0x06, 0x1C, 0x18, 0x00, 0xE1, 0x83, 0x0E, 0x1C,
  0x38, 0x61, 0xC3, 0x87, 0x0C, 0x78, 0xE0, 0x18, 0x06, 0x03, 0x80, 0xE1,
  0x3B, 0x8C, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x86, 0x63, 0x9C, 0xE7, 0x00,
  0x1C, 0x63, 0x8E, 0x38, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE0, 0x02, 0x10,
  0xDD, 0xE3, 0xFF, 0xDC, 0xE7, 0x73, 0x99, 0xCC, 0xE6, 0x33, 0x99, 0xCE,
  0xE7, 0x3B, 0x9C, 0xC0, 0x02, 0x1B, 0xCF, 0xEE, 0x77, 0x3B, 0x99, 0xCC,
  0xCE, 0xE7, 0x73, 0x80, 0x08, 0x3E, 0x7E, 0xE7, 0xE7, 0xC7, 0xC6, 0xCE,
  0xFC, 0x78, 0x01, 0x07, 0xE1, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0x18, 0xEE,
  0x7F, 0x1F, 0xC7, 0x01, 0x80, 0x60, 0x38, 0x00, 0x10, 0x7B, 0x7F, 0xE7,
  0xE7, 0xC6, 0xCE, 0xCE, 0xFE, 0xFC, 0x0C, 0x1C, 0x1C, 0x1C, 0x02, 0x6C,
  0xFB, 0xC7, 0x0E, 0x1C, 0x30, 0xE1, 0xC0, 0x08, 0x7D, 0xDB, 0x87, 0x87,
  0x87, 0xC7, 0xFD, 0xF0, 0x30, 0xCF, 0xFF, 0x63, 0x8E, 0x38, 0xE3, 0xCF,
  0x00, 0x73, 0x67, 0xE7, 0xE7, 0xE6, 0xCE, 0xCE, 0xFE, 0xFE, 0xE7, 0xE6,
  0xEE, 0xEC, 0xFC, 0xF8, 0x78, 0x70, 0x70, 0xEF, 0x3E, 0x7B, 0xB3, 0xD9,
  0xB7, 0xCD, 0xBC, 0x69, 0x63, 0xCF, 0x1E, 0xF0, 0xE7, 0x80, 0x39, 0xC7,
  0xE1, 0xF0, 0x7C, 0x0E, 0x07, 0x83, 0xF1, 0xDC, 0xE3, 0x80, 0x39, 0xCE,
  0x63, 0xB8, 0xEC, 0x3F, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x83,
  0xC0, 0xE0, 0x00, 0x3F, 0x7E, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xFC, 0xFC,
  0x0E, 0x3C, 0x60, 0xC3, 0x87, 0x3C, 0x70, 0x70, 0xE1, 0xC3, 0x07, 0x0E,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x78, 0x70, 0xE1, 0xC3,
  0x87, 0x87, 0x3C, 0x70, 0xC1, 0x87, 0x1C, 0x30, 0x00, 0x01, 0xFF, 0xFF,
  0x84,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 5, 0, -12 },
  { 9, 6, 4, 8, 2, -12 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 9, 14, 9, 0, -13 },
  { 43, 13, 12, 14, 1, -12 },
  { 63, 11, 12, 11, 0, -12 },
  { 80, 3, 4, 4, 2, -12 },
  { 82, 7, 15, 6, 0, -12 },
  { 96, 6, 15, 6, -1, -12 },
  { 108, 8, 8, 9, 1, -13 },
  { 116, 8, 8, 9, 1, -10 },
  { 124, 4, 4, 5, -1, -2 },
  { 126, 5, 3, 5, 0, -6 },
  { 128, 3, 3, 5, 0, -3 },
  { 130, 9, 12, 7, -1, -12 },
  { 144, 9, 12, 9, 0, -12 },
  { 158, 7, 12, 9, 1, -12 },
  { 169, 10, 12, 9, -1, -12 },
  { 184, 9, 12, 9, 0, -12 },
  { 198, 9, 12, 9, 0, -12 },
  { 212, 9, 12, 9, 0, -12 },
  { 226, 8, 12, 9, 1, -12 },
  { 238, 10, 12, 9, 0, -12 },
  { 253, 9, 12, 9, 0, -12 },
  { 267, 8, 12, 9, 1, -12 },
  { 279, 5, 9, 5, 0, -9 },
  { 285, 6, 11, 5, -1, -9 },
  { 294, 8, 9, 9, 1, -11 },
  { 303, 8, 6, 9, 1, -9 },
  { 309, 8, 9, 9, 1, -11 },
  { 318, 7, 12, 7, 1, -12 },
  { 329, 12, 13, 14, 1, -12 },
  { 349, 10, 12, 10, -1, -12 },
  { 364, 10, 12, 10, 0, -12 },
  { 379, 9, 12, 10, 1, -12 },
  { 393, 10, 12, 11, 0, -12 },
  { 408, 9, 12, 8, 0, -12 },
  { 422, 9, 12, 8, 0, -12 },
  { 436, 10, 12, 11, 1, -12 },
  { 451, 11, 12, 11, 0, -12 },
  { 468, 9, 12, 6, -1, -12 },
  { 482, 9, 16, 5, -3, -12 },
  { 500, 11, 12, 10, 0, -12 },
  { 517, 7, 12, 8, 0, -12 },
  { 528, 14, 12, 14, 0, -12 },
  { 549, 12, 12, 12, 0, -12 },
  { 567, 10, 12, 11, 1, -12 },
  { 582, 10, 12, 10, 0, -12 },
  { 597, 10, 15, 11, 1, -12 },
  { 616, 10, 12, 10, 0, -12 },
  { 631, 9, 12, 8, 0, -12 },
  { 645, 9, 12, 8, 1, -12 },
  { 659, 10, 12, 11, 1, -12 },
  { 674, 10, 12, 10, 1, -12 },
  { 689, 15, 12, 14, 1, -12 },
  { 712, 12, 12, 10, -1, -12 },
  { 730, 10, 12, 9, 1, -12 },
  { 745, 10, 12, 8, -1, -12 },
  { 760, 8, 15, 5, -1, -12 },
  { 775, 4, 12, 7, 2, -12 },
  { 781, 7, 15, 5, -1, -12 },
  { 795, 8, 8, 9, 0, -12 },
  { 803, 8, 2, 7, -2, 1 },
  { 805, 4, 3, 6, 2, -13 },
  { 807, 8, 10, 9, 1, -10 },
  { 817, 9, 13, 9, 0, -13 },
  { 832, 7, 10, 8, 1, -10 },
  { 841, 9, 13, 9, 1, -13 },
  { 856, 8, 10, 9, 1, -10 },
  { 866, 10, 17, 6, -2, -13 },
  { 888, 9, 14, 9, 0, -10 },
  { 904, 9, 13, 10, 0, -13 },
  { 919, 5, 13, 5, 0, -13 },
  { 928, 7, 17, 5, -2, -13 },
  { 943, 10, 13, 9, 0, -13 },
  { 960, 6, 13, 5, 0, -13 },
  { 970, 14, 10, 14, 0, -10 },
  { 988, 9, 10, 10, 0, -10 },
  { 1000, 8, 10, 9, 1, -10 },
  { 1010, 10, 14, 9, -1, -10 },
  { 1028, 8, 14, 9, 1, -10 },
  { 1042, 7, 10, 7, 0, -10 },
  { 1051, 7, 10, 8, 0, -10 },
  { 1060, 6, 11, 7, 1, -11 },
  { 1069, 8, 9, 10, 1, -9 },
  { 1078, 8, 9, 8, 1, -9 },
  { 1087, 13, 9, 13, 1, -9 },
  { 1102, 10, 9, 9, -1, -9 },
  { 1114, 10, 13, 8, -1, -9 },
  { 1131, 8, 9, 7, 0, -9 },
  { 1140, 7, 15, 6, 0, -12 },
  { 1154, 2, 17, 8, 3, -13 },
  { 1159, 7, 15, 6, -1, -12 },
  { 1173, 8, 4, 9, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC17PT7B_H_
