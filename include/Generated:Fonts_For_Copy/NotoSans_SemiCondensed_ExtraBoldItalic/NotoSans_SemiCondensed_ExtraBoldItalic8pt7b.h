#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x29, 0x80, 0xB8, 0x29, 0x9E, 0xAE, 0x50, 0x27, 0x63, 0xDE,
  0x65, 0xAB, 0x57, 0x2D, 0x30, 0x32, 0x9C, 0xDB, 0x7C, 0xC0, 0x29, 0x69,
  0x30, 0x24, 0x92, 0x70, 0x5F, 0x30, 0x22, 0xF2, 0xE0, 0xC0, 0x80, 0x12,
  0x24, 0xC8, 0x35, 0xDD, 0xB6, 0x7F, 0x25, 0x80, 0x75, 0x12, 0x5E, 0x75,
  0x37, 0x3E, 0x13, 0x7A, 0xF2, 0x74, 0x6B, 0x3E, 0x34, 0x7D, 0xF6, 0x78,
  0x8C, 0x44, 0x60, 0x35, 0x77, 0x9E, 0x75, 0xD7, 0x2E, 0x42, 0x43, 0x80,
  0x16, 0xE1, 0xFF, 0x86, 0x3C, 0x67, 0x24, 0x0C, 0x39, 0x17, 0xEB, 0xBD,
  0x03, 0x00, 0x33, 0x55, 0xF9, 0x72, 0xD4, 0xED, 0x78, 0x3B, 0x51, 0x8C,
  0x38, 0x72, 0xD6, 0xBD, 0x70, 0x74, 0x77, 0xCE, 0x74, 0x47, 0xC8, 0x3B,
  0x51, 0xFD, 0x38, 0x6A, 0x5E, 0xFD, 0x48, 0x76, 0x44, 0x4C, 0x32, 0x22,
  0x66, 0x4C, 0x6A, 0x9C, 0xCF, 0x48, 0x69, 0x2D, 0xC0, 0x66, 0xDD, 0xB3,
  0xEF, 0x57, 0x80, 0x65, 0xA6, 0x9E, 0xDA, 0x60, 0x33, 0x53, 0x9D, 0xB8,
  0x72, 0xD4, 0xEC, 0x40, 0x33, 0x53, 0x9D, 0xB8, 0xC0, 0x72, 0xD4, 0xEF,
  0x48, 0x35, 0x42, 0x3E, 0xF4, 0x4C, 0x88, 0x6A, 0x56, 0xBD, 0x38, 0x9B,
  0xAE, 0xCC, 0xB6, 0xDB, 0xF6, 0xDA, 0x40, 0x4A, 0x9C, 0xC7, 0x48, 0xBA,
  0xEC, 0xC8, 0x73, 0x26, 0xDE, 0x69, 0x29, 0x30, 0xAA, 0xD0, 0x33, 0x22,
  0x22, 0xC0, 0x22, 0x59, 0xF0, 0xC0, 0x7D, 0xFF, 0x64, 0x75, 0xDE, 0x7C,
  0xC6, 0x18, 0x9D, 0xAD, 0x78, 0x7F, 0xC6, 0x19, 0x1C, 0x42, 0x31, 0x18,
  0x7D, 0xFF, 0x2E, 0x64, 0x75, 0xDB, 0x61, 0x2D, 0x00, 0x30, 0x22, 0x64,
  0x4C, 0x62, 0x54, 0xCE, 0x58, 0x69, 0x2D, 0x00, 0x7D, 0x5D, 0x6F, 0x75,
  0xDB, 0x7D, 0xD6, 0x75, 0xDE, 0x88, 0x7D, 0xDF, 0x22, 0x74, 0xC8, 0xF6,
  0x2E, 0x7D, 0x6E, 0x55, 0xFD, 0xD6, 0x64, 0xF5, 0xF7, 0x96, 0x76, 0x6B,
  0x69, 0x8C, 0x42, 0x60, 0x76, 0x4E, 0x2D, 0x64, 0xB0, 0xFF, 0x49, 0x35,
  0xA0, 0x5B,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 6, 4, 0, -6 },
  { 12, 6, 6, 7, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 1, 2, 2, 1, -6 },
  { 22, 3, 7, 3, 0, -6 },
  { 25, 3, 7, 3, -1, -6 },
  { 28, 3, 4, 4, 1, -6 },
  { 30, 4, 4, 4, 0, -5 },
  { 32, 2, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 1, 1, 2, 0, -1 },
  { 35, 4, 6, 3, 0, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 3, 6, 4, 1, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 5, 6, 4, 0, -6 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 4, 6, 4, 0, -6 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 2, 5, 2, 0, -4 },
  { 72, 4, 4, 4, 0, -5 },
  { 74, 4, 2, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -5 },
  { 77, 4, 6, 3, 0, -6 },
  { 80, 6, 7, 6, 0, -6 },
  { 86, 4, 6, 5, 0, -6 },
  { 89, 5, 6, 5, 0, -6 },
  { 93, 5, 6, 4, 0, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 4, 6, 4, 0, -6 },
  { 104, 4, 6, 4, 0, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 4, 6, 3, 0, -6 },
  { 118, 4, 8, 3, -1, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 3, 6, 4, 0, -6 },
  { 129, 7, 6, 7, 0, -6 },
  { 135, 6, 6, 6, 0, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 7, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 4, 6, 4, 1, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 4, 6, 4, 1, -6 },
  { 170, 6, 6, 7, 1, -6 },
  { 175, 5, 6, 5, 0, -6 },
  { 179, 4, 6, 4, 1, -6 },
  { 182, 4, 6, 4, 0, -6 },
  { 185, 3, 7, 3, 0, -6 },
  { 188, 2, 6, 3, 1, -6 },
  { 190, 4, 7, 3, -1, -6 },
  { 194, 4, 4, 4, 0, -6 },
  { 196, 4, 1, 3, -1, 0 },
  { 197, 2, 1, 3, 1, -6 },
  { 198, 4, 4, 4, 0, -4 },
  { 200, 4, 6, 4, 0, -6 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 5, 6, 4, 0, -6 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 5, 8, 3, -1, -6 },
  { 216, 4, 6, 4, 0, -4 },
  { 219, 4, 6, 4, 0, -6 },
  { 222, 3, 6, 2, 0, -6 },
  { 225, 4, 8, 2, -1, -6 },
  { 229, 5, 6, 4, 0, -6 },
  { 233, 3, 6, 2, 0, -6 },
  { 236, 6, 4, 7, 0, -4 },
  { 239, 4, 4, 4, 0, -4 },
  { 241, 4, 4, 4, 0, -4 },
  { 243, 4, 6, 4, 0, -4 },
  { 246, 4, 6, 4, 0, -4 },
  { 249, 4, 4, 3, 0, -4 },
  { 251, 4, 4, 4, 0, -4 },
  { 253, 3, 5, 3, 0, -5 },
  { 255, 4, 4, 4, 0, -4 },
  { 257, 4, 4, 4, 0, -4 },
  { 259, 6, 4, 6, 0, -4 },
  { 262, 4, 4, 4, 0, -4 },
  { 264, 5, 6, 4, -1, -4 },
  { 268, 4, 4, 3, 0, -4 },
  { 270, 3, 7, 3, 0, -6 },
  { 273, 1, 8, 4, 1, -6 },
  { 274, 3, 7, 3, 0, -6 },
  { 277, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC8PT7B_H_
