#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xE3, 0xFC, 0xFF, 0x8F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF1, 0xFF, 0x3F,
  0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x87,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE1,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xF9, 0xC7, 0xC0, 0x7F, 0x9E, 0x0C,
  0x03, 0xFC, 0xF0, 0x00, 0x3F, 0xE7, 0x80, 0x01, 0xFF, 0x38, 0x00, 0x0F,
  0xFD, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1E, 0xFF, 0x80, 0x00, 0xF7, 0xFC, 0x00, 0x07,
  0x1F, 0xE2, 0x00, 0x38, 0xFF, 0x0C, 0x03, 0xCF, 0xF8, 0x78, 0x1E, 0x7F,
  0xC7, 0xFC, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xF3, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x1F,
  0x80, 0x00, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7, 0xF9, 0xFC, 0x7F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xFE, 0x7F, 0xFF, 0xCF, 0xE7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x7E, 0x3F, 0xFF, 0xCF, 0xFF,
  0x1F, 0xCF, 0xF3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xF0, 0xFC,
  0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0x83,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F, 0xF7,
  0xFE, 0x7F, 0xC7, 0xFE, 0x7F, 0xEF, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0x8F,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x04, 0x07,
  0xF0, 0x03, 0x81, 0xFC, 0x00, 0xF8, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x1F,
  0xFF, 0xE0, 0x37, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xC3, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0x80, 0x3F,
  0xE7, 0xF0, 0x0F, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x80, 0x1E, 0x0F, 0xE0,
  0x03, 0x03, 0xFC, 0x00, 0x40, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0x1F, 0x87, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFC, 0x7F,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03,
  0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x7F,
  0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x1F, 0xFB, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xE0,
  0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF9, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0x7F, 0x87, 0xFD, 0xFF, 0x0F, 0xF3, 0xFE, 0x0F, 0x87, 0xFC, 0x0E, 0x1F,
  0xF0, 0x18, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xFE,
  0x00, 0xF8, 0x0F, 0xFC, 0x00, 0xE0, 0x0F, 0xF8, 0x00, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0x87, 0xFF, 0x00, 0xF0, 0x1F,
  0xF8, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x10, 0x00, 0x1F, 0xF8,
  0xC0, 0x01, 0xFF, 0xC7, 0xC0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF7, 0xFC, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0xC0, 0x03,
  0xF8, 0xFF, 0x80, 0x0F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x1C, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x10, 0x00, 0x3F, 0xF0,
  0xC0, 0x03, 0xFF, 0x87, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x0C, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xEF, 0xFF, 0x01, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF,
  0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF9, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80,
  0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x3F,
  0xFC, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xE7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3,
  0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03,
  0xFE, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F,
  0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0xBF, 0xF9, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0x81, 0xFF, 0xDF, 0xF0, 0x0F, 0xE3, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x10, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xC7, 0xFE, 0x1E, 0x03, 0xFF, 0x08, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x07, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xFF, 0xF8, 0xFE, 0x1F, 0x80, 0xFF,
  0xFF, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF, 0xC1, 0xF8, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0x3F, 0x83, 0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xE0, 0xFD,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xBF, 0x87, 0xF0, 0x3F, 0x03, 0xF7, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFE, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xBF, 0x87, 0xF0,
  0x3F, 0x03, 0xF7, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0x81, 0xFC,
  0x1F, 0xDF, 0x87, 0xF0, 0x3F, 0x83, 0xF3, 0xF0, 0xFE, 0x07, 0xE0, 0xFE,
  0x7E, 0x1F, 0xC1, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0x7F, 0x87, 0xF1, 0xF8,
  0x3F, 0x9F, 0xF9, 0xFC, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xC0, 0xFF, 0x8F,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8,
  0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x78, 0x0F, 0xFE, 0x00, 0x10, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x1E, 0x07, 0xFF, 0x80, 0x02, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0x9F, 0xF8, 0x1F,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0x07,
  0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xC0,
  0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xE0,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0x7F, 0x01,
  0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFC, 0x07,
  0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x1F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF0, 0x3F,
  0xBF, 0xE0, 0x3F, 0xEF, 0xE0, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xC1, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0x87, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x0F, 0xE7,
  0xFC, 0x03, 0xFC, 0xFE, 0x3F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFC, 0x7F, 0x1F,
  0xE0, 0x1F, 0xE3, 0xF9, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF3, 0xF8, 0xFF,
  0x80, 0x7F, 0x8F, 0xEF, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xDF, 0xC3, 0xFC,
  0x03, 0xFE, 0x3F, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x81, 0xFE, 0x01,
  0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x07,
  0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFB,
  0xFC, 0x07, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xF8, 0x07, 0xFB, 0xFE, 0x0F,
  0xF8, 0x07, 0xF9, 0xFE, 0x0F, 0xF8, 0x07, 0xF9, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF9, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x9F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x9F, 0xE0, 0x1F, 0xF0, 0x7F, 0x9F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x9F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF,
  0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x01, 0xE0, 0x0F, 0xF8, 0x01, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x04, 0x00, 0x1F,
  0xF8, 0x18, 0x00, 0x7F, 0xE0, 0x78, 0x03, 0xFF, 0x01, 0xFE, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x80,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x80, 0x7F, 0x81,
  0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xC0, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF7, 0xF0,
  0xFF, 0x80, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xE7, 0xF1,
  0xFF, 0x00, 0xFF, 0x1F, 0xE7, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xE7, 0xF1,
  0xFE, 0x00, 0xFF, 0x1F, 0xC7, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xC7, 0xF3,
  0xFC, 0x00, 0xFF, 0x3F, 0x87, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x87, 0xF7,
  0xFC, 0x00, 0xFF, 0x7F, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF,
  0xC7, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x03,
  0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xFC,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE, 0x1F,
  0xC0, 0x7F, 0xF9, 0xFE, 0x07, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8,
  0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x07, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0,
  0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFE, 0xFF, 0x00, 0x7F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC3, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0x3F, 0xFE, 0x01, 0xFC, 0x7F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x0C, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x60, 0xFF, 0xE0, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x7F,
  0xCF, 0xF8, 0x01, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xEF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0xFE, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC,
  0x0F, 0xFC, 0xFF, 0x9F, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x20, 0xFF, 0xC0, 0x0C, 0x0F, 0xFE, 0x1F, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE1, 0xFC, 0x01, 0xFF,
  0xE7, 0xF8, 0x07, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xBF, 0xE0, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x08, 0x00, 0x3F,
  0xE0, 0x1C, 0x00, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xE0, 0x01, 0xFE,
  0x3F, 0xE0, 0x07, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xE1, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x3F,
  0xFC, 0x3F, 0xFC, 0x07, 0xFB, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xBF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0x00, 0xFF, 0x7F,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83,
  0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7,
  0xFF, 0x1F, 0xF8, 0x7F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF,
  0xBF, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x0F,
  0xE7, 0xFF, 0x00, 0x0F, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xBF, 0xFE, 0x00, 0x3F, 0xCF, 0xFE, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x7F, 0xF9, 0xFE, 0x07,
  0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0x81, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0xFF, 0xC0,
  0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFE, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF,
  0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0,
  0x3F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xE1, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x04, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF1, 0x00, 0x0F, 0xF8, 0xE0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x04, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xBF, 0xC0, 0x3F, 0xFE, 0xFF, 0x00, 0xFF, 0xF3, 0xF8, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xC7,
  0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0x81,
  0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC0,
  0x7F, 0x87, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xBF, 0xE0,
  0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFB, 0xFE,
  0x07, 0xFF, 0x03, 0xFE, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x3F, 0xE0, 0xFF,
  0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xFF, 0x0F,
  0xF8, 0x7F, 0x87, 0xFF, 0xC3, 0xFE, 0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0x07,
  0xF8, 0xFF, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0x7F, 0x1F, 0xE0, 0x7F, 0x9F,
  0xDF, 0xCF, 0xF8, 0x1F, 0xE7, 0xF7, 0xF3, 0xFC, 0x07, 0xFB, 0xF9, 0xFC,
  0xFF, 0x01, 0xFE, 0xFE, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0x1F, 0xDF, 0xE0,
  0x1F, 0xDF, 0xC7, 0xEF, 0xF8, 0x07, 0xF7, 0xF1, 0xFB, 0xFC, 0x01, 0xFD,
  0xF8, 0x7E, 0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x5F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0x20, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 18, 42, 16, 0, -41 },
  { 96, 22, 15, 25, 5, -41 },
  { 138, 34, 41, 34, 1, -41 },
  { 313, 29, 46, 30, 1, -43 },
  { 480, 43, 42, 48, 3, -41 },
  { 706, 36, 42, 38, 1, -41 },
  { 895, 11, 15, 14, 5, -41 },
  { 916, 21, 50, 19, 2, -41 },
  { 1048, 21, 51, 19, -4, -42 },
  { 1182, 26, 27, 29, 4, -44 },
  { 1270, 26, 28, 31, 3, -34 },
  { 1361, 14, 15, 16, -3, -7 },
  { 1388, 16, 8, 18, 1, -19 },
  { 1404, 11, 10, 16, 0, -9 },
  { 1418, 31, 41, 24, -3, -41 },
  { 1577, 27, 42, 30, 2, -41 },
  { 1719, 23, 41, 30, 5, -41 },
  { 1837, 31, 41, 30, -2, -41 },
  { 1996, 29, 42, 30, 0, -41 },
  { 2149, 31, 41, 30, -1, -41 },
  { 2308, 29, 42, 30, 1, -41 },
  { 2461, 29, 42, 30, 2, -41 },
  { 2614, 30, 41, 30, 2, -41 },
  { 2768, 29, 42, 30, 1, -41 },
  { 2921, 27, 42, 30, 2, -41 },
  { 3063, 16, 33, 16, 0, -32 },
  { 3129, 19, 40, 16, -3, -32 },
  { 3224, 26, 29, 31, 3, -35 },
  { 3319, 26, 18, 31, 3, -29 },
  { 3378, 26, 29, 31, 3, -35 },
  { 3473, 24, 42, 24, 3, -41 },
  { 3599, 43, 46, 46, 2, -41 },
  { 3847, 33, 41, 34, -3, -41 },
  { 4017, 32, 41, 33, 1, -41 },
  { 4181, 32, 42, 32, 3, -41 },
  { 4349, 33, 41, 36, 1, -41 },
  { 4519, 30, 41, 28, 1, -41 },
  { 4673, 30, 41, 28, 1, -41 },
  { 4827, 33, 42, 36, 3, -41 },
  { 5001, 37, 41, 37, 1, -41 },
  { 5191, 27, 41, 22, -2, -41 },
  { 5330, 28, 53, 18, -9, -41 },
  { 5516, 37, 41, 33, 1, -41 },
  { 5706, 23, 41, 27, 1, -41 },
  { 5824, 47, 41, 47, 1, -41 },
  { 6065, 40, 41, 40, 1, -41 },
  { 6270, 34, 42, 38, 3, -41 },
  { 6449, 32, 41, 32, 1, -41 },
  { 6613, 34, 51, 38, 3, -41 },
  { 6830, 31, 41, 33, 1, -41 },
  { 6989, 30, 42, 28, 0, -41 },
  { 7147, 28, 41, 28, 4, -41 },
  { 7291, 34, 42, 36, 3, -41 },
  { 7470, 32, 41, 32, 5, -41 },
  { 7634, 48, 41, 48, 5, -41 },
  { 7880, 40, 41, 33, -3, -41 },
  { 8085, 31, 41, 31, 5, -41 },
  { 8244, 33, 41, 28, -2, -41 },
  { 8414, 24, 50, 18, -2, -41 },
  { 8564, 14, 41, 24, 6, -41 },
  { 8636, 24, 50, 18, -4, -41 },
  { 8786, 28, 26, 29, 0, -41 },
  { 8877, 24, 6, 23, -5, 4 },
  { 8895, 12, 9, 19, 8, -44 },
  { 8909, 29, 33, 32, 2, -32 },
  { 9029, 30, 44, 32, 0, -43 },
  { 9194, 25, 33, 26, 2, -32 },
  { 9298, 32, 44, 32, 2, -43 },
  { 9474, 27, 33, 30, 2, -32 },
  { 9586, 32, 58, 20, -6, -44 },
  { 9818, 31, 46, 32, 0, -32 },
  { 9997, 30, 43, 32, 0, -43 },
  { 10159, 18, 44, 16, 0, -44 },
  { 10258, 25, 58, 16, -7, -44 },
  { 10440, 34, 43, 31, 0, -43 },
  { 10623, 19, 43, 16, 0, -43 },
  { 10726, 45, 32, 48, 0, -32 },
  { 10906, 30, 32, 32, 0, -32 },
  { 11026, 27, 33, 31, 2, -32 },
  { 11138, 33, 46, 32, -3, -32 },
  { 11328, 29, 46, 32, 2, -32 },
  { 11495, 25, 32, 23, 0, -32 },
  { 11595, 25, 33, 25, 0, -32 },
  { 11699, 21, 39, 22, 2, -38 },
  { 11802, 30, 32, 32, 2, -31 },
  { 11922, 28, 31, 28, 3, -31 },
  { 12031, 42, 31, 42, 3, -31 },
  { 12194, 35, 31, 29, -3, -31 },
  { 12330, 35, 45, 28, -4, -31 },
  { 12527, 28, 31, 25, -2, -31 },
  { 12636, 24, 50, 20, 0, -41 },
  { 12786, 7, 56, 28, 10, -43 },
  { 12835, 23, 50, 20, -3, -41 },
  { 12979, 26, 10, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC57PT7B_H_
