#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1,
  0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x04, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE7,
  0x8F, 0xC0, 0x1F, 0xF8, 0xF0, 0x30, 0x03, 0xFF, 0x3E, 0x02, 0x00, 0xFF,
  0xC7, 0xC0, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x03, 0xFF, 0x9E, 0x00, 0x00,
  0x3F, 0xF3, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3D, 0xFF,
  0xC0, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x01, 0xF3, 0xFF, 0x00, 0x00, 0x3C,
  0x7F, 0xE0, 0x80, 0x07, 0x8F, 0xFC, 0x1C, 0x00, 0xF1, 0xFF, 0x83, 0xF0,
  0x1E, 0x7F, 0xF0, 0x7F, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x9F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE1, 0xFF,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0xFF, 0x8F,
  0xF0, 0x7F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xFE, 0x3F, 0xC7, 0xFC,
  0x7F, 0x8F, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE7, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF,
  0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x9F, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFF, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x07,
  0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF, 0xC7,
  0xFE, 0x1F, 0xFE, 0x3F, 0xFD, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xF1,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x06, 0x01, 0xFE, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x3F, 0x07, 0xF8,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xFF, 0x87,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x10, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0x80, 0x0F, 0xFC, 0xFF, 0x00, 0x3F,
  0xF9, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x3F,
  0x07, 0xFC, 0x00, 0x1C, 0x0F, 0xFC, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF3, 0xFF, 0x1F, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F,
  0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFD,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF,
  0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F,
  0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF,
  0x3F, 0xF8, 0x3F, 0xC7, 0xFE, 0x03, 0xF0, 0xFF, 0xC0, 0x78, 0x3F, 0xF8,
  0x06, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xFE, 0x00, 0x3E, 0x00,
  0xFF, 0xF0, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x7F,
  0xFC, 0x00, 0xE0, 0x07, 0xFF, 0x80, 0x08, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x04, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE1, 0x00,
  0x00, 0x1F, 0xFC, 0x30, 0x00, 0x07, 0xFF, 0x87, 0x80, 0x03, 0xFF, 0xF0,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x80, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0x00, 0x00, 0x7F, 0xF8, 0x30,
  0x00, 0x1F, 0xFF, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xF0, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xFF, 0x80,
  0x7F, 0xEF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0xFF,
  0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE1,
  0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xCF,
  0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xF1,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0x7F,
  0xE0, 0x0F, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0x0E, 0x00, 0x7F, 0xF0,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x01, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFE, 0x1F,
  0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x0F, 0xF3, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0xFE, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x0F, 0xE7, 0xF8,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE7,
  0xF0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x1F,
  0xC7, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xCF, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0x80,
  0x3F, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0xF8, 0x00, 0x10, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x1E, 0x00, 0x7F, 0xFE, 0x00, 0x02, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFF,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xF8, 0x03, 0xFF,
  0x7F, 0x80, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xF0,
  0x03, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0xFF,
  0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0x87, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0x8F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC,
  0x7F, 0x9F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0x9F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xBF, 0xE1,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x01,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xBF,
  0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0x00,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x7F,
  0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0xE3, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xE0, 0x07,
  0xFF, 0x80, 0x3C, 0x00, 0xFF, 0xE0, 0x01, 0x80, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x04, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x00, 0x7F,
  0xF0, 0x1E, 0x00, 0x1F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF7, 0xF8, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xF9,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xC3, 0xFE, 0x7F, 0x87, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFF,
  0x00, 0x3F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x0F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x87, 0xF9, 0xFF, 0xC0, 0x07, 0xFE,
  0x7F, 0xC3, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC1, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x3F, 0xE0, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x7F,
  0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x3F, 0xDF, 0xF8, 0x00, 0x3F, 0xEF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0,
  0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x02, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xF7, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F,
  0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xF1, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0,
  0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xDF, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0xFC, 0x01, 0xFE, 0x1F, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x81, 0xFF,
  0xF0, 0x02, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x40, 0x7F, 0xF0, 0x07, 0x01, 0xFF, 0xF0,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xFB,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x03, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF0, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x40, 0x7F, 0xF8, 0x01, 0xC0,
  0x7F, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xE3, 0xFE, 0x00, 0x7F,
  0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFB,
  0xFF, 0x00, 0x0F, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0x83, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE1,
  0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0xF1, 0xFF, 0xFE, 0x01, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0x8F, 0xFF,
  0x80, 0x0F, 0xF1, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xC0, 0x1F, 0xF7,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x07, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE3,
  0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF,
  0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F,
  0xFD, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x07,
  0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xFE, 0x00, 0x07, 0xFD,
  0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0xFC,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xF8,
  0xFF, 0x80, 0x7F, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xF7, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xDF,
  0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x78,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xFE,
  0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0x80, 0xFF, 0xE0,
  0x04, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x20, 0x00, 0x7F, 0xF0, 0xE0, 0x01, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x0C, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x40, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xF0, 0x0F,
  0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F,
  0xDF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xF7, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFD, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0xFE, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xBF, 0xC3, 0xFF, 0x03, 0xFF, 0x1F, 0xEF, 0xF1, 0xFF, 0x80, 0xFF,
  0xCF, 0xF3, 0xFC, 0x7F, 0xE0, 0x3F, 0xF3, 0xFC, 0xFF, 0x3F, 0xF0, 0x0F,
  0xFC, 0xFF, 0x3F, 0xCF, 0xFC, 0x03, 0xFF, 0x7F, 0x8F, 0xF3, 0xFE, 0x00,
  0xFF, 0xDF, 0xE3, 0xFD, 0xFF, 0x80, 0x1F, 0xF7, 0xF0, 0xFF, 0x7F, 0xC0,
  0x07, 0xFF, 0xFC, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xBF, 0x83, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80,
  0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x1F, 0xFF, 0x00,
  0x03, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0xFF,
  0xF8, 0x80, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 22, 50, 19, 0, -49 },
  { 139, 27, 18, 30, 6, -49 },
  { 200, 41, 49, 40, 1, -49 },
  { 452, 35, 56, 35, 1, -52 },
  { 697, 51, 50, 57, 4, -49 },
  { 1016, 43, 50, 45, 1, -49 },
  { 1285, 13, 18, 17, 6, -49 },
  { 1315, 25, 60, 22, 2, -49 },
  { 1503, 25, 61, 22, -5, -50 },
  { 1694, 31, 32, 34, 5, -52 },
  { 1818, 32, 33, 37, 3, -41 },
  { 1950, 17, 17, 19, -4, -8 },
  { 1987, 19, 9, 21, 1, -23 },
  { 2009, 13, 12, 19, 0, -11 },
  { 2029, 37, 50, 29, -3, -49 },
  { 2261, 33, 50, 35, 2, -49 },
  { 2468, 27, 49, 36, 6, -49 },
  { 2634, 37, 49, 35, -2, -49 },
  { 2861, 35, 50, 35, 0, -49 },
  { 3080, 36, 49, 36, -1, -49 },
  { 3301, 35, 50, 35, 1, -49 },
  { 3520, 35, 50, 35, 2, -49 },
  { 3739, 37, 49, 35, 2, -49 },
  { 3966, 35, 50, 35, 1, -49 },
  { 4185, 33, 50, 35, 2, -49 },
  { 4392, 19, 39, 19, 0, -38 },
  { 4485, 23, 47, 19, -4, -38 },
  { 4621, 32, 35, 37, 3, -42 },
  { 4761, 32, 22, 37, 3, -35 },
  { 4849, 32, 35, 37, 3, -42 },
  { 4989, 28, 50, 29, 4, -49 },
  { 5164, 52, 55, 55, 2, -49 },
  { 5522, 40, 49, 40, -4, -49 },
  { 5767, 38, 49, 39, 1, -49 },
  { 6000, 38, 50, 38, 3, -49 },
  { 6238, 40, 49, 42, 1, -49 },
  { 6483, 36, 49, 34, 1, -49 },
  { 6704, 35, 49, 34, 1, -49 },
  { 6919, 41, 50, 43, 3, -49 },
  { 7176, 44, 49, 44, 1, -49 },
  { 7446, 32, 49, 26, -2, -49 },
  { 7642, 34, 64, 22, -11, -49 },
  { 7914, 45, 49, 40, 1, -49 },
  { 8190, 27, 49, 32, 1, -49 },
  { 8356, 56, 49, 56, 1, -49 },
  { 8699, 48, 49, 48, 1, -49 },
  { 8993, 41, 50, 45, 3, -49 },
  { 9250, 38, 49, 38, 1, -49 },
  { 9483, 41, 61, 45, 3, -49 },
  { 9796, 37, 49, 39, 1, -49 },
  { 10023, 35, 50, 34, 0, -49 },
  { 10242, 33, 49, 34, 5, -49 },
  { 10445, 40, 50, 43, 4, -49 },
  { 10695, 38, 49, 38, 6, -49 },
  { 10928, 57, 49, 57, 6, -49 },
  { 11278, 48, 49, 39, -4, -49 },
  { 11572, 36, 49, 36, 6, -49 },
  { 11793, 40, 49, 33, -3, -49 },
  { 12038, 29, 60, 22, -2, -49 },
  { 12256, 17, 50, 29, 7, -49 },
  { 12363, 29, 60, 22, -5, -49 },
  { 12581, 34, 32, 35, 0, -49 },
  { 12717, 28, 6, 27, -6, 5 },
  { 12738, 14, 11, 22, 10, -52 },
  { 12758, 35, 39, 38, 2, -38 },
  { 12929, 35, 53, 38, 0, -52 },
  { 13161, 30, 39, 31, 2, -38 },
  { 13308, 38, 53, 38, 2, -52 },
  { 13560, 32, 39, 35, 2, -38 },
  { 13716, 39, 68, 24, -7, -52 },
  { 14048, 37, 54, 38, 0, -38 },
  { 14298, 36, 52, 38, 0, -52 },
  { 14532, 22, 52, 19, 0, -52 },
  { 14675, 31, 68, 19, -9, -52 },
  { 14939, 40, 52, 37, 0, -52 },
  { 15199, 22, 52, 19, 0, -52 },
  { 15342, 54, 38, 57, 0, -38 },
  { 15599, 36, 38, 38, 0, -38 },
  { 15770, 33, 39, 37, 2, -38 },
  { 15931, 38, 54, 38, -3, -38 },
  { 16188, 35, 54, 38, 2, -38 },
  { 16425, 30, 38, 27, 0, -38 },
  { 16568, 30, 39, 30, 0, -38 },
  { 16715, 25, 46, 26, 3, -45 },
  { 16859, 35, 38, 38, 3, -37 },
  { 17026, 33, 37, 33, 4, -37 },
  { 17179, 50, 37, 51, 4, -37 },
  { 17411, 42, 37, 34, -4, -37 },
  { 17606, 42, 53, 34, -5, -37 },
  { 17885, 33, 37, 30, -2, -37 },
  { 18038, 29, 60, 24, 0, -49 },
  { 18256, 8, 67, 34, 13, -52 },
  { 18323, 28, 60, 24, -4, -49 },
  { 18533, 32, 12, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC68PT7B_H_
