#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0x0F, 0xFB, 0xFE, 0x1F, 0xE7,
  0xFC, 0x3F, 0xCF, 0xF8, 0x7F, 0x9F, 0xE1, 0xFF, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE7, 0x8F, 0x00, 0xFF, 0x8E, 0x06, 0x01, 0xFF,
  0x3C, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x0F, 0xF9,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xF7, 0xFE,
  0x00, 0x01, 0xE7, 0xFC, 0x00, 0x03, 0xCF, 0xF8, 0x80, 0x07, 0x1F, 0xF0,
  0xC0, 0x1E, 0x3F, 0xE1, 0xE0, 0x3C, 0xFF, 0x83, 0xF8, 0x7B, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE1, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC7, 0xF0,
  0x3E, 0x0F, 0xF0, 0xFE, 0x3F, 0xC7, 0xFE, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F,
  0xFC, 0x7F, 0x3F, 0xC7, 0xF1, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0,
  0x7F, 0x07, 0xF1, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x7F, 0x00,
  0x01, 0xFE, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xEF, 0xFC, 0x7F,
  0xC3, 0xFF, 0x9F, 0xFD, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xBF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0xBF, 0xE7, 0xFC,
  0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC,
  0x3F, 0x87, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x0C, 0x07, 0xF8, 0x01, 0xE0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xFB,
  0xF8, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF8, 0x7C, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0x7F, 0x00, 0x7F, 0xCF, 0xE0, 0x1F, 0xF9, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0x83, 0xFC, 0x00, 0xF0, 0x7F, 0xC0, 0x0C, 0x0F, 0xE0, 0x00,
  0x80, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFE, 0x00, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x03, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0xFF,
  0xC0, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00,
  0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80,
  0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3, 0xFE, 0x01, 0xFF,
  0x9F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xF7, 0xFC, 0x7F, 0xEF, 0xFC, 0x3F, 0xCF,
  0xFC, 0x3F, 0x0F, 0xF8, 0x1E, 0x0F, 0xF8, 0x0C, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0x80, 0x3F, 0x81, 0xFF, 0xC0, 0x0F, 0x00,
  0x7F, 0xE0, 0x03, 0x00, 0x3F, 0xF0, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0xE0, 0x0F, 0xFC, 0x01, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE3, 0x00, 0x01, 0xFF, 0xC7, 0x80, 0x0F,
  0xFF, 0x0F, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xE3, 0xFF, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC2, 0x00, 0x07, 0xFF, 0x07, 0x80, 0x1F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x04, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x3C, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC,
  0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xC7, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x0F,
  0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE,
  0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x00,
  0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x03, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFE, 0xFF,
  0xE0, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xEF, 0xF8, 0x0F, 0xFE, 0x7F, 0xC0, 0x1F, 0xC7, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x0F, 0x8F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0x81, 0xFF, 0x87, 0x00, 0x7F, 0xC2, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0x81,
  0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0x87, 0xF0, 0xFE, 0x03, 0xFF, 0xFE, 0x1F,
  0xC7, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0x1F, 0xC0, 0xFF, 0xFF, 0xE1, 0xFC,
  0x7F, 0x07, 0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFD, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF7, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xDF, 0xC3,
  0xF8, 0x0F, 0xE0, 0x7E, 0x7E, 0x0F, 0xE0, 0x3F, 0x81, 0xFB, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xEF, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0xBF, 0x87, 0xF0,
  0x1F, 0xC1, 0xFC, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFF,
  0xCF, 0xF0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFB, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xC7, 0xFF,
  0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0x80, 0x0F, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFD, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0xFF, 0xF0, 0x00, 0x40, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x0C, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFE,
  0x03, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x38, 0x07, 0xFF, 0x80, 0x01, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xF8,
  0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x40, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x01,
  0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x7F,
  0xC0, 0x1F, 0xEF, 0xE0, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFC, 0x03, 0xFB,
  0xFE, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xF0, 0x1F,
  0xCF, 0xF8, 0x03, 0xFE, 0xFE, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0x9F, 0xC0,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xF8, 0x3F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F,
  0x87, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFE, 0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xCF, 0xF1, 0xFF, 0x00, 0x7F,
  0xC7, 0xF9, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x3F, 0x87, 0xFC, 0x01,
  0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFD, 0xFC, 0x3F, 0xE0,
  0x07, 0xF8, 0x7F, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0x80, 0x3F, 0xE1, 0xFF, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF8, 0x03, 0xFD, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF7, 0xFC,
  0x01, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0x80, 0x78, 0x03, 0xFF, 0x00, 0x10, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x40, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0xFF, 0xC0, 0x7E,
  0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xDF, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFB, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xBF, 0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF9, 0xFE, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xE3, 0xFC,
  0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x3F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF, 0xC3,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0xC7,
  0xF8, 0x0F, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFF,
  0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xDF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xDF,
  0xE0, 0x1F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFC, 0x7F, 0x80, 0x1F, 0xF0, 0xFE,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0x80, 0x7F, 0x9F, 0xFF,
  0x00, 0x7F, 0x9F, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0x03, 0xFF, 0x80, 0x20, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x08, 0x1F, 0xFC, 0x07, 0x01, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x0F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFD, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0x80, 0x03,
  0xFE, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xCF, 0xFC, 0x03, 0xFE,
  0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF9, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x18, 0x1F, 0xF8, 0x03, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xDF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0x1F, 0xE0,
  0x0F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xC0, 0x07,
  0xFF, 0x7F, 0xE0, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x02,
  0x00, 0x07, 0xFE, 0x01, 0x80, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x8F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x7F, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0C,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF,
  0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x9F, 0xFF, 0x0F, 0xFF, 0x80,
  0x3F, 0xDF, 0xFF, 0x8F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xF8, 0x01, 0xFE, 0x7F, 0xFC, 0x01, 0xFE,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x00,
  0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00,
  0xFF, 0xDF, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x07, 0xFE,
  0x1F, 0xF8, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xFC, 0x00, 0x1F,
  0xEF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xFC,
  0x00, 0x7F, 0xDF, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x60, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xCF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFC,
  0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x01,
  0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xC0,
  0x1F, 0xFD, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x06, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xEF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF0, 0xF8, 0x0F, 0xFC, 0x03, 0x01, 0xFF, 0x80, 0x20, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x80, 0x03,
  0xFE, 0x1C, 0x00, 0xFF, 0xC3, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x01, 0xA0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xBF,
  0xC0, 0x7F, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0x7F, 0x80, 0x1F, 0xFC, 0x7F,
  0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x7F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xCF, 0xFC,
  0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xBF, 0xE0, 0x3F, 0xF8, 0x0F, 0xF9, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xCF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x7F, 0xFC, 0x1F, 0xF0, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFB,
  0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xDF, 0xC7, 0xFC, 0x0F, 0xF0, 0xFE, 0xFE,
  0x3F, 0xE0, 0x7F, 0x8F, 0xE7, 0xF3, 0xFE, 0x03, 0xFC, 0x7F, 0x3F, 0x9F,
  0xF0, 0x1F, 0xE7, 0xF9, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0x8F, 0xEF, 0xF8,
  0x07, 0xF9, 0xFC, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xC7, 0xF3, 0xFC, 0x01,
  0xFE, 0xFE, 0x3F, 0xBF, 0xE0, 0x0F, 0xF7, 0xF1, 0xFD, 0xFE, 0x00, 0x7F,
  0xFF, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x3F, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x18, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x13, 0xFF, 0xC0, 0x01, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE8,
  0x00, 0x3F, 0xFC, 0x80, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 19, 45, 17, 0, -44 },
  { 108, 23, 16, 27, 6, -44 },
  { 154, 36, 44, 36, 1, -44 },
  { 352, 31, 50, 32, 1, -46 },
  { 546, 46, 45, 51, 3, -44 },
  { 805, 39, 45, 40, 1, -44 },
  { 1025, 11, 16, 15, 6, -44 },
  { 1047, 22, 54, 20, 2, -44 },
  { 1196, 22, 55, 20, -4, -45 },
  { 1348, 27, 29, 31, 5, -47 },
  { 1446, 28, 29, 33, 3, -36 },
  { 1548, 15, 16, 17, -3, -8 },
  { 1578, 17, 9, 19, 1, -21 },
  { 1598, 11, 11, 17, 0, -10 },
  { 1614, 33, 44, 26, -3, -44 },
  { 1796, 29, 45, 32, 2, -44 },
  { 1960, 24, 44, 32, 5, -44 },
  { 2092, 33, 44, 32, -2, -44 },
  { 2274, 31, 45, 32, 0, -44 },
  { 2449, 33, 44, 32, -1, -44 },
  { 2631, 31, 45, 32, 1, -44 },
  { 2806, 31, 45, 32, 2, -44 },
  { 2981, 33, 44, 32, 2, -44 },
  { 3163, 31, 45, 32, 1, -44 },
  { 3338, 29, 45, 32, 2, -44 },
  { 3502, 17, 35, 17, 0, -34 },
  { 3577, 20, 42, 17, -3, -34 },
  { 3682, 28, 32, 33, 3, -38 },
  { 3794, 28, 19, 33, 3, -31 },
  { 3861, 28, 32, 33, 3, -38 },
  { 3973, 25, 45, 26, 3, -44 },
  { 4114, 46, 49, 49, 2, -44 },
  { 4396, 37, 44, 36, -4, -44 },
  { 4600, 34, 44, 35, 1, -44 },
  { 4787, 34, 45, 34, 3, -44 },
  { 4979, 36, 44, 38, 1, -44 },
  { 5177, 32, 44, 30, 1, -44 },
  { 5353, 32, 44, 30, 1, -44 },
  { 5529, 36, 45, 39, 3, -44 },
  { 5732, 40, 44, 40, 1, -44 },
  { 5952, 29, 44, 23, -2, -44 },
  { 6112, 31, 57, 19, -10, -44 },
  { 6333, 40, 44, 36, 1, -44 },
  { 6553, 24, 44, 29, 1, -44 },
  { 6685, 51, 44, 51, 1, -44 },
  { 6966, 43, 44, 43, 1, -44 },
  { 7203, 37, 45, 41, 3, -44 },
  { 7412, 34, 44, 34, 1, -44 },
  { 7599, 37, 54, 41, 3, -44 },
  { 7849, 33, 44, 35, 1, -44 },
  { 8031, 32, 45, 30, 0, -44 },
  { 8211, 29, 44, 30, 5, -44 },
  { 8371, 37, 45, 39, 3, -44 },
  { 8580, 34, 44, 34, 5, -44 },
  { 8767, 52, 44, 51, 5, -44 },
  { 9053, 44, 44, 35, -4, -44 },
  { 9295, 33, 44, 33, 5, -44 },
  { 9477, 36, 44, 30, -2, -44 },
  { 9675, 26, 54, 20, -2, -44 },
  { 9851, 15, 44, 26, 6, -44 },
  { 9934, 26, 54, 20, -4, -44 },
  { 10110, 30, 28, 31, 0, -44 },
  { 10215, 26, 5, 24, -6, 5 },
  { 10232, 13, 10, 20, 9, -47 },
  { 10249, 31, 35, 34, 2, -34 },
  { 10385, 32, 47, 34, 0, -46 },
  { 10573, 27, 35, 28, 2, -34 },
  { 10692, 34, 47, 34, 2, -46 },
  { 10892, 29, 35, 32, 2, -34 },
  { 11019, 35, 62, 22, -7, -47 },
  { 11291, 33, 49, 34, 0, -34 },
  { 11494, 32, 46, 34, 0, -46 },
  { 11678, 19, 47, 17, 0, -47 },
  { 11790, 28, 62, 17, -8, -47 },
  { 12007, 36, 46, 33, 0, -46 },
  { 12214, 20, 46, 17, 0, -46 },
  { 12329, 49, 34, 51, 0, -34 },
  { 12538, 32, 34, 34, 0, -34 },
  { 12674, 29, 35, 33, 2, -34 },
  { 12801, 35, 49, 34, -3, -34 },
  { 13016, 31, 49, 34, 2, -34 },
  { 13206, 27, 34, 24, 0, -34 },
  { 13321, 27, 35, 27, 0, -34 },
  { 13440, 22, 41, 24, 3, -40 },
  { 13553, 32, 34, 34, 2, -33 },
  { 13689, 30, 33, 30, 3, -33 },
  { 13813, 45, 33, 45, 4, -33 },
  { 13999, 37, 33, 31, -3, -33 },
  { 14152, 37, 48, 30, -4, -33 },
  { 14374, 30, 33, 27, -2, -33 },
  { 14498, 26, 54, 21, 0, -44 },
  { 14674, 8, 60, 30, 11, -46 },
  { 14734, 24, 54, 21, -3, -44 },
  { 14896, 28, 11, 33, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC61PT7B_H_
