#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x7E, 0x7E, 0xFC, 0xF9, 0xF1,
  0xF3, 0xE7, 0xEF, 0xCF, 0xDF, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1,
  0xE3, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF0, 0x00,
  0xF0, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC7, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x0F, 0x8F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x1F,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xB9,
  0xC1, 0xFB, 0x84, 0x1F, 0x30, 0x01, 0xFB, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x0D, 0xF8, 0x00, 0xCF, 0x88, 0x0C, 0xF8, 0xE1, 0xDF, 0x8F,
  0xDF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x07, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0,
  0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03,
  0xC0, 0x3E, 0xF8, 0x1F, 0x01, 0xF1, 0xE0, 0xF8, 0x07, 0xC7, 0x83, 0xC0,
  0x1E, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0xF8, 0x03, 0xE3, 0xE3, 0xC0, 0x0F,
  0x8F, 0x9F, 0x00, 0x3E, 0x7C, 0xF8, 0xF8, 0xF9, 0xF3, 0xCF, 0xF3, 0xFF,
  0x9F, 0x7F, 0xE7, 0xFE, 0xFB, 0xFF, 0x9F, 0xF7, 0xCF, 0x9E, 0x3F, 0x1F,
  0x7C, 0x7C, 0x00, 0xF9, 0xF1, 0xF0, 0x07, 0xC7, 0xC7, 0x80, 0x1F, 0x1E,
  0x1E, 0x00, 0xF8, 0x78, 0xF8, 0x07, 0xC3, 0xE3, 0xE0, 0x1F, 0x0F, 0x8F,
  0x80, 0xF8, 0x3E, 0x7C, 0x07, 0xC0, 0x7F, 0xF0, 0x1F, 0x01, 0xFF, 0x80,
  0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x41, 0xFF, 0x87, 0xE0, 0xFF, 0xE1, 0xF8, 0x7F, 0xF8, 0xFC, 0x3F,
  0xFF, 0x3F, 0x1F, 0xCF, 0xFF, 0x87, 0xE3, 0xFF, 0xE1, 0xF8, 0x7F, 0xF0,
  0xFE, 0x0F, 0xFC, 0x3F, 0x83, 0xFE, 0x07, 0xE0, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE3, 0xF8, 0x7E, 0xFD, 0xF3, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xE0, 0x00,
  0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x3E, 0x08, 0x1E, 0x07, 0x1F, 0x03, 0xEF, 0x81, 0xFF, 0x87, 0xFF, 0xFF,
  0x7F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE1, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0xC1, 0xF9, 0xF0, 0x78, 0xF8, 0x0C, 0x7E, 0x04, 0x18, 0x00, 0x10, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x00, 0x7F, 0xF7, 0xFE, 0x7F,
  0xE7, 0xFE, 0xFF, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xE7, 0xE0, 0xFD,
  0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0x83, 0xFF,
  0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xCF,
  0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x9F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFC, 0x7E,
  0xFC, 0x3C, 0xFC, 0x38, 0xFC, 0x11, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x0E, 0x0F, 0xE0, 0x20, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x38, 0x7F, 0x02, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC8, 0x01, 0xFC,
  0xC0, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0,
  0xF9, 0xF8, 0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF8,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0x87, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x40, 0x0F, 0xE3, 0x81,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x7F, 0x03, 0xEF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF1, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFC,
  0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F,
  0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFE, 0xFE, 0x3F, 0x8F, 0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF9, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xBF, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xF3, 0xFC,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F,
  0xCF, 0xE1, 0xF9, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xE0, 0xFD, 0xF8, 0x3F,
  0xBF, 0x07, 0xF7, 0xF1, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x1F, 0xEF, 0xC1, 0xF9, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xF8, 0x00,
  0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x38, 0x3F, 0x20, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x1F, 0x07,
  0xFE, 0x7C, 0x78, 0x7F, 0xF9, 0xF3, 0xE3, 0xFF, 0xC7, 0xCF, 0x0F, 0x8F,
  0x1F, 0x7C, 0x7C, 0x7C, 0x7D, 0xE1, 0xE1, 0xF1, 0xF7, 0x8F, 0x87, 0x87,
  0x9E, 0x3C, 0x1E, 0x1E, 0x78, 0xF0, 0xF8, 0x7B, 0xE3, 0xC3, 0xE3, 0xEF,
  0x9F, 0x0F, 0x0F, 0x3E, 0x3C, 0x7C, 0x7C, 0xF8, 0xFF, 0xFF, 0xE3, 0xE3,
  0xFF, 0xFF, 0x07, 0x87, 0xF7, 0xF8, 0x1F, 0x0F, 0x07, 0x80, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x07, 0xFC, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C,
  0x00, 0x7E, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7F, 0x7F, 0x00,
  0xFE, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC3,
  0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0,
  0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xC3, 0xC1, 0xFE, 0x02, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x30, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xF7, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x1F,
  0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x3F,
  0x07, 0xF8, 0x3F, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0x07, 0xF8, 0x02, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE1,
  0xFF, 0x9F, 0xC3, 0xFF, 0x3F, 0x87, 0xFE, 0x7F, 0x0F, 0xFC, 0xFC, 0x3F,
  0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFC, 0x3F, 0xC1, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xFC,
  0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x9F,
  0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xBE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC3, 0xEF, 0xC0, 0xFB, 0xE1, 0xF7, 0xC0, 0x7D, 0xF1, 0xF7, 0xE0,
  0x7E, 0xF8, 0xFB, 0xF0, 0x3F, 0x7C, 0xF9, 0xF8, 0x1F, 0xBE, 0x7C, 0xF8,
  0x0F, 0x9F, 0x7C, 0xFC, 0x0F, 0xCF, 0xBE, 0x7E, 0x07, 0xE7, 0xFE, 0x3F,
  0x03, 0xF3, 0xFF, 0x1F, 0x81, 0xF9, 0xFF, 0x0F, 0x80, 0xF8, 0xFF, 0x8F,
  0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x3E,
  0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x7F,
  0xE0, 0x7E, 0x07, 0xFF, 0x07, 0xC0, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0x0F,
  0xC0, 0xF9, 0xF8, 0xFC, 0x0F, 0x9F, 0x8F, 0x80, 0xF9, 0xF9, 0xF8, 0x1F,
  0x8F, 0x9F, 0x81, 0xF8, 0xFD, 0xF8, 0x1F, 0x8F, 0xDF, 0x81, 0xF0, 0xFD,
  0xF0, 0x3F, 0x07, 0xDF, 0x03, 0xF0, 0x7F, 0xF0, 0x3F, 0x07, 0xFF, 0x03,
  0xF0, 0x7F, 0xF0, 0x3E, 0x03, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7E, 0x03,
  0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xCF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0xC7, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x8F, 0xF0,
  0x7E, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xCF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7E, 0x7E, 0x03, 0xF9, 0xF8, 0x0F,
  0xE7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0x1E, 0x0F, 0xC0, 0x40, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x84, 0x03, 0xF8, 0x70, 0x7F, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E,
  0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x0F, 0xDF, 0x80,
  0xFE, 0x07, 0xEF, 0xC0, 0xFF, 0x07, 0xF7, 0xE0, 0x7F, 0x83, 0xF3, 0xF0,
  0x7F, 0xC1, 0xF9, 0xF8, 0x3F, 0xE1, 0xF8, 0xFC, 0x1F, 0xE0, 0xFC, 0x7E,
  0x1F, 0xF0, 0xFC, 0x3F, 0x0F, 0xF8, 0x7E, 0x1F, 0x8F, 0xBC, 0x3F, 0x0F,
  0xC7, 0xDE, 0x3F, 0x07, 0xE7, 0xEF, 0x1F, 0x83, 0xF3, 0xE7, 0x9F, 0x81,
  0xF9, 0xF3, 0xCF, 0xC0, 0xFD, 0xF1, 0xE7, 0xE0, 0x7E, 0xF8, 0xF7, 0xE0,
  0x3F, 0xFC, 0x7B, 0xF0, 0x1F, 0xFC, 0x3D, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0x81,
  0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07,
  0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x3E, 0x0F, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x7C, 0xF0, 0x1F, 0x1E, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x7C, 0x03,
  0xFF, 0x00, 0x3C, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0,
  0xFC, 0xFE, 0x7E, 0x3E, 0x3E, 0x1F, 0x00, 0xE0, 0x00, 0x3F, 0x9F, 0x07,
  0xFD, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x3F,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xDF, 0x01, 0xF9,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0x80,
  0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F,
  0x0F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03,
  0xF3, 0xF0, 0x3F, 0x3F, 0x07, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0,
  0xFE, 0x7F, 0x1F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7D,
  0xFF, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xF1, 0xFF, 0xF0, 0xFE, 0x38, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x0C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0xE3, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F,
  0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F,
  0xC3, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xDF, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFE, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x02, 0x0F, 0xE3, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x20,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x10, 0x03, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xE7,
  0xC0, 0xFF, 0xBE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xF3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF8, 0x7F, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x04, 0x03, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE7, 0x80, 0x7C, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0x7F, 0x0F, 0xE3, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xCF, 0xC1, 0xF8, 0x01, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x02, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF7, 0xF0, 0x0F,
  0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0xFE,
  0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x0F, 0xBF, 0xC7, 0xF8, 0x3E, 0xFF, 0x9F, 0xF0, 0x7D, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0xFF, 0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0xFC, 0x7E,
  0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x7F, 0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x1F, 0xC7, 0xE1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x43,
  0x80, 0x79, 0xFE, 0x0F, 0xBF, 0xF0, 0xFB, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x7F, 0x0F, 0xE3, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x9F, 0xCF, 0xE1, 0xF9, 0xF8, 0x3F,
  0x7F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xF0, 0xFE, 0xFE, 0x3F, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xDF, 0xC0, 0x3E, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xE7, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x7F, 0xC0, 0xFC, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x9F, 0x07, 0xFD, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE,
  0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x83, 0xE7, 0xC3, 0xF7,
  0xE1, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xE4, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x30, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x80, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x00, 0x3F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFB, 0xE0, 0x3F, 0x3E, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB,
  0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xC1, 0xF8, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3,
  0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0xFC, 0x07,
  0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC1,
  0xFF, 0xE1, 0xFE, 0x1F, 0xBF, 0x0F, 0xF0, 0xFD, 0xF8, 0x7F, 0x8F, 0xCF,
  0xC7, 0xFC, 0x7E, 0x7E, 0x3F, 0xE3, 0xE3, 0xF3, 0xFF, 0x3F, 0x1F, 0x9F,
  0xF9, 0xF8, 0x7C, 0xF7, 0xDF, 0x83, 0xEF, 0xBE, 0xFC, 0x1F, 0x7D, 0xF7,
  0xC0, 0xFB, 0xCF, 0x7E, 0x07, 0xFE, 0x7B, 0xE0, 0x3F, 0xE3, 0xDF, 0x01,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF1, 0xFC, 0x03, 0xF1, 0xFC, 0x03,
  0xF3, 0xF8, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F,
  0xDF, 0x80, 0x1F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE1, 0xF8, 0x03,
  0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x03,
  0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0,
  0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xE0, 0x3F, 0xE8, 0x00, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 28, 11, 0, -28 },
  { 43, 15, 10, 17, 4, -28 },
  { 62, 24, 28, 23, 0, -28 },
  { 146, 20, 32, 20, 1, -30 },
  { 226, 30, 28, 33, 2, -28 },
  { 331, 26, 28, 26, 0, -28 },
  { 422, 7, 10, 10, 4, -28 },
  { 431, 15, 34, 13, 1, -28 },
  { 495, 15, 34, 13, -3, -28 },
  { 559, 17, 19, 20, 3, -30 },
  { 600, 18, 19, 21, 2, -23 },
  { 643, 10, 10, 11, -2, -5 },
  { 656, 12, 5, 12, 0, -13 },
  { 664, 7, 6, 11, 0, -6 },
  { 670, 21, 28, 16, -2, -28 },
  { 744, 19, 28, 20, 1, -28 },
  { 811, 16, 28, 20, 3, -28 },
  { 867, 21, 28, 20, -1, -28 },
  { 941, 20, 28, 20, 0, -28 },
  { 1011, 20, 28, 20, 0, -28 },
  { 1081, 21, 28, 20, 0, -28 },
  { 1155, 20, 28, 20, 1, -28 },
  { 1225, 21, 28, 20, 1, -28 },
  { 1299, 19, 28, 20, 1, -28 },
  { 1366, 19, 28, 20, 1, -28 },
  { 1433, 11, 22, 11, 0, -22 },
  { 1464, 13, 27, 11, -2, -22 },
  { 1508, 18, 20, 21, 2, -24 },
  { 1553, 18, 13, 21, 2, -20 },
  { 1583, 18, 20, 21, 2, -24 },
  { 1628, 16, 28, 17, 2, -28 },
  { 1684, 30, 31, 31, 1, -28 },
  { 1801, 23, 28, 23, -2, -28 },
  { 1882, 22, 28, 23, 0, -28 },
  { 1959, 22, 28, 22, 2, -28 },
  { 2036, 24, 28, 24, 0, -28 },
  { 2120, 21, 28, 19, 0, -28 },
  { 2194, 21, 28, 19, 0, -28 },
  { 2268, 23, 28, 25, 2, -28 },
  { 2349, 26, 28, 25, 0, -28 },
  { 2440, 18, 28, 15, -1, -28 },
  { 2503, 19, 37, 12, -6, -28 },
  { 2591, 26, 28, 23, 0, -28 },
  { 2682, 16, 28, 19, 0, -28 },
  { 2738, 33, 28, 32, 0, -28 },
  { 2854, 28, 28, 27, 0, -28 },
  { 2952, 23, 28, 26, 2, -28 },
  { 3033, 22, 28, 22, 0, -28 },
  { 3110, 23, 35, 26, 2, -28 },
  { 3211, 22, 28, 23, 0, -28 },
  { 3288, 20, 28, 19, 0, -28 },
  { 3358, 19, 28, 19, 3, -28 },
  { 3425, 24, 28, 25, 2, -28 },
  { 3509, 22, 28, 22, 3, -28 },
  { 3586, 33, 28, 33, 3, -28 },
  { 3702, 27, 28, 22, -2, -28 },
  { 3797, 21, 28, 21, 3, -28 },
  { 3871, 22, 28, 19, -1, -28 },
  { 3948, 16, 34, 13, -1, -28 },
  { 4016, 10, 28, 16, 4, -28 },
  { 4051, 17, 34, 13, -3, -28 },
  { 4124, 19, 18, 20, 0, -28 },
  { 4167, 17, 4, 15, -4, 3 },
  { 4176, 8, 6, 13, 6, -30 },
  { 4182, 20, 22, 22, 1, -22 },
  { 4237, 20, 30, 22, 0, -30 },
  { 4312, 17, 22, 18, 1, -22 },
  { 4359, 22, 30, 22, 1, -30 },
  { 4442, 19, 22, 20, 1, -22 },
  { 4495, 22, 39, 14, -4, -30 },
  { 4603, 21, 31, 22, 0, -22 },
  { 4685, 20, 30, 22, 0, -30 },
  { 4760, 12, 30, 11, 0, -30 },
  { 4805, 17, 39, 11, -5, -30 },
  { 4888, 23, 30, 21, 0, -30 },
  { 4975, 13, 30, 11, 0, -30 },
  { 5024, 31, 22, 33, 0, -22 },
  { 5110, 20, 22, 22, 0, -22 },
  { 5165, 19, 22, 21, 1, -22 },
  { 5218, 22, 31, 22, -2, -22 },
  { 5304, 20, 31, 22, 1, -22 },
  { 5382, 17, 22, 15, 0, -22 },
  { 5429, 17, 22, 17, 0, -22 },
  { 5476, 14, 26, 15, 2, -26 },
  { 5522, 20, 21, 22, 2, -21 },
  { 5575, 19, 21, 19, 2, -21 },
  { 5625, 29, 21, 29, 2, -21 },
  { 5702, 24, 21, 20, -2, -21 },
  { 5765, 24, 30, 19, -3, -21 },
  { 5855, 19, 21, 17, -1, -21 },
  { 5905, 16, 34, 14, 0, -28 },
  { 5973, 5, 39, 19, 7, -30 },
  { 5998, 16, 34, 14, -2, -28 },
  { 6066, 18, 7, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC39PT7B_H_
