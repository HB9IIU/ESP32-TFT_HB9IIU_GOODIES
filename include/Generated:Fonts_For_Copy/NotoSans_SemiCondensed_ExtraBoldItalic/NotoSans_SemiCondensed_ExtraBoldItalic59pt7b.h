#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC7, 0xFD, 0xFF,
  0x1F, 0xF7, 0xFC, 0x7F, 0xDF, 0xE1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F,
  0xE7, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF,
  0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xC1,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0xF1, 0xF0, 0x1F, 0xF3, 0xC1, 0x80, 0x7F,
  0x8F, 0x00, 0x01, 0xFE, 0x38, 0x00, 0x07, 0xF9, 0xE0, 0x00, 0x1F, 0xF7,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1C, 0xFF, 0x80, 0x00,
  0xF3, 0xFE, 0x00, 0x03, 0xCF, 0xF8, 0x40, 0x0F, 0x3F, 0xE1, 0xC0, 0x38,
  0xFF, 0x87, 0xE0, 0xE7, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x1F, 0xC1, 0xF8, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0xF1, 0xFE, 0x7F, 0x9F, 0xE7, 0xFF, 0xCF, 0xF7,
  0xF8, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0xFC, 0x7F,
  0x1F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF9, 0xFE, 0x1F, 0xC0, 0xF0, 0x3F, 0x8F,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF,
  0x80, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0x3F, 0xF7, 0xFE, 0x1F, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xFC,
  0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x08, 0x07, 0xF0, 0x03, 0x81, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x9F, 0x80, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xC1, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xEF, 0xF0, 0x1F, 0xF1,
  0xFC, 0x01, 0xF8, 0x7F, 0x80, 0x3E, 0x1F, 0xE0, 0x07, 0x03, 0xFC, 0x00,
  0x80, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0x03, 0xF8, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01,
  0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7,
  0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8,
  0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF,
  0xCF, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF,
  0xF8, 0x3F, 0x8F, 0xF8, 0x3F, 0x1F, 0xF0, 0x1C, 0x1F, 0xF0, 0x08, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x3C, 0x03, 0xFF,
  0x00, 0x38, 0x03, 0xFF, 0x00, 0x10, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xFC, 0x01, 0xC0, 0x3F, 0xF0, 0x04, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE2,
  0x00, 0x01, 0xFF, 0x8E, 0x00, 0x1F, 0xFE, 0x3F, 0x81, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xEF,
  0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0x9F,
  0xF0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x80, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x01, 0xFF, 0xC3, 0x80, 0x0F, 0xFE,
  0x0F, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x10, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x3E, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xF7,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x81, 0xFF,
  0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xE7, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x00, 0xFF,
  0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3,
  0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F,
  0xE1, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFE, 0x03,
  0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7,
  0xFE, 0x07, 0xFF, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x00, 0x60, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x0C, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xC3, 0xFF, 0x0E, 0x01, 0xFF, 0x08, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xFE, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0xFC,
  0x3F, 0x07, 0xF0, 0x3F, 0xFF, 0xE1, 0xF8, 0x7F, 0x03, 0xFF, 0xFF, 0x0F,
  0xC3, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0x3F, 0x83, 0xFE, 0x1F, 0x83, 0xF9,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0xFE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x3F, 0x07,
  0xF0, 0x3F, 0x81, 0xF9, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xDF, 0xC3, 0xF8,
  0x0F, 0xC0, 0xFE, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xE7, 0xF0, 0xFE, 0x07,
  0xF0, 0x7F, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF1, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x0F, 0xFF, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F,
  0xC0, 0xFF, 0x07, 0xFC, 0x00, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x3F, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF1, 0xFC,
  0x03, 0xFF, 0xC0, 0x1E, 0x03, 0xFF, 0xC0, 0x02, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x40, 0x1F, 0xFC, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0x08, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x87, 0xFE,
  0x07, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xC7,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x0F,
  0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF,
  0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xEF, 0xF8,
  0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x07, 0xF7, 0xFC,
  0x01, 0xFE, 0xFF, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0x83, 0xF9, 0xFF,
  0x00, 0xFF, 0x9F, 0xC3, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xE1, 0xFC, 0xFF,
  0x80, 0x3F, 0xC7, 0xF1, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3, 0xF8, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFC, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFE, 0x7F, 0x0F,
  0xF0, 0x07, 0xFC, 0x7F, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xBF, 0x87,
  0xFC, 0x01, 0xFE, 0x1F, 0xDF, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0xF0,
  0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xFE,
  0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x07,
  0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF0, 0x0F, 0xFB, 0xFE,
  0x0F, 0xF8, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0xFF, 0x83, 0xFE,
  0x01, 0xFE, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0xFF,
  0x8F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x9F, 0xE0, 0x1F, 0xF0, 0x7F, 0xCF, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE7, 0xF8, 0x07, 0xFC, 0x0F, 0xF7, 0xFC, 0x03, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xF0,
  0x03, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8,
  0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xE7, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF,
  0xCF, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0x01,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xE0, 0x0F, 0xFC, 0x00, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x40, 0x00, 0xFF, 0xC0, 0xE0,
  0x03, 0xFF, 0x01, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFB,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFB,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xBF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xDF, 0xE1, 0xFF, 0x00, 0xFF, 0x8F,
  0xF7, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xF9, 0xFE, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFE, 0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0x9F, 0xE7, 0xFC, 0x00, 0xFF,
  0xBF, 0xC7, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF1, 0xFE, 0xFF, 0x80, 0x0F,
  0xF3, 0xF8, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0x00,
  0xFF, 0x7F, 0x87, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xC1, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xC0, 0x0F, 0xFE,
  0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80,
  0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC3,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F,
  0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xFB, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0x3F, 0xC0, 0xFF,
  0xFC, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1,
  0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x7F,
  0xFF, 0x01, 0xFE, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFC, 0x06, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x20,
  0xFF, 0xC0, 0x30, 0x3F, 0xFC, 0x3C, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x03,
  0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0x9F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03,
  0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFC, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x02, 0x0F, 0xFE,
  0x00, 0xE0, 0x7F, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x8C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x40,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0x00, 0x7F,
  0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x80, 0x01, 0xFF, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x7F, 0xDF, 0xFE, 0x00, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x02, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x02, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xF1, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xC7, 0xFF, 0xE0,
  0x3F, 0xDF, 0xFF, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x87, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x83, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0xE0, 0x07, 0xF1,
  0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x87,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x1F,
  0xF3, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xEF,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC1,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x41,
  0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x03, 0xF9, 0xFF, 0xE0, 0x00, 0xFE,
  0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xFE, 0x00, 0x3F, 0xE7, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x87,
  0xF0, 0x0F, 0xFF, 0x3F, 0xC0, 0x7F, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF,
  0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xDF,
  0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x06, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF3, 0xFE, 0x03, 0xFD, 0xFF, 0x80, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0xC0, 0x7F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0x7C, 0x0F, 0xF8, 0x06, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xC0, 0x07, 0xFE, 0x3C,
  0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x60, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF7, 0xF8, 0x07,
  0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0,
  0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xFE, 0x3F, 0xC0, 0x3F,
  0xE1, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xFC,
  0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF9, 0xFF,
  0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00,
  0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF7, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x7F, 0x80,
  0xFF, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF,
  0xE0, 0x7F, 0xC7, 0xF8, 0x1F, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFF, 0xE0,
  0xFF, 0x87, 0xF8, 0x3F, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFF, 0xE1, 0xFF,
  0x07, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xEF, 0xE3, 0xFE, 0x07,
  0xF8, 0xFE, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xEF, 0xE3, 0xFC, 0x07, 0xF8,
  0xFC, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xCF, 0xE7, 0xF8, 0x07, 0xF9, 0xFC,
  0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0x8F, 0xEF, 0xF8, 0x07, 0xFB, 0xF8, 0xFC,
  0xFF, 0x00, 0x7F, 0xBF, 0x8F, 0xDF, 0xF0, 0x07, 0xFF, 0xF0, 0xFD, 0xFE,
  0x00, 0x7F, 0xFF, 0x0F, 0xDF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x27, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xD0, 0x00, 0x3F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 19, 43, 17, 0, -42 },
  { 104, 22, 15, 26, 6, -42 },
  { 146, 35, 42, 35, 1, -42 },
  { 330, 30, 48, 31, 1, -45 },
  { 510, 45, 44, 49, 3, -43 },
  { 758, 38, 44, 39, 1, -43 },
  { 967, 11, 15, 14, 6, -42 },
  { 988, 22, 52, 19, 2, -43 },
  { 1131, 22, 52, 19, -4, -43 },
  { 1274, 26, 28, 30, 5, -45 },
  { 1365, 27, 28, 32, 3, -35 },
  { 1460, 14, 15, 16, -3, -7 },
  { 1487, 17, 8, 19, 1, -20 },
  { 1504, 11, 11, 16, 0, -10 },
  { 1520, 32, 43, 25, -3, -43 },
  { 1692, 28, 44, 31, 2, -43 },
  { 1846, 24, 42, 31, 5, -42 },
  { 1972, 32, 43, 31, -2, -43 },
  { 2144, 30, 44, 31, 0, -43 },
  { 2309, 32, 42, 31, -1, -42 },
  { 2477, 30, 43, 31, 1, -42 },
  { 2639, 30, 44, 31, 2, -43 },
  { 2804, 32, 42, 31, 2, -42 },
  { 2972, 30, 44, 31, 1, -43 },
  { 3137, 28, 44, 31, 2, -43 },
  { 3291, 16, 34, 17, 0, -33 },
  { 3359, 19, 41, 17, -3, -33 },
  { 3457, 27, 31, 32, 3, -37 },
  { 3562, 27, 19, 32, 3, -30 },
  { 3627, 27, 31, 32, 3, -37 },
  { 3732, 24, 44, 25, 3, -43 },
  { 3864, 45, 47, 47, 2, -42 },
  { 4129, 35, 42, 35, -4, -42 },
  { 4313, 33, 42, 34, 1, -42 },
  { 4487, 33, 44, 33, 3, -43 },
  { 4669, 35, 42, 37, 1, -42 },
  { 4853, 31, 42, 29, 1, -42 },
  { 5016, 31, 42, 29, 1, -42 },
  { 5179, 35, 44, 38, 3, -43 },
  { 5372, 38, 42, 38, 1, -42 },
  { 5572, 28, 42, 22, -2, -42 },
  { 5719, 29, 55, 19, -9, -42 },
  { 5919, 39, 42, 34, 1, -42 },
  { 6124, 24, 42, 28, 1, -42 },
  { 6250, 49, 42, 49, 1, -42 },
  { 6508, 41, 42, 41, 1, -42 },
  { 6724, 35, 44, 39, 3, -43 },
  { 6917, 33, 42, 33, 1, -42 },
  { 7091, 35, 53, 39, 3, -43 },
  { 7323, 32, 42, 34, 1, -42 },
  { 7491, 31, 44, 29, 0, -43 },
  { 7662, 28, 42, 29, 5, -42 },
  { 7809, 36, 43, 37, 3, -42 },
  { 8003, 33, 42, 33, 5, -42 },
  { 8177, 50, 42, 50, 5, -42 },
  { 8440, 41, 42, 34, -3, -42 },
  { 8656, 32, 42, 32, 5, -42 },
  { 8824, 34, 42, 29, -2, -42 },
  { 9003, 25, 53, 19, -2, -43 },
  { 9169, 14, 43, 25, 6, -43 },
  { 9245, 25, 53, 19, -4, -43 },
  { 9411, 29, 27, 30, 0, -42 },
  { 9509, 24, 5, 23, -5, 5 },
  { 9524, 13, 9, 19, 8, -45 },
  { 9539, 30, 34, 33, 2, -33 },
  { 9667, 31, 46, 33, 0, -45 },
  { 9846, 26, 34, 27, 2, -33 },
  { 9957, 33, 46, 33, 2, -45 },
  { 10147, 28, 34, 31, 2, -33 },
  { 10266, 33, 59, 21, -6, -45 },
  { 10510, 32, 47, 33, 0, -33 },
  { 10698, 31, 45, 33, 0, -45 },
  { 10873, 19, 45, 17, 0, -45 },
  { 10980, 27, 59, 17, -8, -45 },
  { 11180, 35, 45, 32, 0, -45 },
  { 11377, 19, 45, 17, 0, -45 },
  { 11484, 47, 33, 49, 0, -33 },
  { 11678, 31, 33, 33, 0, -33 },
  { 11806, 28, 34, 32, 2, -33 },
  { 11925, 34, 47, 33, -3, -33 },
  { 12125, 30, 47, 33, 2, -33 },
  { 12302, 26, 33, 23, 0, -33 },
  { 12410, 26, 34, 26, 0, -33 },
  { 12521, 22, 40, 23, 2, -39 },
  { 12631, 31, 33, 33, 2, -32 },
  { 12759, 29, 32, 29, 3, -32 },
  { 12875, 44, 32, 44, 3, -32 },
  { 13051, 36, 32, 30, -3, -32 },
  { 13195, 36, 46, 29, -4, -32 },
  { 13402, 29, 32, 26, -2, -32 },
  { 13518, 25, 51, 21, 0, -42 },
  { 13678, 7, 58, 29, 11, -45 },
  { 13729, 24, 51, 21, -3, -42 },
  { 13882, 27, 10, 32, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC59PT7B_H_
