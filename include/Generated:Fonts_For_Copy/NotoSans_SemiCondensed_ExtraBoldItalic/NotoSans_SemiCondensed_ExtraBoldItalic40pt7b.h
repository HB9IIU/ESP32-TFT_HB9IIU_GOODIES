#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0,
  0x00, 0x7E, 0x7E, 0xFC, 0xFD, 0xF9, 0xFB, 0xE3, 0xE7, 0xC7, 0xDF, 0x8F,
  0xBE, 0x3F, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xE1,
  0xE0, 0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xC7,
  0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x0F, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x98, 0x41,
  0xFB, 0x80, 0x1F, 0xB8, 0x01, 0xFB, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0E, 0xFC, 0x00, 0xEF, 0xC8, 0x0C, 0xFC, 0xE0, 0xCF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x3F, 0xC0, 0x0F, 0x81, 0xFF, 0x80, 0x7C, 0x0F, 0xFE, 0x03, 0xE0,
  0x3E, 0xFC, 0x0F, 0x81, 0xF1, 0xF0, 0x7C, 0x07, 0xC7, 0xC3, 0xE0, 0x1F,
  0x1F, 0x0F, 0x80, 0x78, 0x7C, 0x7C, 0x03, 0xE3, 0xE3, 0xE0, 0x0F, 0x8F,
  0x8F, 0x00, 0x3E, 0x3E, 0x7C, 0x20, 0xF9, 0xF3, 0xE7, 0xF3, 0xE7, 0xCF,
  0x3F, 0xE7, 0xFE, 0x7D, 0xFF, 0xDF, 0xFB, 0xE7, 0xFF, 0x3F, 0xCF, 0x3E,
  0x7C, 0x7C, 0x7C, 0xF8, 0xF0, 0x03, 0xE3, 0xE7, 0xC0, 0x0F, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x7C, 0x03, 0xE1, 0xF1, 0xF0, 0x0F, 0x07, 0xC7, 0xC0,
  0x7C, 0x1F, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x0F, 0x01, 0xFF, 0xC0, 0x7C,
  0x07, 0xFF, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xF0, 0x7F, 0xE1, 0xFC, 0x3F,
  0xF8, 0x7E, 0x1F, 0xFF, 0x1F, 0x8F, 0xEF, 0xEF, 0xC7, 0xF3, 0xFF, 0xF1,
  0xF8, 0x7F, 0xF8, 0x7E, 0x1F, 0xFE, 0x3F, 0x83, 0xFF, 0x0F, 0xE0, 0x7F,
  0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFB, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0x7E, 0xFD, 0xFB,
  0xE7, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x20, 0xF0, 0x1E, 0x3C, 0x07, 0xEF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xDF, 0x1F, 0xF8,
  0x0F, 0xDE, 0x07, 0xF7, 0xC0, 0xF9, 0xF0, 0x1C, 0x7E, 0x03, 0x0F, 0x00,
  0x03, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0x7C, 0x3E, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x08, 0xFD, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE,
  0xFE, 0x1F, 0xC7, 0xE1, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC,
  0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFE, 0x7F, 0xFE, 0xFF, 0x7E, 0x7E, 0xFC, 0x3C, 0xFC, 0x10, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0x0F, 0xE0, 0x30, 0x3F, 0x01, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x04,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xE7, 0xFC, 0x0C, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF2,
  0x00, 0x7F, 0x1C, 0x07, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7D, 0xF8,
  0x07, 0xDF, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x3E, 0x3F, 0x03, 0xE3,
  0xF8, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE2, 0x00, 0x7F,
  0x1C, 0x0F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFE, 0x18, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0x00, 0x7E, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFB, 0xF8, 0x7F,
  0x0F, 0xE3, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC,
  0x7F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x87, 0xF3, 0xF8, 0x7E, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFF, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x9F, 0xCF, 0xE1, 0xF9,
  0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x87, 0xF7,
  0xF0, 0xFE, 0xFE, 0x3F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3,
  0xFD, 0xF8, 0x3F, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC4, 0x07, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1,
  0xF1, 0xFC, 0x40, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7E,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x83,
  0xFC, 0x3C, 0x3E, 0x1F, 0xFC, 0x78, 0xF8, 0x7F, 0xF8, 0xF9, 0xF1, 0xFD,
  0xF1, 0xF3, 0xC3, 0xE3, 0xE3, 0xEF, 0x8F, 0x87, 0x87, 0x9F, 0x1E, 0x0F,
  0x0F, 0x3C, 0x7C, 0x3E, 0x1E, 0x78, 0xF8, 0x7C, 0x7C, 0xF1, 0xE0, 0xF0,
  0xFB, 0xE3, 0xC3, 0xE1, 0xE7, 0xC7, 0x87, 0xC7, 0xCF, 0x8F, 0x9F, 0x9F,
  0x1F, 0x1F, 0xFF, 0xFC, 0x1E, 0x3F, 0xFF, 0xF8, 0x3C, 0x3F, 0x9F, 0xC0,
  0x7C, 0x1C, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x40, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0x80,
  0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x3F, 0x87, 0xF0, 0x7F, 0x3F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0x7E,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC1,
  0xFE, 0x1F, 0x87, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFE, 0x03, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x08, 0x1F, 0xE1,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x07, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x10, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0,
  0x08, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F,
  0xFC, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFF, 0x03,
  0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x01,
  0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE7, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFB, 0xF0, 0x3F, 0xF8, 0x3E, 0xF8, 0x0F, 0xFE, 0x1F, 0x7E,
  0x03, 0xFF, 0x87, 0xDF, 0x80, 0xF9, 0xE3, 0xF7, 0xE0, 0x7E, 0x78, 0xF9,
  0xF8, 0x1F, 0x9E, 0x3E, 0xFC, 0x07, 0xE7, 0x9F, 0x3F, 0x01, 0xF9, 0xF7,
  0xCF, 0xC0, 0xFC, 0x7F, 0xE3, 0xF0, 0x3F, 0x1F, 0xF8, 0xFC, 0x0F, 0xC7,
  0xFC, 0x7E, 0x03, 0xF1, 0xFF, 0x1F, 0x80, 0xF8, 0x7F, 0x87, 0xE0, 0x7E,
  0x1F, 0xE1, 0xF8, 0x1F, 0x87, 0xF0, 0x7C, 0x07, 0xE1, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xFC, 0x01,
  0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x07, 0xE0,
  0x3F, 0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xFF,
  0xE0, 0xFC, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x3F, 0x03, 0xF7, 0xE1,
  0xF8, 0x1F, 0xBF, 0x0F, 0x80, 0xFD, 0xF8, 0xFC, 0x07, 0xEF, 0xC7, 0xE0,
  0x3E, 0x3F, 0x3F, 0x03, 0xF1, 0xF9, 0xF8, 0x1F, 0x8F, 0xCF, 0x80, 0xFC,
  0x7E, 0xFC, 0x07, 0xE1, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x7F,
  0xF8, 0x1F, 0x83, 0xFF, 0x80, 0xFC, 0x0F, 0xFC, 0x07, 0xE0, 0x7F, 0xE0,
  0x7E, 0x03, 0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0xFC,
  0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC3, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xF9, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F,
  0x1F, 0x80, 0xFE, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0x81,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC1, 0x00, 0xFE, 0x0F, 0x0F, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0,
  0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F,
  0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0x01, 0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0x3F,
  0xBF, 0x03, 0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0x07, 0xF3, 0xF0, 0x3F, 0xC1,
  0xF8, 0xFC, 0x1F, 0xF0, 0x7E, 0x1F, 0x07, 0xFC, 0x3F, 0x07, 0xC3, 0xFF,
  0x0F, 0xC1, 0xF0, 0xFF, 0xC7, 0xF0, 0x7C, 0x7F, 0xF1, 0xF8, 0x1F, 0x1F,
  0x7C, 0x7E, 0x07, 0xC7, 0xDF, 0x3F, 0x01, 0xF3, 0xE7, 0xCF, 0xC0, 0x7C,
  0xF9, 0xF3, 0xF0, 0x1F, 0x7E, 0x7D, 0xF8, 0x07, 0xDF, 0x1F, 0x7E, 0x01,
  0xF7, 0xC7, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x00,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE,
  0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F,
  0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x10, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x78, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E,
  0x7E, 0x03, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0xFE, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F,
  0x01, 0xF8, 0xF8, 0x3F, 0xEF, 0xC3, 0xFF, 0x7C, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xE7, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x7F, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x07,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFD, 0xF8, 0x0F, 0xCF, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x3F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x3F,
  0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE1,
  0xFC, 0x7F, 0x8F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xDF, 0xF0, 0x7C, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xF0, 0x43, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x0C, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xFB, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF9, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0x7C, 0x03, 0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFC, 0xFE, 0x7F, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x7F, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x01, 0x0F, 0xF3, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFB, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFC, 0x7C, 0x0F, 0xFB, 0xF0, 0x7F, 0xEF, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x7F, 0x07,
  0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x82, 0x00, 0xFC,
  0x0F, 0x9F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x7F,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xE0,
  0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFF, 0x07, 0xE1, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x3F, 0x80,
  0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xCF, 0xE0, 0xFC, 0x07,
  0xDF, 0xF3, 0xFE, 0x0F, 0xFF, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x1F,
  0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0x7E, 0x3F, 0x83, 0xF0, 0x7E, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0x07, 0xE0, 0xFE, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x7F,
  0x07, 0xE0, 0xFC, 0x7E, 0x0F, 0xE1, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x07,
  0xCF, 0xE0, 0x3E, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83,
  0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x0F, 0xCF,
  0xE1, 0xF9, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF7, 0xF0, 0xFE, 0x7E,
  0x3F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x03, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE1, 0xFC,
  0x1F, 0xE3, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFB, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0xF8, 0x3F, 0xEF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xE7, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8,
  0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xCF,
  0xC1, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xCF, 0x07,
  0xE0, 0x41, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0xC0, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83,
  0xFC, 0x00, 0x1F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x07, 0xF3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1,
  0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFD, 0xF0, 0x7F, 0x9F, 0x03, 0xF1, 0xF0, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xC7, 0xC1, 0xF8,
  0x7C, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0xFE,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x07, 0xEF,
  0xC1, 0xFC, 0x1F, 0xBF, 0x0F, 0xF0, 0xFC, 0xFC, 0x3F, 0xC3, 0xF3, 0xF1,
  0xFF, 0x1F, 0x87, 0xC7, 0xFC, 0x7E, 0x1F, 0x1E, 0xF1, 0xF8, 0x7C, 0xFB,
  0xCF, 0xC1, 0xF3, 0xFF, 0x3F, 0x07, 0xDF, 0x7D, 0xF8, 0x1F, 0x7D, 0xF7,
  0xE0, 0x7D, 0xE7, 0xDF, 0x01, 0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0,
  0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x03, 0xF1, 0xFC,
  0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0, 0x1F, 0x8F, 0xE0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3,
  0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x5F, 0xF0,
  0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 29, 11, 0, -29 },
  { 49, 15, 11, 18, 4, -29 },
  { 70, 24, 29, 24, 0, -29 },
  { 157, 20, 32, 21, 1, -30 },
  { 237, 30, 29, 33, 2, -29 },
  { 346, 26, 29, 26, 0, -29 },
  { 441, 7, 11, 10, 4, -29 },
  { 451, 15, 35, 13, 1, -29 },
  { 517, 15, 35, 13, -3, -29 },
  { 583, 18, 19, 20, 3, -31 },
  { 626, 18, 20, 22, 2, -24 },
  { 671, 10, 10, 11, -2, -5 },
  { 684, 11, 5, 13, 1, -13 },
  { 691, 7, 7, 11, 0, -7 },
  { 698, 22, 29, 17, -2, -29 },
  { 778, 20, 29, 21, 1, -29 },
  { 851, 16, 29, 21, 3, -29 },
  { 909, 21, 29, 21, -1, -29 },
  { 986, 21, 29, 21, 0, -29 },
  { 1063, 21, 29, 21, 0, -29 },
  { 1140, 21, 29, 21, 0, -29 },
  { 1217, 21, 29, 21, 1, -29 },
  { 1294, 22, 29, 21, 1, -29 },
  { 1374, 20, 29, 21, 1, -29 },
  { 1447, 19, 29, 21, 1, -29 },
  { 1516, 11, 22, 11, 0, -22 },
  { 1547, 13, 27, 11, -2, -22 },
  { 1591, 18, 21, 22, 2, -25 },
  { 1639, 18, 13, 22, 2, -21 },
  { 1669, 18, 21, 22, 2, -25 },
  { 1717, 17, 29, 17, 2, -29 },
  { 1779, 31, 32, 32, 1, -29 },
  { 1903, 23, 29, 24, -2, -29 },
  { 1987, 23, 29, 23, 0, -29 },
  { 2071, 22, 29, 22, 2, -29 },
  { 2151, 24, 29, 25, 0, -29 },
  { 2238, 21, 29, 20, 0, -29 },
  { 2315, 21, 29, 20, 0, -29 },
  { 2392, 24, 29, 25, 2, -29 },
  { 2479, 27, 29, 26, 0, -29 },
  { 2577, 19, 29, 15, -1, -29 },
  { 2646, 19, 38, 13, -6, -29 },
  { 2737, 27, 29, 23, 0, -29 },
  { 2835, 17, 29, 19, 0, -29 },
  { 2897, 34, 29, 33, 0, -29 },
  { 3021, 29, 29, 28, 0, -29 },
  { 3127, 24, 29, 27, 2, -29 },
  { 3214, 23, 29, 23, 0, -29 },
  { 3298, 24, 36, 27, 2, -29 },
  { 3406, 22, 29, 23, 0, -29 },
  { 3486, 21, 29, 20, 0, -29 },
  { 3563, 20, 29, 20, 3, -29 },
  { 3636, 24, 29, 25, 2, -29 },
  { 3723, 23, 29, 22, 3, -29 },
  { 3807, 34, 29, 34, 3, -29 },
  { 3931, 28, 29, 23, -2, -29 },
  { 4033, 21, 29, 21, 4, -29 },
  { 4110, 24, 29, 20, -2, -29 },
  { 4197, 17, 36, 13, -1, -29 },
  { 4274, 10, 29, 17, 4, -29 },
  { 4311, 17, 36, 13, -3, -29 },
  { 4388, 20, 19, 20, 0, -29 },
  { 4436, 17, 4, 16, -4, 3 },
  { 4445, 8, 7, 13, 6, -31 },
  { 4452, 21, 22, 22, 1, -22 },
  { 4510, 21, 30, 22, 0, -30 },
  { 4589, 18, 22, 18, 1, -22 },
  { 4639, 23, 30, 22, 1, -30 },
  { 4726, 19, 22, 21, 1, -22 },
  { 4779, 23, 41, 14, -4, -31 },
  { 4897, 22, 32, 22, 0, -22 },
  { 4985, 21, 30, 22, 0, -30 },
  { 5064, 13, 31, 11, 0, -31 },
  { 5115, 18, 41, 11, -5, -31 },
  { 5208, 24, 30, 22, 0, -30 },
  { 5298, 13, 30, 11, 0, -30 },
  { 5347, 32, 22, 33, 0, -22 },
  { 5435, 21, 22, 22, 0, -22 },
  { 5493, 19, 22, 22, 1, -22 },
  { 5546, 23, 32, 22, -2, -22 },
  { 5638, 21, 32, 22, 1, -22 },
  { 5722, 18, 22, 16, 0, -22 },
  { 5772, 18, 22, 18, 0, -22 },
  { 5822, 14, 27, 16, 2, -27 },
  { 5870, 20, 22, 22, 2, -22 },
  { 5925, 20, 22, 20, 2, -22 },
  { 5980, 30, 22, 30, 2, -22 },
  { 6063, 24, 22, 20, -2, -22 },
  { 6129, 25, 32, 20, -3, -22 },
  { 6229, 19, 22, 17, -1, -22 },
  { 6282, 17, 35, 14, 0, -29 },
  { 6357, 5, 39, 20, 7, -30 },
  { 6382, 16, 35, 14, -2, -29 },
  { 6452, 18, 7, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC40PT7B_H_
