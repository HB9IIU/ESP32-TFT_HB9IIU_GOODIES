#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x20, 0x78, 0x7C, 0x3E, 0x1E, 0x00,
  0x7B, 0xFC, 0xFF, 0x3F, 0xCE, 0xF3, 0xB8, 0xEE, 0x78, 0x01, 0xC7, 0x00,
  0xE7, 0x80, 0x73, 0x80, 0x71, 0xC0, 0x39, 0xE1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xCF, 0x27, 0xFF,
  0xE7, 0xFF, 0xF0, 0x73, 0xC0, 0x39, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E,
  0x70, 0x0F, 0x38, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0x87, 0xFF, 0x3F,
  0xF8, 0xFE, 0xE3, 0xD8, 0x0F, 0x60, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xF0, 0x1B, 0xC0, 0x6F, 0x21, 0xBC, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFC, 0x1F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x1F, 0x01, 0xC1,
  0xF8, 0x1C, 0x1F, 0xE1, 0xE1, 0xE7, 0x0E, 0x0F, 0x38, 0xE0, 0x73, 0xCF,
  0x03, 0x9E, 0x70, 0x1C, 0xE7, 0x00, 0xE7, 0x7B, 0xE7, 0xFB, 0xBF, 0xBF,
  0xB9, 0xFE, 0xFB, 0xDE, 0xF0, 0x1C, 0xE7, 0x81, 0xCF, 0x3C, 0x1E, 0x79,
  0xC0, 0xE3, 0xCE, 0x0E, 0x1E, 0xF0, 0xF0, 0xFF, 0x07, 0x03, 0xF8, 0x70,
  0x0F, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3E, 0x78, 0x0F,
  0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0xF1, 0xFE, 0x7C, 0xFF, 0x9E, 0x7D, 0xFF, 0x9E, 0x3F, 0xCF, 0x8F, 0xF3,
  0xE1, 0xF8, 0xFD, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0x7E, 0x7F,
  0xBD, 0xEF, 0x73, 0x80, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03,
  0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x07, 0x83, 0xE0, 0x03, 0x80, 0x1C, 0x10, 0xE0, 0xEE, 0x07, 0xF7,
  0xFF, 0xFC, 0x3F, 0xE3, 0xF3, 0x3F, 0x83, 0xDE, 0x0E, 0x70, 0x23, 0xC0,
  0x10, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3D, 0xF7, 0x9E, 0xF3, 0xCE, 0x00, 0x7F, 0x7F, 0xFF, 0x23, 0xFF,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x7F, 0xF3, 0xE7,
  0xBE, 0x3D, 0xF1, 0xEF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7B, 0xC7, 0xDE, 0x3C, 0xFF, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E,
  0x00, 0x01, 0xF0, 0x3E, 0x0F, 0xE1, 0xFE, 0x3F, 0xEF, 0xFC, 0x7B, 0xC2,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF0, 0x61, 0xE0, 0x83, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xF0, 0x7F,
  0xF1, 0xFF, 0xC3, 0xFF, 0x08, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x0F,
  0xF0, 0x3F, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0xA0,
  0x3E, 0xF7, 0xF3, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xBC, 0x0E,
  0xF8, 0x3D, 0xF0, 0xF3, 0xC3, 0xC7, 0x87, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFC, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x3E, 0x40, 0x7C, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xF2, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0xF8, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0xBE, 0x3E, 0xF8, 0xFB, 0xC3,
  0xEF, 0x0F, 0x3E, 0x7C, 0xFB, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xF9, 0xF1, 0xE3, 0xE3, 0xC7,
  0x87, 0xCF, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC7,
  0xCF, 0x8F, 0x0F, 0x1E, 0x1E, 0x7C, 0x3C, 0x78, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0x7D, 0xF7, 0xC7, 0xBC,
  0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xFB, 0xEF, 0xDF, 0xFE, 0xFF, 0xF3, 0xEF,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0xDF, 0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x00,
  0x04, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x78, 0xF8, 0xF8, 0xF0, 0x01, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0x08, 0x03, 0xC0, 0x7E, 0x0F, 0xF1,
  0xFE, 0x3F, 0x83, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x07, 0xF8, 0xFF, 0x3F,
  0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x3F, 0x9F, 0xF9, 0xFF, 0xBD, 0xF4,
  0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x1F, 0x87, 0xE0, 0xF0, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x01, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x1E,
  0x1F, 0x1C, 0xE3, 0xFC, 0xEE, 0x3F, 0xE7, 0x73, 0xCF, 0x3B, 0x9C, 0x71,
  0xF8, 0xE3, 0x8F, 0xCF, 0x1C, 0xFE, 0x71, 0xE7, 0x73, 0x8E, 0x7B, 0x9F,
  0xFF, 0x9C, 0x7D, 0xF8, 0xF3, 0xC7, 0x83, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x3C, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07,
  0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x3E, 0x0F, 0x9E, 0x07, 0xDF, 0x03,
  0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xFC, 0x3E, 0x7C, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7F,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0x04, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x10, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF1, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xC1,
  0xE3, 0xC1, 0xF1, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xE0, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0x21, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x7F, 0xBE, 0x3F, 0x9F, 0x1F, 0xCF,
  0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0xF8, 0x78, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x0F,
  0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xC1, 0xF0,
  0x78, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0xC1,
  0xE0, 0xF8, 0x7C, 0x1E, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x03, 0xFE, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xE1,
  0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0x8F, 0x80, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xDF, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0x7C,
  0x7C, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0xF7, 0xFE,
  0x7F, 0xEF, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xE3, 0xFC,
  0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xBC, 0x1F, 0xE7, 0xFC, 0x3D, 0xE7, 0x78,
  0x3D, 0xEF, 0x78, 0x3D, 0xEE, 0x78, 0x3D, 0xFE, 0x78, 0x7D, 0xFC, 0xF8,
  0x78, 0xFC, 0xF0, 0x78, 0xF8, 0xF0, 0x78, 0xF8, 0xF0, 0x78, 0xF0, 0xF0,
  0xF8, 0xF1, 0xF0, 0x0F, 0xC0, 0xF0, 0xFC, 0x0F, 0x0F, 0xC1, 0xF0, 0xFE,
  0x1E, 0x0F, 0xE1, 0xE1, 0xFE, 0x1E, 0x1F, 0xE1, 0xE1, 0xEF, 0x3E, 0x1E,
  0xF3, 0xC1, 0xEF, 0x3C, 0x3C, 0xF3, 0xC3, 0xC7, 0xBC, 0x3C, 0x7B, 0x83,
  0xC7, 0xF8, 0x7C, 0x7F, 0x87, 0x83, 0xF8, 0x78, 0x3F, 0x87, 0x83, 0xF0,
  0x78, 0x3F, 0x0F, 0x81, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0xFC, 0xF8, 0x7C, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x3F, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xE0, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xFC,
  0xF8, 0x7C, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x78, 0x78, 0x7C, 0x78, 0x7C,
  0xF8, 0x3E, 0x03, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xF0, 0x83,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x60, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0xF8, 0x1F, 0xF8, 0x1E, 0x78,
  0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0x78,
  0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7B, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8,
  0x3C, 0x1F, 0xF8, 0x3C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x3E, 0xF8,
  0xFC, 0x3C, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0x78, 0xF9, 0xFC, 0x78, 0xF9,
  0xDC, 0xF8, 0xFB, 0xDC, 0xF0, 0xF3, 0xDD, 0xF0, 0xF7, 0x9D, 0xE0, 0xF7,
  0x9D, 0xE0, 0x77, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x7C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xEF, 0x80,
  0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xBE,
  0x01, 0xF3, 0xE0, 0x1F, 0x1E, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x3E, 0xF0, 0x7D, 0xE1, 0xF3, 0xE3, 0xC7, 0xCF, 0x87, 0xBE,
  0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0xF1, 0xE3, 0xC7,
  0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x38, 0x70, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x07, 0x9E, 0x1C, 0x78, 0xF0, 0xE3, 0x83,
  0x9E, 0x0F, 0xF0, 0x3C, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0xF9, 0xE3, 0xC7,
  0x06, 0x00, 0x3E, 0xF1, 0xFF, 0xCF, 0xFF, 0x7E, 0xFD, 0xF1, 0xE7, 0x87,
  0xBE, 0x1E, 0xF8, 0xFB, 0xE3, 0xCF, 0x0F, 0x3E, 0x7C, 0xFB, 0xF3, 0xFF,
  0xC7, 0xEE, 0x0F, 0x38, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE6, 0x07, 0xBE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0x7C, 0xF8,
  0xF9, 0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0x78,
  0xFB, 0xF1, 0xFF, 0xC7, 0xBF, 0x8F, 0x7C, 0x00, 0x03, 0x80, 0xFF, 0x1F,
  0xF3, 0xFE, 0x7E, 0x27, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x84, 0xFD, 0xCF, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x06, 0x3C, 0x0F, 0xBC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x7C, 0xFC, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0x78,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xFB, 0xF0, 0xFF, 0xF0, 0x7E, 0xE0,
  0x3C, 0xE0, 0x01, 0x80, 0x7F, 0x87, 0xFE, 0x7F, 0xF7, 0xC7, 0xBC, 0x3D,
  0xE3, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x3C, 0x01, 0xE0, 0x0F, 0x86, 0x3F,
  0xF1, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0F, 0xBC, 0x3F, 0xF8, 0xFF, 0xF3, 0xE7, 0xE7, 0xC7, 0x8F,
  0x0F, 0x3E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xE3, 0xE7, 0xC7, 0xDF,
  0x8F, 0xFF, 0x0F, 0xFC, 0x1F, 0x78, 0x00, 0xF0, 0x03, 0xE2, 0x07, 0x87,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE6, 0x07, 0xBF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3E, 0x7C, 0xF8, 0xF9, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F,
  0x3E, 0x3E, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F, 0x80,
  0x02, 0x03, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x3E, 0x1E, 0x0F, 0x07,
  0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87,
  0xC0, 0x00, 0x20, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x04, 0x7C, 0x7C, 0x3C, 0x7C, 0x1E, 0x7C, 0x0F, 0x7C, 0x0F, 0xBC,
  0x07, 0xBC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x79,
  0xF0, 0x3C, 0x78, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC0, 0x0F, 0x87,
  0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3,
  0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x80, 0x00, 0x30,
  0x30, 0x7B, 0xF3, 0xE1, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0x1F, 0x3F, 0x3C,
  0xF8, 0xF8, 0xF3, 0xE3, 0xC3, 0xCF, 0x0F, 0x1F, 0x3C, 0x3C, 0x7C, 0xF1,
  0xF1, 0xE7, 0xC7, 0x87, 0x9F, 0x1E, 0x1E, 0x78, 0x78, 0xF9, 0xE3, 0xE3,
  0xEF, 0x8F, 0x8F, 0x3E, 0x3C, 0x3C, 0x00, 0x30, 0x3D, 0xF8, 0x7F, 0xF0,
  0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0xF9, 0xF1, 0xF3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C,
  0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xF7, 0xC7, 0xBE, 0x3D, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0xBF, 0x3F, 0xF1, 0xFF,
  0x07, 0xF0, 0x00, 0x18, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x9F,
  0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF8, 0x7D, 0xE0, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x3E, 0xF1, 0xFF, 0xCF, 0xFF, 0x7C, 0xFD, 0xF1, 0xE7, 0x87,
  0xBE, 0x1E, 0xF8, 0x7B, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xFB, 0xF3, 0xFF,
  0xC7, 0xFE, 0x1F, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x31, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xE3, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0x81, 0xFF, 0x3F, 0xF3, 0xFE, 0x3C,
  0x23, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0xC7,
  0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x17, 0xFD,
  0xFF, 0xBF, 0xF1, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC8, 0xFF, 0x0F, 0xE1, 0xFC, 0x00, 0x3E, 0x3E, 0x78, 0x78,
  0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0xF8,
  0xF9, 0xF1, 0xE3, 0xE7, 0xC7, 0xDF, 0x8F, 0xFF, 0x0F, 0xDE, 0x1F, 0x38,
  0x00, 0xF8, 0x7D, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0x79, 0xF1, 0xE7, 0x87,
  0xBE, 0x1E, 0xF0, 0x7B, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0xF1, 0xF0, 0xFF, 0x1F, 0x1F, 0xF3, 0xF1, 0xEF,
  0x3F, 0x3E, 0xF3, 0xF3, 0xCF, 0x77, 0x3C, 0xF7, 0x77, 0x8F, 0xF7, 0x78,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x87, 0x9F, 0x03, 0xCF,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x07, 0xCF, 0x83, 0xE7, 0xC3,
  0xE1, 0xE0, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3,
  0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80,
  0x00, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x7C, 0x0F, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x03, 0xF0, 0x3F,
  0x01, 0xE0, 0x7E, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x87,
  0xF8, 0x04, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 20, 8, 0, -20 },
  { 24, 10, 7, 12, 3, -20 },
  { 33, 17, 20, 17, 0, -20 },
  { 76, 14, 23, 15, 1, -21 },
  { 117, 21, 20, 23, 2, -20 },
  { 170, 18, 20, 18, 0, -20 },
  { 215, 5, 7, 7, 3, -20 },
  { 220, 10, 24, 9, 1, -20 },
  { 250, 10, 24, 9, -2, -20 },
  { 280, 13, 13, 14, 2, -21 },
  { 302, 13, 14, 15, 1, -17 },
  { 325, 6, 7, 8, -1, -3 },
  { 331, 8, 3, 9, 0, -9 },
  { 334, 5, 5, 8, 0, -5 },
  { 338, 15, 20, 12, -1, -20 },
  { 376, 13, 20, 15, 1, -20 },
  { 409, 12, 20, 15, 2, -20 },
  { 439, 15, 20, 15, -1, -20 },
  { 477, 14, 20, 15, 0, -20 },
  { 512, 15, 20, 15, 0, -20 },
  { 550, 15, 20, 15, 0, -20 },
  { 588, 14, 20, 15, 1, -20 },
  { 623, 15, 20, 15, 1, -20 },
  { 661, 15, 20, 15, 0, -20 },
  { 699, 13, 20, 15, 1, -20 },
  { 732, 8, 16, 8, 0, -16 },
  { 748, 10, 20, 8, -2, -16 },
  { 773, 13, 14, 15, 1, -17 },
  { 796, 13, 9, 15, 1, -14 },
  { 811, 13, 14, 15, 1, -17 },
  { 834, 11, 20, 12, 2, -20 },
  { 862, 21, 22, 22, 1, -20 },
  { 920, 17, 20, 17, -2, -20 },
  { 963, 16, 20, 16, 0, -20 },
  { 1003, 16, 20, 16, 1, -20 },
  { 1043, 17, 20, 17, 0, -20 },
  { 1086, 15, 20, 14, 0, -20 },
  { 1124, 15, 20, 14, 0, -20 },
  { 1162, 17, 20, 18, 1, -20 },
  { 1205, 19, 20, 18, 0, -20 },
  { 1253, 13, 20, 11, -1, -20 },
  { 1286, 13, 26, 9, -4, -20 },
  { 1329, 19, 20, 16, 0, -20 },
  { 1377, 12, 20, 13, 0, -20 },
  { 1407, 24, 20, 23, 0, -20 },
  { 1467, 20, 20, 20, 0, -20 },
  { 1517, 17, 20, 19, 1, -20 },
  { 1560, 16, 20, 16, 0, -20 },
  { 1600, 17, 25, 19, 1, -20 },
  { 1654, 16, 20, 16, 0, -20 },
  { 1694, 15, 20, 14, 0, -20 },
  { 1732, 14, 20, 14, 2, -20 },
  { 1767, 16, 20, 18, 2, -20 },
  { 1807, 16, 20, 16, 2, -20 },
  { 1847, 24, 20, 24, 2, -20 },
  { 1907, 20, 20, 16, -2, -20 },
  { 1957, 15, 20, 15, 2, -20 },
  { 1995, 16, 20, 14, -1, -20 },
  { 2035, 12, 25, 9, -1, -20 },
  { 2073, 7, 20, 12, 3, -20 },
  { 2091, 12, 25, 9, -2, -20 },
  { 2129, 14, 13, 14, 0, -20 },
  { 2152, 12, 3, 11, -3, 2 },
  { 2157, 6, 4, 9, 4, -21 },
  { 2160, 14, 16, 15, 1, -16 },
  { 2188, 15, 21, 15, 0, -21 },
  { 2228, 12, 16, 13, 1, -16 },
  { 2252, 16, 21, 15, 1, -21 },
  { 2294, 13, 16, 15, 1, -16 },
  { 2320, 16, 28, 10, -3, -21 },
  { 2376, 15, 23, 16, 0, -16 },
  { 2420, 15, 21, 16, 0, -21 },
  { 2460, 9, 22, 8, 0, -22 },
  { 2485, 13, 29, 8, -4, -22 },
  { 2533, 17, 21, 15, 0, -21 },
  { 2578, 9, 21, 8, 0, -21 },
  { 2602, 22, 16, 23, 0, -16 },
  { 2646, 15, 16, 16, 0, -16 },
  { 2676, 13, 16, 15, 1, -16 },
  { 2702, 16, 23, 15, -1, -16 },
  { 2748, 14, 23, 15, 1, -16 },
  { 2789, 12, 16, 11, 0, -16 },
  { 2813, 12, 16, 12, 0, -16 },
  { 2837, 11, 19, 11, 1, -19 },
  { 2864, 15, 15, 16, 1, -15 },
  { 2893, 14, 15, 14, 1, -15 },
  { 2920, 20, 15, 21, 2, -15 },
  { 2958, 17, 15, 14, -1, -15 },
  { 2990, 17, 22, 14, -2, -15 },
  { 3037, 14, 15, 12, -1, -15 },
  { 3064, 12, 24, 10, 0, -20 },
  { 3100, 4, 27, 14, 5, -21 },
  { 3114, 12, 24, 10, -2, -20 },
  { 3150, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC28PT7B_H_
