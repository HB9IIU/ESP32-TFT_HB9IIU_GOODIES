#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF3, 0xFF,
  0x87, 0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF9, 0xF0, 0xF8, 0x03,
  0xFF, 0x8F, 0x01, 0x80, 0x1F, 0xFC, 0x78, 0x00, 0x00, 0xFF, 0xC7, 0xC0,
  0x00, 0x07, 0xFE, 0x3E, 0x00, 0x00, 0x3F, 0xF9, 0xE0, 0x00, 0x01, 0xFF,
  0xCF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0x00, 0x00, 0x0F, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0xFF, 0xC0, 0x00, 0x07, 0xC7, 0xFE, 0x08, 0x00, 0x3C,
  0x3F, 0xF0, 0x70, 0x01, 0xE3, 0xFF, 0x83, 0xE0, 0x1F, 0x1F, 0xFC, 0x1F,
  0xE0, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x1F, 0xE0, 0x0C, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC7, 0xFC, 0x3F, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFF, 0xFC,
  0xFF, 0xDF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFC, 0x7F, 0xE7, 0xFC, 0x7F, 0xFE,
  0x1F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0x9F, 0xFE, 0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFD,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x10, 0x07, 0xFC, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0x3E, 0x07, 0xF8, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFD, 0xFE, 0x00,
  0x1F, 0xFD, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0xC0, 0x03, 0xC0, 0x7F, 0xC0,
  0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x03, 0xC0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0xFF,
  0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xE3, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xCF, 0xFE,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF,
  0xE7, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00,
  0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFE,
  0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF,
  0x87, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7, 0xFF, 0x07, 0xFE, 0x7F, 0xF0,
  0x3F, 0xE3, 0xFF, 0x80, 0xFE, 0x1F, 0xFC, 0x03, 0xC0, 0xFF, 0xE0, 0x1C,
  0x0F, 0xFF, 0x00, 0x40, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xFE,
  0x00, 0x38, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x80, 0x00, 0x0F, 0xFF, 0x87, 0x00, 0x00, 0xFF, 0xFC, 0x3F,
  0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xE0,
  0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xE1, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x10, 0x00, 0x07, 0xFF, 0xE0, 0xE0,
  0x00, 0x7F, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x1C, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0x80, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xF9, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xFF, 0xC0, 0x3F, 0xF7,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF,
  0x87, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0xFF,
  0xF3, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x01,
  0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0xFF,
  0xE0, 0x3F, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x03, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xC7, 0xFF, 0xC3, 0xF0, 0x0F, 0xFE, 0x1C, 0x00, 0x7F, 0xF0,
  0x40, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0x81, 0xFF,
  0x00, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x87, 0xF8,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0xF9,
  0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF3, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x7F,
  0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xE7, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF3,
  0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0x80, 0xFF, 0x81,
  0xFE, 0x3F, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F,
  0xF8, 0x7F, 0xC3, 0xF8, 0x1F, 0xF1, 0xFF, 0xE7, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x03, 0xFF, 0xFB, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x02, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x20,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xE0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xC0, 0x0F, 0xFB,
  0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xBF,
  0xE0, 0x1F, 0xF7, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xF0,
  0x03, 0xFF, 0xBF, 0xE0, 0x3F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xEF, 0xFE, 0x00, 0x3F,
  0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xE0, 0xFF, 0xCF,
  0xFE, 0x00, 0x7F, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0x3F,
  0xE1, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0xC0,
  0x07, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFE, 0x3F,
  0xE1, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0xC3, 0xFE, 0x7F, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x3F,
  0xEF, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE7, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x87, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF1,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x18, 0x00, 0x07, 0xFF,
  0x80, 0x78, 0x00, 0x1F, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFD,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF3, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF7,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x3F, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xCF, 0xF8,
  0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xFE,
  0x7F, 0xE3, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFE, 0x1F, 0xF1, 0xFF,
  0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF,
  0x87, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x3F, 0xE7, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF7, 0xFC, 0x0F,
  0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF,
  0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0xF1, 0xFF, 0x80, 0x1F, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x9F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x03, 0xFF, 0x9F, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFE, 0x00, 0x7F, 0xC7,
  0xFF, 0xF0, 0x01, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0xF8, 0x0F, 0xFF, 0x80,
  0x10, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x40, 0x7F, 0xF8, 0x01, 0x80, 0x7F, 0xFC, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFF,
  0xEF, 0xFE, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0xF0, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0x03, 0xFF,
  0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF3,
  0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x04, 0x07, 0xFF, 0x80, 0x07, 0x01,
  0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x82, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFF, 0xE7, 0xFE,
  0x00, 0x3F, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0xE7,
  0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x10, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x03, 0xFF,
  0x9F, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x87, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x1F,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xFE,
  0x00, 0x3F, 0xE3, 0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xFF, 0xF0, 0x03, 0xFE,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xF1, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x7F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFE, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xBF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x07,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F,
  0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0xFD, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x00, 0xF0, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0x9F,
  0xFC, 0x01, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x08, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0x80, 0x70, 0x07, 0xFF, 0x00,
  0x10, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0xC0, 0x00, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x04,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFC,
  0xFF, 0x80, 0x1F, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F,
  0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFD, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0x07,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0x7F, 0x83, 0xFF,
  0x81, 0xFF, 0x87, 0xFB, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xDF, 0xE1,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFC, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x1F, 0xE7,
  0xF8, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x3F, 0xC7, 0xFE, 0x00, 0xFF, 0xCF,
  0xF1, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0x8F, 0xF3, 0xFF, 0x00, 0x3F,
  0xF7, 0xFC, 0x7F, 0x9F, 0xF8, 0x01, 0xFF, 0xBF, 0xC3, 0xFD, 0xFF, 0xC0,
  0x0F, 0xFB, 0xFE, 0x1F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0xFF, 0x7F,
  0xE0, 0x03, 0xFE, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE1, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x04, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x20, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x43, 0xFF, 0xC0, 0x00,
  0x33, 0xFF, 0xFC, 0x00, 0x1D, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF3, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 23, 52, 20, 0, -51 },
  { 151, 28, 18, 32, 7, -51 },
  { 214, 43, 51, 43, 1, -51 },
  { 489, 37, 59, 38, 1, -55 },
  { 762, 54, 53, 60, 4, -52 },
  { 1120, 46, 53, 47, 1, -52 },
  { 1425, 13, 18, 18, 7, -51 },
  { 1455, 27, 63, 23, 2, -52 },
  { 1668, 27, 64, 24, -5, -53 },
  { 1884, 32, 34, 36, 6, -55 },
  { 2020, 34, 35, 39, 3, -43 },
  { 2169, 18, 19, 20, -4, -9 },
  { 2212, 20, 10, 23, 1, -24 },
  { 2237, 13, 13, 20, 0, -12 },
  { 2259, 39, 53, 30, -3, -52 },
  { 2518, 35, 53, 38, 2, -52 },
  { 2750, 29, 51, 38, 6, -51 },
  { 2935, 39, 52, 38, -2, -52 },
  { 3189, 37, 53, 38, 0, -52 },
  { 3435, 38, 51, 38, -1, -51 },
  { 3678, 37, 52, 38, 1, -51 },
  { 3919, 36, 53, 38, 3, -52 },
  { 4158, 39, 51, 38, 2, -51 },
  { 4407, 37, 53, 38, 1, -52 },
  { 4653, 35, 53, 38, 2, -52 },
  { 4885, 20, 41, 20, 0, -40 },
  { 4988, 24, 50, 20, -4, -40 },
  { 5138, 34, 38, 39, 3, -45 },
  { 5300, 34, 23, 39, 3, -37 },
  { 5398, 34, 38, 39, 3, -45 },
  { 5560, 29, 53, 31, 4, -52 },
  { 5753, 54, 58, 58, 3, -52 },
  { 6145, 42, 51, 43, -4, -51 },
  { 6413, 40, 51, 42, 1, -51 },
  { 6668, 41, 53, 40, 3, -52 },
  { 6940, 42, 51, 45, 1, -51 },
  { 7208, 38, 51, 36, 1, -51 },
  { 7451, 38, 51, 36, 1, -51 },
  { 7694, 43, 53, 46, 3, -52 },
  { 7979, 47, 51, 47, 1, -51 },
  { 8279, 35, 51, 27, -3, -51 },
  { 8503, 35, 67, 23, -11, -51 },
  { 8797, 47, 51, 42, 1, -51 },
  { 9097, 29, 51, 34, 1, -51 },
  { 9282, 60, 51, 60, 1, -51 },
  { 9665, 51, 51, 51, 1, -51 },
  { 9991, 44, 53, 48, 3, -52 },
  { 10283, 40, 51, 41, 1, -51 },
  { 10538, 44, 64, 48, 3, -52 },
  { 10890, 39, 51, 42, 1, -51 },
  { 11139, 38, 53, 36, 0, -52 },
  { 11391, 35, 51, 36, 6, -51 },
  { 11615, 43, 52, 46, 4, -51 },
  { 11895, 41, 51, 40, 6, -51 },
  { 12157, 61, 51, 61, 6, -51 },
  { 12546, 51, 51, 41, -4, -51 },
  { 12872, 39, 51, 39, 6, -51 },
  { 13121, 43, 51, 35, -3, -51 },
  { 13396, 30, 64, 23, -2, -52 },
  { 13636, 17, 53, 30, 8, -52 },
  { 13749, 30, 64, 23, -5, -52 },
  { 13989, 36, 33, 37, 0, -51 },
  { 14138, 31, 6, 29, -7, 6 },
  { 14162, 16, 11, 24, 10, -55 },
  { 14184, 38, 41, 40, 2, -40 },
  { 14379, 38, 56, 40, 0, -55 },
  { 14645, 32, 41, 33, 2, -40 },
  { 14809, 41, 56, 40, 2, -55 },
  { 15096, 34, 41, 38, 2, -40 },
  { 15271, 41, 72, 26, -8, -55 },
  { 15640, 40, 57, 40, 0, -40 },
  { 15925, 38, 55, 40, 0, -55 },
  { 16187, 23, 55, 21, 0, -55 },
  { 16346, 32, 72, 21, -9, -55 },
  { 16634, 43, 55, 39, 0, -55 },
  { 16930, 23, 55, 20, 0, -55 },
  { 17089, 57, 40, 60, 0, -40 },
  { 17374, 38, 40, 40, 0, -40 },
  { 17564, 35, 41, 39, 2, -40 },
  { 17744, 41, 57, 40, -3, -40 },
  { 18037, 37, 57, 40, 2, -40 },
  { 18301, 32, 40, 28, 0, -40 },
  { 18461, 32, 41, 32, 0, -40 },
  { 18625, 27, 49, 28, 3, -48 },
  { 18791, 37, 41, 40, 3, -40 },
  { 18981, 35, 40, 35, 4, -40 },
  { 19156, 53, 40, 54, 4, -40 },
  { 19421, 44, 40, 36, -4, -40 },
  { 19641, 44, 57, 36, -5, -40 },
  { 19955, 35, 40, 31, -2, -40 },
  { 20130, 30, 62, 25, 0, -51 },
  { 20363, 9, 71, 36, 13, -55 },
  { 20443, 29, 62, 25, -4, -51 },
  { 20668, 34, 13, 39, 3, -32 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC72PT7B_H_
