#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0x00, 0x07,
  0x1E, 0x3C, 0x78, 0x73, 0xBB, 0xDD, 0xDC, 0xEE, 0x77, 0x30, 0x03, 0xB8,
  0x1C, 0xE0, 0x73, 0x01, 0x9C, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC3, 0x38,
  0x1C, 0xC3, 0xFF, 0xEF, 0xFF, 0x8E, 0x70, 0x39, 0x80, 0xCE, 0x03, 0x38,
  0x1C, 0xC0, 0x00, 0x80, 0x7E, 0x0F, 0xF1, 0xFF, 0x3D, 0x23, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0xC0, 0x7C, 0x07, 0xE0, 0x6E, 0x45, 0xE7, 0xFC, 0xFF,
  0xC7, 0xF0, 0x0C, 0x00, 0x80, 0x0C, 0x01, 0x0F, 0x83, 0x87, 0xF0, 0xE1,
  0xDC, 0x70, 0x67, 0x38, 0x39, 0xCE, 0x0E, 0x77, 0x03, 0xBB, 0xBC, 0xFE,
  0xDF, 0x9F, 0x77, 0x73, 0x3B, 0x9C, 0x0C, 0xE7, 0x07, 0x39, 0x83, 0x8E,
  0xE0, 0xC3, 0xB8, 0x70, 0xFC, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0xDE, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x9E, 0x7F, 0x39, 0xEF, 0xF3, 0x9F, 0xCF, 0x1F, 0x9E, 0x3E, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7C, 0x77, 0x7E, 0xEE, 0x07, 0x0E, 0x1E, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xF0, 0x70, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E,
  0x0E, 0x0E, 0x0F, 0x00, 0x08, 0x03, 0x88, 0xE3, 0xB8, 0xFF, 0xDF, 0xF1,
  0xFC, 0xF8, 0xF7, 0x19, 0xC2, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3B, 0xDE,
  0xEF, 0x70, 0x7E, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xF8,
  0x7F, 0x1E, 0xF7, 0x9E, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3B, 0x8F,
  0x71, 0xEE, 0x3D, 0xCF, 0x3F, 0xE7, 0xF8, 0x7E, 0x00, 0x07, 0x8F, 0xCF,
  0xCF, 0xEF, 0x73, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0,
  0xE0, 0xF0, 0x78, 0x01, 0xC0, 0x3F, 0x87, 0xFC, 0x3F, 0xF0, 0xC7, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xFF, 0x8F, 0xFC, 0xFF, 0xE0, 0x03, 0x83, 0xFE, 0x1F, 0xF1,
  0xDF, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFC, 0x1F, 0x01, 0xFC, 0x03, 0xC0,
  0x1E, 0x01, 0xE8, 0x3C, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x00, 0xF0, 0x1F,
  0x03, 0xE0, 0x7E, 0x06, 0xE0, 0xFE, 0x1D, 0xC3, 0x9C, 0x31, 0xC7, 0x3C,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xC0, 0x1C, 0x03, 0xE0, 0x3F, 0xC3, 0xFC, 0x33, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x83, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x01, 0xE0, 0xFC,
  0x7F, 0x9F, 0x13, 0xC0, 0xF0, 0x1D, 0xC7, 0xFE, 0xFF, 0xDF, 0x7B, 0xC7,
  0x79, 0xEE, 0x3D, 0xE7, 0xBF, 0xE3, 0xF8, 0x3E, 0x00, 0x3F, 0xF7, 0xFF,
  0x7F, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x03, 0x80, 0xFE,
  0x1F, 0xF1, 0xCF, 0x3C, 0x73, 0xCF, 0x1F, 0xE1, 0xFC, 0x0F, 0x83, 0xFC,
  0x79, 0xE7, 0x1E, 0xF1, 0xEF, 0x1E, 0x7F, 0xC7, 0xFC, 0x3F, 0x00, 0x07,
  0x03, 0xF0, 0xFF, 0x3D, 0xE7, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xCF,
  0xF9, 0xF7, 0x01, 0xE0, 0x38, 0x0E, 0x3F, 0xC7, 0xF0, 0xF8, 0x00, 0x1C,
  0xF3, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x3C, 0xF0, 0x0E, 0x3C, 0x78,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xC7, 0x0E, 0x38, 0x70, 0x00,
  0x60, 0x3C, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC1,
  0xF8, 0xFC, 0x7E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x0E, 0x1F, 0xE7, 0xF9,
  0xCF, 0x43, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x07, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x60, 0x01, 0xFE, 0x03, 0xFF,
  0xC3, 0xC0, 0xE3, 0x80, 0x3B, 0x8F, 0xDD, 0xCF, 0xE6, 0xCE, 0x73, 0xE6,
  0x31, 0xF7, 0x39, 0xF3, 0x9C, 0xF9, 0xCE, 0xEC, 0xFF, 0xE7, 0x3D, 0xF3,
  0x88, 0x60, 0xE0, 0x00, 0x78, 0x30, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xCF,
  0x1E, 0x78, 0xFF, 0xCF, 0xFE, 0x7F, 0xF7, 0x87, 0xBC, 0x1F, 0xC0, 0xFE,
  0x07, 0x0F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3C, 0xF1, 0xC7, 0x9E, 0x3C, 0xFF,
  0xC7, 0xF8, 0x3F, 0xE1, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x01, 0xC0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE3, 0xC1, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x21, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x87, 0x9F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE1,
  0xE7, 0x87, 0x9E, 0x3E, 0x79, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xE0, 0x1C, 0x03, 0xC0, 0x3F, 0xE3, 0xFC, 0x3F,
  0xC3, 0x80, 0x78, 0x07, 0x80, 0x78, 0x47, 0xF8, 0x7F, 0x8F, 0xF8, 0x0F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x23, 0xFC, 0x3F,
  0xC3, 0xFC, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x01,
  0xE0, 0x1F, 0xF1, 0xFF, 0x87, 0xFE, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF1, 0xFB, 0xCF, 0xCF, 0x3F, 0x3C, 0x3C, 0xF0, 0xF3, 0xE3, 0xC7,
  0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0xE1, 0xC1, 0xC7, 0x87, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x70, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0E, 0x1C, 0x3C, 0x78, 0x78, 0x1F,
  0xE3, 0xFC, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0xC7, 0xF8, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xF0,
  0x7E, 0x0F, 0xE0, 0xF8, 0x00, 0x0E, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0xF7,
  0x81, 0xCF, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xE7, 0x03, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x1C, 0x3C, 0x78, 0x78, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0xF7, 0xFB, 0xFE, 0x0F, 0x83, 0xE3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xE7, 0x71,
  0xDC, 0xFE, 0x3B, 0xBB, 0xC7, 0x77, 0x71, 0xEF, 0xCE, 0x3D, 0xFB, 0xC7,
  0x3E, 0x78, 0xE7, 0xCE, 0x1C, 0xF1, 0xC7, 0x9E, 0x38, 0x0F, 0x07, 0x8F,
  0x83, 0x87, 0xE1, 0xC3, 0xF1, 0xE1, 0xF8, 0xE1, 0xFE, 0x70, 0xFF, 0x38,
  0x73, 0xBC, 0x39, 0xDE, 0x1C, 0xFE, 0x1E, 0x7F, 0x0F, 0x1F, 0x87, 0x0F,
  0xC3, 0x87, 0xE1, 0xC3, 0xE1, 0xE0, 0xF0, 0x01, 0xC0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xE3, 0xC7, 0xFE, 0x1F, 0xF0, 0x1F,
  0x80, 0x0F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3C, 0xF1, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3C, 0x3D,
  0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x1E,
  0xF0, 0xFB, 0xE7, 0xC7, 0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x3C, 0xF1, 0xC7,
  0x9E, 0x3C, 0xF3, 0xC7, 0xFE, 0x3F, 0xE1, 0xFE, 0x1E, 0xF0, 0xF3, 0xC7,
  0x9E, 0x3C, 0xF1, 0xC3, 0xDE, 0x1E, 0x03, 0x80, 0xFF, 0x1F, 0xF3, 0xFE,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xCC, 0x3C, 0xFF, 0x8F, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8F,
  0x1E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x78, 0xF1, 0xC3, 0xCF,
  0x0F, 0x3C, 0x38, 0xF1, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0xF0, 0x7F,
  0x87, 0xBC, 0x39, 0xE3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x1E, 0xF0, 0xF7,
  0x83, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xE0, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0x71, 0xF1, 0xEE, 0x3E, 0x39,
  0xC7, 0xCF, 0x39, 0xF9, 0xE7, 0x3F, 0x38, 0xEE, 0xEF, 0x1D, 0xDD, 0xC3,
  0xBB, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07,
  0x87, 0xC0, 0x1F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x78, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1E, 0xE0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x78, 0xF0, 0xFF,
  0x1E, 0x71, 0xC7, 0x3C, 0x7F, 0x87, 0xF8, 0x3F, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0x07, 0xC3, 0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0xC1, 0xF0, 0xFC, 0x00, 0xE1, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x07, 0xC3, 0xF0, 0xFC, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x03, 0x80, 0x70,
  0x1E, 0x07, 0xE0, 0xFC, 0x3B, 0x8E, 0x39, 0xC7, 0x70, 0xFC, 0x0C, 0xFF,
  0xFF, 0xE0, 0xF3, 0x8E, 0x70, 0x0E, 0x73, 0xFE, 0x3F, 0xE7, 0x9E, 0x71,
  0xEF, 0x1E, 0xF1, 0xCF, 0x1C, 0xE3, 0xCF, 0x3C, 0xFF, 0x8F, 0xF8, 0x7B,
  0x80, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1D, 0xC1, 0xFE, 0x3F, 0xF3,
  0xCF, 0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8F, 0x79, 0xE7, 0x9E, 0x7F, 0xCF,
  0xFC, 0xEF, 0x80, 0x0F, 0x87, 0xF3, 0xF9, 0xE2, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x3C, 0x4F, 0xF1, 0xFC, 0x7E, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0xEF, 0x1F, 0xF0, 0xFF, 0x8F, 0x3C, 0x71, 0xE7, 0x8F,
  0x3C, 0x71, 0xE3, 0x8E, 0x3C, 0x79, 0xE3, 0xFE, 0x1F, 0xF0, 0x7B, 0x80,
  0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x1D, 0xEF, 0xBF, 0xE7, 0xF0, 0xE0,
  0x1E, 0x03, 0xFE, 0x3F, 0xC3, 0xF0, 0x00, 0x60, 0x0F, 0xC0, 0xFC, 0x07,
  0xA0, 0x38, 0x03, 0xF0, 0x7F, 0x83, 0xFC, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x08, 0x00, 0x07, 0x38, 0xFF,
  0x87, 0xFC, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0x8F, 0x1C, 0x71, 0xE3,
  0xCF, 0x1F, 0xF0, 0xFF, 0x83, 0xDC, 0x01, 0xE0, 0x0F, 0x18, 0xF0, 0xFF,
  0x87, 0xF8, 0x04, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1D, 0xE1,
  0xFF, 0x3F, 0xF3, 0xEF, 0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7,
  0x1E, 0x71, 0xEF, 0x1E, 0xF1, 0xC0, 0x04, 0x1C, 0x78, 0x70, 0x03, 0x87,
  0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xE0, 0x00, 0xC0,
  0x70, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0xFC,
  0x3F, 0x0F, 0x81, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x7C, 0x71, 0xE3, 0xCF, 0x0F, 0x78, 0x3B, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0x78, 0xF1, 0xE0, 0x0E, 0x3C,
  0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8F, 0x1C, 0x78,
  0xF0, 0x1D, 0xE3, 0x87, 0xFB, 0xF3, 0xFF, 0xFC, 0xFB, 0xEF, 0x3C, 0xF1,
  0xCE, 0x3C, 0xF3, 0x8E, 0x3D, 0xE3, 0x8F, 0x79, 0xE3, 0x9C, 0x78, 0xE7,
  0x1E, 0x7B, 0xC7, 0x1E, 0xF1, 0xC7, 0x80, 0x1D, 0xE1, 0xFF, 0x3F, 0xF3,
  0xEF, 0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7, 0x1E, 0x71, 0xEF,
  0x1E, 0xF1, 0xC0, 0x0F, 0x03, 0xF8, 0xFF, 0x3C, 0xF7, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8E, 0xE3, 0xDE, 0x7B, 0xFE, 0x3F, 0x83, 0xE0, 0x0E, 0xE0, 0x7F,
  0x87, 0xFE, 0x3C, 0xF1, 0xE7, 0x8E, 0x3C, 0x71, 0xE7, 0x8F, 0x3C, 0x71,
  0xE7, 0x8F, 0xF8, 0xFF, 0xC7, 0xBC, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x0E, 0x73, 0xFE, 0x3F, 0xE7, 0x9E, 0x71, 0xEF,
  0x1E, 0xF1, 0xCF, 0x1C, 0xE3, 0xCF, 0x3C, 0xFF, 0x8F, 0xF8, 0x7B, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x1D, 0xC7, 0xF3,
  0xFC, 0xFE, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x0F, 0xF3, 0xF9, 0xE2, 0x7C, 0x0F, 0x83, 0xF0, 0x3E,
  0x07, 0xA1, 0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0x1C, 0x1C, 0x3F, 0xFF, 0xFF,
  0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x38, 0xF7,
  0x8F, 0x78, 0xE7, 0x8E, 0x71, 0xE7, 0x1E, 0xF1, 0xCF, 0x1C, 0xF3, 0xCF,
  0x3C, 0xFF, 0xCF, 0xF8, 0x7B, 0x80, 0xF0, 0xFF, 0x1E, 0xF1, 0xCF, 0x3C,
  0x73, 0x87, 0x78, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x78, 0x00, 0xF1, 0xE3, 0xF9, 0xF3, 0xFC, 0xF9, 0xDE, 0x7D, 0xEF, 0x7E,
  0xF7, 0xB7, 0x71, 0xFB, 0xF8, 0xFD, 0xB8, 0x7C, 0xDC, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x79, 0xE1, 0xEF, 0x03,
  0xB8, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x03,
  0xDC, 0x1E, 0x78, 0xF1, 0xE0, 0x1E, 0x1E, 0x3C, 0x78, 0x78, 0xF0, 0x73,
  0xC0, 0xE7, 0x81, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF0, 0x02, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x81, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xFF, 0x3F, 0xCF, 0xF8, 0x07,
  0xC1, 0xE0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0xFC, 0x3C, 0x0F,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x83, 0xC3, 0xE3, 0xC1, 0xC1,
  0xE0, 0xE0, 0x70, 0x78, 0x7C, 0x3C, 0x18, 0x00, 0x7C, 0x3F, 0xFF, 0xFF,
  0xC1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 14, 16, 14, 0, -16 },
  { 50, 12, 18, 12, 0, -17 },
  { 77, 18, 17, 19, 1, -17 },
  { 116, 15, 17, 15, 0, -17 },
  { 148, 4, 6, 6, 2, -16 },
  { 151, 8, 21, 8, 1, -17 },
  { 172, 9, 21, 8, -2, -17 },
  { 196, 10, 11, 12, 2, -18 },
  { 210, 11, 11, 12, 1, -14 },
  { 226, 5, 6, 6, -1, -3 },
  { 230, 7, 3, 7, 0, -8 },
  { 233, 4, 4, 6, 0, -4 },
  { 235, 12, 17, 10, -1, -17 },
  { 261, 11, 17, 12, 1, -17 },
  { 285, 9, 16, 12, 2, -16 },
  { 303, 13, 17, 12, -1, -17 },
  { 331, 12, 17, 12, 0, -17 },
  { 357, 12, 16, 12, 0, -16 },
  { 381, 12, 16, 12, 0, -16 },
  { 405, 11, 17, 12, 1, -17 },
  { 429, 12, 16, 12, 1, -16 },
  { 453, 12, 17, 12, 0, -17 },
  { 479, 11, 17, 12, 1, -17 },
  { 503, 6, 13, 6, 0, -13 },
  { 513, 7, 16, 6, -1, -13 },
  { 527, 11, 12, 12, 1, -14 },
  { 544, 11, 8, 12, 1, -12 },
  { 555, 11, 12, 12, 1, -14 },
  { 572, 10, 17, 10, 1, -17 },
  { 594, 17, 19, 18, 1, -17 },
  { 635, 13, 16, 14, -1, -16 },
  { 661, 13, 16, 13, 0, -16 },
  { 687, 13, 17, 13, 1, -17 },
  { 715, 14, 16, 14, 0, -16 },
  { 743, 12, 16, 11, 0, -16 },
  { 767, 12, 16, 11, 0, -16 },
  { 791, 14, 17, 15, 1, -17 },
  { 821, 15, 16, 15, 0, -16 },
  { 851, 11, 16, 9, -1, -16 },
  { 873, 12, 21, 7, -4, -16 },
  { 905, 15, 16, 13, 0, -16 },
  { 935, 10, 16, 11, 0, -16 },
  { 955, 19, 16, 19, 0, -16 },
  { 993, 17, 16, 16, 0, -16 },
  { 1027, 14, 17, 15, 1, -17 },
  { 1057, 13, 16, 13, 0, -16 },
  { 1083, 14, 21, 15, 1, -17 },
  { 1120, 13, 16, 13, 0, -16 },
  { 1146, 12, 17, 11, 0, -17 },
  { 1172, 11, 16, 11, 2, -16 },
  { 1194, 14, 16, 15, 1, -16 },
  { 1222, 13, 16, 13, 2, -16 },
  { 1248, 19, 16, 19, 2, -16 },
  { 1286, 16, 16, 13, -1, -16 },
  { 1318, 12, 16, 12, 2, -16 },
  { 1342, 14, 16, 11, -1, -16 },
  { 1370, 10, 21, 7, -1, -17 },
  { 1397, 6, 17, 10, 2, -17 },
  { 1410, 10, 21, 7, -2, -17 },
  { 1437, 11, 10, 12, 0, -16 },
  { 1451, 10, 2, 9, -2, 2 },
  { 1454, 5, 4, 8, 3, -18 },
  { 1457, 12, 13, 13, 1, -13 },
  { 1477, 12, 17, 13, 0, -17 },
  { 1503, 10, 13, 10, 1, -13 },
  { 1520, 13, 17, 13, 1, -17 },
  { 1548, 11, 13, 12, 1, -13 },
  { 1566, 13, 24, 8, -2, -18 },
  { 1605, 13, 19, 13, 0, -13 },
  { 1636, 12, 17, 13, 0, -17 },
  { 1662, 7, 18, 7, 0, -18 },
  { 1678, 10, 24, 7, -3, -18 },
  { 1708, 14, 17, 12, 0, -17 },
  { 1738, 7, 17, 7, 0, -17 },
  { 1753, 18, 13, 19, 0, -13 },
  { 1783, 12, 13, 13, 0, -13 },
  { 1803, 11, 13, 13, 1, -13 },
  { 1821, 13, 19, 13, -1, -13 },
  { 1852, 12, 19, 13, 1, -13 },
  { 1881, 10, 13, 9, 0, -13 },
  { 1898, 10, 13, 10, 0, -13 },
  { 1915, 8, 15, 9, 1, -15 },
  { 1930, 12, 13, 13, 1, -13 },
  { 1950, 12, 13, 11, 1, -13 },
  { 1970, 17, 13, 17, 1, -13 },
  { 1998, 14, 13, 12, -1, -13 },
  { 2021, 15, 19, 11, -2, -13 },
  { 2057, 11, 13, 10, -1, -13 },
  { 2075, 10, 20, 8, 0, -16 },
  { 2100, 3, 23, 11, 4, -18 },
  { 2109, 9, 20, 8, -1, -16 },
  { 2132, 11, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC23PT7B_H_
