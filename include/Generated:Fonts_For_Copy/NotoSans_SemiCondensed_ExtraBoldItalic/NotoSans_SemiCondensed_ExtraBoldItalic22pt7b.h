#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC0, 0x02,
  0x1E, 0x3C, 0x78, 0x77, 0xBB, 0x9D, 0xDC, 0xEE, 0x67, 0x70, 0x03, 0x38,
  0x39, 0x81, 0xDC, 0x0C, 0xE0, 0x66, 0x1F, 0xFD, 0xFF, 0xE1, 0x98, 0x1C,
  0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE3, 0xB8, 0x19, 0xC0, 0xCC, 0x0E, 0xE0,
  0x01, 0x80, 0x18, 0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0xB2, 0x3A, 0x03, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x5C, 0x45, 0xC7, 0xFC, 0xFF, 0x87, 0xF0,
  0x08, 0x00, 0x80, 0x1C, 0x0E, 0x1F, 0x06, 0x1D, 0xC7, 0x0C, 0xE7, 0x0E,
  0x73, 0x07, 0x33, 0x83, 0xBB, 0x99, 0xDD, 0xBE, 0x7D, 0xFF, 0xBD, 0xDD,
  0xC0, 0xCC, 0xE0, 0xE6, 0x70, 0xE7, 0x30, 0x63, 0xB8, 0x70, 0xF8, 0x70,
  0x78, 0x03, 0xC0, 0x3F, 0x80, 0xFF, 0x07, 0xBC, 0x1C, 0xE0, 0x7F, 0x80,
  0xFC, 0x03, 0xE7, 0x3F, 0x1D, 0xFE, 0xF7, 0x3F, 0xBC, 0xFC, 0xF1, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xDE, 0x77, 0x7E, 0xEE, 0x0F, 0x0E, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xF0, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x3C,
  0x00, 0x0C, 0x03, 0x84, 0xC3, 0xB0, 0xFF, 0xCF, 0xF3, 0xC5, 0xF8, 0xE6,
  0x09, 0xC0, 0x40, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3B, 0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF0,
  0x2F, 0xFF, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x00, 0x0F, 0x07, 0xF3, 0xFD, 0xE7, 0x79, 0xDC, 0x7F, 0x1F, 0xC7,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8E, 0xE7, 0xBF, 0xCF, 0xE1, 0xF0, 0x07, 0x87,
  0x87, 0xCF, 0xEF, 0xF3, 0x79, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x70, 0x03, 0xC0, 0xFE, 0x1F, 0xF0, 0xCF, 0x08, 0x70,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0xFE, 0x7F, 0xCF, 0xFC, 0x0F, 0x87, 0xFC, 0x7F, 0x88, 0x70, 0x0E, 0x03,
  0xC0, 0xF0, 0xFC, 0x1F, 0x80, 0x78, 0x07, 0x00, 0xE8, 0x3D, 0xFF, 0xBF,
  0xE7, 0xF0, 0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x7E, 0x1F, 0x87, 0x71,
  0xCE, 0x3B, 0xCE, 0x73, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x01, 0xC0, 0x38,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xC0, 0x1C, 0x03, 0xC0, 0x3F, 0x83, 0xFC,
  0x3F, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x83, 0xCF, 0xF8, 0xFF, 0x8F, 0xE0,
  0x03, 0xE1, 0xFC, 0x7F, 0x1E, 0x07, 0x80, 0xE0, 0x1F, 0xE7, 0xFC, 0xFF,
  0xDE, 0x7B, 0x8F, 0x71, 0xEE, 0x39, 0xFF, 0x1F, 0xC1, 0xF0, 0x3F, 0xF7,
  0xFE, 0x7F, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x07, 0xC0,
  0xFE, 0x1F, 0xE3, 0xCF, 0x3C, 0xE3, 0xCE, 0x1F, 0xC0, 0xF8, 0x1F, 0x87,
  0xBC, 0x71, 0xCF, 0x1C, 0xF1, 0xC7, 0xBC, 0x7F, 0x83, 0xF0, 0x0F, 0x0F,
  0xE7, 0xFD, 0xE7, 0x71, 0xFC, 0x7F, 0x3F, 0xCF, 0x7F, 0xDF, 0xF3, 0x38,
  0x1E, 0x0F, 0x3F, 0x8F, 0xE3, 0xE0, 0x1C, 0xF3, 0xC4, 0x00, 0x00, 0x00,
  0x23, 0xCF, 0x3C, 0x0E, 0x3C, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00, 0x71,
  0xE3, 0x87, 0x1C, 0x38, 0x00, 0x00, 0x40, 0x30, 0x3C, 0x3F, 0x3E, 0x3E,
  0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3C, 0x7E, 0x7E, 0x3E, 0x0E, 0x02, 0x00, 0x1E, 0x3F, 0xDF, 0xE4,
  0x70, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x00, 0x02, 0x03, 0x83,
  0xC1, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0x1E, 0x3C, 0x07, 0x30, 0xE3,
  0x73, 0xF3, 0x67, 0x33, 0xE6, 0x73, 0xCE, 0x73, 0xCC, 0x67, 0xCC, 0xE6,
  0xCE, 0xEE, 0xCF, 0xFC, 0xE6, 0x30, 0xE0, 0x00, 0x78, 0x60, 0x3F, 0xE0,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03, 0xB8,
  0x3D, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x8F, 0xFC, 0x7F, 0xE7, 0xFF, 0x3C,
  0x3F, 0xC1, 0xFE, 0x0F, 0x0F, 0xC0, 0xFF, 0x87, 0xFC, 0x38, 0xF1, 0xC7,
  0x9E, 0x38, 0xFF, 0xC7, 0xF8, 0x3F, 0xE1, 0xCF, 0x1E, 0x3C, 0xF1, 0xC7,
  0x9E, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0x07, 0xE0, 0xFF, 0x1F, 0xF3, 0xE2,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x47, 0xF8, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0xFF, 0x07, 0xFC, 0x39,
  0xF1, 0xC7, 0x9E, 0x1C, 0xF0, 0xE7, 0x87, 0x38, 0x79, 0xC3, 0xDE, 0x1C,
  0xF1, 0xE7, 0x9E, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFF, 0x1F,
  0xE1, 0xC0, 0x1C, 0x03, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0x1F,
  0xE1, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xFC, 0x3F, 0xC3, 0xF8, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xF0, 0x7F, 0xC7,
  0xFC, 0x7C, 0x27, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x7E, 0xF3, 0xF7, 0x9F,
  0xBC, 0x39, 0xE1, 0xCF, 0x0E, 0x3F, 0xF1, 0xFF, 0x87, 0xF8, 0x0E, 0x1E,
  0x3C, 0x38, 0x78, 0x70, 0xE1, 0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x70, 0xF1, 0xE1, 0xC3, 0xC3, 0x87, 0x8F, 0x0E, 0x1E,
  0x1C, 0x3C, 0x78, 0x70, 0x1F, 0xE3, 0xF8, 0x3F, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x7C, 0x1F,
  0xC7, 0xF8, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x2F,
  0x8F, 0xC3, 0xE0, 0xF0, 0x00, 0x0E, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0xE7,
  0x81, 0xCE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x81,
  0xEF, 0x03, 0xDE, 0x07, 0x9C, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0x78, 0x0E,
  0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0xFD, 0xFF, 0xFF, 0x0F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x0E, 0xC7, 0xE1, 0xD9, 0xDC,
  0x3B, 0x3B, 0x87, 0x7E, 0xF1, 0xEF, 0xDC, 0x39, 0xF3, 0x87, 0x3E, 0x70,
  0xE7, 0x8E, 0x1C, 0xF3, 0xC7, 0x9C, 0x70, 0x0F, 0x07, 0x1F, 0x0F, 0x1F,
  0x0E, 0x1F, 0x0E, 0x1F, 0x8E, 0x3B, 0x9E, 0x3B, 0x9E, 0x3B, 0xDC, 0x39,
  0xDC, 0x39, 0xDC, 0x79, 0xDC, 0x71, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0x70,
  0xF8, 0xF0, 0xF8, 0x07, 0xC0, 0x7F, 0x87, 0xFE, 0x78, 0xF7, 0x87, 0xBC,
  0x1D, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x1F,
  0x3F, 0xF1, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x39, 0xF1,
  0xC7, 0x9E, 0x3C, 0xF1, 0xC7, 0xBE, 0x3F, 0xE1, 0xFE, 0x1F, 0x80, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE,
  0x78, 0xF7, 0x87, 0xBC, 0x1D, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1D, 0xE1, 0xEF, 0x1F, 0x3F, 0xF1, 0xFF, 0x07, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x81, 0xFE, 0x1F, 0xF1, 0xCF, 0x1C, 0x73,
  0xC7, 0x3C, 0xF3, 0xFF, 0x3F, 0xE3, 0xF8, 0x7B, 0xC7, 0xBC, 0x79, 0xC7,
  0x1E, 0x71, 0xEF, 0x0F, 0x07, 0xC3, 0xFC, 0x7F, 0x9E, 0x23, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE8, 0x39, 0xFF, 0x3F,
  0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0x3C, 0x39,
  0xE1, 0xCF, 0x1E, 0x70, 0xF3, 0x87, 0x3C, 0x39, 0xE1, 0xCF, 0x1E, 0x70,
  0xF3, 0x87, 0x3C, 0x39, 0xE3, 0xCF, 0x1E, 0x7F, 0xE1, 0xFE, 0x07, 0xE0,
  0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xF3, 0x8F, 0x78,
  0xF7, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xE0, 0xE1, 0xFC, 0x3C, 0x3B, 0x87, 0x8F, 0x71, 0xF1, 0xCE, 0x3E, 0x79,
  0xCF, 0xCE, 0x39, 0xF9, 0xC7, 0x37, 0x70, 0xEE, 0xEE, 0x1D, 0xDF, 0xC3,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x1C, 0x38, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF,
  0x03, 0xCE, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x78, 0xF0, 0xFF, 0x1E, 0xF1,
  0xC7, 0x3C, 0x77, 0x87, 0x70, 0x7F, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x0F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0x0F, 0xC3,
  0xE0, 0xF8, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x07, 0xC3, 0xF0, 0xE1,
  0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x07,
  0xC3, 0xE0, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x1F, 0x07, 0xC3, 0xF0,
  0x03, 0x00, 0x70, 0x1E, 0x07, 0xC0, 0xF8, 0x3B, 0x86, 0x71, 0xC6, 0x70,
  0xDC, 0x1C, 0xFF, 0xFF, 0xC0, 0xF3, 0x8E, 0x70, 0x1E, 0xE7, 0xFD, 0xFF,
  0xB8, 0xEF, 0x1D, 0xE3, 0xB8, 0xF7, 0x1C, 0xE7, 0x9F, 0xF3, 0xFE, 0x3D,
  0xC0, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x3F, 0x8F, 0xF9, 0xFF,
  0x3C, 0xE7, 0x1C, 0xE3, 0xBC, 0x77, 0x1E, 0xF3, 0xDF, 0xF7, 0xFC, 0xEF,
  0x00, 0x1F, 0x9F, 0xDF, 0xCE, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE1, 0x7F,
  0x3F, 0x8F, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE1, 0xEE,
  0x3F, 0xE7, 0xFE, 0x71, 0xCF, 0x1C, 0xF1, 0xCE, 0x3C, 0xE3, 0x8E, 0x38,
  0xFF, 0x8F, 0xF8, 0x7B, 0x80, 0x1F, 0x8F, 0xF7, 0x9D, 0xC7, 0xF3, 0xFF,
  0xEF, 0xF3, 0x80, 0xE0, 0x3C, 0xCF, 0xF1, 0xFC, 0x00, 0xF0, 0x3F, 0x03,
  0xF0, 0x38, 0x07, 0x80, 0xFE, 0x1F, 0xC1, 0xFC, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x0F, 0x71, 0xFF, 0x3F, 0xF3, 0x8E, 0x78,
  0xE7, 0x8E, 0x71, 0xE7, 0x1C, 0x73, 0xC7, 0xFC, 0x7F, 0xC3, 0xFC, 0x03,
  0x80, 0x38, 0xEF, 0x8F, 0xF0, 0xFE, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xFE, 0x3F, 0xE3, 0xFF, 0x3C, 0xE3, 0x8E, 0x38, 0xE7,
  0x9E, 0x79, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xF3, 0xC0, 0x0E, 0x3C, 0x78,
  0x60, 0x03, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF0,
  0x01, 0xC0, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC3,
  0xF0, 0xFC, 0x3E, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x3C, 0xF3, 0xC7, 0xBC, 0x3B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFF, 0x07,
  0xF8, 0x39, 0xC1, 0xCF, 0x1E, 0x78, 0xF1, 0xE0, 0x0E, 0x3C, 0x78, 0xE1,
  0xC3, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF0, 0x1B,
  0xEF, 0x8E, 0xFB, 0xE3, 0xFF, 0xFC, 0xF3, 0xCE, 0x38, 0xE3, 0x8E, 0x38,
  0xE7, 0x9E, 0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x9C, 0x71, 0xCF, 0x1C, 0x73,
  0xCF, 0x3C, 0x1B, 0xE3, 0xFE, 0x3F, 0xF3, 0xCE, 0x38, 0xE3, 0x8E, 0x79,
  0xE7, 0x9E, 0x71, 0xE7, 0x1C, 0xF1, 0xCF, 0x3C, 0x1F, 0x8F, 0xF7, 0xFD,
  0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xBF, 0xEF, 0xF1, 0xF8, 0x0D,
  0xE1, 0xFF, 0x1F, 0xF1, 0xE7, 0x1C, 0x71, 0xC7, 0x3C, 0x73, 0x8F, 0x3C,
  0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0xB8, 0xEF, 0x1D, 0xE3, 0xB8, 0xF7, 0x1C,
  0xE3, 0x9F, 0xF3, 0xFE, 0x3F, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x00, 0x1B, 0xCE, 0xE3, 0xF8, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x0F, 0x03, 0xC0, 0x1F, 0xCF, 0xE3, 0x99, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x3F, 0xCF, 0xF3, 0xF8, 0x0C, 0x1C, 0x18, 0x7F, 0xFF,
  0xFE, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x78, 0xEF,
  0x3D, 0xC7, 0xB8, 0xE7, 0x1D, 0xE3, 0xBC, 0xF7, 0x1E, 0xE3, 0x9F, 0xF3,
  0xFE, 0x3D, 0xC0, 0xF1, 0xFE, 0x3B, 0xCF, 0x79, 0xC7, 0x78, 0xEE, 0x1F,
  0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0xF3, 0xC7, 0xF9, 0xE7,
  0xBD, 0xF3, 0x9E, 0xF9, 0xCE, 0x6D, 0xE7, 0x76, 0xE3, 0xB7, 0xF1, 0xDB,
  0xF0, 0xFD, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C, 0x0E, 0x3C, 0x00, 0x1C, 0x78,
  0xF7, 0x87, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F,
  0xC1, 0xDE, 0x1E, 0x71, 0xE3, 0xC0, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x39,
  0xC1, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0xF1,
  0xFE, 0x7F, 0xC0, 0x01, 0x83, 0xC3, 0xE1, 0xC0, 0xE0, 0xF0, 0x70, 0x38,
  0x7C, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x78, 0x3E, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x0F,
  0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0xC3, 0xC3, 0xC3,
  0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x78, 0x3C, 0x00, 0x70, 0x7F, 0xBF, 0xFE,
  0x1F,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 13, 16, 13, 0, -16 },
  { 48, 12, 18, 11, 0, -17 },
  { 75, 17, 16, 18, 1, -16 },
  { 109, 14, 16, 15, 0, -16 },
  { 137, 4, 6, 5, 2, -16 },
  { 140, 8, 19, 7, 1, -16 },
  { 159, 9, 19, 7, -2, -16 },
  { 181, 10, 11, 11, 2, -17 },
  { 195, 10, 11, 12, 1, -13 },
  { 209, 5, 6, 6, -1, -3 },
  { 213, 7, 3, 7, 0, -7 },
  { 216, 4, 4, 6, 0, -4 },
  { 218, 12, 16, 9, -1, -16 },
  { 242, 10, 16, 11, 1, -16 },
  { 262, 9, 16, 12, 2, -16 },
  { 280, 12, 16, 11, -1, -16 },
  { 304, 11, 16, 11, 0, -16 },
  { 326, 11, 16, 12, 0, -16 },
  { 348, 12, 16, 11, 0, -16 },
  { 372, 11, 16, 11, 1, -16 },
  { 394, 12, 16, 11, 1, -16 },
  { 418, 12, 16, 11, 0, -16 },
  { 442, 10, 16, 11, 1, -16 },
  { 462, 6, 12, 6, 0, -12 },
  { 471, 7, 15, 6, -1, -12 },
  { 485, 10, 12, 12, 1, -14 },
  { 500, 10, 7, 12, 1, -11 },
  { 509, 10, 12, 12, 1, -14 },
  { 524, 9, 16, 9, 1, -16 },
  { 542, 16, 18, 18, 1, -16 },
  { 578, 13, 16, 13, -1, -16 },
  { 604, 13, 16, 13, 0, -16 },
  { 630, 12, 16, 12, 1, -16 },
  { 654, 13, 16, 14, 0, -16 },
  { 680, 12, 16, 11, 0, -16 },
  { 704, 12, 16, 11, 0, -16 },
  { 728, 13, 16, 14, 1, -16 },
  { 754, 15, 16, 14, 0, -16 },
  { 784, 11, 16, 8, -1, -16 },
  { 806, 10, 21, 7, -3, -16 },
  { 833, 15, 16, 13, 0, -16 },
  { 863, 9, 16, 10, 0, -16 },
  { 881, 19, 16, 18, 0, -16 },
  { 919, 16, 16, 15, 0, -16 },
  { 951, 13, 16, 15, 1, -16 },
  { 977, 13, 16, 12, 0, -16 },
  { 1003, 13, 20, 15, 1, -16 },
  { 1036, 12, 16, 13, 0, -16 },
  { 1060, 11, 16, 11, 0, -16 },
  { 1082, 10, 16, 11, 2, -16 },
  { 1102, 13, 16, 14, 1, -16 },
  { 1128, 12, 16, 12, 2, -16 },
  { 1152, 19, 16, 19, 2, -16 },
  { 1190, 15, 16, 13, -1, -16 },
  { 1220, 12, 16, 12, 2, -16 },
  { 1244, 13, 16, 11, -1, -16 },
  { 1270, 10, 20, 7, -1, -16 },
  { 1295, 6, 16, 9, 2, -16 },
  { 1307, 10, 20, 7, -2, -16 },
  { 1332, 11, 10, 11, 0, -16 },
  { 1346, 9, 2, 9, -2, 2 },
  { 1349, 5, 4, 7, 3, -17 },
  { 1352, 11, 12, 12, 1, -12 },
  { 1369, 11, 17, 12, 0, -17 },
  { 1393, 9, 12, 10, 1, -12 },
  { 1407, 12, 17, 12, 1, -17 },
  { 1433, 10, 12, 11, 1, -12 },
  { 1448, 12, 22, 8, -2, -17 },
  { 1481, 12, 17, 12, 0, -12 },
  { 1507, 12, 17, 12, 0, -17 },
  { 1533, 7, 17, 6, 0, -17 },
  { 1548, 10, 22, 6, -3, -17 },
  { 1576, 13, 17, 12, 0, -17 },
  { 1604, 7, 17, 6, 0, -17 },
  { 1619, 18, 12, 18, 0, -12 },
  { 1646, 12, 12, 12, 0, -12 },
  { 1664, 10, 12, 12, 1, -12 },
  { 1679, 12, 17, 12, -1, -12 },
  { 1705, 11, 17, 12, 1, -12 },
  { 1729, 10, 12, 9, 0, -12 },
  { 1744, 10, 12, 10, 0, -12 },
  { 1759, 8, 15, 9, 1, -15 },
  { 1774, 11, 12, 12, 1, -12 },
  { 1791, 11, 12, 11, 1, -12 },
  { 1808, 17, 12, 16, 1, -12 },
  { 1834, 13, 12, 11, -1, -12 },
  { 1854, 13, 17, 11, -1, -12 },
  { 1882, 11, 12, 10, -1, -12 },
  { 1899, 9, 19, 8, 0, -16 },
  { 1921, 3, 22, 11, 4, -17 },
  { 1930, 9, 19, 8, -1, -16 },
  { 1952, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC22PT7B_H_
