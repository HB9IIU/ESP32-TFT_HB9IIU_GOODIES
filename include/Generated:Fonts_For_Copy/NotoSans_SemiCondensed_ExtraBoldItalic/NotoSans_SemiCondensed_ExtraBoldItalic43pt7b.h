#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x04, 0x00, 0x3F, 0x3F, 0xBF,
  0x9F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF1, 0xF8,
  0xF8, 0xFC, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0x7C, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x07, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0,
  0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0x71, 0xC1, 0xFD, 0xC1, 0x07, 0xE7, 0x00, 0x1F,
  0xDC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x06, 0x7E, 0x20, 0x19, 0xF8, 0xC0, 0xE7, 0xE3, 0xE3,
  0xBF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x03, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x03, 0xF7, 0xE0,
  0x7E, 0x01, 0xF1, 0xF0, 0x3E, 0x01, 0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0x7C,
  0x3F, 0x00, 0x7C, 0x7E, 0x1F, 0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x3F, 0x1F,
  0x1F, 0x80, 0x1F, 0x8F, 0x8F, 0x80, 0x0F, 0xCF, 0xCF, 0x87, 0x87, 0xE7,
  0xCF, 0xCF, 0xF3, 0xF7, 0xE7, 0xCF, 0xFC, 0xFF, 0xE7, 0xCF, 0xFE, 0x7F,
  0xF7, 0xEF, 0xFF, 0x9F, 0xF3, 0xE7, 0xC7, 0xC7, 0xE3, 0xE7, 0xE3, 0xE0,
  0x03, 0xF3, 0xE1, 0xF0, 0x01, 0xF1, 0xF1, 0xF8, 0x01, 0xF0, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x7C, 0x00, 0xF8, 0x7E, 0x3E, 0x00, 0xF8, 0x3E, 0x1F,
  0x00, 0xFC, 0x1F, 0x1F, 0x00, 0x7C, 0x0F, 0xDF, 0x80, 0x7C, 0x03, 0xFF,
  0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xC3, 0xF8, 0x7F, 0xF0, 0x7F, 0x1F, 0xFF, 0x0F, 0xC7, 0xFF,
  0xE3, 0xF9, 0xFF, 0xFE, 0xFE, 0x7F, 0x9F, 0xDF, 0xCF, 0xE1, 0xFF, 0xF1,
  0xFC, 0x3F, 0xFE, 0x3F, 0x83, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0xFE, 0x07,
  0xF8, 0x1F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x30, 0x7C, 0x03, 0x8F, 0x80, 0x7E, 0xF8, 0x07, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xBE, 0x07, 0xF3, 0xE0, 0x3F, 0x3F, 0x00,
  0xE3, 0xF0, 0x04, 0x1F, 0x00, 0x01, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F,
  0x0F, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81,
  0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0x7E, 0x7F, 0x7F, 0x1F, 0x3F, 0x87, 0x1F, 0x82,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xF8, 0x7F,
  0x80, 0xE0, 0x7F, 0x01, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x38, 0x1F, 0xC0, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0xC0, 0x0F, 0xF3, 0xE1, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xF0,
  0x1F, 0x9F, 0xC0, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0xFC,
  0x3F, 0x83, 0xE0, 0xFC, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x08, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0xC0,
  0x1F, 0xE1, 0xF1, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x7E, 0x07, 0xEF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0xFF, 0xDF, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x83, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF3, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xF9, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF9, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE7,
  0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFE, 0x07,
  0xF7, 0xF0, 0x7F, 0xBF, 0xC3, 0xFC, 0xFE, 0x3F, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFD, 0xFC, 0x1F, 0xCF, 0xC0, 0x10, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x86, 0x0F,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0x81, 0xFC, 0x40, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x07, 0xC1, 0xFF, 0xC7, 0xC7, 0xC1,
  0xFF, 0xE3, 0xE3, 0xE1, 0xFF, 0xF1, 0xF3, 0xE1, 0xF8, 0xF8, 0xF9, 0xF1,
  0xF8, 0xF8, 0x7D, 0xF0, 0xF8, 0x7C, 0x3E, 0xF8, 0xF8, 0x3E, 0x1F, 0x7C,
  0x7C, 0x1F, 0x0F, 0x3E, 0x3E, 0x1F, 0x0F, 0x9E, 0x3E, 0x0F, 0x87, 0xCF,
  0x1F, 0x07, 0xC3, 0xEF, 0x8F, 0x87, 0xE3, 0xE7, 0xC7, 0xC3, 0xF3, 0xF1,
  0xE1, 0xFF, 0xFF, 0xF0, 0xF0, 0xFF, 0xFF, 0xF0, 0x7C, 0x7F, 0xDF, 0xF0,
  0x3E, 0x1F, 0xC7, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x7F, 0xE7, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xDF, 0x00,
  0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xF8, 0x1C, 0x1F, 0xF0, 0x04, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x40, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xC7, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF8, 0x7F, 0x0F, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xE0, 0x7F, 0xC0, 0x08,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFF, 0xC7, 0xF0, 0xFF, 0xF3, 0xFC,
  0x3F, 0xF8, 0xFF, 0x0F, 0xFE, 0x3F, 0x83, 0xFF, 0x8F, 0xE1, 0xFF, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x03, 0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0x7C, 0x1F, 0x7F, 0x07, 0xEF, 0xC7, 0xEF, 0xC0,
  0xFD, 0xF8, 0xF9, 0xF8, 0x1F, 0xBF, 0x3F, 0x7F, 0x07, 0xF7, 0xE7, 0xCF,
  0xE0, 0xFC, 0xFD, 0xF9, 0xF8, 0x1F, 0x9F, 0xBE, 0x3F, 0x03, 0xF3, 0xFF,
  0xC7, 0xE0, 0x7E, 0x7F, 0xF1, 0xFC, 0x1F, 0xCF, 0xFE, 0x3F, 0x83, 0xF0,
  0xFF, 0xC7, 0xE0, 0x7E, 0x1F, 0xF0, 0xFC, 0x0F, 0xC3, 0xFE, 0x1F, 0x83,
  0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0x81, 0xFF, 0x80,
  0x7E, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xE0, 0x7F, 0xF0, 0x3F,
  0x83, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0,
  0xFF, 0xF8, 0x7F, 0x03, 0xF7, 0xE1, 0xFC, 0x1F, 0x9F, 0x87, 0xE0, 0x7E,
  0x7E, 0x1F, 0x81, 0xF9, 0xFC, 0x7E, 0x07, 0xE3, 0xF3, 0xF8, 0x1F, 0x8F,
  0xCF, 0xE0, 0xFE, 0x3F, 0x3F, 0x03, 0xF0, 0xFE, 0xFC, 0x0F, 0xC1, 0xFB,
  0xF0, 0x3F, 0x07, 0xEF, 0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xF0, 0x7F, 0xF8,
  0x1F, 0x80, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0x81, 0xF8, 0x0F, 0xFE, 0x0F,
  0xE0, 0x3F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xF0,
  0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFE,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xFC, 0x07,
  0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xCF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F,
  0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8,
  0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0xC3, 0xF8, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x1F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0x07, 0x03, 0xF8, 0x04, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x10, 0x07,
  0xF8, 0x70, 0x1F, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x0F, 0xEF, 0xC0,
  0x3F, 0x80, 0xFE, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x81, 0xFC,
  0xFC, 0x0F, 0xF8, 0x1F, 0xCF, 0xC0, 0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0xF8,
  0x3F, 0x8F, 0xC1, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0xF8, 0x7F, 0x0F, 0xC3,
  0xFF, 0x87, 0xE0, 0xFC, 0x3F, 0xF8, 0xFE, 0x0F, 0xC7, 0xFF, 0x8F, 0xE0,
  0xFC, 0x7D, 0xF8, 0xFC, 0x0F, 0xCF, 0xDF, 0x9F, 0xC0, 0xFC, 0xFD, 0xF9,
  0xF8, 0x0F, 0xCF, 0x9F, 0xBF, 0x80, 0xFD, 0xF9, 0xFB, 0xF0, 0x0F, 0xDF,
  0x1F, 0xBF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB,
  0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xC7, 0xE0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7F, 0x00, 0xFD,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE0,
  0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xDF,
  0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x3F, 0x9F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1E, 0x00, 0xF8,
  0x7E, 0x07, 0xF8, 0xF8, 0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8,
  0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F,
  0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC1, 0xFC, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x7F,
  0xFF, 0x01, 0xFB, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xF3, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0x3F, 0xE0, 0xFC,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x21, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x41, 0xFE, 0x38, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x7C, 0x7F, 0x00, 0xFF, 0x3F, 0x00, 0xFF, 0xDF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0x87,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xDF, 0x80, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x7F,
  0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF3, 0xF8, 0x7F, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x02, 0x1F, 0xC0, 0x60, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x04, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x01, 0xFF, 0x3E, 0x03, 0xFF, 0x7E, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x81,
  0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0x9F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xF7, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xCF,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x80, 0x3F,
  0xC0, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x7F,
  0x7F, 0x81, 0xFB, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFC, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0xC1, 0xFC,
  0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0xFE,
  0x0F, 0xE0, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7E, 0x1F, 0xE0,
  0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xCF, 0xE0,
  0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xDF,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x00, 0x07, 0xE3, 0xF0, 0x3E, 0x01, 0xF3, 0xFE, 0x3F, 0xE0, 0x7D, 0xFF,
  0x9F, 0xF8, 0x1F, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xF1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x7F, 0x07, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8,
  0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x07, 0xF1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0,
  0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x3F,
  0xE0, 0x7D, 0xFF, 0xC1, 0xF7, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0x01, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F, 0xF3, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0xF8, 0x01, 0xF3, 0xFC, 0x01, 0xF7,
  0xFE, 0x01, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFC,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xF3,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xBF,
  0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x7E, 0x07, 0xFC, 0xF8, 0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xEF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x87, 0x07,
  0xF0, 0x20, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x90, 0x0F, 0xE3, 0x81, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x30, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xC0, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81,
  0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE7, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x0F, 0xE3, 0xE0, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0xFE, 0x3F,
  0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC,
  0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x00, 0xFB,
  0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0x83,
  0xF7, 0xE1, 0xFF, 0x0F, 0xEF, 0xC3, 0xFE, 0x1F, 0x9F, 0x87, 0xFC, 0x7F,
  0x3F, 0x1F, 0xF8, 0xFE, 0x7E, 0x3F, 0xF1, 0xF8, 0xFC, 0xFB, 0xE7, 0xF1,
  0xF9, 0xF7, 0xCF, 0xC3, 0xF3, 0xEF, 0xBF, 0x87, 0xEF, 0x9F, 0x7E, 0x0F,
  0xDF, 0x3E, 0xFC, 0x1F, 0xFC, 0x7B, 0xF0, 0x3F, 0xF8, 0xF7, 0xE0, 0x7F,
  0xF3, 0xEF, 0xC0, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF,
  0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F,
  0x83, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x08, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xE8, 0x00, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 32, 12, 0, -31 },
  { 57, 17, 11, 19, 4, -31 },
  { 81, 26, 31, 26, 0, -31 },
  { 182, 22, 36, 22, 1, -33 },
  { 281, 33, 31, 36, 2, -31 },
  { 409, 27, 31, 28, 1, -31 },
  { 514, 8, 11, 11, 4, -31 },
  { 525, 16, 38, 14, 1, -31 },
  { 601, 16, 38, 14, -3, -31 },
  { 677, 20, 20, 22, 3, -33 },
  { 727, 20, 21, 23, 2, -26 },
  { 780, 10, 11, 12, -2, -5 },
  { 794, 12, 5, 14, 1, -14 },
  { 802, 8, 8, 12, 0, -7 },
  { 810, 23, 31, 18, -2, -31 },
  { 900, 21, 31, 22, 1, -31 },
  { 982, 17, 31, 22, 4, -31 },
  { 1048, 23, 31, 22, -1, -31 },
  { 1138, 22, 31, 22, 0, -31 },
  { 1224, 22, 31, 22, 0, -31 },
  { 1310, 23, 31, 22, 0, -31 },
  { 1400, 21, 31, 22, 2, -31 },
  { 1482, 24, 31, 22, 1, -31 },
  { 1575, 22, 31, 22, 1, -31 },
  { 1661, 21, 31, 22, 1, -31 },
  { 1743, 12, 25, 12, 0, -24 },
  { 1781, 14, 30, 12, -2, -24 },
  { 1834, 20, 23, 23, 2, -27 },
  { 1892, 20, 14, 23, 2, -22 },
  { 1927, 20, 23, 23, 2, -27 },
  { 1985, 18, 32, 18, 2, -31 },
  { 2057, 33, 35, 34, 1, -31 },
  { 2202, 26, 31, 26, -3, -31 },
  { 2303, 24, 31, 25, 1, -31 },
  { 2396, 24, 31, 24, 2, -31 },
  { 2489, 25, 31, 27, 1, -31 },
  { 2586, 22, 31, 21, 1, -31 },
  { 2672, 22, 31, 21, 1, -31 },
  { 2758, 26, 31, 27, 2, -31 },
  { 2859, 28, 31, 28, 1, -31 },
  { 2968, 21, 31, 16, -2, -31 },
  { 3050, 21, 40, 14, -7, -31 },
  { 3155, 28, 31, 25, 1, -31 },
  { 3264, 17, 31, 20, 1, -31 },
  { 3330, 35, 31, 36, 1, -31 },
  { 3466, 30, 31, 30, 1, -31 },
  { 3583, 26, 31, 29, 2, -31 },
  { 3684, 24, 31, 24, 1, -31 },
  { 3777, 26, 38, 29, 2, -31 },
  { 3901, 23, 31, 25, 1, -31 },
  { 3991, 22, 31, 21, 0, -31 },
  { 4077, 21, 31, 21, 3, -31 },
  { 4159, 26, 31, 27, 2, -31 },
  { 4260, 24, 31, 24, 4, -31 },
  { 4353, 36, 31, 36, 4, -31 },
  { 4493, 31, 31, 25, -3, -31 },
  { 4614, 23, 31, 23, 4, -31 },
  { 4704, 26, 31, 21, -2, -31 },
  { 4805, 18, 38, 14, -1, -31 },
  { 4891, 10, 31, 18, 5, -31 },
  { 4930, 18, 38, 14, -3, -31 },
  { 5016, 21, 20, 22, 0, -31 },
  { 5069, 18, 4, 17, -4, 3 },
  { 5078, 9, 7, 14, 6, -33 },
  { 5086, 23, 24, 24, 1, -24 },
  { 5155, 22, 33, 24, 0, -33 },
  { 5246, 19, 24, 19, 1, -24 },
  { 5303, 25, 33, 24, 1, -33 },
  { 5407, 21, 24, 22, 1, -24 },
  { 5470, 25, 43, 15, -5, -33 },
  { 5605, 24, 34, 24, 0, -24 },
  { 5707, 22, 33, 24, 0, -33 },
  { 5798, 14, 33, 12, 0, -33 },
  { 5856, 19, 43, 12, -5, -33 },
  { 5959, 25, 33, 23, 0, -33 },
  { 6063, 14, 33, 12, 0, -33 },
  { 6121, 34, 24, 36, 0, -24 },
  { 6223, 22, 24, 24, 0, -24 },
  { 6289, 21, 24, 23, 1, -24 },
  { 6352, 24, 34, 24, -2, -24 },
  { 6454, 23, 34, 24, 1, -24 },
  { 6552, 19, 24, 17, 0, -24 },
  { 6609, 19, 24, 19, 0, -24 },
  { 6666, 16, 29, 17, 2, -29 },
  { 6724, 22, 24, 24, 2, -24 },
  { 6790, 21, 24, 21, 2, -24 },
  { 6853, 31, 24, 32, 3, -24 },
  { 6946, 26, 24, 22, -2, -24 },
  { 7024, 27, 34, 21, -3, -24 },
  { 7139, 21, 24, 19, -1, -24 },
  { 7202, 18, 38, 15, 0, -31 },
  { 7288, 5, 43, 21, 8, -33 },
  { 7315, 17, 38, 15, -2, -31 },
  { 7396, 20, 8, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC43PT7B_H_
