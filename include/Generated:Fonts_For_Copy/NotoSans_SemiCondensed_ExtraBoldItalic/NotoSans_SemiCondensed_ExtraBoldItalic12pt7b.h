#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x66, 0x0C, 0xC0, 0x5E, 0xB5, 0x20, 0x16, 0x2C, 0x53,
  0xF2, 0xDF, 0xFF, 0xAC, 0x50, 0x08, 0xF7, 0x5C, 0x38, 0x79, 0xFE, 0x20,
  0x80, 0x63, 0x79, 0x2D, 0x17, 0x8E, 0xB6, 0xAC, 0xD6, 0x4A, 0x47, 0x00,
  0x18, 0x3C, 0x24, 0x3C, 0x3B, 0x7E, 0xDE, 0xFC, 0x7E, 0x7E, 0x19, 0x88,
  0xC4, 0x23, 0x18, 0xC2, 0x18, 0x30, 0x86, 0x31, 0x88, 0x46, 0x23, 0x30,
  0x37, 0x1E, 0xED, 0x00, 0x21, 0x3E, 0x42, 0x10, 0x6B, 0x00, 0xFE, 0xF0,
  0x06, 0x08, 0x30, 0x41, 0x86, 0x0C, 0x30, 0xC0, 0x18, 0xF6, 0xDB, 0x4F,
  0x3C, 0xFE, 0x70, 0x19, 0xFC, 0xE3, 0x18, 0xCC, 0x60, 0x19, 0xF4, 0xC3,
  0x18, 0xC6, 0x3E, 0xF8, 0x39, 0xF0, 0xC3, 0x30, 0x60, 0xFE, 0xF0, 0x0C,
  0x31, 0xCF, 0x6B, 0x6F, 0xC6, 0x18, 0x3C, 0xF2, 0x1C, 0x78, 0x30, 0xFE,
  0xF0, 0x0C, 0xF6, 0x1E, 0x7F, 0xBC, 0xDE, 0x78, 0x7E, 0xFC, 0x30, 0x61,
  0x86, 0x0C, 0x30, 0xE0, 0x18, 0xF6, 0xDB, 0x39, 0xEC, 0xF6, 0x78, 0x19,
  0xF6, 0xDB, 0x7D, 0xF1, 0xAE, 0xF0, 0x2C, 0x01, 0xB0, 0x13, 0x00, 0x00,
  0x64, 0xC0, 0x1B, 0xB1, 0xC3, 0x84, 0xF8, 0x3F, 0xF0, 0x87, 0x06, 0xFC,
  0x40, 0x77, 0x86, 0x66, 0x60, 0x18, 0xC0, 0x06, 0x0F, 0xC8, 0x29, 0xD5,
  0x2E, 0xB7, 0x5E, 0xB6, 0x62, 0x1F, 0x00, 0x0E, 0x1C, 0x78, 0xF3, 0x66,
  0xDF, 0xB3, 0xE6, 0x38, 0x7C, 0x9B, 0x37, 0x8D, 0x9B, 0x7E, 0xF8, 0x19,
  0xFE, 0x70, 0xC3, 0x0C, 0x3E, 0xF8, 0x38, 0x7C, 0x9B, 0x36, 0x6C, 0xDB,
  0xFE, 0xF8, 0x3C, 0xF2, 0x19, 0x79, 0x86, 0x3E, 0xF8, 0x3C, 0xF2, 0x18,
  0x79, 0xE6, 0x30, 0xC0, 0x1C, 0xFF, 0x86, 0x0D, 0xDB, 0xB3, 0x7C, 0x78,
  0x33, 0x33, 0x23, 0x66, 0x7E, 0x66, 0x66, 0xC4, 0xCC, 0x7B, 0xCC, 0x62,
  0x31, 0x8C, 0xF0, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x86, 0x30, 0xCF, 0x30,
  0x33, 0x36, 0x2C, 0x6C, 0x78, 0x78, 0x6C, 0xCC, 0xCC, 0x31, 0x88, 0xC6,
  0x31, 0x9F, 0xF8, 0x31, 0xCE, 0x73, 0x9D, 0xEE, 0x7B, 0x9F, 0xE5, 0xDB,
  0x76, 0xD9, 0x00, 0x31, 0x98, 0x8E, 0xCF, 0x67, 0xB3, 0x59, 0x39, 0x9C,
  0xCE, 0x00, 0x18, 0xFB, 0x9E, 0x3C, 0x79, 0xF3, 0x7E, 0x78, 0x38, 0x7C,
  0x9B, 0x37, 0xCF, 0x18, 0x60, 0xC0, 0x18, 0xFB, 0x9E, 0x3C, 0x79, 0xB3,
  0x7E, 0x78, 0x30, 0x60, 0x38, 0x78, 0x9B, 0x37, 0xCF, 0x1E, 0x66, 0xCC,
  0x18, 0xF6, 0x18, 0x38, 0x61, 0xBE, 0xF0, 0xFF, 0xF3, 0x18, 0x61, 0x86,
  0x18, 0xC0, 0x66, 0xCF, 0x36, 0x6C, 0xD9, 0xB3, 0x7C, 0xF0, 0xC7, 0x9B,
  0x36, 0xCD, 0x9E, 0x3C, 0x70, 0xE0, 0xCC, 0xF3, 0x3D, 0xDB, 0x76, 0xDD,
  0x3F, 0xCE, 0xF3, 0xB8, 0xCE, 0x00, 0x31, 0x8D, 0x87, 0x83, 0xC1, 0xC0,
  0xE0, 0xF0, 0xCC, 0xE6, 0x00, 0xCF, 0x35, 0x9E, 0x71, 0x86, 0x18, 0x60,
  0x7E, 0xF8, 0x30, 0xC3, 0x0E, 0x18, 0x7C, 0xF8, 0x39, 0x98, 0xC6, 0x21,
  0x18, 0xC6, 0x38, 0xD9, 0x24, 0xDB, 0x60, 0x39, 0xC6, 0x31, 0x08, 0xC6,
  0x21, 0x38, 0x08, 0x63, 0x8A, 0x4F, 0x30, 0xF8, 0xD0, 0x36, 0xF9, 0xB3,
  0x6C, 0xDF, 0x9A, 0x00, 0x30, 0xC6, 0x9F, 0x6D, 0xB4, 0xFF, 0xF8, 0x1D,
  0xE6, 0x10, 0xC3, 0xE7, 0x80, 0x06, 0x0C, 0xDB, 0xE6, 0xC9, 0xB3, 0x7C,
  0x68, 0x19, 0xF6, 0xDE, 0xC1, 0xA7, 0x80, 0x1E, 0x30, 0x71, 0xE3, 0x06,
  0x0C, 0x18, 0x60, 0xC3, 0x86, 0x00, 0x36, 0xF9, 0xB3, 0x6C, 0xDF, 0x9E,
  0x0C, 0xF9, 0xE0, 0x30, 0xC6, 0xDF, 0x6D, 0xB4, 0xF3, 0xD8, 0x32, 0x66,
  0x66, 0x6C, 0xC0, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xCF, 0x38,
  0x30, 0x61, 0x9B, 0x67, 0x8F, 0x1E, 0x6C, 0xCC, 0x33, 0x66, 0x66, 0x4C,
  0xC0, 0x6D, 0x9F, 0xF6, 0xCD, 0xB6, 0x4D, 0xB3, 0x6D, 0x98, 0x6D, 0xF6,
  0xDB, 0x4F, 0x3D, 0x80, 0x19, 0xF6, 0xD3, 0xCD, 0xE7, 0x80, 0x34, 0x7C,
  0xD9, 0xB2, 0x6F, 0xDF, 0x30, 0x61, 0x80, 0x36, 0xF9, 0xB2, 0x6C, 0xDF,
  0x9E, 0x0C, 0x18, 0x30, 0x6B, 0xD8, 0xC6, 0x63, 0x00, 0x33, 0xD8, 0xE3,
  0xDF, 0xC0, 0x31, 0xFE, 0xC6, 0x31, 0xCE, 0x66, 0xC9, 0xB3, 0x64, 0xDF,
  0x9A, 0x00, 0x8F, 0x6D, 0x3C, 0xE3, 0x8C, 0x00, 0x99, 0xCD, 0xAE, 0xD5,
  0xCA, 0xE6, 0x63, 0x30, 0x37, 0x36, 0x1C, 0x18, 0x38, 0x6C, 0xEC, 0x33,
  0x36, 0x36, 0x3C, 0x3C, 0x38, 0x30, 0x30, 0xE0, 0xC0, 0x7B, 0xCE, 0x66,
  0x7B, 0xC0, 0x09, 0xCC, 0x66, 0x61, 0x8C, 0x43, 0x18, 0xFF, 0xFF, 0xFF,
  0x21, 0x86, 0x23, 0x0C, 0xC4, 0x27, 0x30, 0xFD, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 7, 9, 7, 0, -9 },
  { 17, 6, 10, 6, 0, -9 },
  { 25, 9, 9, 10, 1, -9 },
  { 36, 8, 9, 8, 0, -9 },
  { 45, 2, 4, 3, 1, -9 },
  { 46, 5, 11, 4, 0, -9 },
  { 53, 5, 11, 4, -1, -9 },
  { 60, 5, 5, 6, 1, -9 },
  { 64, 5, 6, 7, 1, -7 },
  { 68, 3, 3, 3, -1, -1 },
  { 70, 4, 2, 4, 0, -4 },
  { 71, 2, 2, 3, 0, -2 },
  { 72, 7, 9, 5, -1, -9 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 5, 9, 6, 1, -9 },
  { 93, 6, 9, 6, 0, -9 },
  { 100, 6, 9, 6, 0, -9 },
  { 107, 6, 9, 6, 0, -9 },
  { 114, 6, 9, 6, 0, -9 },
  { 121, 6, 9, 6, 0, -9 },
  { 128, 7, 9, 6, 0, -9 },
  { 136, 6, 9, 6, 0, -9 },
  { 143, 6, 9, 6, 0, -9 },
  { 150, 3, 7, 3, 0, -7 },
  { 153, 4, 9, 3, -1, -7 },
  { 158, 5, 6, 7, 1, -7 },
  { 162, 5, 4, 7, 1, -6 },
  { 165, 5, 6, 7, 1, -7 },
  { 169, 5, 9, 5, 1, -9 },
  { 175, 9, 10, 10, 0, -9 },
  { 187, 7, 9, 7, -1, -9 },
  { 195, 7, 9, 7, 0, -9 },
  { 203, 6, 9, 7, 1, -9 },
  { 210, 7, 9, 7, 0, -9 },
  { 218, 6, 9, 6, 0, -9 },
  { 225, 6, 9, 6, 0, -9 },
  { 232, 7, 9, 8, 1, -9 },
  { 240, 8, 9, 8, 0, -9 },
  { 249, 5, 9, 5, 0, -9 },
  { 255, 6, 12, 4, -2, -9 },
  { 264, 8, 9, 7, 0, -9 },
  { 273, 5, 9, 6, 0, -9 },
  { 279, 10, 9, 10, 0, -9 },
  { 291, 9, 9, 8, 0, -9 },
  { 302, 7, 9, 8, 1, -9 },
  { 310, 7, 9, 7, 0, -9 },
  { 318, 7, 11, 8, 1, -9 },
  { 328, 7, 9, 7, 0, -9 },
  { 336, 6, 9, 6, 0, -9 },
  { 343, 6, 9, 6, 1, -9 },
  { 350, 7, 9, 8, 1, -9 },
  { 358, 7, 9, 7, 1, -9 },
  { 366, 10, 9, 10, 1, -9 },
  { 378, 9, 9, 7, -1, -9 },
  { 389, 6, 9, 6, 1, -9 },
  { 396, 7, 9, 6, 0, -9 },
  { 404, 5, 11, 4, 0, -9 },
  { 411, 3, 9, 5, 1, -9 },
  { 415, 5, 11, 4, -1, -9 },
  { 422, 6, 6, 6, 0, -9 },
  { 427, 5, 1, 5, -1, 1 },
  { 428, 2, 2, 4, 2, -9 },
  { 429, 7, 7, 7, 0, -7 },
  { 436, 6, 9, 7, 0, -9 },
  { 443, 6, 7, 5, 0, -7 },
  { 449, 7, 9, 7, 0, -9 },
  { 457, 6, 7, 6, 0, -7 },
  { 463, 7, 12, 4, -1, -9 },
  { 474, 7, 10, 7, 0, -7 },
  { 483, 6, 9, 7, 0, -9 },
  { 490, 4, 9, 3, 0, -9 },
  { 495, 6, 12, 3, -2, -9 },
  { 504, 7, 9, 6, 0, -9 },
  { 512, 4, 9, 3, 0, -9 },
  { 517, 10, 7, 10, 0, -7 },
  { 526, 6, 7, 7, 0, -7 },
  { 532, 6, 7, 7, 0, -7 },
  { 538, 7, 10, 7, -1, -7 },
  { 547, 7, 10, 7, 0, -7 },
  { 556, 5, 7, 5, 0, -7 },
  { 561, 5, 7, 5, 0, -7 },
  { 566, 5, 8, 5, 0, -8 },
  { 571, 7, 7, 7, 0, -7 },
  { 578, 6, 7, 6, 1, -7 },
  { 584, 9, 7, 9, 1, -7 },
  { 592, 8, 7, 6, -1, -7 },
  { 599, 8, 10, 6, -1, -7 },
  { 609, 5, 7, 5, 0, -7 },
  { 614, 5, 11, 4, 0, -9 },
  { 621, 2, 12, 6, 2, -9 },
  { 624, 5, 11, 4, -1, -9 },
  { 631, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC12PT7B_H_
