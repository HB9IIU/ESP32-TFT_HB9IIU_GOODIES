#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0xB0, 0xFA, 0x3C, 0xA7, 0xCE, 0xFD, 0x47, 0x00, 0x11,
  0xDE, 0xC3, 0x1F, 0xEC, 0x40, 0xE5, 0x52, 0xE6, 0xF2, 0xAD, 0x73, 0x00,
  0x38, 0xD0, 0xE3, 0xBD, 0xDB, 0x1F, 0x00, 0xE0, 0x36, 0x44, 0xCC, 0xCC,
  0x40, 0x31, 0x11, 0x32, 0x24, 0xC0, 0x2A, 0xFE, 0xB0, 0x21, 0x3E, 0x42,
  0x00, 0x78, 0xE0, 0x70, 0x18, 0x88, 0xC4, 0x62, 0x00, 0x3B, 0x53, 0xBD,
  0xE9, 0xC0, 0x3E, 0xA6, 0x66, 0x40, 0x7A, 0xC6, 0x66, 0x63, 0xC0, 0x7A,
  0xC6, 0xE1, 0xCF, 0xC0, 0x19, 0xCE, 0xAF, 0xFC, 0xC0, 0x3B, 0x1C, 0xF1,
  0xCB, 0xC0, 0x3B, 0x15, 0xFD, 0xED, 0xC0, 0x7C, 0x61, 0x8C, 0x21, 0x8C,
  0x00, 0x3B, 0x5E, 0xED, 0xED, 0xC0, 0x7A, 0xD6, 0xF5, 0x9B, 0x80, 0x4C,
  0x05, 0x80, 0x23, 0x00, 0x06, 0xC0, 0x09, 0xB0, 0x70, 0x80, 0xF8, 0x3E,
  0xC3, 0x86, 0xEC, 0x00, 0xEB, 0x6C, 0x88, 0x80, 0x3E, 0x63, 0x5D, 0xF5,
  0xAE, 0xF6, 0x44, 0x38, 0x0C, 0x51, 0x4D, 0x3D, 0x9C, 0x40, 0x79, 0xB6,
  0x9E, 0x4B, 0x6F, 0x00, 0x3D, 0x96, 0x10, 0xC1, 0xA7, 0x80, 0x79, 0xB6,
  0xD3, 0x4F, 0x6F, 0x00, 0x7B, 0x1A, 0xE4, 0x63, 0xC0, 0x7B, 0x18, 0xF4,
  0x63, 0x00, 0x3D, 0x96, 0x17, 0xCD, 0xA7, 0x80, 0x66, 0xC9, 0xB3, 0xE4,
  0xD9, 0x32, 0x00, 0x72, 0x66, 0x64, 0xE0, 0x08, 0xC6, 0x31, 0x08, 0xC6,
  0xE0, 0x6E, 0xD1, 0xE3, 0x85, 0x1B, 0x36, 0x00, 0x66, 0x64, 0x4C, 0xF0,
  0x73, 0x77, 0x57, 0x57, 0x5A, 0xDA, 0xD6, 0x72, 0xED, 0x5A, 0xA5, 0xDB,
  0xB3, 0x00, 0x3D, 0x96, 0x51, 0xCD, 0x37, 0x80, 0x79, 0xB6, 0xDE, 0x63,
  0x0C, 0x00, 0x3D, 0x96, 0x51, 0xCD, 0x37, 0x86, 0x18, 0x79, 0xB6, 0xDE,
  0x53, 0x6D, 0x80, 0x7B, 0x58, 0x61, 0x4B, 0xC0, 0xFB, 0x18, 0x84, 0x63,
  0x00, 0xCF, 0x2D, 0xA6, 0x9A, 0xCF, 0x00, 0x9C, 0xF5, 0xEE, 0x73, 0x00,
  0x9B, 0x9B, 0xBA, 0xBE, 0xFC, 0xDC, 0xDC, 0x36, 0x28, 0x70, 0xC3, 0x8D,
  0xBB, 0x00, 0xDE, 0xBC, 0xC4, 0x23, 0x00, 0x7C, 0x63, 0x08, 0x63, 0x0F,
  0x00, 0x76, 0x44, 0x4C, 0xC8, 0xC0, 0xBD, 0x54, 0x38, 0x84, 0x63, 0x10,
  0x84, 0xE0, 0x11, 0x9D, 0x90, 0xF0, 0xCC, 0x23, 0xD7, 0xBD, 0xB8, 0x23,
  0x1C, 0xF4, 0xAF, 0x7E, 0x3B, 0x91, 0x8D, 0x38, 0x0C, 0x32, 0x9E, 0x4B,
  0x6D, 0x9C, 0x13, 0xD7, 0xEC, 0xB8, 0x0C, 0x63, 0x1E, 0x30, 0x82, 0x18,
  0x63, 0x00, 0x23, 0xD7, 0xBD, 0xB8, 0x5E, 0x23, 0x1C, 0xF4, 0xAF, 0x7B,
  0x2C, 0x34, 0xB6, 0x13, 0x03, 0x22, 0x66, 0x6C, 0x21, 0x86, 0x5E, 0x71,
  0xCD, 0x36, 0x2D, 0xB4, 0xB6, 0x12, 0x7F, 0x4B, 0x5B, 0xDA, 0xDA, 0x13,
  0xD2, 0xBD, 0xEC, 0x33, 0xD3, 0xBD, 0xB8, 0x13, 0xD2, 0xBD, 0xFB, 0x10,
  0x23, 0xD3, 0xBD, 0xB8, 0x46, 0x17, 0x64, 0xCC, 0x27, 0x67, 0xBE, 0x22,
  0xF4, 0x4C, 0x60, 0x6D, 0x25, 0xB6, 0x70, 0xBA, 0xEC, 0xC0, 0xB7, 0x6B,
  0x76, 0xCD, 0x80, 0x3E, 0x70, 0xE1, 0xCE, 0x80, 0x2C, 0xA3, 0x8C, 0x30,
  0x8E, 0x00, 0x79, 0x99, 0x8F, 0x00, 0x32, 0x66, 0xC4, 0x46, 0x20, 0xFF,
  0xC0, 0x31, 0x8C, 0x73, 0x11, 0x9C, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 4, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 7, 7, 8, 1, -7 },
  { 24, 7, 7, 7, 0, -7 },
  { 31, 2, 2, 2, 1, -7 },
  { 32, 4, 9, 3, 0, -7 },
  { 37, 4, 9, 3, -1, -7 },
  { 42, 4, 5, 5, 1, -8 },
  { 45, 5, 5, 5, 0, -6 },
  { 49, 3, 2, 3, -1, -1 },
  { 50, 3, 1, 3, 0, -3 },
  { 51, 2, 2, 3, 0, -2 },
  { 52, 5, 7, 4, 0, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 6, 7, 5, 0, -7 },
  { 97, 5, 7, 5, 0, -7 },
  { 102, 5, 7, 5, 0, -7 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 4, 7, 3, -1, -6 },
  { 114, 5, 5, 5, 0, -6 },
  { 118, 5, 3, 5, 0, -5 },
  { 120, 5, 5, 5, 0, -6 },
  { 124, 4, 7, 4, 1, -7 },
  { 128, 8, 8, 8, 0, -7 },
  { 136, 6, 7, 6, -1, -7 },
  { 142, 6, 7, 6, 0, -7 },
  { 148, 6, 7, 6, 0, -7 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 5, 7, 5, 0, -7 },
  { 165, 5, 7, 5, 0, -7 },
  { 170, 6, 7, 6, 0, -7 },
  { 176, 7, 7, 6, 0, -7 },
  { 183, 4, 7, 4, 0, -7 },
  { 187, 5, 9, 3, -2, -7 },
  { 193, 7, 7, 6, 0, -7 },
  { 200, 4, 7, 5, 0, -7 },
  { 204, 8, 7, 8, 0, -7 },
  { 211, 7, 7, 7, 0, -7 },
  { 218, 6, 7, 7, 0, -7 },
  { 224, 6, 7, 6, 0, -7 },
  { 230, 6, 9, 7, 0, -7 },
  { 237, 6, 7, 6, 0, -7 },
  { 243, 5, 7, 5, 0, -7 },
  { 248, 5, 7, 5, 1, -7 },
  { 253, 6, 7, 6, 1, -7 },
  { 259, 5, 7, 6, 1, -7 },
  { 264, 8, 7, 8, 1, -7 },
  { 271, 7, 7, 6, -1, -7 },
  { 278, 5, 7, 5, 1, -7 },
  { 283, 6, 7, 5, 0, -7 },
  { 289, 4, 9, 3, 0, -7 },
  { 294, 2, 7, 4, 1, -7 },
  { 296, 5, 9, 3, -1, -7 },
  { 302, 5, 4, 5, 0, -7 },
  { 305, 4, 1, 4, -1, 1 },
  { 306, 3, 2, 3, 1, -8 },
  { 307, 5, 6, 6, 0, -6 },
  { 311, 5, 8, 6, 0, -8 },
  { 316, 5, 6, 5, 0, -6 },
  { 320, 6, 8, 6, 0, -8 },
  { 326, 5, 6, 5, 0, -6 },
  { 330, 6, 10, 4, -1, -8 },
  { 338, 5, 8, 6, 0, -6 },
  { 343, 5, 8, 6, 0, -8 },
  { 348, 3, 8, 3, 0, -8 },
  { 351, 4, 10, 3, -1, -8 },
  { 356, 6, 8, 5, 0, -8 },
  { 362, 3, 8, 3, 0, -8 },
  { 365, 8, 6, 8, 0, -6 },
  { 371, 5, 6, 6, 0, -6 },
  { 375, 5, 6, 5, 0, -6 },
  { 379, 5, 8, 6, 0, -6 },
  { 384, 5, 8, 6, 0, -6 },
  { 389, 4, 6, 4, 0, -6 },
  { 392, 4, 6, 4, 0, -6 },
  { 395, 4, 7, 4, 0, -7 },
  { 399, 6, 5, 6, 0, -5 },
  { 403, 4, 5, 5, 1, -5 },
  { 406, 7, 5, 7, 1, -5 },
  { 411, 7, 5, 5, -1, -5 },
  { 416, 6, 7, 5, -1, -5 },
  { 422, 5, 5, 4, 0, -5 },
  { 426, 4, 9, 4, 0, -7 },
  { 431, 1, 10, 5, 2, -8 },
  { 433, 5, 9, 4, -1, -7 },
  { 439, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC10PT7B_H_
