#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0xFB,
  0xFC, 0xEF, 0x3B, 0x9E, 0xE7, 0xB9, 0xCE, 0x70, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0xE7, 0x80, 0x73, 0x80, 0x39, 0xC9, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x0F, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF0, 0x73, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x1E, 0x70,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x1F, 0xF1, 0xFF, 0x9F, 0xF8, 0xF6,
  0x47, 0xA0, 0x3F, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x03, 0xF8,
  0x1B, 0xD0, 0xDE, 0xF7, 0xE7, 0xFF, 0x3F, 0xF0, 0xFE, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x20, 0xFC, 0x0E, 0x0F, 0xE0, 0xF0, 0x77,
  0x07, 0x07, 0xBC, 0x70, 0x39, 0xE7, 0x81, 0xCE, 0x38, 0x0E, 0x73, 0x80,
  0xF3, 0xBD, 0xE3, 0xB9, 0xDF, 0x9F, 0xDD, 0xFE, 0xFD, 0xEE, 0x70, 0x8E,
  0xF3, 0x80, 0xE7, 0x3C, 0x0E, 0x39, 0xE0, 0x71, 0xCE, 0x07, 0x0E, 0x70,
  0x70, 0x7F, 0x83, 0x83, 0xF8, 0x38, 0x0F, 0x80, 0x00, 0x60, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF9, 0xF1, 0xFC, 0x78, 0xFF, 0x9E, 0x7D,
  0xEF, 0x1E, 0x7F, 0xCF, 0x8F, 0xE3, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFE, 0x7C, 0xFF, 0xBD, 0xCE, 0x73, 0x80, 0x03, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x06, 0x00,
  0x78, 0x07, 0x86, 0x70, 0x7F, 0x0F, 0xFF, 0x3F, 0xF1, 0xFF, 0x3F, 0x87,
  0xB8, 0x7B, 0xC3, 0x3C, 0x01, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x3D, 0xF7, 0x9E, 0xF3, 0xCE, 0x00, 0x7F, 0x7F,
  0x7E, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0x01, 0x00, 0x3F, 0x03, 0xFC, 0x3F, 0xF3, 0xEF,
  0x9E, 0x3D, 0xF1, 0xEF, 0x0F, 0x78, 0x7F, 0xC7, 0xFC, 0x3F, 0xE1, 0xEF,
  0x0F, 0x78, 0xFB, 0xC7, 0xDE, 0x3C, 0xFB, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E,
  0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x1F, 0xEF, 0xFC, 0xF7, 0x9D, 0xF1, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x40, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0,
  0xF3, 0xE0, 0x87, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x87,
  0xFF, 0x0C, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xA0, 0x3C, 0xE3, 0xF3,
  0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF8, 0x1F, 0xE0, 0x77, 0x83, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3, 0x8F,
  0x1C, 0x7C, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC8, 0x1F, 0x3C, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xF8,
  0x00, 0x00, 0x70, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x60, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0x3E, 0x3C, 0xF8, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xFB, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xD0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xC0,
  0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDE,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xFC, 0x7C, 0xF1, 0xE3, 0xE7, 0x87,
  0xBE, 0x1E, 0x78, 0xF1, 0xFF, 0xC7, 0xFE, 0x07, 0xF0, 0x03, 0x00, 0x7F,
  0x07, 0xFC, 0x7F, 0xE7, 0xCF, 0xBC, 0x7D, 0xE3, 0xEF, 0x1F, 0x78, 0xFB,
  0xCF, 0xDF, 0xFC, 0xFF, 0xE3, 0xEF, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x8F,
  0xC7, 0xFC, 0x3F, 0xC1, 0xF8, 0x00, 0x0E, 0x3C, 0xF8, 0xF0, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xCF, 0x9F, 0x3C, 0x00, 0x03, 0x83, 0xC3, 0xE0,
  0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xE0,
  0xF0, 0x78, 0x78, 0x38, 0x3C, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x03, 0xF8, 0xFF,
  0x1F, 0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x06, 0x0F, 0xF3, 0xFF, 0x3F,
  0xE6, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0x83, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0x73,
  0x8F, 0xF7, 0x79, 0xFE, 0x77, 0x3C, 0xE7, 0x73, 0x8E, 0x7E, 0x79, 0xE7,
  0xE7, 0x1C, 0x7E, 0x71, 0xC7, 0xE7, 0x3C, 0xEE, 0x7B, 0xDE, 0xE7, 0xFF,
  0xCE, 0x3C, 0xF0, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x1C, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xEE, 0x01, 0xEF, 0x03, 0xCF, 0x03, 0xCF, 0x07, 0xCF, 0x07, 0x8F,
  0x0F, 0x8F, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x0F,
  0x3C, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0x3F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x1F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0x7C, 0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C,
  0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x60, 0x07, 0xFC,
  0x3F, 0xF8, 0xFF, 0xF1, 0xF8, 0xC7, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7E, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0x3F, 0x1F, 0x1F, 0x1F, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x80,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x86, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0xFE, 0xF8, 0xFE, 0xF8, 0xFE, 0xF9, 0xFE,
  0xF8, 0x3C, 0xF8, 0x3C, 0x78, 0x3C, 0x7E, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F,
  0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0xC3, 0xE1,
  0xE0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC0, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFC, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x7F,
  0x87, 0xFC, 0x3F, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xF8, 0x00, 0x0F, 0x87, 0xC3,
  0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0xF8, 0x1F, 0x3C, 0x07, 0x9F, 0x01, 0xEF,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3C, 0xF0, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0x78, 0x1E,
  0x1F, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0xFE, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x87, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1D, 0xC7, 0x78, 0x7B, 0x9E, 0xF0,
  0xF7, 0x3B, 0xE1, 0xEE, 0xF7, 0x83, 0xDF, 0xCF, 0x0F, 0x3F, 0x9E, 0x1E,
  0x7E, 0x3C, 0x3C, 0xFC, 0xF0, 0x79, 0xF1, 0xE0, 0xF3, 0xE3, 0xC3, 0xC7,
  0xC7, 0x80, 0x0F, 0xC1, 0xE1, 0xF8, 0x3C, 0x3F, 0x07, 0x87, 0xE0, 0xF1,
  0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1C, 0xF3, 0xC7,
  0x9E, 0xF0, 0xF3, 0xDE, 0x1E, 0x7B, 0xC3, 0xC7, 0xF8, 0xF0, 0xFF, 0x1E,
  0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x3F, 0x0F, 0x07, 0xE3, 0xC0, 0xF8, 0x00,
  0x00, 0x60, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF1, 0xF1, 0xF0,
  0x78, 0xF0, 0x3C, 0xF8, 0x1F, 0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDF,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xF3, 0xE0, 0xF8, 0xF0, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x79, 0xF1, 0xF1, 0xE3, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x7E,
  0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x60, 0x01, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xE1, 0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1F,
  0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0,
  0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x79, 0xF1, 0xF1, 0xE3, 0xE3,
  0xC7, 0x8F, 0x8F, 0x1F, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83,
  0xCF, 0x0F, 0x9E, 0x1F, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xFB, 0xE1,
  0xF0, 0x00, 0x40, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x18, 0x78, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x20, 0x7C, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x0F, 0x8F, 0x07, 0x87,
  0x83, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0xC3,
  0xE3, 0xE1, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x1F, 0x1E,
  0x3C, 0x3C, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0xF0, 0x3C, 0x1F, 0xE0, 0xF8, 0x7B, 0xC1, 0xF0, 0xF7, 0x87, 0xE3, 0xEF,
  0x0F, 0xC7, 0x9E, 0x3F, 0x8F, 0x3C, 0x7F, 0x3C, 0x78, 0xFE, 0x78, 0xF3,
  0xFD, 0xE1, 0xE7, 0x7B, 0xC3, 0xDE, 0xF7, 0x87, 0xB9, 0xFE, 0x0F, 0xF3,
  0xBC, 0x1F, 0xE7, 0x70, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x3C,
  0x03, 0xC7, 0xC0, 0x3C, 0xF8, 0x03, 0xEF, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xC0, 0x0F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E,
  0x1E, 0x07, 0xC1, 0xE0, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0xF0, 0xF9, 0xE3,
  0xE3, 0xC7, 0x87, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFE, 0x10, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xE3, 0xCF, 0x3C,
  0xF1, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8F, 0x3C, 0xF3, 0xC7,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xF8, 0x39, 0xC3,
  0x8E, 0x3C, 0x79, 0xC1, 0xDE, 0x0F, 0xE0, 0x70, 0x7F, 0xF7, 0xFF, 0xFF,
  0xE0, 0xF3, 0xE7, 0x8E, 0x1C, 0x0F, 0x3C, 0x7E, 0xF3, 0xFF, 0x9F, 0xFE,
  0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F,
  0x3E, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xDE, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xEF, 0x07, 0xFE, 0x1F, 0xFC,
  0x7D, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0xDF, 0x1E,
  0x7C, 0xF9, 0xF7, 0xE7, 0xFF, 0x3F, 0xF8, 0xF7, 0xC0, 0x07, 0xE1, 0xFF,
  0x3F, 0xE7, 0xEE, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x98, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xCF, 0x0F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0xF1, 0xF1, 0xF7, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xDE, 0x00,
  0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x79, 0xF7, 0x87, 0xBC, 0x7B, 0xFF, 0xDF,
  0xFC, 0xFF, 0x87, 0x80, 0x3C, 0x01, 0xF0, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0x9E, 0x1F, 0xBC, 0x7F,
  0xF0, 0xFF, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xE3, 0xE3, 0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xBC, 0x00,
  0xF8, 0x01, 0xE1, 0x07, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xEF, 0x87,
  0xFF, 0x1F, 0xFC, 0x7D, 0xF3, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0xF1, 0xF3,
  0xC7, 0x9F, 0x1E, 0x78, 0x79, 0xE3, 0xE7, 0x8F, 0xBE, 0x3C, 0xF8, 0xF0,
  0x02, 0x07, 0xC3, 0xE1, 0xE0, 0x20, 0x00, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x80,
  0x00, 0x40, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E,
  0xF8, 0x3E, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x79, 0xE0, 0x79, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF0, 0xF8, 0x0F,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87,
  0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x80, 0x1E,
  0xF8, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xE3, 0xE7,
  0x9F, 0x1E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0x7B, 0xE3,
  0xC7, 0xDE, 0x1E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8F, 0x0F, 0x7C, 0x78, 0xFB,
  0xC3, 0xC7, 0xC0, 0x1E, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7, 0xDF, 0x3E, 0x3C,
  0xF8, 0xF3, 0xC3, 0xCF, 0x1F, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x3E,
  0x78, 0xFB, 0xE3, 0xCF, 0x8F, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x7D,
  0xF7, 0xCF, 0xBC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0xBC, 0x7D,
  0xF7, 0xCF, 0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0x0F, 0x78, 0x1F, 0xF8, 0x3F,
  0xF8, 0x7D, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3E,
  0x7C, 0x78, 0xF9, 0xF1, 0xF7, 0xE3, 0xFF, 0x8F, 0xFE, 0x1E, 0x78, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x0F,
  0x3C, 0x7E, 0xF3, 0xFF, 0x8F, 0xFE, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3E, 0xF8, 0xFF, 0xE1, 0xFF, 0x87,
  0xDE, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x00, 0x0F,
  0xC1, 0xFF, 0x3F, 0xE3, 0xC6, 0x3C, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7C, 0x03, 0xCC, 0x7C, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x0E, 0x03,
  0x81, 0xE0, 0xFF, 0x7F, 0xFF, 0xF3, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x0F, 0x93, 0xFC, 0x7F, 0x1F, 0xC0, 0x3C, 0x3C, 0xF1,
  0xF3, 0xC7, 0xDF, 0x1E, 0x7C, 0x79, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0xF8,
  0xF3, 0xC3, 0xCF, 0x1F, 0x3E, 0xFC, 0xFF, 0xE1, 0xFB, 0x87, 0xDE, 0x00,
  0xF8, 0x7D, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0xBE,
  0x1E, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0xF1, 0xF1, 0xFF, 0x1F, 0x1E, 0xF3, 0xF3, 0xEF, 0x3F,
  0x3C, 0xF7, 0x73, 0xCF, 0x77, 0x78, 0xF7, 0xF7, 0x8F, 0xEF, 0xF0, 0xEE,
  0xEF, 0x0E, 0xEE, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC0, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F,
  0x7C, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0xF8, 0xF8, 0x1F,
  0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0xFE, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xE0, 0x7C,
  0x1F, 0x83, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC3, 0xF0,
  0x78, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0xF8, 0x3F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x7E, 0x1F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x0F, 0xC1, 0xF8, 0x3E, 0x00,
  0x3C, 0x0F, 0xFD, 0xFF, 0xFF, 0x8F, 0xF8, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 19, 8, 0, -19 },
  { 23, 10, 7, 12, 3, -19 },
  { 32, 17, 19, 16, 0, -19 },
  { 73, 13, 23, 14, 1, -21 },
  { 111, 21, 20, 23, 1, -20 },
  { 164, 18, 20, 18, 0, -20 },
  { 209, 5, 7, 7, 3, -19 },
  { 214, 10, 24, 9, 1, -20 },
  { 244, 10, 24, 9, -2, -20 },
  { 274, 12, 13, 14, 2, -21 },
  { 294, 13, 13, 15, 1, -16 },
  { 316, 6, 7, 8, -1, -3 },
  { 322, 8, 4, 9, 0, -9 },
  { 326, 5, 4, 8, 0, -4 },
  { 329, 14, 20, 11, -1, -20 },
  { 364, 13, 20, 14, 1, -20 },
  { 397, 11, 19, 14, 2, -19 },
  { 424, 15, 20, 14, -1, -20 },
  { 462, 14, 20, 14, 0, -20 },
  { 497, 14, 19, 14, 0, -19 },
  { 531, 14, 19, 14, 0, -19 },
  { 565, 14, 20, 14, 1, -20 },
  { 600, 14, 19, 14, 1, -19 },
  { 634, 14, 20, 14, 0, -20 },
  { 669, 13, 20, 14, 1, -20 },
  { 702, 7, 15, 8, 0, -15 },
  { 716, 9, 19, 8, -2, -15 },
  { 738, 13, 14, 15, 1, -17 },
  { 761, 13, 9, 15, 1, -14 },
  { 776, 13, 14, 15, 1, -17 },
  { 799, 11, 20, 12, 2, -20 },
  { 827, 20, 21, 22, 1, -19 },
  { 880, 16, 19, 16, -2, -19 },
  { 918, 16, 19, 16, 0, -19 },
  { 956, 15, 20, 15, 1, -20 },
  { 994, 16, 19, 17, 0, -19 },
  { 1032, 15, 19, 13, 0, -19 },
  { 1068, 14, 19, 13, 0, -19 },
  { 1102, 16, 20, 17, 1, -20 },
  { 1142, 18, 19, 18, 0, -19 },
  { 1185, 13, 19, 10, -1, -19 },
  { 1216, 13, 25, 9, -4, -19 },
  { 1257, 18, 19, 16, 0, -19 },
  { 1300, 11, 19, 13, 0, -19 },
  { 1327, 23, 19, 22, 0, -19 },
  { 1382, 19, 19, 19, 0, -19 },
  { 1428, 17, 20, 18, 1, -20 },
  { 1471, 15, 19, 15, 0, -19 },
  { 1507, 17, 25, 18, 1, -20 },
  { 1561, 15, 19, 16, 0, -19 },
  { 1597, 14, 20, 13, 0, -20 },
  { 1632, 13, 19, 13, 2, -19 },
  { 1663, 17, 19, 17, 1, -19 },
  { 1704, 15, 19, 15, 2, -19 },
  { 1740, 23, 19, 23, 2, -19 },
  { 1795, 20, 19, 15, -2, -19 },
  { 1843, 15, 19, 14, 2, -19 },
  { 1879, 16, 19, 13, -1, -19 },
  { 1917, 12, 24, 9, -1, -20 },
  { 1953, 6, 20, 11, 3, -20 },
  { 1968, 12, 24, 9, -2, -20 },
  { 2004, 13, 12, 14, 0, -19 },
  { 2024, 12, 3, 11, -3, 2 },
  { 2029, 6, 5, 9, 4, -21 },
  { 2033, 14, 15, 15, 1, -15 },
  { 2060, 14, 21, 15, 0, -21 },
  { 2097, 12, 15, 12, 1, -15 },
  { 2120, 15, 21, 15, 1, -21 },
  { 2160, 13, 15, 14, 1, -15 },
  { 2185, 16, 27, 10, -3, -21 },
  { 2239, 15, 21, 15, 0, -15 },
  { 2279, 14, 21, 15, 0, -21 },
  { 2316, 9, 21, 8, 0, -21 },
  { 2340, 12, 27, 8, -3, -21 },
  { 2381, 16, 21, 15, 0, -21 },
  { 2423, 9, 21, 8, 0, -21 },
  { 2447, 21, 15, 23, 0, -15 },
  { 2487, 14, 15, 15, 0, -15 },
  { 2514, 13, 15, 15, 1, -15 },
  { 2539, 15, 21, 15, -1, -15 },
  { 2579, 14, 21, 15, 1, -15 },
  { 2616, 12, 15, 11, 0, -15 },
  { 2639, 12, 15, 12, 0, -15 },
  { 2662, 10, 18, 11, 1, -18 },
  { 2685, 14, 15, 15, 1, -15 },
  { 2712, 14, 15, 13, 1, -15 },
  { 2739, 20, 15, 20, 2, -15 },
  { 2777, 16, 15, 14, -1, -15 },
  { 2807, 17, 21, 13, -2, -15 },
  { 2852, 13, 15, 12, -1, -15 },
  { 2877, 11, 23, 9, 0, -19 },
  { 2909, 3, 27, 13, 5, -21 },
  { 2920, 11, 23, 9, -2, -19 },
  { 2952, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC27PT7B_H_
