#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x70, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x38, 0x3C, 0x70, 0x71, 0xE0, 0xE3, 0x81,
  0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xC3,
  0x83, 0x87, 0x07, 0x0C, 0x0E, 0x38, 0x18, 0x70, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00,
  0x0C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x38, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x00, 0x70, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0C, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x80, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x01, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0xFD, 0x9F, 0x01, 0xE1, 0x82, 0x03, 0xC3, 0x00, 0x03, 0x83, 0x00,
  0x03, 0x83, 0x00, 0x07, 0x83, 0x00, 0x07, 0x03, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x86, 0x00, 0x03, 0x86, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0xCC, 0x00, 0x01, 0xEC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1B, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x31, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0,
  0x80, 0xC3, 0xC0, 0xE0, 0xC7, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x3F, 0xC0, 0x0E, 0x01,
  0xC7, 0x00, 0x38, 0x0E, 0x0C, 0x01, 0xC0, 0x38, 0x38, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x30,
  0x1C, 0x03, 0x80, 0xC0, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x1C, 0x1C,
  0x01, 0xC0, 0x70, 0x70, 0x07, 0x01, 0xC3, 0x80, 0x18, 0x07, 0x0E, 0x00,
  0xE0, 0x38, 0x70, 0x03, 0x80, 0xE1, 0xC0, 0x0E, 0x03, 0x8E, 0x04, 0x38,
  0x0C, 0x38, 0x7E, 0xE0, 0x71, 0xC7, 0xFB, 0x81, 0xC7, 0x1C, 0x7E, 0x0E,
  0x38, 0xE1, 0xF8, 0x38, 0xE7, 0x07, 0xE1, 0xC7, 0x1C, 0x1F, 0xCF, 0x1C,
  0xE0, 0x77, 0xF8, 0xE3, 0x81, 0xCF, 0xC3, 0x8E, 0x07, 0x08, 0x1C, 0x70,
  0x1C, 0x00, 0x71, 0xC0, 0x70, 0x03, 0x87, 0x01, 0xC0, 0x0E, 0x18, 0x07,
  0x00, 0x70, 0xE0, 0x18, 0x01, 0xC3, 0x80, 0xE0, 0x0E, 0x0E, 0x03, 0x80,
  0x30, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x30, 0x06, 0x03, 0x81, 0xC0, 0x38,
  0x0C, 0x07, 0x00, 0xC0, 0x30, 0x18, 0x07, 0x00, 0xC0, 0xE0, 0x18, 0x03,
  0x83, 0x00, 0xE0, 0x0E, 0x1C, 0x07, 0x00, 0x38, 0xE0, 0x1C, 0x00, 0x7F,
  0x80, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0x73, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0x9E, 0x00, 0x07, 0x0E, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x0E, 0x0E,
  0x1C, 0x0F, 0x1E, 0x3C, 0x07, 0x1C, 0x38, 0x07, 0x1C, 0x78, 0x07, 0xB8,
  0x70, 0x07, 0xB8, 0x70, 0x03, 0xF8, 0x70, 0x03, 0xF0, 0x70, 0x03, 0xF0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x03, 0xE0, 0x70, 0x07, 0xE0,
  0x70, 0x0F, 0xE0, 0x78, 0x1E, 0xF0, 0x3E, 0x7C, 0xF0, 0x3F, 0xF8, 0x70,
  0x1F, 0xF0, 0x78, 0x03, 0x00, 0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E,
  0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x04, 0x0C, 0x03, 0x06, 0x03, 0xE3, 0x00, 0xF9, 0x87, 0x1F, 0xFF, 0x83,
  0xFF, 0xC0, 0xF0, 0x00, 0xF8, 0x00, 0xE6, 0x00, 0xE3, 0x80, 0xF1, 0xC1,
  0xF0, 0x70, 0x70, 0x38, 0x10, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0xFF,
  0xFF, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x38,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x07, 0x03, 0xC0, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF1,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0x80,
  0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x80, 0x07,
  0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x01, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xB8, 0xFB, 0xCF, 0x1C, 0xF0, 0xE3, 0x07,
  0x10, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07,
  0x80, 0xF0, 0x01, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xE0,
  0x1E, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x80, 0x1F, 0x00, 0xF8, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xDE, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x07,
  0x00, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x80, 0x07, 0x80,
  0x60, 0x0F, 0x80, 0x3E, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xF8, 0x60, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0xF8, 0x01, 0xC7,
  0xF8, 0x07, 0xBF, 0xF8, 0x0E, 0xF0, 0xF8, 0x1D, 0x80, 0xF0, 0x3E, 0x00,
  0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x07,
  0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x70, 0x03, 0x80, 0xE0,
  0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xC7, 0xC0,
  0x07, 0x80, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x0F,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00,
  0xF0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x01, 0xC0,
  0xF0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x01,
  0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xF7, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x01, 0xE0,
  0x0F, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x83, 0x80, 0x1F, 0x07, 0x80, 0x7E, 0x0F,
  0x01, 0xF8, 0x0F, 0x0F, 0x70, 0x1F, 0xFC, 0xE0, 0x1F, 0xF3, 0xC0, 0x0F,
  0x87, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0x7E, 0x06, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x38, 0x07, 0x0E, 0x01, 0xFF, 0x07, 0x0E, 0x03, 0xFF,
  0x07, 0x1C, 0x07, 0x86, 0x07, 0x1C, 0x07, 0x0E, 0x07, 0x18, 0x0E, 0x0E,
  0x06, 0x38, 0x1C, 0x0E, 0x06, 0x38, 0x1C, 0x0C, 0x0E, 0x30, 0x38, 0x1C,
  0x0E, 0x70, 0x38, 0x1C, 0x0E, 0x70, 0x30, 0x1C, 0x0E, 0x70, 0x70, 0x18,
  0x0C, 0x60, 0x70, 0x38, 0x0C, 0x60, 0x60, 0x38, 0x1C, 0xE0, 0x60, 0x38,
  0x1C, 0xE0, 0xE0, 0x70, 0x18, 0xE0, 0xE0, 0x70, 0x38, 0xE0, 0xE0, 0x70,
  0x38, 0xE0, 0xE0, 0xF0, 0x30, 0xC0, 0xE0, 0xF0, 0x70, 0xC0, 0xE0, 0xF0,
  0x60, 0xC0, 0xE1, 0xB0, 0xE0, 0xC0, 0xE3, 0x31, 0xC0, 0xC0, 0x7F, 0x3F,
  0x80, 0xC0, 0x7E, 0x3F, 0x00, 0xC0, 0x3C, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x00, 0x1F, 0x03, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x06, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00,
  0x07, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x78, 0x03, 0xC0,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00,
  0x07, 0x9E, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xC0, 0x7C, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03,
  0xC0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03,
  0x80, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x0E, 0x03, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1C, 0x07,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x38,
  0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xE0, 0x1C, 0x03, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xBE, 0x00,
  0x3E, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x10, 0x00, 0x7F, 0x7C, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x38, 0x1F, 0x80, 0x07, 0x00, 0xF8,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0xE0,
  0x03, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x00, 0xE0,
  0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x1E, 0x00,
  0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x1E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80,
  0x70, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x0F,
  0x80, 0x0E, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xF0, 0x07, 0x00, 0x3E, 0x00, 0x08, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xF0,
  0x70, 0x00, 0xFF, 0x83, 0x80, 0x0F, 0xFC, 0x1C, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x70,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0xF0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x38,
  0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0xF0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x77, 0xC0, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xCE,
  0x00, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0x80,
  0x03, 0x80, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x1E,
  0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x01,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xEE, 0x00, 0x00, 0xFE, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0x03,
  0xBC, 0x01, 0xCE, 0x00, 0x03, 0xBC, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x03, 0xCE, 0x00,
  0x0E, 0x78, 0x03, 0x8E, 0x00, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x07, 0x8E,
  0x00, 0x78, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0,
  0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x0E,
  0x0F, 0x01, 0xC1, 0xE0, 0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x07, 0x03, 0xC0,
  0x1C, 0x07, 0x07, 0x03, 0xC0, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0x1C, 0x07,
  0x0E, 0x03, 0x80, 0x3C, 0x07, 0x1E, 0x03, 0x80, 0x3C, 0x07, 0x1C, 0x07,
  0x80, 0x38, 0x07, 0x3C, 0x07, 0x00, 0x38, 0x07, 0x38, 0x07, 0x00, 0x38,
  0x07, 0x78, 0x07, 0x00, 0x78, 0x07, 0x70, 0x07, 0x00, 0x70, 0x07, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x0E, 0x00,
  0xFE, 0x00, 0x1E, 0x00, 0xEE, 0x00, 0x1E, 0x00, 0xEE, 0x00, 0x1C, 0x00,
  0xEE, 0x00, 0x1C, 0x00, 0xEE, 0x00, 0x1C, 0x01, 0xEE, 0x00, 0x3C, 0x01,
  0xC7, 0x00, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x01,
  0xC7, 0x00, 0x78, 0x03, 0xC7, 0x00, 0x78, 0x03, 0x87, 0x80, 0x70, 0x03,
  0x83, 0x80, 0x70, 0x03, 0x83, 0x80, 0x70, 0x07, 0x83, 0x80, 0xF0, 0x07,
  0x83, 0x80, 0xF0, 0x07, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0xE0, 0x07,
  0x01, 0xC0, 0xE0, 0x0F, 0x01, 0xC1, 0xE0, 0x0E, 0x01, 0xC1, 0xC0, 0x0E,
  0x01, 0xC1, 0xC0, 0x0E, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0xE3, 0xC0, 0x1E,
  0x00, 0xE3, 0xC0, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0x00, 0xE3, 0x80, 0x3C, 0x00, 0xF3, 0x80, 0x3C, 0x00, 0x77, 0x80, 0x38,
  0x00, 0x77, 0x00, 0x38, 0x00, 0x77, 0x00, 0x38, 0x00, 0x77, 0x00, 0x78,
  0x00, 0x77, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x70, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x3C, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C,
  0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x38, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x07, 0xC0, 0x07, 0x01, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x70,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x07, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x0F, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x38, 0x03, 0xC0, 0x1C, 0x07, 0xC0, 0x0E, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x3C, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C,
  0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x38, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x1F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0E, 0x07, 0xC0, 0x07, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x38, 0x07,
  0xC0, 0x1C, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0x87,
  0x00, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E,
  0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0xF0, 0x01, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x7C, 0x01, 0x80,
  0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0xF3,
  0x80, 0x00, 0xF3, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x01, 0xE0,
  0x00, 0x77, 0x80, 0x03, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x80, 0x03, 0x9E,
  0x00, 0x1F, 0x00, 0x07, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0xFC,
  0x00, 0x38, 0xF0, 0x01, 0xF8, 0x00, 0xF1, 0xC0, 0x03, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0xE0, 0x03, 0x87, 0x00, 0x1D, 0xC0, 0x0F, 0x0E, 0x00, 0x73,
  0x80, 0x1C, 0x1C, 0x00, 0xE7, 0x00, 0x78, 0x38, 0x01, 0xCE, 0x00, 0xE0,
  0x70, 0x07, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x38, 0x07, 0x81, 0xC0, 0x38,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0xE0, 0x3C, 0x07, 0x00, 0xE1, 0xC0, 0x70,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0x1C, 0x07, 0x07, 0x03, 0xC0, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0x70, 0x38, 0x1C, 0x1E, 0x00, 0xE0, 0x70, 0x38, 0x38,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x07, 0x0F,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x03, 0x0F, 0x00, 0x1C, 0x38, 0x06, 0x1C,
  0x00, 0x38, 0xE0, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x38, 0xF0, 0x00, 0xE7,
  0x80, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0xE7, 0x80, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0x07, 0x70, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x07, 0x78, 0x00, 0x1D,
  0xC0, 0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0x80, 0x07,
  0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0E,
  0x00, 0xF0, 0x38, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03,
  0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00,
  0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x1C,
  0xE0, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x04, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x73, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xE1,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0x70, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x3C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x06, 0x0C, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0x1C, 0x07, 0xFF, 0x30, 0x1F, 0x0E, 0xE0, 0x7C, 0x0F, 0xC0, 0xF0,
  0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x0E,
  0x1E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xC3,
  0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0x80,
  0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xF8, 0x1E, 0x03, 0x70, 0x1C, 0x0E,
  0xE0, 0x3E, 0x7B, 0x80, 0x3F, 0xE7, 0x00, 0x3F, 0x8E, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0xFC, 0x00, 0xE3, 0xFC, 0x01,
  0xCF, 0xFC, 0x03, 0xB8, 0x78, 0x0F, 0xC0, 0x78, 0x1F, 0x00, 0x70, 0x3E,
  0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x1E, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0x60, 0x78, 0x0E, 0xF3,
  0xE0, 0x38, 0xFF, 0x80, 0x70, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0x82, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x81, 0xF1, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xF0, 0xE0, 0x03, 0xFE, 0x78, 0x01, 0xFF, 0xDC,
  0x00, 0xF8, 0x77, 0x00, 0x7C, 0x0F, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x7C, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03,
  0x80, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03,
  0x80, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF8,
  0x03, 0xC0, 0x6E, 0x00, 0xF0, 0x3B, 0x80, 0x1F, 0x3D, 0xC0, 0x03, 0xFE,
  0x70, 0x00, 0x7F, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xE0, 0xF0, 0x78, 0x0E, 0x0E, 0x01, 0xC3,
  0xC0, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x07, 0x1C,
  0x00, 0xE7, 0x80, 0x38, 0xE0, 0x0F, 0x1C, 0x07, 0xC3, 0x87, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFC, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0x03, 0xF1,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x70, 0x03, 0xFF, 0x98,
  0x01, 0xF0, 0xEE, 0x00, 0x78, 0x1F, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF8, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80,
  0xF0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x07,
  0x00, 0x3E, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0xC0, 0x1C, 0x01, 0xF0,
  0x07, 0x80, 0xDC, 0x01, 0xE0, 0x7F, 0x00, 0x3E, 0x7B, 0x80, 0x0F, 0xFC,
  0xE0, 0x01, 0xFE, 0x38, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x80, 0x1E, 0x00, 0x38, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x3F, 0x00,
  0x73, 0xFE, 0x01, 0xDF, 0xFC, 0x07, 0xE0, 0xF0, 0x3F, 0x01, 0xC0, 0xF8,
  0x07, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07,
  0x07, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0F,
  0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00,
  0x70, 0x78, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0,
  0xF0, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0E,
  0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x00, 0x10, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x0F,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0xF0, 0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x80,
  0x38, 0x1E, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0xF7,
  0x80, 0x01, 0xDF, 0x80, 0x03, 0xBF, 0x00, 0x07, 0xEE, 0x00, 0x1F, 0x9C,
  0x00, 0x3E, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xE0,
  0x07, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0F, 0x00,
  0x70, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x39, 0xFF, 0x1F, 0xF0, 0x07, 0x7F, 0xE7, 0xFF, 0x00, 0xDC, 0x1E,
  0xE1, 0xE0, 0x3B, 0x03, 0xF0, 0x1E, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0xF0,
  0x07, 0x80, 0x78, 0x1E, 0x00, 0xE0, 0x0F, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0xF0, 0x07, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x07, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xC0,
  0x0E, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x03, 0x81,
  0xC0, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x38, 0x03,
  0xC1, 0xE0, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x0E, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0x3F, 0xE0, 0x1D, 0xFF, 0xC0, 0x6E, 0x0F,
  0x03, 0xB0, 0x1C, 0x0F, 0x80, 0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x03,
  0x80, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78,
  0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x70,
  0x03, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07,
  0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x0F, 0x07,
  0x00, 0x3C, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x0E, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x1E, 0x07, 0x80, 0xF0,
  0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x07,
  0x3C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x0F,
  0x01, 0xE0, 0x70, 0x3E, 0x07, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0E, 0x3F, 0xC0, 0x03, 0x9F,
  0xF8, 0x00, 0xEE, 0x1E, 0x00, 0x76, 0x03, 0xC0, 0x1D, 0x80, 0x70, 0x07,
  0xC0, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0x70,
  0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0x70,
  0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x0F, 0x80,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xEC, 0x0F, 0x00, 0x3B, 0xCF, 0x80, 0x0E,
  0x7F, 0xC0, 0x07, 0x8F, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x1C, 0x07, 0xFF, 0x30,
  0x1F, 0x0E, 0xE0, 0x78, 0x0F, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x07,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0,
  0x03, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x07,
  0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0,
  0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E,
  0x00, 0xF8, 0x1E, 0x03, 0x70, 0x3C, 0x0F, 0xE0, 0x3E, 0x7B, 0x80, 0x7F,
  0xE7, 0x00, 0x7F, 0x8E, 0x00, 0x18, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x39, 0xFC, 0x07, 0x7F, 0x00, 0xDE, 0x20, 0x3B, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3C, 0x06, 0x07, 0x80, 0x20, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0xC0, 0x3C, 0x0F, 0x8F, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x90, 0x1F, 0xC0, 0x7F,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83,
  0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x80,
  0x1C, 0x1E, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x38,
  0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03,
  0x83, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0xC0, 0xE0, 0x3F, 0x03, 0xC1,
  0xDC, 0x0F, 0x9E, 0xE0, 0x1F, 0xF3, 0x80, 0x3F, 0x8E, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07,
  0x38, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x38, 0x07, 0x0E,
  0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80,
  0x39, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x7B,
  0x80, 0x3E, 0x00, 0xE7, 0x00, 0x7C, 0x01, 0xCE, 0x00, 0xF8, 0x07, 0x9C,
  0x03, 0xF0, 0x0E, 0x38, 0x07, 0xE0, 0x1C, 0x70, 0x1D, 0xC0, 0x70, 0xE0,
  0x3B, 0x80, 0xE1, 0xC0, 0x77, 0x03, 0xC3, 0x81, 0xCE, 0x07, 0x07, 0x03,
  0x9C, 0x0E, 0x0E, 0x0E, 0x38, 0x38, 0x1C, 0x1C, 0x70, 0x70, 0x38, 0x38,
  0xE1, 0xE0, 0x70, 0xE1, 0xC3, 0x80, 0xE1, 0xC3, 0x87, 0x01, 0xC7, 0x07,
  0x1C, 0x03, 0x8E, 0x0E, 0x38, 0x07, 0x1C, 0x1C, 0x70, 0x0E, 0x70, 0x39,
  0xC0, 0x1C, 0xE0, 0x73, 0x80, 0x3B, 0x80, 0xEE, 0x00, 0x77, 0x01, 0xDC,
  0x00, 0xEE, 0x03, 0xB8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0D, 0xC0,
  0x06, 0xC0, 0x1B, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x0E, 0x03,
  0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x78, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0x80, 0x05, 0xFF, 0xC0, 0x1F, 0xCF, 0xE0, 0xFE, 0x03,
  0xFF, 0xD8, 0x01, 0xFF, 0x20, 0x00, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 45, 14, 1, -45 },
  { 75, 15, 16, 19, 6, -45 },
  { 105, 26, 45, 25, 0, -45 },
  { 252, 24, 52, 23, 0, -48 },
  { 408, 30, 47, 36, 3, -46 },
  { 585, 24, 47, 24, -1, -46 },
  { 726, 7, 16, 10, 6, -45 },
  { 740, 18, 55, 16, 1, -45 },
  { 864, 18, 55, 16, -4, -45 },
  { 988, 17, 19, 21, 7, -48 },
  { 1029, 23, 29, 26, 2, -37 },
  { 1113, 10, 14, 11, -3, -6 },
  { 1131, 14, 4, 16, 1, -19 },
  { 1138, 5, 6, 11, 1, -6 },
  { 1142, 27, 45, 20, -3, -45 },
  { 1294, 22, 47, 23, 1, -46 },
  { 1424, 13, 45, 23, 7, -45 },
  { 1498, 25, 46, 23, -2, -46 },
  { 1642, 24, 47, 23, -1, -46 },
  { 1783, 25, 45, 23, -1, -45 },
  { 1924, 25, 46, 23, -1, -45 },
  { 2068, 23, 47, 23, 2, -46 },
  { 2204, 24, 45, 23, 2, -45 },
  { 2339, 25, 47, 23, -1, -46 },
  { 2486, 23, 47, 23, 0, -46 },
  { 2622, 11, 34, 11, 0, -34 },
  { 2669, 14, 42, 11, -3, -34 },
  { 2743, 23, 27, 26, 2, -36 },
  { 2821, 23, 16, 26, 2, -30 },
  { 2867, 23, 27, 26, 2, -36 },
  { 2945, 18, 46, 17, 1, -46 },
  { 3049, 32, 50, 35, 2, -45 },
  { 3249, 23, 45, 23, -4, -45 },
  { 3379, 26, 45, 25, 0, -45 },
  { 3526, 26, 47, 23, 2, -46 },
  { 3679, 27, 45, 28, 0, -45 },
  { 3831, 25, 45, 22, 0, -45 },
  { 3972, 25, 45, 21, 0, -45 },
  { 4113, 29, 47, 30, 2, -46 },
  { 4284, 30, 45, 29, 0, -45 },
  { 4453, 21, 45, 13, -3, -45 },
  { 4572, 22, 56, 11, -9, -45 },
  { 4726, 28, 45, 24, 0, -45 },
  { 4884, 16, 45, 20, 0, -45 },
  { 4974, 40, 45, 39, 0, -45 },
  { 5199, 32, 45, 31, 0, -45 },
  { 5379, 27, 47, 30, 2, -46 },
  { 5538, 25, 45, 24, 0, -45 },
  { 5679, 27, 57, 30, 2, -46 },
  { 5872, 25, 45, 24, 0, -45 },
  { 6013, 27, 47, 23, -2, -46 },
  { 6172, 21, 45, 20, 4, -45 },
  { 6291, 28, 46, 28, 2, -45 },
  { 6452, 24, 45, 24, 5, -45 },
  { 6587, 39, 45, 39, 5, -45 },
  { 6807, 30, 45, 21, -4, -45 },
  { 6976, 22, 45, 20, 4, -45 },
  { 7100, 27, 45, 20, -3, -45 },
  { 7252, 23, 55, 18, -1, -45 },
  { 7411, 10, 45, 21, 6, -45 },
  { 7468, 23, 55, 18, -4, -45 },
  { 7627, 24, 23, 25, 1, -45 },
  { 7696, 18, 3, 18, -5, 5 },
  { 7703, 7, 10, 14, 9, -48 },
  { 7712, 23, 35, 25, 2, -34 },
  { 7813, 23, 49, 25, 0, -48 },
  { 7954, 18, 35, 18, 2, -34 },
  { 8033, 26, 49, 25, 2, -48 },
  { 8193, 19, 35, 22, 2, -34 },
  { 8277, 28, 63, 13, -8, -48 },
  { 8498, 26, 49, 25, -1, -34 },
  { 8658, 22, 48, 24, 0, -48 },
  { 8790, 13, 46, 11, 0, -46 },
  { 8865, 21, 61, 11, -8, -46 },
  { 9026, 23, 48, 21, 0, -48 },
  { 9164, 14, 48, 11, 0, -48 },
  { 9248, 35, 34, 36, 0, -34 },
  { 9397, 22, 34, 24, 0, -34 },
  { 9491, 20, 35, 24, 2, -34 },
  { 9579, 26, 48, 25, -3, -34 },
  { 9735, 23, 49, 25, 2, -34 },
  { 9876, 19, 34, 16, 0, -34 },
  { 9957, 20, 35, 19, -1, -34 },
  { 10045, 14, 42, 13, 1, -41 },
  { 10119, 22, 34, 24, 2, -33 },
  { 10213, 18, 33, 19, 4, -33 },
  { 10288, 31, 33, 32, 4, -33 },
  { 10416, 25, 33, 20, -3, -33 },
  { 10520, 30, 48, 20, -7, -33 },
  { 10700, 20, 33, 16, -2, -33 },
  { 10783, 22, 55, 20, 2, -45 },
  { 10935, 3, 63, 22, 10, -48 },
  { 10959, 22, 55, 20, -4, -45 },
  { 11111, 23, 7, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC63PT7B_H_
