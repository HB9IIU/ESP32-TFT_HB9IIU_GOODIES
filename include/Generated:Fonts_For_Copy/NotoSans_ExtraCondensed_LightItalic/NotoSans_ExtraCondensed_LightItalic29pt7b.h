#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x00, 0x01, 0x07, 0x0C, 0x00, 0x66, 0xC9, 0x12, 0x6C,
  0xD9, 0x22, 0x44, 0x03, 0x10, 0x23, 0x02, 0x20, 0x22, 0x04, 0x60, 0x44,
  0x3F, 0xF0, 0xCC, 0x08, 0x80, 0x88, 0x19, 0x81, 0x10, 0x11, 0x0F, 0xFC,
  0x22, 0x02, 0x20, 0x62, 0x04, 0x60, 0x44, 0x04, 0x40, 0xCC, 0x00, 0x01,
  0x80, 0x20, 0x0E, 0x07, 0xF1, 0x92, 0x24, 0x0C, 0x81, 0x90, 0x12, 0x03,
  0x40, 0x30, 0x03, 0x00, 0x70, 0x0A, 0x01, 0x60, 0x44, 0x09, 0x81, 0x32,
  0x24, 0x7F, 0x03, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x0C, 0x08, 0x58, 0x62,
  0x21, 0x08, 0x8C, 0x62, 0x21, 0x09, 0x84, 0x64, 0x11, 0x30, 0xC4, 0x9B,
  0x16, 0xFC, 0x96, 0x56, 0xD1, 0x72, 0x44, 0x1B, 0x10, 0x48, 0x43, 0x23,
  0x08, 0x8C, 0x62, 0x21, 0x09, 0x8C, 0x24, 0x60, 0xE0, 0x07, 0x83, 0x60,
  0x88, 0x22, 0x18, 0x86, 0x61, 0x98, 0x2C, 0x0A, 0x03, 0x01, 0xC0, 0xD0,
  0x66, 0x51, 0xBC, 0x2E, 0x0A, 0x83, 0xA0, 0xC8, 0x33, 0x16, 0x79, 0x80,
  0x6D, 0x2D, 0xA4, 0x03, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60,
  0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0x40, 0x40, 0x60, 0x06, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x0C,
  0x0C, 0x18, 0x10, 0x30, 0x20, 0x40, 0x80, 0x08, 0x08, 0xC8, 0x6B, 0x1E,
  0x38, 0x64, 0xC6, 0x04, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F,
  0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x33, 0x26, 0x4C,
  0x80, 0xFF, 0xF0, 0x5F, 0x00, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x00, 0x07, 0x03, 0x61, 0x88, 0x43, 0x30, 0xC8, 0x36, 0x0D, 0x82, 0x40,
  0xB0, 0x2C, 0x1B, 0x06, 0x81, 0xA0, 0x48, 0x32, 0x0C, 0x82, 0x21, 0x88,
  0x43, 0x30, 0x78, 0x00, 0x04, 0x73, 0xDB, 0xC8, 0x21, 0x86, 0x10, 0x41,
  0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x10, 0xC0, 0x03, 0xC0, 0xEE, 0x08,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0xEE, 0x08, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x38, 0x0F, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x88, 0x30, 0xFE, 0x00,
  0x00, 0x30, 0x07, 0x00, 0xE0, 0x0A, 0x01, 0xE0, 0x16, 0x02, 0x40, 0x64,
  0x04, 0x40, 0xCC, 0x08, 0xC1, 0x08, 0x30, 0x82, 0x18, 0x41, 0x87, 0xFE,
  0x81, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x07, 0xF0, 0x7F, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x12, 0x01, 0xF8, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x8C, 0x70, 0xFE, 0x00, 0x03, 0xC1, 0x90, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x01, 0x80, 0x4E, 0x17, 0xCE, 0x13, 0x06, 0xC1, 0xA0, 0x68, 0x12, 0x04,
  0x83, 0x20, 0xC8, 0x63, 0x18, 0x7C, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x00,
  0x07, 0x81, 0xD8, 0x61, 0x88, 0x31, 0x06, 0x20, 0xC4, 0x10, 0xC6, 0x19,
  0x81, 0xE0, 0x38, 0x19, 0x86, 0x10, 0x83, 0x30, 0x64, 0x04, 0x81, 0x90,
  0x33, 0x04, 0x71, 0x87, 0xE0, 0x07, 0x81, 0xB8, 0x61, 0x08, 0x23, 0x06,
  0x60, 0x88, 0x11, 0x02, 0x20, 0xC4, 0x18, 0x87, 0x19, 0xE1, 0xE8, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x06, 0x0F, 0x80, 0x08, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0x18, 0x04, 0x30, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x18, 0x61, 0x0C, 0x20, 0x00,
  0xC0, 0x60, 0x70, 0x70, 0x70, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x1C, 0x1C, 0x1C, 0x0C,
  0x0E, 0x02, 0x00, 0x1F, 0x1D, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x04,
  0x06, 0x06, 0x02, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x10,
  0x1C, 0x0C, 0x00, 0x00, 0xF0, 0x0C, 0x60, 0x40, 0xC2, 0x01, 0x10, 0x04,
  0xC0, 0x12, 0x1E, 0x58, 0x99, 0x46, 0x45, 0x11, 0x1C, 0xC4, 0x72, 0x31,
  0x88, 0x8E, 0x22, 0x28, 0x98, 0xA2, 0x64, 0x8E, 0xF2, 0x11, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x03, 0xF0, 0x02, 0x00, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0xF0, 0x16, 0x06, 0xC0, 0xD8, 0x13, 0x06, 0x60, 0x8C, 0x31,
  0x86, 0x30, 0xFE, 0x3F, 0xC4, 0x19, 0x83, 0x30, 0x64, 0x0D, 0x81, 0xA0,
  0x3C, 0x06, 0x0F, 0x80, 0xFE, 0x0C, 0x30, 0x83, 0x08, 0x31, 0x83, 0x18,
  0x21, 0x06, 0x10, 0x43, 0xF8, 0x3F, 0x83, 0x0C, 0x20, 0xC2, 0x04, 0x60,
  0x46, 0x0C, 0x60, 0xC4, 0x08, 0x41, 0x8C, 0x70, 0xFE, 0x00, 0x03, 0xF0,
  0x76, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x20, 0x3E, 0x00, 0x0F, 0x00, 0xFE, 0x0C, 0x60, 0x83,
  0x08, 0x31, 0x81, 0x18, 0x11, 0x01, 0x10, 0x33, 0x03, 0x30, 0x33, 0x03,
  0x20, 0x22, 0x06, 0x60, 0x66, 0x04, 0x60, 0xC4, 0x18, 0x43, 0x0C, 0xE0,
  0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x07, 0xF0, 0xFE, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xFE, 0x1F, 0xC2,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x00,
  0x01, 0xF0, 0x3D, 0xC3, 0x02, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x7D, 0x83, 0xCC, 0x02, 0x60, 0x33, 0x01,
  0x98, 0x08, 0xC0, 0x46, 0x06, 0x18, 0x30, 0xE1, 0x83, 0xF8, 0x00, 0x0C,
  0x0C, 0x30, 0x30, 0xC0, 0x82, 0x02, 0x08, 0x18, 0x60, 0x61, 0x81, 0x84,
  0x04, 0x10, 0x10, 0xFF, 0xC3, 0xFF, 0x0C, 0x0C, 0x20, 0x20, 0x80, 0x86,
  0x06, 0x18, 0x18, 0x60, 0x41, 0x01, 0x04, 0x0C, 0x30, 0x30, 0xC0, 0xC0,
  0x07, 0xC0, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0xFC, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x3C, 0x00,
  0x0C, 0x18, 0x60, 0x83, 0x0C, 0x10, 0xC0, 0x8C, 0x0C, 0x40, 0x66, 0x02,
  0x60, 0x16, 0x01, 0xB0, 0x0F, 0x80, 0x7C, 0x03, 0x20, 0x11, 0x01, 0x8C,
  0x0C, 0x60, 0x63, 0x02, 0x08, 0x10, 0x41, 0x83, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18,
  0x30, 0x60, 0x81, 0x06, 0x0F, 0xE0, 0x0E, 0x00, 0xC3, 0x80, 0x70, 0xE0,
  0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC7, 0x80, 0xA1, 0xA0, 0x68, 0x48, 0x16,
  0x12, 0x0D, 0x8C, 0x82, 0x43, 0x21, 0x90, 0xC8, 0x44, 0x22, 0x33, 0x08,
  0x88, 0xC6, 0x26, 0x21, 0x89, 0x08, 0x42, 0x46, 0x10, 0xB1, 0x84, 0x28,
  0x63, 0x0E, 0x10, 0xC3, 0x0C, 0x00, 0x0C, 0x06, 0x1C, 0x08, 0x38, 0x10,
  0x70, 0x60, 0xA0, 0xC3, 0x41, 0x86, 0x82, 0x09, 0x84, 0x13, 0x18, 0x66,
  0x30, 0xC4, 0x61, 0x88, 0x82, 0x11, 0x04, 0x36, 0x18, 0x6C, 0x30, 0x50,
  0x60, 0xA0, 0x81, 0x41, 0x03, 0x86, 0x07, 0x0C, 0x0C, 0x00, 0x03, 0xC0,
  0x6E, 0x0C, 0x31, 0x83, 0x30, 0x33, 0x01, 0x20, 0x16, 0x03, 0x60, 0x34,
  0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC,
  0x08, 0xC1, 0x86, 0x30, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x31, 0x84, 0x10,
  0x82, 0x30, 0x46, 0x08, 0x83, 0x10, 0x66, 0x18, 0xC6, 0x1F, 0x83, 0x80,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0xC0, 0x6E, 0x0C, 0x31, 0x83, 0x30, 0x33, 0x01, 0x20, 0x16, 0x03, 0x60,
  0x34, 0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x04, 0xC0,
  0xCC, 0x08, 0xC1, 0x86, 0x30, 0x3E, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x0F, 0x01, 0xF8, 0x31, 0x84, 0x10, 0x82, 0x30, 0x46, 0x08,
  0x83, 0x10, 0x66, 0x18, 0xC6, 0x1F, 0x82, 0x20, 0x44, 0x18, 0xC3, 0x18,
  0x63, 0x08, 0x21, 0x04, 0x60, 0xCC, 0x18, 0x03, 0xE0, 0x77, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x8C,
  0x30, 0xFE, 0x00, 0x7F, 0xFF, 0xC2, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x00, 0x18, 0x18, 0xC0, 0x84, 0x04, 0x20, 0x63, 0x03, 0x18,
  0x18, 0xC0, 0x84, 0x04, 0x20, 0x63, 0x03, 0x18, 0x10, 0x80, 0x84, 0x0C,
  0x60, 0x63, 0x03, 0x18, 0x10, 0xC1, 0x86, 0x0C, 0x30, 0x41, 0xCE, 0x07,
  0xE0, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0x60, 0x6C, 0x09, 0x83, 0x30, 0x66,
  0x18, 0xC3, 0x18, 0x43, 0x18, 0x62, 0x0C, 0xC1, 0x98, 0x12, 0x02, 0xC0,
  0x50, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x40, 0x70, 0x30, 0x3C,
  0x0C, 0x0B, 0x07, 0x06, 0xC1, 0x41, 0xB0, 0x50, 0x4C, 0x34, 0x33, 0x09,
  0x08, 0xC6, 0x46, 0x31, 0x91, 0x8C, 0x4C, 0x43, 0x33, 0x30, 0xC8, 0xC8,
  0x32, 0x36, 0x0D, 0x8D, 0x83, 0x43, 0x40, 0xF0, 0xF0, 0x38, 0x38, 0x0E,
  0x0A, 0x03, 0x83, 0x80, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x18, 0x20, 0x21,
  0x80, 0x8C, 0x02, 0x30, 0x09, 0x80, 0x34, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x80, 0x16, 0x00, 0xD8, 0x06, 0x60, 0x10,
  0x80, 0xC2, 0x02, 0x08, 0x18, 0x20, 0xC0, 0xC0, 0xC0, 0xD0, 0x24, 0x19,
  0x04, 0x43, 0x10, 0x86, 0x61, 0x90, 0x6C, 0x1A, 0x07, 0x80, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x7C, 0x1F, 0x80, 0x8C, 0xCC, 0x44, 0x44, 0x46,
  0x66, 0x22, 0x22, 0x33, 0x31, 0x10, 0x07, 0xE0, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0xFC, 0x1F, 0x00, 0x06, 0x01, 0x80, 0xE0, 0x2C, 0x19,
  0x0C, 0x42, 0x19, 0x82, 0x40, 0xF0, 0x38, 0x04, 0xFF, 0xC4, 0x63, 0x06,
  0x07, 0xD3, 0x14, 0x83, 0x60, 0xD8, 0x24, 0x0B, 0x06, 0xC1, 0xB0, 0x68,
  0x12, 0x0C, 0x83, 0x31, 0xCC, 0xF1, 0xE8, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x40, 0xFE, 0x14, 0x43, 0x0C, 0x41, 0x98, 0x33,
  0x06, 0x40, 0xC8, 0x13, 0x06, 0x60, 0xCC, 0x11, 0x86, 0x30, 0xCE, 0x31,
  0x3C, 0x00, 0x07, 0x1F, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0xC0, 0xC4, 0x7C, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x06, 0x41, 0xF4, 0x31, 0x42, 0x0C, 0x60, 0xC6, 0x08,
  0x40, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0x81, 0x08, 0x30, 0x83, 0x08, 0x70,
  0xCF, 0x07, 0xA0, 0x06, 0x0F, 0x8C, 0x64, 0x36, 0x1A, 0x0B, 0x0D, 0xBC,
  0xF0, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x08, 0xF8, 0x00, 0x38, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x7C, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x01, 0x60, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x7D,
  0x0C, 0x50, 0x83, 0x18, 0x31, 0x82, 0x10, 0x23, 0x06, 0x30, 0x63, 0x06,
  0x20, 0x42, 0x0C, 0x20, 0xC2, 0x1C, 0x33, 0xC1, 0xE8, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x0E, 0xE0, 0x7C, 0x00, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x98, 0x7F, 0x18, 0x46, 0x11, 0x04, 0xC3, 0x30,
  0xC8, 0x32, 0x09, 0x82, 0x61, 0x98, 0x64, 0x11, 0x04, 0xC1, 0x30, 0xC0,
  0x0C, 0x30, 0x80, 0x00, 0x01, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x86, 0x18,
  0x61, 0x04, 0x30, 0xC0, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x0F, 0x03, 0x80, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x08, 0xC6, 0x10, 0x82, 0x30, 0x4C, 0x1B, 0x03, 0x40, 0x58, 0x0D, 0x03,
  0xB0, 0x66, 0x0C, 0xC1, 0x08, 0x21, 0x0C, 0x21, 0x86, 0x00, 0x04, 0x30,
  0xC3, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x84,
  0x10, 0xC3, 0x00, 0x09, 0x8C, 0x17, 0xDF, 0x18, 0xE3, 0x18, 0x43, 0x30,
  0xC3, 0x30, 0xC3, 0x30, 0xC2, 0x20, 0x82, 0x20, 0x86, 0x61, 0x86, 0x61,
  0x86, 0x61, 0x84, 0x41, 0x04, 0x41, 0x0C, 0xC3, 0x0C, 0xC3, 0x08, 0x09,
  0x85, 0xF1, 0x84, 0x61, 0x30, 0x4C, 0x33, 0x0C, 0x83, 0x20, 0x98, 0x26,
  0x19, 0x86, 0x41, 0x10, 0x4C, 0x13, 0x0C, 0x06, 0x0F, 0xCC, 0x64, 0x16,
  0x0A, 0x05, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x50, 0x28, 0x36, 0x13, 0x18,
  0xF0, 0x04, 0x80, 0xBE, 0x0A, 0x30, 0xC3, 0x08, 0x31, 0x83, 0x18, 0x31,
  0x03, 0x10, 0x23, 0x02, 0x30, 0x63, 0x06, 0x30, 0xC3, 0x0C, 0x71, 0x86,
  0xF0, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x00,
  0x06, 0x07, 0xD3, 0x14, 0x83, 0x60, 0xD8, 0x24, 0x0B, 0x02, 0xC1, 0xB0,
  0x68, 0x12, 0x0C, 0x83, 0x21, 0xCC, 0xF1, 0xE8, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x09, 0x8B, 0x87, 0x03, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x0E,
  0x0F, 0xCC, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x32, 0x31, 0xF0, 0x18, 0x41, 0x0C, 0x7C, 0x82, 0x18, 0x61,
  0x84, 0x10, 0xC3, 0x08, 0x20, 0x82, 0x0E, 0x00, 0x30, 0xC8, 0x32, 0x09,
  0x82, 0x61, 0x98, 0x64, 0x19, 0x04, 0xC1, 0x30, 0xCC, 0x32, 0x08, 0x86,
  0x32, 0x8F, 0x60, 0x83, 0x82, 0x86, 0x86, 0x84, 0x8C, 0x88, 0x98, 0x90,
  0xB0, 0xB0, 0xA0, 0xE0, 0xC0, 0xC0, 0x83, 0x0E, 0x1C, 0x28, 0x71, 0xA1,
  0xC4, 0x8B, 0x32, 0x2C, 0xC9, 0xB2, 0x24, 0xD8, 0x93, 0x42, 0xCD, 0x0A,
  0x3C, 0x38, 0xA0, 0xC3, 0x83, 0x0C, 0x0C, 0x30, 0x00, 0x18, 0x61, 0x18,
  0x22, 0x04, 0xC0, 0xD0, 0x1E, 0x01, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0xC8,
  0x11, 0x06, 0x30, 0x86, 0x30, 0xC0, 0x06, 0x0C, 0x18, 0x60, 0x61, 0x01,
  0x8C, 0x06, 0x30, 0x18, 0x80, 0x66, 0x01, 0x90, 0x06, 0xC0, 0x1A, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0xB0, 0x03, 0x80, 0x00, 0x1F, 0x80, 0xC0,
  0x40, 0x60, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06,
  0x03, 0xF0, 0x00, 0xC0, 0xF0, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x40, 0xE0, 0x38, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x80, 0x38, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x01, 0xE0, 0x18, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x04, 0x01, 0xC0,
  0x70, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0xF0, 0x20, 0x00, 0x30, 0x7F, 0x18, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 21, 6, 0, -21 },
  { 20, 7, 8, 9, 3, -21 },
  { 27, 12, 21, 11, 0, -21 },
  { 59, 11, 24, 11, 0, -22 },
  { 92, 14, 21, 16, 1, -21 },
  { 129, 10, 21, 11, 0, -21 },
  { 156, 3, 8, 5, 3, -21 },
  { 159, 8, 26, 7, 1, -21 },
  { 185, 8, 26, 7, -2, -21 },
  { 211, 8, 9, 10, 3, -22 },
  { 220, 10, 13, 12, 1, -17 },
  { 237, 4, 7, 5, -1, -3 },
  { 241, 6, 2, 8, 1, -9 },
  { 243, 3, 3, 5, 0, -3 },
  { 245, 12, 21, 9, -1, -21 },
  { 277, 10, 21, 11, 1, -21 },
  { 304, 6, 21, 11, 3, -21 },
  { 320, 12, 21, 11, -1, -21 },
  { 352, 12, 21, 11, -1, -21 },
  { 384, 12, 21, 11, -1, -21 },
  { 416, 12, 21, 11, -1, -21 },
  { 448, 10, 21, 11, 1, -21 },
  { 475, 11, 21, 11, 1, -21 },
  { 504, 11, 21, 11, 0, -21 },
  { 533, 11, 21, 11, 0, -21 },
  { 562, 5, 16, 5, 0, -16 },
  { 572, 6, 20, 5, -1, -16 },
  { 587, 10, 12, 12, 1, -16 },
  { 602, 10, 8, 12, 1, -14 },
  { 612, 10, 12, 12, 1, -16 },
  { 627, 9, 21, 8, 0, -21 },
  { 651, 14, 24, 16, 1, -21 },
  { 693, 11, 21, 11, -2, -21 },
  { 722, 12, 21, 12, 0, -21 },
  { 754, 12, 21, 11, 1, -21 },
  { 786, 12, 21, 13, 0, -21 },
  { 818, 11, 21, 10, 0, -21 },
  { 847, 11, 21, 10, 0, -21 },
  { 876, 13, 21, 14, 1, -21 },
  { 911, 14, 21, 13, 0, -21 },
  { 948, 10, 21, 6, -2, -21 },
  { 975, 10, 26, 5, -4, -21 },
  { 1008, 13, 21, 11, 0, -21 },
  { 1043, 7, 21, 9, 0, -21 },
  { 1062, 18, 21, 18, 0, -21 },
  { 1110, 15, 21, 14, 0, -21 },
  { 1150, 12, 21, 14, 1, -21 },
  { 1182, 11, 21, 11, 0, -21 },
  { 1211, 12, 26, 14, 1, -21 },
  { 1250, 11, 21, 11, 0, -21 },
  { 1279, 12, 21, 10, -1, -21 },
  { 1311, 9, 21, 9, 2, -21 },
  { 1335, 13, 21, 13, 1, -21 },
  { 1370, 11, 21, 11, 2, -21 },
  { 1399, 18, 21, 18, 2, -21 },
  { 1447, 14, 21, 10, -2, -21 },
  { 1484, 10, 21, 9, 2, -21 },
  { 1511, 12, 21, 9, -1, -21 },
  { 1543, 11, 26, 8, -1, -21 },
  { 1579, 4, 21, 10, 3, -21 },
  { 1590, 11, 26, 8, -2, -21 },
  { 1626, 10, 11, 11, 1, -21 },
  { 1640, 8, 1, 8, -2, 3 },
  { 1641, 4, 4, 7, 4, -22 },
  { 1643, 10, 16, 12, 1, -16 },
  { 1663, 11, 22, 11, 0, -22 },
  { 1694, 8, 16, 9, 1, -16 },
  { 1710, 12, 22, 12, 1, -22 },
  { 1743, 9, 16, 10, 1, -16 },
  { 1761, 13, 29, 6, -4, -22 },
  { 1809, 12, 23, 12, -1, -16 },
  { 1844, 10, 22, 11, 0, -22 },
  { 1872, 6, 21, 5, 0, -21 },
  { 1888, 10, 28, 5, -4, -21 },
  { 1923, 11, 22, 10, 0, -22 },
  { 1954, 6, 22, 5, 0, -22 },
  { 1971, 16, 16, 17, 0, -16 },
  { 2003, 10, 16, 11, 0, -16 },
  { 2023, 9, 16, 11, 1, -16 },
  { 2041, 12, 23, 11, -1, -16 },
  { 2076, 10, 23, 12, 1, -16 },
  { 2105, 9, 16, 7, 0, -16 },
  { 2123, 9, 16, 9, 0, -16 },
  { 2141, 6, 19, 6, 1, -19 },
  { 2156, 10, 15, 11, 1, -15 },
  { 2175, 8, 15, 9, 2, -15 },
  { 2190, 14, 15, 15, 2, -15 },
  { 2217, 11, 15, 9, -1, -15 },
  { 2238, 14, 22, 9, -3, -15 },
  { 2277, 9, 15, 7, -1, -15 },
  { 2294, 10, 26, 9, 1, -21 },
  { 2327, 2, 29, 10, 4, -22 },
  { 2335, 10, 26, 9, -2, -21 },
  { 2368, 10, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC29PT7B_H_
