#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x00, 0x01, 0x07, 0x0C, 0x00, 0x66, 0xCD, 0x12, 0x2C,
  0xD9, 0xA2, 0x00, 0x03, 0x10, 0x23, 0x02, 0x20, 0x22, 0x06, 0x60, 0x44,
  0x3F, 0xF0, 0xC4, 0x08, 0xC0, 0x88, 0x18, 0x81, 0x18, 0x11, 0x0F, 0xFC,
  0x23, 0x02, 0x20, 0x62, 0x04, 0x60, 0x44, 0x04, 0x40, 0xCC, 0x00, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x7F, 0x1D, 0x21, 0x10, 0x11, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x1A, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x05, 0x80, 0x48, 0x08,
  0x80, 0x88, 0x09, 0x88, 0x90, 0xFF, 0x03, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x00, 0x0C, 0x04, 0x3C, 0x10, 0xC8, 0x61, 0x10, 0x86, 0x23, 0x08, 0x44,
  0x10, 0x98, 0x23, 0x20, 0x46, 0xC1, 0x89, 0x3B, 0x16, 0xDE, 0x49, 0x37,
  0xB4, 0x66, 0x48, 0xC1, 0xB1, 0x82, 0x62, 0x0C, 0x84, 0x11, 0x08, 0x62,
  0x30, 0x84, 0x43, 0x09, 0x8C, 0x1E, 0x00, 0x03, 0x00, 0xF0, 0x33, 0x04,
  0x60, 0x8C, 0x11, 0x02, 0x20, 0x4C, 0x0B, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x66, 0xCC, 0xD1, 0x96, 0x16, 0x83, 0x90, 0x72, 0x0C, 0x41, 0xCC, 0x58,
  0xF1, 0x00, 0x6D, 0x2D, 0xA0, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x06, 0x03, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x06,
  0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x40, 0x80, 0x0C, 0x0C, 0x88,
  0xE9, 0x3F, 0x18, 0x24, 0x64, 0x46, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x33, 0x26, 0x4C, 0x80, 0xFF, 0xF0, 0x5F, 0x00, 0x00, 0x38,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x00, 0x03, 0x03, 0xE1,
  0x8C, 0x63, 0x30, 0xCC, 0x32, 0x0D, 0x83, 0x60, 0xD0, 0x3C, 0x0B, 0x02,
  0xC1, 0xB0, 0x68, 0x1A, 0x04, 0x83, 0x20, 0xC8, 0x62, 0x18, 0xCC, 0x1E,
  0x00, 0x0E, 0x38, 0xF6, 0x64, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83,
  0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x0C, 0x00, 0x01, 0xC0, 0xFE, 0x04,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0F, 0xF8, 0x01, 0xC0, 0x7E, 0x0C, 0x30, 0x03, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x07, 0x80, 0xF8, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0xC7,
  0x0F, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x70, 0x0F, 0x00, 0xA0, 0x12, 0x03,
  0x60, 0x26, 0x06, 0x40, 0x44, 0x08, 0xC1, 0x8C, 0x10, 0xC3, 0x08, 0x20,
  0x84, 0x18, 0xFF, 0xE0, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x07,
  0xF0, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x1F,
  0x01, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x01, 0x8C, 0x70, 0xFE, 0x00, 0x01, 0xE0, 0xF8, 0x30, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0B, 0xE1, 0xCC, 0x70, 0xCC,
  0x19, 0x83, 0x20, 0x64, 0x0C, 0x81, 0x90, 0x22, 0x0C, 0x61, 0x0C, 0x60,
  0xF8, 0x00, 0x3F, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x03, 0x81, 0xF8, 0x61, 0x8C,
  0x11, 0x02, 0x20, 0x44, 0x18, 0x83, 0x18, 0xC1, 0xB0, 0x18, 0x0F, 0x03,
  0x30, 0xC3, 0x30, 0x66, 0x04, 0x80, 0x90, 0x12, 0x06, 0x60, 0xCE, 0x30,
  0xFC, 0x00, 0x03, 0x81, 0xF8, 0x21, 0x0C, 0x31, 0x06, 0x60, 0xCC, 0x19,
  0x03, 0x20, 0x64, 0x0C, 0x83, 0x18, 0xE3, 0xFC, 0x39, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x08, 0xC1, 0xF0, 0x00, 0x18, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0x18, 0x0C, 0x30, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x18, 0x61, 0x0C, 0x20, 0x00, 0x20,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x02, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x08, 0x00, 0x06, 0x0F, 0xC4, 0x60,
  0x10, 0x08, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x01, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x00, 0x00, 0x08, 0x0E, 0x06, 0x00, 0x00, 0x20, 0x07,
  0xF0, 0x18, 0x30, 0x60, 0x21, 0x80, 0x62, 0x00, 0x4C, 0x10, 0x90, 0xF1,
  0x62, 0x22, 0x8C, 0xC5, 0x11, 0x1E, 0x62, 0x3C, 0x84, 0x51, 0x18, 0xA2,
  0x33, 0x44, 0x44, 0x89, 0x99, 0x1D, 0xE2, 0x11, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x02,
  0x80, 0x70, 0x1E, 0x02, 0xC0, 0xD8, 0x1B, 0x02, 0x60, 0xCC, 0x11, 0x86,
  0x30, 0xC6, 0x1F, 0xC6, 0x18, 0x83, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x34,
  0x07, 0x80, 0xC0, 0x0F, 0xE0, 0xC3, 0x0C, 0x30, 0x81, 0x08, 0x11, 0x83,
  0x18, 0x31, 0x86, 0x10, 0xC3, 0xF8, 0x33, 0x83, 0x0C, 0x20, 0x42, 0x06,
  0x60, 0x66, 0x04, 0x60, 0xC4, 0x0C, 0x41, 0x8C, 0xF0, 0xFE, 0x00, 0x01,
  0xE0, 0x3F, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x71, 0x03, 0xF0, 0x0F, 0xE0, 0x63, 0x83,
  0x0C, 0x10, 0x20, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x11, 0x80,
  0x8C, 0x0C, 0x60, 0x62, 0x03, 0x10, 0x11, 0x81, 0x8C, 0x0C, 0x60, 0xC2,
  0x0C, 0x10, 0xE1, 0xBE, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0xF8, 0x3F, 0x83,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x10, 0xFE, 0x00, 0x0F, 0xF0, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x3F, 0x83, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x0F, 0xF0, 0xE0, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x7C, 0xC0, 0x33, 0x00, 0x8C,
  0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x04, 0x18, 0x10, 0x70, 0xC0,
  0xFF, 0x00, 0x0C, 0x04, 0x30, 0x30, 0xC0, 0xC2, 0x03, 0x08, 0x08, 0x60,
  0x21, 0x81, 0x86, 0x06, 0x10, 0x18, 0xFF, 0xC3, 0xFF, 0x0C, 0x0C, 0x20,
  0x30, 0x80, 0x86, 0x02, 0x18, 0x18, 0x60, 0x61, 0x01, 0x84, 0x04, 0x30,
  0x10, 0xC0, 0xC0, 0x07, 0xE0, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x0F, 0xC0, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x3C, 0x00, 0x0C, 0x1C, 0x30, 0xC0, 0xC2, 0x02, 0x18,
  0x08, 0xC0, 0x62, 0x01, 0x98, 0x06, 0xC0, 0x16, 0x00, 0xD8, 0x03, 0xE0,
  0x0C, 0x80, 0x32, 0x00, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x61, 0x01, 0x06,
  0x04, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0F,
  0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x28, 0x07, 0x05, 0x00, 0xA0, 0xA0,
  0x3C, 0x34, 0x05, 0x86, 0x81, 0xB0, 0x90, 0x24, 0x12, 0x0C, 0x86, 0x41,
  0xB0, 0xC8, 0x26, 0x19, 0x0C, 0xC2, 0x21, 0x10, 0x44, 0x62, 0x18, 0xC8,
  0xC3, 0x1B, 0x18, 0x63, 0x42, 0x08, 0x78, 0x41, 0x0E, 0x18, 0x61, 0xC3,
  0x0C, 0x30, 0x60, 0x0E, 0x06, 0x1C, 0x0C, 0x28, 0x18, 0x50, 0x20, 0xA0,
  0x43, 0x61, 0x86, 0xC3, 0x09, 0x86, 0x11, 0x08, 0x62, 0x30, 0xC4, 0x61,
  0x8C, 0xC2, 0x19, 0x04, 0x32, 0x18, 0x2C, 0x30, 0x58, 0x60, 0xB0, 0x81,
  0xC1, 0x03, 0x86, 0x07, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x3F, 0x03, 0x0C,
  0x30, 0x21, 0x81, 0x18, 0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x13, 0x00, 0x90,
  0x05, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x06,
  0x30, 0x31, 0x83, 0x06, 0x30, 0x1F, 0x00, 0x0F, 0xC0, 0xC6, 0x0C, 0x30,
  0x83, 0x08, 0x31, 0x83, 0x18, 0x31, 0x82, 0x10, 0x63, 0x0C, 0x31, 0x83,
  0xF0, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0x03, 0x0C, 0x30, 0x21, 0x81, 0x18,
  0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x13, 0x00, 0x90, 0x05, 0x80, 0x6C, 0x03,
  0x60, 0x1B, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x31, 0x83, 0x06,
  0x30, 0x1F, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x0F,
  0xC0, 0xC6, 0x0C, 0x30, 0x83, 0x08, 0x31, 0x83, 0x18, 0x31, 0x86, 0x10,
  0x63, 0x0C, 0x3F, 0x83, 0xE0, 0x22, 0x02, 0x30, 0x63, 0x06, 0x30, 0x61,
  0x04, 0x10, 0x41, 0x8C, 0x18, 0xC1, 0x80, 0x00, 0xE0, 0x3F, 0xC3, 0x84,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x0C, 0x38, 0x7F, 0x00, 0xFF, 0xC3, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x18,
  0xC0, 0xC4, 0x06, 0x20, 0x23, 0x03, 0x18, 0x18, 0xC0, 0xC4, 0x04, 0x20,
  0x23, 0x03, 0x18, 0x18, 0xC0, 0xC4, 0x04, 0x60, 0x63, 0x03, 0x18, 0x18,
  0xC0, 0x86, 0x0C, 0x30, 0x60, 0xC6, 0x07, 0xE0, 0x00, 0x80, 0x70, 0x1A,
  0x02, 0x40, 0xC8, 0x19, 0x06, 0x20, 0xC4, 0x10, 0x86, 0x10, 0x82, 0x30,
  0x46, 0x09, 0x81, 0x30, 0x24, 0x05, 0x80, 0xA0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x00, 0x40, 0x60, 0x68, 0x1C, 0x09, 0x03, 0x03, 0x60, 0x60, 0x4C,
  0x1C, 0x19, 0x82, 0x83, 0x30, 0xD0, 0x46, 0x12, 0x18, 0xC2, 0x42, 0x18,
  0xC8, 0xC3, 0x11, 0x18, 0x66, 0x22, 0x0C, 0x84, 0xC1, 0x90, 0x90, 0x36,
  0x16, 0x06, 0x82, 0xC0, 0xF0, 0x50, 0x1E, 0x0E, 0x03, 0x81, 0x80, 0x70,
  0x30, 0x0C, 0x0E, 0x00, 0x06, 0x0C, 0x08, 0x20, 0x21, 0x80, 0x8C, 0x03,
  0x30, 0x0D, 0x80, 0x34, 0x00, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x36, 0x00, 0xC8, 0x06, 0x20, 0x10, 0x80, 0xC2, 0x02,
  0x0C, 0x18, 0x30, 0xC0, 0xC0, 0x40, 0xD0, 0x24, 0x19, 0x04, 0x63, 0x18,
  0x86, 0x61, 0x90, 0x6C, 0x0A, 0x03, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x7C, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x0F, 0x83, 0xF0, 0x00, 0xCC, 0xC4, 0x44, 0x46, 0x66, 0x22,
  0x22, 0x33, 0x33, 0x11, 0x10, 0x03, 0xE0, 0xFC, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x1F, 0x83, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x2C, 0x0C,
  0x81, 0x18, 0x63, 0x08, 0x23, 0x06, 0x40, 0xD8, 0x0C, 0xFF, 0xC6, 0x62,
  0x10, 0x0F, 0x63, 0x3C, 0xC3, 0x10, 0x66, 0x0C, 0xC1, 0x90, 0x36, 0x04,
  0xC0, 0x98, 0x32, 0x06, 0x40, 0x88, 0x31, 0x86, 0x31, 0xC3, 0xD8, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xDE, 0x1E, 0x63,
  0x0C, 0x60, 0x88, 0x13, 0x06, 0x60, 0xC8, 0x19, 0x03, 0x60, 0x4C, 0x19,
  0x83, 0x30, 0x46, 0x19, 0xE6, 0x27, 0x80, 0x0F, 0x8C, 0x4C, 0x04, 0x06,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x06, 0x03, 0x10,
  0xF8, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0xF6, 0x19, 0xE3, 0x0C, 0x20, 0xC6, 0x0C, 0x40, 0xC4, 0x08, 0xC0, 0x8C,
  0x08, 0xC1, 0x88, 0x18, 0x81, 0x08, 0x30, 0xC3, 0x0C, 0x70, 0x7B, 0x00,
  0x0F, 0x0C, 0xCC, 0x24, 0x16, 0x1A, 0x0B, 0x0D, 0xF8, 0xE0, 0x40, 0x20,
  0x10, 0x08, 0x06, 0x03, 0x08, 0xFC, 0x00, 0x3C, 0x01, 0xE0, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0xF8, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x03,
  0xD8, 0x33, 0xC3, 0x0C, 0x10, 0x61, 0x83, 0x08, 0x18, 0x40, 0x86, 0x04,
  0x30, 0x21, 0x83, 0x08, 0x18, 0x40, 0x82, 0x0C, 0x18, 0xE0, 0xCF, 0x03,
  0xD8, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x63, 0x01, 0xF0,
  0x00, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xDE,
  0x1C, 0xE3, 0x0C, 0x61, 0x88, 0x23, 0x04, 0x61, 0x88, 0x31, 0x06, 0x60,
  0x8C, 0x11, 0x86, 0x20, 0xC4, 0x19, 0x82, 0x30, 0xC0, 0x04, 0x30, 0xC0,
  0x00, 0x01, 0x86, 0x18, 0x41, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x10,
  0xC3, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0xC0, 0xE0, 0x00, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC3, 0x18, 0xC3, 0x10, 0x46, 0x09, 0x83, 0x60, 0x68, 0x0B, 0x81,
  0xB0, 0x76, 0x0C, 0xC1, 0x88, 0x21, 0x04, 0x31, 0x86, 0x30, 0xC0, 0x04,
  0x10, 0xC3, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC2, 0x08, 0x61,
  0x86, 0x10, 0x43, 0x0C, 0x00, 0x1B, 0xCF, 0x0E, 0x69, 0x86, 0x18, 0x63,
  0x0C, 0x21, 0x04, 0x11, 0x86, 0x08, 0xC3, 0x0C, 0x41, 0x86, 0x20, 0x82,
  0x30, 0x41, 0x18, 0x61, 0x8C, 0x30, 0xC4, 0x18, 0x62, 0x08, 0x23, 0x04,
  0x11, 0x86, 0x18, 0x1B, 0xC2, 0x9C, 0x61, 0x8C, 0x31, 0x04, 0x60, 0x8C,
  0x31, 0x06, 0x20, 0xCC, 0x11, 0x82, 0x30, 0xC4, 0x18, 0x83, 0x30, 0x46,
  0x18, 0x0F, 0x06, 0x63, 0x08, 0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x02, 0xC0,
  0xB0, 0x68, 0x1A, 0x04, 0x83, 0x30, 0x8C, 0x61, 0xF0, 0x0D, 0xE0, 0xF3,
  0x0C, 0x30, 0xC1, 0x08, 0x11, 0x83, 0x18, 0x31, 0x03, 0x10, 0x33, 0x02,
  0x30, 0x63, 0x06, 0x30, 0x43, 0x0C, 0x79, 0x86, 0xF0, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x0F, 0x63, 0x3C, 0xC3,
  0x10, 0x66, 0x0C, 0x81, 0x90, 0x26, 0x04, 0xC0, 0x98, 0x33, 0x06, 0x40,
  0x88, 0x31, 0x86, 0x33, 0xC3, 0xD8, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x1B, 0x8B, 0x46, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x1F, 0x98,
  0x4C, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x32, 0x31, 0xF0, 0x18, 0x41, 0x04, 0x7C, 0xC2, 0x08, 0x61, 0x86,
  0x10, 0x43, 0x0C, 0x30, 0x82, 0x08, 0x38, 0x30, 0x4C, 0x32, 0x0C, 0x83,
  0x60, 0x98, 0x26, 0x19, 0x06, 0x41, 0xB0, 0x4C, 0x13, 0x0C, 0x83, 0x21,
  0xCC, 0xE3, 0xE8, 0x81, 0xC1, 0xA0, 0xD0, 0x48, 0x64, 0x22, 0x31, 0x10,
  0x98, 0x4C, 0x2C, 0x16, 0x0A, 0x07, 0x03, 0x01, 0x80, 0x83, 0x06, 0x0C,
  0x38, 0x70, 0xA1, 0x42, 0x85, 0x1A, 0x34, 0x48, 0x93, 0x26, 0x4C, 0x91,
  0x22, 0x45, 0x8B, 0x14, 0x28, 0xF0, 0xE3, 0xC3, 0x0E, 0x0C, 0x38, 0x30,
  0xC0, 0x18, 0x30, 0x86, 0x08, 0xC0, 0xC8, 0x0D, 0x80, 0xD0, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x1A, 0x03, 0x20, 0x23, 0x06, 0x30, 0x43, 0x0C,
  0x10, 0x06, 0x0C, 0x18, 0x20, 0x61, 0x81, 0x86, 0x06, 0x10, 0x18, 0xC0,
  0x62, 0x01, 0x98, 0x06, 0x40, 0x1B, 0x00, 0x68, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0xC4, 0x20, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C,
  0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0xC0, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x38, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x30, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0xF0, 0x18, 0x00, 0x78, 0x39, 0xFE, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 21, 7, 0, -21 },
  { 20, 7, 7, 9, 3, -21 },
  { 27, 12, 21, 12, 0, -21 },
  { 59, 12, 25, 11, 0, -23 },
  { 97, 15, 22, 17, 1, -22 },
  { 139, 11, 22, 11, 0, -22 },
  { 170, 3, 7, 5, 3, -21 },
  { 173, 8, 26, 7, 1, -21 },
  { 199, 8, 26, 8, -2, -21 },
  { 225, 8, 9, 10, 3, -23 },
  { 234, 11, 14, 12, 1, -18 },
  { 254, 4, 7, 5, -1, -3 },
  { 258, 6, 2, 8, 1, -9 },
  { 260, 3, 3, 5, 0, -3 },
  { 262, 13, 21, 9, -1, -21 },
  { 297, 10, 22, 11, 1, -22 },
  { 325, 7, 21, 11, 3, -21 },
  { 344, 12, 22, 11, -1, -22 },
  { 377, 12, 22, 11, -1, -22 },
  { 410, 12, 22, 11, -1, -22 },
  { 443, 12, 21, 11, -1, -21 },
  { 475, 11, 22, 11, 1, -22 },
  { 506, 11, 21, 11, 1, -21 },
  { 535, 11, 22, 11, 0, -22 },
  { 566, 11, 22, 11, 0, -22 },
  { 597, 5, 16, 5, 0, -16 },
  { 607, 6, 20, 5, -1, -16 },
  { 622, 11, 13, 12, 1, -17 },
  { 640, 11, 7, 12, 1, -14 },
  { 650, 11, 13, 12, 1, -17 },
  { 668, 9, 22, 8, 0, -22 },
  { 693, 15, 25, 16, 1, -22 },
  { 740, 11, 22, 11, -2, -22 },
  { 771, 12, 21, 12, 0, -21 },
  { 803, 12, 22, 11, 1, -22 },
  { 836, 13, 21, 13, 0, -21 },
  { 871, 12, 21, 11, 0, -21 },
  { 903, 12, 21, 10, 0, -21 },
  { 935, 14, 22, 14, 1, -22 },
  { 974, 14, 21, 14, 0, -21 },
  { 1011, 11, 21, 6, -2, -21 },
  { 1040, 10, 26, 5, -4, -21 },
  { 1073, 14, 21, 11, 0, -21 },
  { 1110, 7, 21, 10, 0, -21 },
  { 1129, 19, 21, 19, 0, -21 },
  { 1179, 15, 21, 15, 0, -21 },
  { 1219, 13, 22, 14, 1, -22 },
  { 1255, 12, 21, 11, 0, -21 },
  { 1287, 13, 27, 14, 1, -22 },
  { 1331, 12, 21, 12, 0, -21 },
  { 1363, 13, 22, 11, -1, -22 },
  { 1399, 10, 21, 10, 2, -21 },
  { 1426, 13, 21, 13, 1, -21 },
  { 1461, 11, 21, 11, 3, -21 },
  { 1490, 19, 21, 19, 2, -21 },
  { 1540, 14, 21, 10, -2, -21 },
  { 1577, 10, 21, 10, 2, -21 },
  { 1604, 12, 21, 10, -1, -21 },
  { 1636, 11, 27, 8, -1, -22 },
  { 1674, 4, 21, 10, 3, -21 },
  { 1685, 11, 27, 8, -2, -22 },
  { 1723, 11, 10, 12, 1, -21 },
  { 1737, 8, 1, 8, -2, 3 },
  { 1738, 4, 5, 7, 4, -23 },
  { 1741, 11, 16, 12, 1, -16 },
  { 1763, 11, 23, 12, 0, -23 },
  { 1795, 9, 16, 9, 1, -16 },
  { 1813, 12, 23, 12, 1, -23 },
  { 1848, 9, 16, 11, 1, -16 },
  { 1866, 14, 30, 6, -4, -23 },
  { 1919, 13, 23, 12, -1, -16 },
  { 1957, 11, 23, 12, 0, -23 },
  { 1989, 6, 22, 5, 0, -22 },
  { 2006, 10, 29, 5, -4, -22 },
  { 2043, 11, 23, 10, 0, -23 },
  { 2075, 6, 23, 5, 0, -23 },
  { 2093, 17, 16, 17, 0, -16 },
  { 2127, 11, 16, 12, 0, -16 },
  { 2149, 10, 16, 11, 1, -16 },
  { 2169, 12, 23, 12, -1, -16 },
  { 2204, 11, 23, 12, 1, -16 },
  { 2236, 9, 16, 8, 0, -16 },
  { 2254, 9, 16, 9, 0, -16 },
  { 2272, 6, 20, 6, 1, -20 },
  { 2287, 10, 16, 12, 1, -16 },
  { 2307, 9, 16, 9, 2, -16 },
  { 2325, 14, 16, 15, 2, -16 },
  { 2353, 12, 16, 9, -1, -16 },
  { 2377, 14, 23, 10, -3, -16 },
  { 2418, 10, 16, 8, -1, -16 },
  { 2438, 10, 26, 10, 1, -21 },
  { 2471, 1, 30, 11, 5, -23 },
  { 2475, 11, 26, 10, -2, -21 },
  { 2511, 11, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC30PT7B_H_
