#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x21, 0x00,
  0x00, 0xC3, 0x00, 0x65, 0x94, 0xD3, 0x49, 0x28, 0x80, 0x02, 0x41, 0x10,
  0x4C, 0x12, 0x08, 0x8F, 0xF0, 0x90, 0x44, 0x11, 0x04, 0x83, 0x23, 0xFE,
  0x24, 0x19, 0x04, 0x41, 0x20, 0x48, 0x22, 0x00, 0x02, 0x00, 0x80, 0xF8,
  0x6B, 0x32, 0x09, 0x02, 0x40, 0xD0, 0x14, 0x02, 0x00, 0xC0, 0x28, 0x0B,
  0x02, 0xC1, 0x30, 0x48, 0x9E, 0x3E, 0x01, 0x00, 0x80, 0x18, 0x22, 0x46,
  0x64, 0x44, 0x4C, 0x44, 0x8C, 0xD8, 0x89, 0x08, 0xB6, 0x8A, 0xD9, 0x69,
  0x65, 0x10, 0xD1, 0x09, 0x11, 0x91, 0x13, 0x23, 0x32, 0x23, 0x66, 0x1C,
  0x0F, 0x04, 0x86, 0x42, 0x21, 0x30, 0x90, 0x58, 0x38, 0x18, 0x1C, 0x1B,
  0x28, 0xBC, 0x54, 0x3A, 0x19, 0x0C, 0xCE, 0x3D, 0x80, 0x2D, 0x24, 0xA0,
  0x06, 0x18, 0x20, 0x83, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x00, 0x04, 0x0C, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x06, 0x08, 0x30,
  0x41, 0x06, 0x18, 0x00, 0x10, 0x23, 0x43, 0xF3, 0x0A, 0x22, 0x04, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x32, 0x24, 0x48, 0xFC, 0xF0, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x00, 0x0E, 0x1B, 0x31, 0x21, 0x61,
  0x41, 0x41, 0xC3, 0xC3, 0x83, 0x82, 0x82, 0x86, 0x84, 0x84, 0x8C, 0x98,
  0xF0, 0x19, 0xDD, 0x21, 0x08, 0xC4, 0x21, 0x18, 0xC4, 0x21, 0x18, 0xC4,
  0x00, 0x07, 0x82, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x3F, 0xC0,
  0x07, 0x82, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x06, 0x0E, 0x01,
  0xC0, 0x10, 0x04, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x86, 0x3F, 0x00, 0x01,
  0x80, 0xC0, 0xA0, 0x70, 0x50, 0x48, 0x24, 0x26, 0x33, 0x11, 0x10, 0x88,
  0x48, 0x67, 0xF8, 0x10, 0x08, 0x04, 0x06, 0x00, 0x0F, 0x8C, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x78, 0x6E, 0x01, 0x80, 0xC0, 0x20, 0x30, 0x18,
  0x08, 0x0C, 0x8C, 0x7C, 0x00, 0x07, 0x8C, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x01, 0xB8, 0xE6, 0x61, 0x20, 0x90, 0x48, 0x24, 0x12, 0x19, 0x08, 0xCC,
  0x3C, 0x00, 0x7F, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0x40, 0x00, 0x0F,
  0x0C, 0xC4, 0x26, 0x13, 0x09, 0x84, 0x44, 0x34, 0x0C, 0x1A, 0x18, 0x98,
  0x68, 0x34, 0x0A, 0x0D, 0x04, 0xC6, 0x3E, 0x00, 0x0F, 0x0C, 0xCC, 0x24,
  0x12, 0x09, 0x05, 0x82, 0xC3, 0x61, 0x91, 0x8F, 0x40, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x08, 0x78, 0x00, 0x13, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0,
  0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x46, 0x21, 0x10, 0x01, 0x81,
  0x83, 0x06, 0x0C, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x20, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38,
  0x1C, 0x18, 0x30, 0x60, 0x60, 0x20, 0x00, 0x1E, 0x22, 0x03, 0x03, 0x02,
  0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x20, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x03, 0xC0, 0xC2, 0x18, 0x11, 0x01, 0x20, 0x16, 0x39, 0x44, 0x94,
  0x89, 0x89, 0x99, 0x91, 0x91, 0x19, 0x12, 0x93, 0x29, 0x34, 0x9D, 0xC8,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0xE0, 0x00, 0x80, 0xC0, 0x60, 0x70,
  0x28, 0x34, 0x12, 0x09, 0x0C, 0x84, 0x47, 0xE3, 0xF1, 0x09, 0x84, 0x82,
  0xC1, 0x40, 0xE0, 0x40, 0x0F, 0x02, 0x71, 0x84, 0x41, 0x10, 0x44, 0x33,
  0x08, 0xC6, 0x3E, 0x08, 0xC2, 0x19, 0x86, 0x61, 0x90, 0x64, 0x11, 0x0C,
  0xC6, 0x3F, 0x00, 0x07, 0xC3, 0x11, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40,
  0x1F, 0x00, 0x0F, 0x01, 0x30, 0x63, 0x08, 0x21, 0x04, 0x20, 0xCC, 0x11,
  0x82, 0x20, 0x44, 0x08, 0x83, 0x30, 0x66, 0x08, 0x83, 0x10, 0x42, 0x18,
  0xCE, 0x1F, 0x00, 0x0F, 0xC2, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x3F, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x3F, 0x00, 0x0F, 0xC2, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x0F, 0xC2, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x00, 0x07, 0xE1, 0x84, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x7A, 0x02, 0x40, 0x48, 0x09, 0x03, 0x20, 0x66, 0x08, 0x61,
  0x07, 0xE0, 0x08, 0x10, 0x83, 0x18, 0x31, 0x02, 0x10, 0x21, 0x02, 0x30,
  0x63, 0x04, 0x3F, 0xC2, 0x04, 0x20, 0xC6, 0x0C, 0x60, 0x84, 0x08, 0x40,
  0x84, 0x18, 0xC1, 0x88, 0x10, 0x1F, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0xF0, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x83, 0x83,
  0x00, 0x08, 0x21, 0x08, 0x63, 0x08, 0xC1, 0x10, 0x24, 0x0D, 0x81, 0xA0,
  0x2C, 0x06, 0x80, 0x90, 0x32, 0x06, 0x60, 0x8C, 0x10, 0x82, 0x10, 0xC2,
  0x10, 0x60, 0x08, 0x21, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x18, 0x61,
  0x04, 0x10, 0xC3, 0xF0, 0x0C, 0x03, 0x0C, 0x07, 0x1C, 0x06, 0x14, 0x0E,
  0x14, 0x0A, 0x14, 0x1E, 0x34, 0x16, 0x34, 0x34, 0x24, 0x24, 0x24, 0x64,
  0x24, 0x4C, 0x64, 0x48, 0x44, 0x88, 0x44, 0x88, 0x45, 0x08, 0x45, 0x18,
  0xC7, 0x10, 0x86, 0x10, 0x08, 0x18, 0x60, 0x87, 0x04, 0x28, 0x21, 0x43,
  0x0A, 0x18, 0xD8, 0x86, 0xC4, 0x22, 0x21, 0x13, 0x08, 0x90, 0xC4, 0x86,
  0x34, 0x20, 0xA1, 0x07, 0x08, 0x30, 0xC1, 0x84, 0x0C, 0x00, 0x07, 0x82,
  0x31, 0x04, 0xC1, 0x20, 0x58, 0x14, 0x05, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x02, 0x80, 0xA0, 0x68, 0x13, 0x0C, 0xC6, 0x1F, 0x00, 0x0F, 0x02, 0x61,
  0x8C, 0x43, 0x10, 0xC4, 0x33, 0x08, 0xC2, 0x21, 0x8F, 0xC3, 0xC1, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x07, 0x82, 0x31, 0x04,
  0xC1, 0x20, 0x58, 0x14, 0x05, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x02, 0x80,
  0xA0, 0x68, 0x13, 0x0C, 0xC6, 0x1F, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x0F, 0x02, 0x61, 0x8C, 0x43, 0x10, 0xC4, 0x33, 0x08, 0xC2, 0x21, 0x0F,
  0x82, 0x41, 0x90, 0x66, 0x11, 0x84, 0x21, 0x08, 0xC2, 0x30, 0xC0, 0x07,
  0xE1, 0x88, 0x60, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x86, 0x1F, 0x80,
  0xFF, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x10, 0x66, 0x08, 0xC1, 0x10, 0x22,
  0x0C, 0x41, 0x98, 0x22, 0x04, 0x40, 0x88, 0x31, 0x06, 0x60, 0x88, 0x11,
  0x06, 0x20, 0xC4, 0x10, 0xC6, 0x0F, 0x80, 0x80, 0xC0, 0xE0, 0x50, 0x28,
  0x34, 0x12, 0x19, 0x08, 0x8C, 0x44, 0x22, 0x13, 0x09, 0x05, 0x82, 0x81,
  0x40, 0xC0, 0x60, 0x00, 0x81, 0x03, 0x81, 0x02, 0x83, 0x06, 0x83, 0x04,
  0x83, 0x0C, 0x85, 0x08, 0x85, 0x08, 0x8D, 0x18, 0x89, 0x10, 0x89, 0x30,
  0x91, 0x20, 0x91, 0x20, 0xB1, 0x60, 0xA1, 0x40, 0xA1, 0xC0, 0xC1, 0x80,
  0xC1, 0x80, 0xC1, 0x80, 0x08, 0x21, 0x08, 0x21, 0x06, 0x40, 0xD8, 0x0A,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x0D, 0x01, 0x20, 0x44, 0x08,
  0x82, 0x10, 0xC2, 0x10, 0x60, 0x81, 0xC3, 0xC2, 0xC4, 0x44, 0x48, 0x48,
  0x50, 0x50, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x0F,
  0xE0, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x1F, 0xC0,
  0x07, 0xC1, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x3E, 0x00, 0x92, 0x49, 0x32, 0x49, 0x24, 0xD9, 0x24, 0x07,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x3E, 0x00, 0x06, 0x01, 0x80, 0xA0, 0x2C, 0x11, 0x04, 0x42, 0x19,
  0x82, 0xC0, 0xC0, 0xFE, 0x99, 0x30, 0x08, 0x0F, 0x48, 0xEC, 0x24, 0x16,
  0x0B, 0x0D, 0x04, 0x82, 0x41, 0x21, 0x90, 0xC8, 0xC3, 0xA0, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x90, 0x5E, 0x71, 0x30, 0x98, 0x48, 0x24, 0x16,
  0x0A, 0x0D, 0x04, 0x82, 0x43, 0x73, 0x2F, 0x00, 0x04, 0x3C, 0x83, 0x04,
  0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x0F, 0x00, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x82, 0x21, 0xF8, 0x8C, 0x61, 0x10, 0x4C, 0x13, 0x0C,
  0x82, 0x20, 0x88, 0x22, 0x18, 0x86, 0x23, 0x0F, 0x40, 0x04, 0x3C, 0x8B,
  0x14, 0x38, 0xE7, 0x78, 0x81, 0x02, 0x04, 0x0C, 0x4F, 0x00, 0x00, 0xE0,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x03, 0xE0, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0xE0, 0x00, 0x02, 0x00, 0xF4,
  0x23, 0x8C, 0x21, 0x04, 0x61, 0x8C, 0x31, 0x04, 0x20, 0x84, 0x10, 0x86,
  0x10, 0xC2, 0x30, 0x7A, 0x00, 0x40, 0x18, 0x02, 0x00, 0x42, 0x10, 0x3C,
  0x00, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x90, 0x7E, 0x31, 0x30, 0x98,
  0xC8, 0x44, 0x26, 0x13, 0x09, 0x0C, 0x84, 0x42, 0x61, 0x21, 0x80, 0x08,
  0xC0, 0x00, 0x08, 0x46, 0x21, 0x08, 0xC6, 0x21, 0x08, 0xC4, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0xC0, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x46, 0x26, 0x32, 0x12, 0x0B, 0x07,
  0x07, 0xC3, 0x61, 0x10, 0x88, 0x44, 0x62, 0x21, 0x80, 0x08, 0x42, 0x31,
  0x08, 0x42, 0x31, 0x08, 0x46, 0x31, 0x08, 0x46, 0x20, 0x02, 0x10, 0x7D,
  0xE3, 0x18, 0xCC, 0x63, 0x21, 0x8C, 0x84, 0x22, 0x10, 0x98, 0x42, 0x63,
  0x19, 0x08, 0x64, 0x21, 0x10, 0x84, 0xC2, 0x12, 0x18, 0xC0, 0x02, 0x0F,
  0xCE, 0x66, 0x13, 0x19, 0x08, 0x84, 0xC2, 0x61, 0x21, 0x90, 0x88, 0x4C,
  0x24, 0x30, 0x04, 0x1E, 0x23, 0x61, 0x41, 0xC1, 0xC3, 0x83, 0x82, 0x82,
  0x86, 0x84, 0x8C, 0x78, 0x01, 0x02, 0xF0, 0xC4, 0x61, 0x18, 0x44, 0x11,
  0x04, 0xC1, 0x30, 0xC8, 0x22, 0x08, 0x86, 0x73, 0x1F, 0x84, 0x01, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x00, 0x08, 0x0F, 0x48, 0xEC, 0x24, 0x16, 0x0B,
  0x0D, 0x04, 0x82, 0x41, 0x21, 0x90, 0xC8, 0xC7, 0xA0, 0x10, 0x18, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x03, 0x1E, 0x38, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x0C, 0x3F, 0x20, 0x60, 0x60, 0x20,
  0x30, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x88, 0xF8, 0x18, 0x41, 0x1F, 0x30,
  0xC2, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x1C, 0x21, 0x61, 0x61, 0x43,
  0x42, 0x42, 0xC2, 0x86, 0x86, 0x84, 0x8C, 0x8C, 0xF4, 0xC3, 0xC2, 0xC6,
  0xC4, 0x4C, 0x48, 0x48, 0x50, 0x50, 0x70, 0x60, 0x60, 0x40, 0x42, 0x1A,
  0x30, 0x91, 0x8C, 0x9C, 0x4C, 0xA2, 0x65, 0x23, 0x49, 0x1A, 0x58, 0xF2,
  0x87, 0x14, 0x38, 0xC1, 0x86, 0x0C, 0x30, 0x00, 0x10, 0xC6, 0x61, 0x90,
  0x28, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x14, 0x09, 0x06, 0x61, 0x18, 0xC2,
  0x00, 0x04, 0x10, 0x42, 0x04, 0x20, 0x46, 0x04, 0x40, 0x4C, 0x04, 0x80,
  0x58, 0x05, 0x00, 0x50, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0xE0, 0x00, 0x1F, 0x03, 0x02, 0x04, 0x04, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xFC, 0x03, 0x83, 0x03, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x38, 0x18, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x06, 0x01, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0xE0, 0x70, 0x60, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x03, 0x07,
  0x00, 0xF0, 0xC7, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 18, 5, 0, -18 },
  { 15, 6, 7, 7, 2, -18 },
  { 21, 10, 18, 10, 0, -18 },
  { 44, 10, 20, 9, 0, -19 },
  { 69, 12, 18, 14, 1, -18 },
  { 96, 9, 18, 9, 0, -18 },
  { 117, 3, 7, 4, 2, -18 },
  { 120, 7, 22, 6, 1, -18 },
  { 140, 7, 22, 6, -2, -18 },
  { 160, 7, 8, 8, 3, -19 },
  { 167, 9, 12, 10, 1, -15 },
  { 181, 4, 6, 4, -1, -3 },
  { 184, 6, 1, 7, 0, -7 },
  { 185, 2, 2, 4, 0, -2 },
  { 186, 11, 18, 8, -1, -18 },
  { 211, 8, 18, 9, 1, -18 },
  { 229, 5, 18, 9, 3, -18 },
  { 241, 10, 18, 9, -1, -18 },
  { 264, 10, 18, 9, -1, -18 },
  { 287, 9, 18, 9, 0, -18 },
  { 308, 9, 18, 9, 0, -18 },
  { 329, 9, 18, 9, 1, -18 },
  { 350, 9, 18, 9, 1, -18 },
  { 371, 9, 18, 9, 0, -18 },
  { 392, 9, 18, 9, 0, -18 },
  { 413, 4, 13, 4, 0, -13 },
  { 420, 5, 16, 5, -1, -13 },
  { 430, 9, 11, 10, 1, -14 },
  { 443, 9, 6, 10, 1, -12 },
  { 450, 9, 11, 10, 1, -14 },
  { 463, 8, 18, 7, 0, -18 },
  { 481, 12, 20, 14, 1, -18 },
  { 511, 9, 18, 9, -2, -18 },
  { 532, 10, 18, 10, 0, -18 },
  { 555, 10, 18, 9, 1, -18 },
  { 578, 11, 18, 11, 0, -18 },
  { 603, 10, 18, 9, 0, -18 },
  { 626, 10, 18, 8, 0, -18 },
  { 649, 11, 18, 12, 1, -18 },
  { 674, 12, 18, 12, 0, -18 },
  { 701, 8, 18, 5, -1, -18 },
  { 719, 9, 23, 4, -4, -18 },
  { 745, 11, 18, 9, 0, -18 },
  { 770, 6, 18, 8, 0, -18 },
  { 784, 16, 18, 15, 0, -18 },
  { 820, 13, 18, 12, 0, -18 },
  { 850, 10, 18, 12, 1, -18 },
  { 873, 10, 18, 9, 0, -18 },
  { 896, 10, 22, 12, 1, -18 },
  { 924, 10, 18, 10, 0, -18 },
  { 947, 11, 18, 9, -1, -18 },
  { 972, 8, 18, 8, 2, -18 },
  { 990, 11, 18, 11, 1, -18 },
  { 1015, 9, 18, 9, 2, -18 },
  { 1036, 16, 18, 16, 2, -18 },
  { 1072, 11, 18, 8, -1, -18 },
  { 1097, 8, 18, 8, 2, -18 },
  { 1115, 11, 18, 8, -1, -18 },
  { 1140, 10, 22, 7, -1, -18 },
  { 1168, 3, 18, 8, 3, -18 },
  { 1175, 10, 22, 7, -2, -18 },
  { 1203, 10, 9, 10, 0, -18 },
  { 1215, 7, 1, 7, -2, 2 },
  { 1216, 3, 4, 6, 4, -19 },
  { 1218, 9, 14, 10, 1, -14 },
  { 1234, 9, 19, 10, 0, -19 },
  { 1256, 7, 14, 7, 1, -14 },
  { 1269, 10, 19, 10, 1, -19 },
  { 1293, 7, 14, 9, 1, -14 },
  { 1306, 11, 25, 5, -3, -19 },
  { 1341, 11, 20, 10, -1, -14 },
  { 1369, 9, 19, 10, 0, -19 },
  { 1391, 5, 18, 4, 0, -18 },
  { 1403, 8, 24, 4, -3, -18 },
  { 1427, 9, 19, 8, 0, -19 },
  { 1449, 5, 19, 4, 0, -19 },
  { 1461, 14, 14, 14, 0, -14 },
  { 1486, 9, 14, 10, 0, -14 },
  { 1502, 8, 14, 10, 1, -14 },
  { 1516, 10, 20, 10, -1, -14 },
  { 1541, 9, 20, 10, 1, -14 },
  { 1564, 8, 14, 6, 0, -14 },
  { 1578, 8, 14, 7, 0, -14 },
  { 1592, 6, 16, 5, 0, -16 },
  { 1604, 8, 13, 10, 1, -13 },
  { 1617, 8, 13, 8, 1, -13 },
  { 1630, 13, 13, 13, 1, -13 },
  { 1652, 10, 13, 8, -1, -13 },
  { 1669, 12, 19, 8, -3, -13 },
  { 1698, 8, 13, 6, -1, -13 },
  { 1711, 9, 22, 8, 1, -18 },
  { 1736, 1, 25, 9, 4, -19 },
  { 1740, 9, 22, 8, -2, -18 },
  { 1765, 9, 2, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC25PT7B_H_
