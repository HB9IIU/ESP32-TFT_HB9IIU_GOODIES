#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x20, 0x82,
  0x00, 0x01, 0x0C, 0x30, 0x65, 0x34, 0xF2, 0x8A, 0x29, 0x80, 0x03, 0x20,
  0x22, 0x02, 0x60, 0x44, 0x04, 0x40, 0x44, 0x3F, 0xF0, 0x88, 0x08, 0x81,
  0x98, 0x11, 0x01, 0x10, 0xFF, 0xCF, 0xFC, 0x22, 0x06, 0x60, 0x44, 0x04,
  0x40, 0x4C, 0x08, 0x80, 0x01, 0x00, 0x20, 0x1F, 0x0E, 0xF1, 0x20, 0x64,
  0x0C, 0x81, 0x90, 0x14, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x12, 0x02,
  0x60, 0x4C, 0x09, 0x11, 0x63, 0xF8, 0x3C, 0x01, 0x00, 0x20, 0x08, 0x00,
  0x1C, 0x18, 0xD8, 0x42, 0x22, 0x18, 0x88, 0x46, 0x41, 0x19, 0x04, 0x48,
  0x31, 0x20, 0xCD, 0x3B, 0x25, 0xBD, 0xA4, 0x5C, 0xB3, 0x04, 0x8C, 0x12,
  0x20, 0x88, 0x82, 0x62, 0x11, 0x98, 0x46, 0x42, 0x1B, 0x18, 0x38, 0x07,
  0x83, 0x60, 0x88, 0x62, 0x19, 0x86, 0x41, 0x90, 0x28, 0x0E, 0x07, 0x03,
  0xC0, 0x91, 0x44, 0xF1, 0xAC, 0x3A, 0x0C, 0x83, 0x21, 0xCC, 0xD1, 0xE6,
  0x69, 0x6D, 0x20, 0x03, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0x40, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0xC0, 0x08, 0x08, 0xC8, 0x3F, 0x18, 0x28, 0xCC, 0x44, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x33, 0x26, 0x4C, 0x80, 0xFC, 0x5F, 0x00, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x0F, 0x0C, 0xC4, 0x26, 0x12, 0x0B, 0x05,
  0x82, 0x83, 0x41, 0xE0, 0xF0, 0x70, 0x28, 0x14, 0x1A, 0x09, 0x04, 0x86,
  0x42, 0x32, 0x0F, 0x00, 0x0C, 0x72, 0xB2, 0x98, 0x61, 0x84, 0x10, 0xC3,
  0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0x07, 0xC1, 0x8C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x7F, 0x80, 0x07,
  0xC1, 0x8C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x01, 0x81,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x22,
  0x1C, 0x7F, 0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0xF0, 0x14, 0x04, 0x81,
  0x90, 0x26, 0x0C, 0xC1, 0x10, 0x42, 0x18, 0x42, 0x18, 0xC3, 0x1F, 0xF4,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x07, 0xF0, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x1F, 0x01, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x87, 0x0F,
  0xE0, 0x07, 0xC3, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x5E,
  0x38, 0xCC, 0x13, 0x04, 0x81, 0x20, 0x48, 0x32, 0x0C, 0x82, 0x21, 0x8C,
  0xC1, 0xE0, 0x3F, 0xC0, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x0F, 0x83, 0x18, 0x41, 0x08, 0x33, 0x04, 0x20, 0x84,
  0x30, 0xCC, 0x0B, 0x01, 0xC0, 0x78, 0x31, 0x84, 0x11, 0x83, 0x20, 0x64,
  0x0C, 0x81, 0x98, 0x23, 0x0C, 0x3F, 0x00, 0x07, 0x82, 0x31, 0x8C, 0xC1,
  0x30, 0x48, 0x12, 0x04, 0x83, 0x20, 0xC8, 0x73, 0x18, 0xFA, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0xC3, 0xE0, 0x18, 0xC4, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x63, 0x00, 0x0C, 0x30, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x86, 0x18, 0x42, 0x08, 0x00, 0x00, 0x40, 0x70,
  0x70, 0x70, 0x30, 0x30, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x02,
  0x00, 0x3F, 0x09, 0x80, 0x60, 0x30, 0x10, 0x08, 0x08, 0x0C, 0x0C, 0x04,
  0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x00, 0x00, 0x20, 0x38, 0x18, 0x00,
  0x01, 0xF0, 0x18, 0x60, 0x80, 0x86, 0x03, 0x10, 0x04, 0x82, 0x12, 0x3E,
  0x51, 0x91, 0x44, 0x45, 0x33, 0x3C, 0x88, 0xA2, 0x22, 0x88, 0x8A, 0x66,
  0x49, 0x99, 0x22, 0xA8, 0x8C, 0xC2, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0xFC, 0x00, 0x00, 0xC0, 0x30, 0x1C, 0x05, 0x01, 0x40, 0xD0, 0x24,
  0x19, 0x04, 0x43, 0x10, 0xC4, 0x3F, 0x1F, 0xC4, 0x13, 0x04, 0xC1, 0x20,
  0x58, 0x14, 0x07, 0x01, 0x0F, 0xC1, 0x1C, 0x20, 0x84, 0x11, 0x82, 0x30,
  0x44, 0x18, 0x82, 0x31, 0xC7, 0xE0, 0xC6, 0x10, 0x62, 0x0C, 0xC1, 0x98,
  0x33, 0x06, 0x40, 0x88, 0x33, 0x1C, 0x7E, 0x00, 0x03, 0xE1, 0xC4, 0x60,
  0x0C, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x88, 0x1F, 0x00,
  0x0F, 0x80, 0x9E, 0x08, 0x60, 0x83, 0x18, 0x31, 0x83, 0x10, 0x31, 0x03,
  0x30, 0x33, 0x02, 0x30, 0x22, 0x06, 0x20, 0x66, 0x04, 0x60, 0xC4, 0x0C,
  0x41, 0x84, 0x30, 0xCE, 0x0F, 0xC0, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x07, 0xF0, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x7F, 0x00, 0x0F, 0xE1,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xFE, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x00, 0x03, 0xF0, 0x70, 0xC7, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x79, 0x80, 0xCC, 0x06, 0x60,
  0x23, 0x01, 0x18, 0x18, 0xC0, 0xC2, 0x04, 0x1C, 0x20, 0x7F, 0x00, 0x0C,
  0x08, 0x40, 0x42, 0x06, 0x10, 0x31, 0x81, 0x0C, 0x08, 0x40, 0x42, 0x06,
  0x30, 0x31, 0xFF, 0x0C, 0x08, 0x40, 0xC2, 0x06, 0x30, 0x31, 0x81, 0x08,
  0x08, 0x40, 0xC2, 0x06, 0x30, 0x31, 0x81, 0x00, 0x07, 0xC0, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x03, 0xF0, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x82, 0xC0, 0xF0, 0x00, 0x0C, 0x18, 0x41, 0x82, 0x18, 0x11, 0x81,
  0x88, 0x0C, 0xC0, 0x4C, 0x02, 0x40, 0x36, 0x01, 0xE0, 0x0F, 0x80, 0x6C,
  0x02, 0x20, 0x31, 0x01, 0x88, 0x08, 0x60, 0x43, 0x02, 0x08, 0x30, 0x41,
  0x83, 0x00, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1,
  0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x07, 0xF0, 0x0C, 0x01, 0xC3, 0x00,
  0x60, 0xC0, 0x38, 0x38, 0x0A, 0x1E, 0x07, 0x87, 0x81, 0x61, 0x60, 0xD0,
  0x58, 0x24, 0x36, 0x0B, 0x0D, 0x86, 0xC2, 0x21, 0x30, 0x88, 0xC8, 0x22,
  0x22, 0x18, 0x99, 0x86, 0x24, 0x61, 0x0B, 0x10, 0x42, 0x84, 0x10, 0xE1,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x0C, 0x04, 0x30, 0x30, 0xE0, 0xC3, 0x82,
  0x1E, 0x08, 0x68, 0x21, 0x21, 0x84, 0x86, 0x33, 0x10, 0xCC, 0x43, 0x13,
  0x08, 0x4C, 0x21, 0x31, 0x84, 0x86, 0x1A, 0x10, 0x78, 0x40, 0xE1, 0x03,
  0x0C, 0x0C, 0x30, 0x30, 0x07, 0xC0, 0xC6, 0x18, 0x21, 0x03, 0x30, 0x32,
  0x03, 0x60, 0x36, 0x03, 0x40, 0x24, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x6C,
  0x04, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x10, 0x63, 0x03, 0xC0, 0x0F, 0x81,
  0x38, 0x21, 0x84, 0x31, 0x86, 0x30, 0xC4, 0x18, 0x83, 0x30, 0xC6, 0x30,
  0xFC, 0x1F, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x00, 0x07, 0xC0, 0xC6, 0x18, 0x21, 0x03, 0x30, 0x32, 0x03, 0x60,
  0x36, 0x03, 0x40, 0x24, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x04, 0xC0,
  0xCC, 0x0C, 0xC1, 0x8C, 0x10, 0x63, 0x03, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x0F, 0x81, 0x38, 0x21, 0x84, 0x31, 0x86, 0x30,
  0xC4, 0x18, 0x82, 0x30, 0xC6, 0x30, 0xFC, 0x13, 0x02, 0x20, 0xC4, 0x18,
  0x82, 0x18, 0x43, 0x08, 0x63, 0x04, 0x60, 0x80, 0x07, 0xF0, 0xE2, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0xC3,
  0x0F, 0xE0, 0xFF, 0x84, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10,
  0x00, 0x18, 0x11, 0x03, 0x10, 0x33, 0x02, 0x30, 0x22, 0x06, 0x20, 0x62,
  0x06, 0x60, 0x46, 0x04, 0x40, 0xC4, 0x0C, 0xC0, 0x8C, 0x08, 0xC0, 0x88,
  0x18, 0x81, 0x0C, 0x30, 0xC6, 0x07, 0xC0, 0xC0, 0x78, 0x0B, 0x03, 0x60,
  0x4C, 0x19, 0x82, 0x30, 0xC6, 0x18, 0xC2, 0x18, 0xC3, 0x10, 0x66, 0x0C,
  0x81, 0xB0, 0x36, 0x06, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0xC0, 0xF0, 0x30, 0x6C, 0x1C, 0x1B, 0x07, 0x04, 0xC1, 0xC3, 0x30, 0xF0,
  0x8C, 0x2C, 0x23, 0x1B, 0x18, 0xC4, 0x84, 0x31, 0x23, 0x0C, 0xC8, 0x83,
  0x22, 0x20, 0xD8, 0x98, 0x34, 0x24, 0x0D, 0x0B, 0x03, 0xC2, 0x80, 0xA0,
  0xA0, 0x28, 0x38, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x06, 0x08, 0x30, 0xC1,
  0x84, 0x04, 0x60, 0x26, 0x01, 0x20, 0x0B, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x50, 0x06, 0xC0, 0x66, 0x02, 0x30, 0x31, 0x81,
  0x0C, 0x18, 0x21, 0x81, 0x00, 0xC0, 0xA0, 0xD0, 0x48, 0x64, 0x22, 0x31,
  0x10, 0x98, 0x68, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xF0, 0x07, 0xE0,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x07, 0xE0, 0x88, 0xCC, 0xC4, 0x44, 0x46,
  0x66, 0x22, 0x22, 0x23, 0x33, 0x07, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC3, 0xE0, 0x02,
  0x00, 0xE0, 0x14, 0x06, 0xC0, 0x98, 0x31, 0x04, 0x31, 0x02, 0x60, 0x58,
  0x0C, 0xFF, 0xFF, 0xC9, 0x90, 0x0E, 0x46, 0x73, 0x1D, 0x82, 0x60, 0x90,
  0x6C, 0x1B, 0x06, 0x81, 0x20, 0x48, 0x32, 0x0C, 0x86, 0x32, 0x87, 0xA0,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0xB8, 0x53, 0x18, 0x4C,
  0x13, 0x04, 0xC1, 0x20, 0x48, 0x36, 0x0D, 0x83, 0x60, 0x98, 0x66, 0x13,
  0x8C, 0x9E, 0x00, 0x0F, 0x19, 0x30, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xC4, 0x78, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x83, 0x90, 0xCE, 0x31, 0xCC, 0x11, 0x82, 0x20, 0xCC, 0x19,
  0x82, 0x20, 0x44, 0x08, 0x83, 0x10, 0x62, 0x18, 0x65, 0x07, 0xA0, 0x0F,
  0x19, 0x21, 0x61, 0x41, 0xC3, 0xCE, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xC4, 0x7C, 0x00, 0x78, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x0F, 0x80, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x3C, 0x01, 0xC0, 0x00,
  0x03, 0x90, 0x67, 0x0C, 0x71, 0x82, 0x18, 0x21, 0x06, 0x30, 0x63, 0x06,
  0x20, 0x42, 0x04, 0x20, 0xC2, 0x0C, 0x21, 0x83, 0x38, 0x1E, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x08, 0x20, 0xFE, 0x03, 0x80, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x01, 0xB8, 0x53, 0x18, 0xC4, 0x33, 0x0C, 0xC3,
  0x20, 0x88, 0x26, 0x19, 0x86, 0x61, 0x10, 0x44, 0x13, 0x0C, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x21, 0x86, 0x10,
  0x41, 0x0C, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x3C, 0x0E,
  0x00, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x8C, 0x42, 0x11,
  0x84, 0xC3, 0x60, 0xD0, 0x2C, 0x0D, 0x07, 0x41, 0x98, 0x46, 0x11, 0x84,
  0x23, 0x08, 0xC2, 0x00, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10, 0x43,
  0x0C, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC0, 0x17, 0x9E, 0x39, 0xCC,
  0x63, 0x09, 0x86, 0x13, 0x0C, 0x26, 0x10, 0xC8, 0x21, 0x90, 0xC3, 0x61,
  0x84, 0xC2, 0x09, 0x84, 0x32, 0x08, 0x64, 0x30, 0x98, 0x61, 0x30, 0x86,
  0x00, 0x17, 0x85, 0x31, 0x8C, 0xC3, 0x30, 0xCC, 0x22, 0x08, 0x82, 0x61,
  0x98, 0x66, 0x11, 0x04, 0x41, 0x30, 0xCC, 0x30, 0x0F, 0x08, 0x88, 0x6C,
  0x34, 0x1A, 0x0F, 0x07, 0x83, 0x81, 0x40, 0xA0, 0xD0, 0x48, 0x66, 0x61,
  0xE0, 0x09, 0xC1, 0x4C, 0x30, 0x84, 0x11, 0x82, 0x30, 0x44, 0x08, 0x81,
  0x30, 0x66, 0x0C, 0xC1, 0x18, 0x63, 0x08, 0xE3, 0x1B, 0xC2, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x00, 0x0E, 0x46, 0x73, 0x1D, 0x82, 0x60,
  0x90, 0x6C, 0x1B, 0x06, 0x81, 0x20, 0x48, 0x32, 0x0C, 0x86, 0x32, 0x87,
  0xA0, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x13, 0x15,
  0x18, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0x1F, 0x98, 0x88, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0xC0, 0x44, 0x63, 0xE0, 0x10, 0x43, 0x1F, 0x20, 0x86, 0x18,
  0x41, 0x04, 0x30, 0xC2, 0x08, 0x20, 0x83, 0x80, 0x30, 0xC8, 0x22, 0x09,
  0x86, 0x61, 0x98, 0x44, 0x11, 0x04, 0xC3, 0x30, 0xC8, 0x22, 0x18, 0x86,
  0x33, 0x8F, 0x60, 0x83, 0x82, 0x86, 0x84, 0x84, 0x8C, 0x88, 0x98, 0x90,
  0xB0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0x82, 0x0C, 0x30, 0xE1, 0x85, 0x1C,
  0x28, 0xA3, 0x45, 0x12, 0x69, 0x92, 0x48, 0xB2, 0x45, 0x16, 0x28, 0xA1,
  0xC5, 0x0C, 0x30, 0x61, 0x82, 0x0C, 0x00, 0x18, 0x63, 0x18, 0x22, 0x04,
  0xC0, 0x90, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0xC0, 0x58, 0x11, 0x06,
  0x20, 0x84, 0x30, 0xC0, 0x04, 0x08, 0x20, 0xC1, 0x04, 0x08, 0x60, 0x42,
  0x03, 0x30, 0x19, 0x00, 0xC8, 0x06, 0xC0, 0x34, 0x01, 0xE0, 0x0E, 0x00,
  0x50, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x0F, 0x00, 0x70, 0x00, 0x1F, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0xF0, 0x01, 0xC1, 0xC0,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x01, 0xC0,
  0xE0, 0x08, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x06, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x07, 0x01, 0xC0, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x83, 0xC0, 0xF8, 0x63, 0xF8, 0x10,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 20, 6, 0, -20 },
  { 16, 6, 7, 8, 3, -20 },
  { 22, 12, 20, 11, 0, -20 },
  { 52, 11, 23, 10, 0, -21 },
  { 84, 14, 20, 16, 1, -20 },
  { 119, 10, 20, 11, 0, -20 },
  { 144, 3, 7, 5, 3, -20 },
  { 147, 8, 24, 7, 1, -20 },
  { 171, 8, 24, 7, -2, -20 },
  { 195, 8, 8, 9, 3, -21 },
  { 203, 10, 13, 12, 1, -16 },
  { 220, 4, 7, 5, -1, -3 },
  { 224, 6, 1, 7, 1, -8 },
  { 225, 3, 3, 5, 0, -3 },
  { 227, 12, 20, 9, -1, -20 },
  { 257, 9, 20, 10, 1, -20 },
  { 280, 6, 20, 10, 3, -20 },
  { 295, 11, 20, 10, -1, -20 },
  { 323, 11, 20, 10, -1, -20 },
  { 351, 11, 20, 10, -1, -20 },
  { 379, 12, 20, 10, -1, -20 },
  { 409, 10, 20, 10, 1, -20 },
  { 434, 10, 20, 10, 1, -20 },
  { 459, 11, 20, 10, 0, -20 },
  { 487, 10, 20, 10, 0, -20 },
  { 512, 5, 15, 5, 0, -15 },
  { 522, 6, 19, 5, -1, -15 },
  { 537, 10, 12, 12, 1, -16 },
  { 552, 10, 8, 12, 1, -14 },
  { 562, 10, 12, 12, 1, -16 },
  { 577, 9, 20, 7, 0, -20 },
  { 600, 14, 22, 15, 1, -20 },
  { 639, 10, 20, 10, -2, -20 },
  { 664, 11, 20, 11, 0, -20 },
  { 692, 11, 20, 10, 1, -20 },
  { 720, 12, 20, 12, 0, -20 },
  { 750, 11, 20, 10, 0, -20 },
  { 778, 11, 20, 9, 0, -20 },
  { 806, 13, 20, 13, 1, -20 },
  { 839, 13, 20, 13, 0, -20 },
  { 872, 10, 20, 6, -2, -20 },
  { 897, 10, 25, 5, -4, -20 },
  { 929, 13, 20, 11, 0, -20 },
  { 962, 7, 20, 9, 0, -20 },
  { 980, 18, 20, 17, 0, -20 },
  { 1025, 14, 20, 14, 0, -20 },
  { 1060, 12, 20, 13, 1, -20 },
  { 1090, 11, 20, 11, 0, -20 },
  { 1118, 12, 25, 13, 1, -20 },
  { 1156, 11, 20, 11, 0, -20 },
  { 1184, 12, 20, 10, -1, -20 },
  { 1214, 9, 20, 9, 2, -20 },
  { 1237, 12, 20, 13, 1, -20 },
  { 1267, 11, 20, 10, 2, -20 },
  { 1295, 18, 20, 18, 2, -20 },
  { 1340, 13, 20, 9, -2, -20 },
  { 1373, 9, 20, 9, 2, -20 },
  { 1396, 12, 20, 9, -1, -20 },
  { 1426, 11, 24, 8, -1, -20 },
  { 1459, 4, 20, 9, 3, -20 },
  { 1469, 10, 24, 8, -2, -20 },
  { 1499, 11, 10, 11, 0, -20 },
  { 1513, 8, 2, 8, -2, 2 },
  { 1515, 3, 4, 6, 4, -21 },
  { 1517, 10, 15, 11, 1, -15 },
  { 1536, 10, 21, 11, 0, -21 },
  { 1563, 8, 15, 8, 1, -15 },
  { 1578, 11, 21, 11, 1, -21 },
  { 1607, 8, 15, 10, 1, -15 },
  { 1622, 13, 28, 6, -4, -21 },
  { 1668, 12, 22, 11, -1, -15 },
  { 1701, 10, 21, 11, 0, -21 },
  { 1728, 6, 20, 5, 0, -20 },
  { 1743, 10, 27, 5, -4, -20 },
  { 1777, 10, 21, 9, 0, -21 },
  { 1804, 6, 21, 5, 0, -21 },
  { 1820, 15, 15, 16, 0, -15 },
  { 1849, 10, 15, 11, 0, -15 },
  { 1868, 9, 15, 11, 1, -15 },
  { 1885, 11, 21, 11, -1, -15 },
  { 1914, 10, 22, 11, 1, -15 },
  { 1942, 8, 15, 7, 0, -15 },
  { 1957, 9, 15, 8, 0, -15 },
  { 1974, 6, 18, 6, 1, -18 },
  { 1988, 10, 15, 11, 1, -15 },
  { 2007, 8, 15, 9, 2, -15 },
  { 2022, 13, 15, 14, 2, -15 },
  { 2047, 11, 15, 9, -1, -15 },
  { 2068, 13, 22, 9, -3, -15 },
  { 2104, 9, 15, 7, -1, -15 },
  { 2121, 10, 24, 9, 1, -20 },
  { 2151, 2, 28, 10, 4, -21 },
  { 2158, 10, 24, 9, -2, -20 },
  { 2188, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC28PT7B_H_
