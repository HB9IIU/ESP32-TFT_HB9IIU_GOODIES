#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10, 0x43, 0x08, 0x20, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x4D, 0x2C, 0xA2, 0x9A, 0x49, 0x00, 0x02, 0x60,
  0x48, 0x11, 0x02, 0x20, 0x48, 0x11, 0x0F, 0xF8, 0x48, 0x11, 0x02, 0x20,
  0x4C, 0x19, 0x0F, 0xF8, 0x4C, 0x19, 0x02, 0x20, 0x44, 0x09, 0x02, 0x20,
  0x00, 0x01, 0x00, 0x80, 0x30, 0x7F, 0x12, 0x0C, 0x82, 0x40, 0xD0, 0x14,
  0x07, 0x00, 0xC0, 0x38, 0x0B, 0x02, 0x40, 0x90, 0x24, 0x13, 0x35, 0x87,
  0x80, 0x40, 0x20, 0x08, 0x00, 0x18, 0x11, 0xA1, 0x09, 0x08, 0x88, 0x84,
  0x44, 0x22, 0x43, 0x16, 0x11, 0xA0, 0x8B, 0x74, 0x56, 0xF5, 0xA2, 0xCB,
  0x30, 0xD1, 0x84, 0x88, 0x64, 0x42, 0x22, 0x31, 0x21, 0x09, 0x18, 0x70,
  0x07, 0x06, 0x82, 0x43, 0x21, 0x10, 0x88, 0x48, 0x3C, 0x0C, 0x0C, 0x0B,
  0x0D, 0x94, 0x5E, 0x2A, 0x1D, 0x04, 0x86, 0x67, 0x9E, 0x40, 0x5F, 0xA8,
  0x02, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x40, 0x83, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0x10, 0x00, 0x04, 0x06, 0x02,
  0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x60, 0xC0, 0x18, 0x22, 0x43, 0xF3,
  0x0F, 0x32, 0x06, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x32, 0x26, 0x48, 0xFF, 0xC0, 0xF0, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x00, 0x06, 0x1F, 0x11, 0x21, 0x21, 0x61, 0x41, 0x41, 0xC1, 0xC1,
  0x83, 0x83, 0x82, 0x82, 0x86, 0x84, 0x8C, 0x98, 0xF0, 0x08, 0xCB, 0xB9,
  0x08, 0x46, 0x31, 0x08, 0x46, 0x31, 0x08, 0x46, 0x20, 0x07, 0x81, 0xF8,
  0x21, 0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0xFC, 0x00,
  0x03, 0x81, 0xD8, 0x21, 0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x04, 0x03,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x10,
  0xC3, 0xF0, 0x00, 0x00, 0x60, 0x18, 0x03, 0x00, 0xA0, 0x3C, 0x05, 0x81,
  0x20, 0x24, 0x08, 0x83, 0x30, 0x46, 0x10, 0x86, 0x10, 0x82, 0xBF, 0xE0,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x00, 0x07, 0xE0, 0xFC, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x1F, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x10, 0xC3, 0xF0, 0x00, 0x03, 0x87, 0x46,
  0x06, 0x02, 0x03, 0x01, 0x00, 0x90, 0xFE, 0x71, 0x30, 0xD0, 0x68, 0x34,
  0x12, 0x09, 0x0C, 0x84, 0x66, 0x1E, 0x00, 0x3F, 0xDF, 0xE0, 0x08, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x07, 0x07, 0x61, 0x0C, 0xC3,
  0x30, 0xCC, 0x31, 0x08, 0x44, 0x0E, 0x07, 0x03, 0x61, 0x8C, 0xC3, 0x20,
  0x48, 0x12, 0x04, 0x83, 0x31, 0x87, 0xC0, 0x06, 0x06, 0xC4, 0x26, 0x12,
  0x09, 0x05, 0x82, 0xC1, 0x61, 0x90, 0xCD, 0xE3, 0xA0, 0x10, 0x18, 0x08,
  0x0C, 0x04, 0x06, 0x3C, 0x00, 0x10, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x60, 0x0C, 0x30, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x21,
  0x84, 0x10, 0x80, 0x00, 0x80, 0xC1, 0x83, 0x87, 0x06, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x0C, 0x1C, 0x18, 0x30, 0x20,
  0x00, 0x1E, 0x37, 0x03, 0x01, 0x03, 0x02, 0x02, 0x04, 0x08, 0x18, 0x10,
  0x20, 0x20, 0x60, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0x31, 0x82,
  0x04, 0x20, 0x33, 0x00, 0x90, 0x85, 0x8F, 0x28, 0x91, 0x48, 0x8E, 0x44,
  0xE2, 0x65, 0x22, 0x29, 0x11, 0x49, 0x92, 0x4C, 0x91, 0xB8, 0x80, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xB0, 0x6C, 0x13, 0x04, 0xC3, 0x30, 0x8C, 0x7F, 0x10, 0xC4,
  0x33, 0x0C, 0x83, 0x60, 0xD0, 0x3C, 0x0C, 0x0E, 0x01, 0xF8, 0x21, 0x0C,
  0x31, 0x86, 0x20, 0x84, 0x11, 0x86, 0x33, 0x87, 0xC0, 0x86, 0x10, 0x46,
  0x08, 0xC1, 0x10, 0x62, 0x0C, 0x43, 0x18, 0xC3, 0xF0, 0x00, 0x03, 0xC3,
  0xB1, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x83, 0xC0, 0x0E, 0x01,
  0xF8, 0x23, 0x0C, 0x31, 0x86, 0x20, 0xC4, 0x19, 0x83, 0x30, 0x64, 0x0C,
  0x81, 0x10, 0x26, 0x0C, 0xC1, 0x90, 0x62, 0x08, 0x43, 0x19, 0xC3, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0F, 0xC2, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x8F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0F, 0xC3, 0xF0, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x00, 0x03, 0xC0, 0xF7, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC3, 0xC8, 0x0C, 0x80, 0xC8, 0x08, 0x80, 0x8C,
  0x08, 0xC1, 0x86, 0x18, 0x3F, 0x00, 0x08, 0x10, 0x81, 0x08, 0x11, 0x83,
  0x18, 0x31, 0x02, 0x10, 0x23, 0x02, 0x30, 0x63, 0xFE, 0x20, 0x42, 0x04,
  0x60, 0x46, 0x0C, 0x40, 0xC4, 0x08, 0x40, 0x8C, 0x18, 0xC1, 0x80, 0x1F,
  0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x20, 0xF8, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC3, 0xC1, 0xC0, 0x08, 0x30, 0x86,
  0x08, 0x41, 0x8C, 0x19, 0x81, 0x10, 0x12, 0x03, 0x60, 0x3C, 0x02, 0xC0,
  0x34, 0x02, 0x40, 0x66, 0x06, 0x60, 0x42, 0x04, 0x20, 0x43, 0x0C, 0x30,
  0xC3, 0x00, 0x08, 0x20, 0x86, 0x18, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x61,
  0x84, 0x10, 0x43, 0x0F, 0xC0, 0x0C, 0x03, 0x86, 0x01, 0x83, 0x01, 0xC3,
  0x80, 0xA1, 0x40, 0x70, 0xA0, 0x50, 0x50, 0x28, 0x68, 0x24, 0x34, 0x16,
  0x12, 0x1B, 0x09, 0x09, 0x04, 0x8C, 0x86, 0x44, 0x43, 0x36, 0x61, 0x1A,
  0x30, 0x8F, 0x10, 0x47, 0x08, 0x63, 0x84, 0x21, 0x86, 0x00, 0x0C, 0x08,
  0x60, 0x43, 0x06, 0x38, 0x31, 0x41, 0x0B, 0x08, 0x58, 0xC6, 0x46, 0x32,
  0x21, 0x11, 0x08, 0x88, 0x46, 0xC6, 0x36, 0x30, 0xA1, 0x05, 0x08, 0x28,
  0x41, 0xC6, 0x0E, 0x20, 0x60, 0x03, 0x81, 0xF8, 0x61, 0x18, 0x32, 0x06,
  0x40, 0xD8, 0x1A, 0x03, 0x40, 0x78, 0x0B, 0x01, 0x60, 0x68, 0x0D, 0x01,
  0x20, 0x64, 0x08, 0xC3, 0x08, 0xC1, 0xF0, 0x00, 0x0E, 0x03, 0xE0, 0x8C,
  0x61, 0x18, 0x44, 0x11, 0x04, 0xC3, 0x30, 0x88, 0x63, 0xE0, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x03, 0x81, 0xF8, 0x61,
  0x18, 0x32, 0x06, 0x40, 0xD8, 0x1A, 0x03, 0x40, 0x78, 0x0B, 0x01, 0x60,
  0x68, 0x0D, 0x01, 0x20, 0x64, 0x08, 0xC3, 0x08, 0xC1, 0xF0, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x0E, 0x03, 0xE0, 0x8C, 0x61, 0x18, 0x44, 0x11,
  0x04, 0xC3, 0x30, 0x88, 0xC3, 0xE0, 0x90, 0x66, 0x19, 0x84, 0x21, 0x08,
  0x42, 0x30, 0xCC, 0x30, 0x03, 0xC1, 0xFC, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x10, 0x63, 0xF8, 0x00, 0xFF, 0xFF, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0x80, 0x80, 0x10, 0x22, 0x04, 0xC1, 0x98, 0x32, 0x04, 0x40, 0x88, 0x13,
  0x06, 0x60, 0xC8, 0x11, 0x02, 0x20, 0xCC, 0x19, 0x02, 0x20, 0x44, 0x18,
  0x82, 0x18, 0xC1, 0xF0, 0x00, 0xC0, 0xF0, 0x2C, 0x1B, 0x06, 0xC1, 0x30,
  0xCC, 0x23, 0x18, 0xC4, 0x31, 0x0C, 0xC3, 0x20, 0xD8, 0x34, 0x0F, 0x03,
  0x80, 0xA0, 0x38, 0x0C, 0x00, 0xC0, 0x81, 0xC1, 0x83, 0xC1, 0x82, 0xC3,
  0x82, 0xC2, 0x86, 0x82, 0x84, 0x84, 0x8C, 0x85, 0x88, 0x8D, 0x88, 0x89,
  0x98, 0x89, 0x90, 0x99, 0xB0, 0x91, 0xA0, 0xB1, 0x20, 0xA1, 0x60, 0xA1,
  0x40, 0xE1, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0x04, 0x18, 0x20, 0x81, 0x88,
  0x0C, 0xC0, 0x64, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0A, 0x00, 0xD0, 0x04, 0x80, 0x44, 0x06, 0x20, 0x21, 0x03, 0x0C,
  0x30, 0x60, 0xC1, 0xE0, 0xB0, 0xD8, 0x44, 0x62, 0x21, 0x20, 0x90, 0x50,
  0x28, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x00,
  0x0F, 0xE1, 0xFC, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18,
  0x03, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0F, 0x80, 0x92, 0x49, 0xB2, 0x49,
  0x26, 0xC9, 0x24, 0x80, 0x07, 0xC1, 0xF0, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x0F, 0x80, 0x02, 0x01, 0x80,
  0x60, 0x2C, 0x19, 0x04, 0x63, 0x08, 0x82, 0x60, 0xF0, 0x10, 0xFE, 0x99,
  0x30, 0x1E, 0x99, 0x48, 0x6C, 0x34, 0x16, 0x0B, 0x05, 0x06, 0x83, 0x41,
  0x21, 0x90, 0xCC, 0xE3, 0xA0, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x01, 0x78, 0x72, 0x38, 0xCC, 0x33, 0x0C, 0x83, 0x20, 0x98, 0x26, 0x09,
  0x06, 0x41, 0x10, 0xCE, 0x62, 0xF0, 0x1E, 0x64, 0x83, 0x04, 0x18, 0x30,
  0x40, 0x81, 0x02, 0x04, 0x0C, 0x8F, 0x00, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x07, 0xA1, 0x94, 0x21, 0x8C, 0x31, 0x04, 0x60, 0x8C,
  0x11, 0x06, 0x20, 0xC4, 0x10, 0x86, 0x10, 0xC3, 0x38, 0x3A, 0x00, 0x1E,
  0x33, 0x23, 0x43, 0x42, 0xC6, 0xFC, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC4,
  0x7C, 0x00, 0xE0, 0x34, 0x04, 0x00, 0x80, 0x10, 0x06, 0x01, 0xE0, 0x50,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x1C,
  0x00, 0x07, 0xA1, 0x94, 0x21, 0x8C, 0x31, 0x04, 0x60, 0x8C, 0x11, 0x06,
  0x20, 0xC4, 0x10, 0x86, 0x10, 0xC3, 0x38, 0x3A, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x42, 0x18, 0x7E, 0x00, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x5E, 0x33, 0x10, 0x98, 0x4C, 0x24, 0x32, 0x1B, 0x09, 0x84, 0x82, 0x43,
  0x21, 0x30, 0x98, 0x40, 0x08, 0x40, 0x00, 0x08, 0x42, 0x31, 0x08, 0x46,
  0x31, 0x08, 0x46, 0x30, 0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x10, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0xE0, 0x00, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x04, 0x01, 0x0C, 0x46, 0x13, 0x0C, 0x82, 0x40, 0xB0,
  0x3C, 0x1F, 0x06, 0x41, 0x10, 0x44, 0x11, 0x8C, 0x63, 0x18, 0x0C, 0x20,
  0x82, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C,
  0x30, 0x17, 0x3C, 0x67, 0x33, 0x0C, 0x4C, 0x21, 0x21, 0x84, 0x86, 0x32,
  0x10, 0xD8, 0x42, 0x61, 0x09, 0x0C, 0x24, 0x31, 0x90, 0x86, 0xC2, 0x13,
  0x18, 0x40, 0x17, 0x8C, 0xCC, 0x26, 0x13, 0x09, 0x0C, 0x86, 0xC2, 0x61,
  0x20, 0x90, 0xC8, 0x4C, 0x26, 0x10, 0x1E, 0x33, 0x21, 0x61, 0x41, 0xC1,
  0xC1, 0x83, 0x83, 0x82, 0x82, 0x86, 0xCC, 0x78, 0x0B, 0xC1, 0xC8, 0x31,
  0x8C, 0x31, 0x86, 0x20, 0xC4, 0x11, 0x82, 0x30, 0x44, 0x18, 0x82, 0x10,
  0xC7, 0x30, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x00,
  0x1E, 0x99, 0x48, 0x6C, 0x34, 0x16, 0x0B, 0x05, 0x06, 0x83, 0x41, 0x21,
  0x90, 0xCC, 0xE3, 0xA0, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x17,
  0x1C, 0x38, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0x1F, 0x31, 0x20, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x04,
  0x0C, 0x8C, 0xF8, 0x11, 0x88, 0xFA, 0x31, 0x88, 0x42, 0x31, 0x88, 0x42,
  0x10, 0xE0, 0x21, 0x90, 0xD8, 0x4C, 0x24, 0x12, 0x19, 0x0D, 0x84, 0xC2,
  0x43, 0x21, 0x90, 0x88, 0xC7, 0xA0, 0x83, 0x0E, 0x14, 0x68, 0x93, 0x24,
  0x48, 0xB1, 0x43, 0x86, 0x0C, 0x10, 0x00, 0x43, 0x0A, 0x18, 0xD1, 0x44,
  0x8A, 0x24, 0x53, 0x25, 0x91, 0x2D, 0x8B, 0x68, 0x53, 0x46, 0x9E, 0x38,
  0xE1, 0xC5, 0x0E, 0x30, 0x61, 0x80, 0x10, 0xC6, 0x21, 0x98, 0x24, 0x0A,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x05, 0x02, 0x61, 0x98, 0x42, 0x30, 0x80,
  0x04, 0x18, 0x20, 0x81, 0x0C, 0x08, 0x40, 0x46, 0x02, 0x20, 0x13, 0x00,
  0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0x03,
  0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xFC, 0x00,
  0x83, 0xC1, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x1C,
  0x0E, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x03, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x30, 0x30, 0x30, 0x10, 0x08, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x81, 0x83, 0x80, 0x20, 0x7C, 0x61, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 19, 6, 0, -19 },
  { 16, 6, 7, 8, 3, -19 },
  { 22, 11, 19, 10, 0, -19 },
  { 49, 10, 22, 10, 0, -20 },
  { 77, 13, 19, 15, 1, -19 },
  { 108, 9, 19, 10, 0, -19 },
  { 130, 2, 7, 4, 3, -19 },
  { 132, 7, 23, 6, 1, -19 },
  { 153, 8, 23, 7, -2, -19 },
  { 176, 7, 8, 9, 3, -20 },
  { 183, 9, 12, 11, 1, -15 },
  { 197, 4, 6, 5, -1, -3 },
  { 200, 5, 2, 7, 1, -8 },
  { 202, 2, 2, 5, 0, -2 },
  { 203, 11, 19, 8, -1, -19 },
  { 230, 8, 19, 10, 1, -19 },
  { 249, 5, 19, 10, 3, -19 },
  { 261, 11, 19, 10, -1, -19 },
  { 288, 11, 19, 10, -1, -19 },
  { 315, 11, 19, 10, -1, -19 },
  { 342, 11, 19, 10, -1, -19 },
  { 369, 9, 19, 10, 1, -19 },
  { 391, 10, 19, 10, 1, -19 },
  { 415, 10, 19, 10, 0, -19 },
  { 439, 9, 19, 10, 0, -19 },
  { 461, 5, 14, 5, 0, -14 },
  { 470, 6, 17, 5, -1, -14 },
  { 483, 9, 11, 11, 1, -15 },
  { 496, 9, 7, 11, 1, -13 },
  { 504, 9, 11, 11, 1, -15 },
  { 517, 8, 19, 7, 0, -19 },
  { 536, 13, 21, 14, 1, -19 },
  { 571, 10, 19, 9, -2, -19 },
  { 595, 11, 19, 10, 0, -19 },
  { 622, 10, 19, 9, 1, -19 },
  { 646, 11, 19, 11, 0, -19 },
  { 673, 10, 19, 9, 0, -19 },
  { 697, 10, 19, 9, 0, -19 },
  { 721, 12, 19, 12, 1, -19 },
  { 750, 12, 19, 12, 0, -19 },
  { 779, 8, 19, 6, -1, -19 },
  { 798, 9, 24, 5, -4, -19 },
  { 825, 12, 19, 10, 0, -19 },
  { 854, 6, 19, 8, 0, -19 },
  { 869, 17, 19, 16, 0, -19 },
  { 910, 13, 19, 13, 0, -19 },
  { 941, 11, 19, 12, 1, -19 },
  { 968, 10, 19, 10, 0, -19 },
  { 992, 11, 23, 12, 1, -19 },
  { 1024, 10, 19, 10, 0, -19 },
  { 1048, 11, 19, 9, -1, -19 },
  { 1075, 8, 19, 8, 2, -19 },
  { 1094, 11, 19, 12, 1, -19 },
  { 1121, 10, 19, 10, 2, -19 },
  { 1145, 16, 19, 16, 2, -19 },
  { 1183, 13, 19, 9, -2, -19 },
  { 1214, 9, 19, 8, 2, -19 },
  { 1236, 11, 19, 8, -1, -19 },
  { 1263, 10, 23, 7, -1, -19 },
  { 1292, 3, 19, 9, 3, -19 },
  { 1300, 10, 23, 7, -2, -19 },
  { 1329, 10, 10, 10, 0, -19 },
  { 1342, 7, 1, 7, -2, 2 },
  { 1343, 3, 4, 6, 4, -20 },
  { 1345, 9, 14, 10, 1, -14 },
  { 1361, 10, 20, 10, 0, -20 },
  { 1386, 7, 14, 8, 1, -14 },
  { 1399, 11, 20, 10, 1, -20 },
  { 1427, 8, 14, 9, 1, -14 },
  { 1441, 11, 26, 5, -3, -20 },
  { 1477, 11, 20, 10, -1, -14 },
  { 1505, 9, 20, 10, 0, -20 },
  { 1528, 5, 19, 5, 0, -19 },
  { 1540, 9, 25, 5, -3, -19 },
  { 1569, 10, 20, 9, 0, -20 },
  { 1594, 6, 20, 4, 0, -20 },
  { 1609, 14, 14, 15, 0, -14 },
  { 1634, 9, 14, 10, 0, -14 },
  { 1650, 8, 14, 10, 1, -14 },
  { 1664, 11, 20, 10, -1, -14 },
  { 1692, 9, 20, 10, 1, -14 },
  { 1715, 8, 14, 7, 0, -14 },
  { 1729, 8, 14, 8, 0, -14 },
  { 1743, 5, 17, 5, 1, -17 },
  { 1754, 9, 14, 10, 1, -14 },
  { 1770, 7, 14, 8, 2, -14 },
  { 1783, 13, 14, 13, 1, -14 },
  { 1806, 10, 14, 8, -1, -14 },
  { 1824, 13, 20, 8, -3, -14 },
  { 1857, 8, 14, 7, -1, -14 },
  { 1871, 9, 23, 8, 1, -19 },
  { 1897, 1, 26, 9, 4, -20 },
  { 1901, 9, 23, 8, -2, -19 },
  { 1927, 9, 3, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC26PT7B_H_
