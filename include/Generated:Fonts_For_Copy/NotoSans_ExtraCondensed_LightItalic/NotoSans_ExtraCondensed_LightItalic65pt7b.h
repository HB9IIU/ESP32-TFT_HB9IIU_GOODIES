#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x0F,
  0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x30,
  0x70, 0x70, 0x60, 0x70, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0x80, 0xE0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x00, 0x70, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x18, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x18, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x06, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF9, 0x8F, 0x00, 0xF0,
  0xC0, 0x80, 0x70, 0x60, 0x00, 0x70, 0x30, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x1E, 0x0C, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x83, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x78, 0xC0, 0x00, 0x3C, 0x60, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xBC,
  0x00, 0x00, 0xCF, 0x00, 0x00, 0x67, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30,
  0xF0, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x03, 0x80, 0x01, 0x83, 0xC0, 0x00, 0xC1, 0xC0, 0x00,
  0xC1, 0xE0, 0x40, 0x61, 0xE0, 0x3C, 0x33, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x03, 0xF8, 0x00, 0x60,
  0x0F, 0xF0, 0x01, 0xC0, 0x38, 0x70, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x01,
  0xC1, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xC0,
  0x70, 0x70, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x83, 0x80, 0x1C, 0x07,
  0x07, 0x00, 0x38, 0x0E, 0x1C, 0x00, 0x60, 0x1C, 0x38, 0x01, 0xC0, 0x38,
  0xE0, 0x03, 0x80, 0xE1, 0xC0, 0x07, 0x01, 0xC7, 0x07, 0xCE, 0x03, 0x8E,
  0x3F, 0xDC, 0x0E, 0x38, 0x7B, 0xF8, 0x1C, 0x71, 0xC3, 0xF0, 0x71, 0xC7,
  0x07, 0xE0, 0xE3, 0x8E, 0x0F, 0xE3, 0x8E, 0x38, 0x1D, 0xFE, 0x1C, 0x70,
  0x3B, 0xFC, 0x70, 0xC0, 0x71, 0xE0, 0xE3, 0x80, 0xE0, 0x03, 0x87, 0x01,
  0xC0, 0x07, 0x0E, 0x03, 0x80, 0x1C, 0x38, 0x07, 0x00, 0x38, 0x70, 0x0E,
  0x00, 0xE0, 0xE0, 0x38, 0x01, 0xC1, 0xC0, 0x70, 0x07, 0x03, 0x80, 0xE0,
  0x0E, 0x06, 0x01, 0xC0, 0x38, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0x03, 0x07, 0x00, 0xE0, 0x07, 0x1C, 0x03, 0x80,
  0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70,
  0xE0, 0x00, 0x79, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0x8E, 0x07, 0x0F, 0x0E, 0x07, 0x0E, 0x0F,
  0x0F, 0x1E, 0x07, 0x0E, 0x1C, 0x07, 0x0E, 0x3C, 0x07, 0x9E, 0x38, 0x07,
  0x9C, 0x78, 0x03, 0x9C, 0x70, 0x03, 0xB8, 0x70, 0x03, 0xF8, 0x70, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03,
  0xE0, 0x70, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x1E, 0x70, 0x3F, 0xFC,
  0x78, 0x3F, 0xF8, 0x78, 0x1F, 0xF0, 0x38, 0x03, 0x80, 0x00, 0x1E, 0x3C,
  0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x18, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x40,
  0xE0, 0x1C, 0x38, 0x0F, 0xCE, 0x04, 0xFB, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x70, 0x07, 0x8C, 0x03, 0xC3, 0x81,
  0xE0, 0xE0, 0x30, 0x1C, 0x08, 0x07, 0x80, 0x00, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x73, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xE3, 0xE0, 0x07, 0x83,
  0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x1E,
  0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE0,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00,
  0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x3C,
  0x01, 0xE0, 0x78, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xE0,
  0x78, 0x03, 0xC1, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x07,
  0xF8, 0x7D, 0xC3, 0xE7, 0x1F, 0x1C, 0xF0, 0xF1, 0x83, 0xC4, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x30, 0x07, 0x80, 0x08, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x03, 0xE0, 0x0E,
  0x00, 0xF0, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x20, 0x01, 0xF0,
  0x18, 0x01, 0xF0, 0x0F, 0xCF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x03,
  0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x18, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x40, 0x03, 0xE0, 0x30, 0x07, 0xE0, 0x1F, 0xBF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x10, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x78, 0x01, 0xC7, 0xFC, 0x03, 0x9F, 0xFC, 0x0F, 0x78,
  0xF8, 0x1F, 0xC0, 0x78, 0x3F, 0x00, 0xF0, 0x7C, 0x00, 0xE0, 0xF0, 0x01,
  0xC3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38,
  0x00, 0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0xF0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x0F,
  0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x03,
  0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x9F, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0xF0,
  0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x0E, 0x03, 0x80,
  0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00,
  0x3E, 0x0E, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x00,
  0xFC, 0x07, 0x83, 0xFC, 0x07, 0xFF, 0xBC, 0x03, 0xFF, 0x38, 0x01, 0xFC,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF7, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xC3,
  0xE0, 0x40, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0x38, 0x38, 0x01, 0xE0, 0x1C, 0x18, 0x03, 0xFE, 0x0E, 0x1C, 0x03, 0xFF,
  0x07, 0x0C, 0x03, 0x87, 0x03, 0x8E, 0x03, 0x83, 0x81, 0xC7, 0x03, 0x81,
  0xC0, 0xC3, 0x01, 0xC0, 0xE0, 0x63, 0x81, 0xC0, 0xE0, 0x71, 0xC0, 0xE0,
  0x70, 0x38, 0xC0, 0xE0, 0x38, 0x1C, 0xE0, 0x70, 0x1C, 0x0E, 0x70, 0x38,
  0x1C, 0x07, 0x38, 0x38, 0x0E, 0x03, 0x1C, 0x1C, 0x07, 0x03, 0x8C, 0x0E,
  0x03, 0x81, 0xCE, 0x07, 0x03, 0x80, 0xC7, 0x03, 0x01, 0xC0, 0xE3, 0x83,
  0x80, 0xE0, 0x71, 0xC1, 0xC0, 0xF0, 0x30, 0xE0, 0xE0, 0x70, 0x38, 0x70,
  0x70, 0x78, 0x1C, 0x38, 0x38, 0x3C, 0x1C, 0x18, 0x1C, 0x36, 0x0C, 0x0C,
  0x07, 0x3B, 0x8E, 0x06, 0x03, 0xF8, 0xFE, 0x03, 0x00, 0xF8, 0x7E, 0x01,
  0x80, 0x10, 0x08, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x40, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x07,
  0x81, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C,
  0x1E, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC7,
  0x80, 0x03, 0x8F, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0,
  0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x3C, 0x07, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0x80,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00,
  0x78, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x3E, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x38, 0x0F, 0x80, 0x07,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x0F,
  0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x70,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x01,
  0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7E, 0x06, 0x00, 0x3E, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x04,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x3C, 0x0F, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0x70, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x3C,
  0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xF0,
  0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x0E, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x01,
  0xC1, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0x18, 0x01, 0xF0, 0x00,
  0x20, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0xFF, 0xC1,
  0xC0, 0x03, 0xFF, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x70, 0x03, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x0C, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0,
  0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xED, 0xC0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xDC, 0x00, 0x01, 0xFE,
  0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x00, 0xF7, 0x00, 0x3B,
  0x80, 0x00, 0x73, 0x80, 0x3D, 0xC0, 0x00, 0x7B, 0xC0, 0x1E, 0xE0, 0x00,
  0x39, 0xE0, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x07, 0x3C, 0x00, 0x1C, 0x70,
  0x03, 0x9E, 0x00, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x01, 0xC7,
  0x80, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x3C, 0x38, 0x01, 0xC3, 0xC0,
  0x1C, 0x1C, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0xF0, 0x70, 0x07, 0x83, 0x80, 0x70, 0x78, 0x03, 0xC1, 0xC0, 0x78,
  0x3C, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x00,
  0x70, 0x38, 0x1C, 0x0F, 0x00, 0x78, 0x1C, 0x0E, 0x07, 0x80, 0x38, 0x0E,
  0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x87, 0x80,
  0xE0, 0x0F, 0x01, 0xC3, 0x80, 0xF0, 0x07, 0x80, 0xE3, 0xC0, 0x78, 0x03,
  0x80, 0x79, 0xC0, 0x38, 0x01, 0xC0, 0x3D, 0xE0, 0x1C, 0x00, 0xE0, 0x1E,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0xF8, 0x01, 0xC0, 0x0E,
  0x00, 0x7C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0,
  0x1F, 0x80, 0x01, 0xC0, 0x0F, 0xC0, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0xF0,
  0x03, 0xF0, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x38, 0x01, 0xFC, 0x00, 0x1C,
  0x00, 0xEF, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x0F, 0x00, 0x39, 0xC0, 0x07,
  0x80, 0x3C, 0xE0, 0x03, 0x80, 0x1E, 0x70, 0x01, 0xC0, 0x0E, 0x3C, 0x01,
  0xE0, 0x07, 0x1E, 0x00, 0xF0, 0x03, 0x87, 0x00, 0x78, 0x03, 0xC3, 0x80,
  0x38, 0x01, 0xE1, 0xC0, 0x1C, 0x00, 0xE0, 0xE0, 0x1E, 0x00, 0x70, 0x78,
  0x0F, 0x00, 0x78, 0x1C, 0x07, 0x00, 0x3C, 0x0E, 0x03, 0x80, 0x1C, 0x07,
  0x01, 0xC0, 0x0E, 0x03, 0x81, 0xE0, 0x07, 0x01, 0xC0, 0xF0, 0x07, 0x80,
  0xF0, 0x70, 0x03, 0xC0, 0x38, 0x38, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0xE0,
  0x0E, 0x1E, 0x00, 0x70, 0x07, 0x0F, 0x00, 0x78, 0x03, 0xC7, 0x00, 0x3C,
  0x01, 0xE3, 0x80, 0x1C, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x39, 0xE0, 0x0F,
  0x00, 0x1C, 0xE0, 0x07, 0x80, 0x0E, 0x70, 0x03, 0x80, 0x07, 0xB8, 0x01,
  0xC0, 0x03, 0xDC, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x0F, 0xC0,
  0x0E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x78, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1F, 0x03, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x70, 0x0F, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x03,
  0xC0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x78,
  0x03, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x1C, 0x1F,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0x78, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1F, 0x03, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x70, 0x0F, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x38,
  0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0x80,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0x00, 0xF0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x07, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x1E,
  0x01, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC1,
  0xF0, 0x07, 0xC0, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x07, 0x80,
  0x38, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x07,
  0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80,
  0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x3C, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE1, 0xC0, 0x00,
  0xE3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00,
  0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0xB8, 0x00, 0x1E, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x00, 0x03,
  0x8E, 0x00, 0x0F, 0x80, 0x03, 0xCF, 0x00, 0x07, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xF8,
  0x00, 0x70, 0xF0, 0x00, 0xDC, 0x00, 0x78, 0x78, 0x00, 0xEE, 0x00, 0x3C,
  0x3C, 0x00, 0x77, 0x00, 0x1C, 0x1E, 0x00, 0x73, 0x80, 0x1E, 0x0F, 0x00,
  0x39, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0xE0, 0x0F, 0x03, 0xC0, 0x1C, 0x70,
  0x07, 0x81, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0xF0, 0x0F, 0x1C, 0x03, 0xC0,
  0x78, 0x07, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x87, 0x01, 0xE0, 0x1E, 0x03,
  0x83, 0x80, 0xF0, 0x0F, 0x01, 0xC1, 0xC0, 0x70, 0x07, 0x81, 0xE0, 0xE0,
  0x78, 0x03, 0x80, 0xE0, 0x60, 0x38, 0x01, 0xC0, 0x70, 0x70, 0x3C, 0x00,
  0xE0, 0x70, 0x38, 0x1E, 0x00, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x38, 0x3C,
  0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x03, 0x83,
  0x80, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x01,
  0xC7, 0x80, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x00, 0x71, 0xC0,
  0x1C, 0x70, 0x00, 0x39, 0xC0, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x03, 0xBC, 0x00, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x0F,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x70, 0x00, 0x78, 0xE0, 0x01,
  0xE1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x1E, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E,
  0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0x80, 0x00, 0xEF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0E, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x10, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x79, 0xC0, 0x00,
  0x71, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xF0, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0x78, 0x03, 0x80, 0x78, 0x07, 0x00, 0x38, 0x0F,
  0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x0E,
  0x0E, 0x07, 0x03, 0x00, 0x3F, 0x07, 0x00, 0x7F, 0xC6, 0x01, 0xFF, 0xCE,
  0x01, 0xE0, 0xEE, 0x03, 0xC0, 0x6E, 0x07, 0x80, 0x7E, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0,
  0xE0, 0x03, 0xC0, 0xE0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x0F, 0x80,
  0x78, 0x3B, 0x80, 0x7E, 0xF3, 0x80, 0x3F, 0xE3, 0x80, 0x1F, 0xC3, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE1, 0xF8,
  0x01, 0xE7, 0xFC, 0x01, 0xCF, 0xFE, 0x01, 0xDC, 0x1E, 0x01, 0xF8, 0x0E,
  0x03, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x07, 0x03, 0xC0, 0x07,
  0x03, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x38,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x7C, 0x01, 0xE0, 0x76, 0x03, 0xC0, 0x76, 0x07, 0xC0, 0x77, 0xDF, 0x80,
  0xE3, 0xFF, 0x00, 0xE1, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF0, 0x20, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x40, 0x7E, 0x78, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0xC3, 0xC0, 0x03, 0xFE, 0x70, 0x01, 0xFF, 0xCE, 0x00, 0x7C, 0x1D, 0xC0,
  0x0F, 0x01, 0xB8, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xF0,
  0x00, 0x70, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00,
  0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0xF8, 0x03, 0x80, 0x1F, 0x00,
  0x78, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x00, 0xF0, 0x77, 0x00, 0x1F, 0xBC,
  0xE0, 0x01, 0xFF, 0x1C, 0x00, 0x1F, 0xC3, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x78, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0xF1, 0xC0,
  0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x78,
  0x0F, 0x87, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x60, 0x7E, 0x3E, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x20, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xE0, 0x01, 0xFF,
  0x18, 0x00, 0x7F, 0xE7, 0x00, 0x1E, 0x0E, 0xE0, 0x07, 0x80, 0xDC, 0x01,
  0xE0, 0x1F, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00,
  0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x01,
  0xE0, 0x0E, 0x00, 0x7C, 0x01, 0xC0, 0x0F, 0x80, 0x3C, 0x03, 0xF0, 0x07,
  0x80, 0xFC, 0x00, 0x78, 0x3B, 0x80, 0x0F, 0xDE, 0x70, 0x00, 0xFF, 0x9E,
  0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x01, 0x00, 0x1E, 0x00, 0x30, 0x07, 0x80, 0x07, 0xE7, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0xFC, 0x00, 0xF3, 0xFE, 0x01, 0xCF, 0xFC,
  0x03, 0xB8, 0x7C, 0x07, 0xC0, 0x78, 0x1F, 0x80, 0x70, 0x3E, 0x00, 0xE0,
  0x78, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0xF0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0,
  0x03, 0x81, 0xE0, 0x03, 0x83, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x87, 0x80,
  0x07, 0x8F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x3C, 0x00,
  0x0F, 0x7C, 0x00, 0x0E, 0xFC, 0x00, 0x0E, 0xDC, 0x00, 0x0F, 0xDE, 0x00,
  0x1F, 0x9E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x0F, 0x00,
  0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x70, 0x07, 0x80, 0x70, 0x07, 0x80, 0xF0, 0x03, 0x80, 0xF0, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x01, 0xC3, 0xF0, 0x1F, 0x80, 0x1C, 0xFF, 0x87, 0xFC, 0x01,
  0xDF, 0xFC, 0xFF, 0xE0, 0x1D, 0x83, 0xDC, 0x1E, 0x01, 0xF0, 0x1F, 0x80,
  0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x0E, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x70, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xF0, 0x03,
  0x80, 0x1C, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0x3C, 0x0E,
  0x00, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x03,
  0x81, 0xC0, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x07, 0x81, 0xC0, 0x0E,
  0x00, 0x70, 0x3C, 0x00, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xE0, 0x0F, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x0E,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x70, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x01, 0xC3, 0xF0, 0x03, 0x8F, 0xF8, 0x07, 0x7F,
  0xF0, 0x0E, 0xE1, 0xF0, 0x1F, 0x01, 0xE0, 0x7E, 0x01, 0xC0, 0xF8, 0x03,
  0x81, 0xE0, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x70,
  0x3C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x07,
  0x80, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xC1, 0xE0, 0x3C, 0x07, 0x03, 0xC0,
  0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0xCF,
  0x00, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x01,
  0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0,
  0x00, 0xEF, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x3C,
  0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00,
  0x78, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0x7E, 0xFC, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x3F, 0x00,
  0x07, 0x1F, 0xF0, 0x00, 0xE7, 0xFF, 0x00, 0x1D, 0xC1, 0xE0, 0x03, 0xB0,
  0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x00,
  0x78, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00,
  0x70, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xB0, 0x1E, 0x00, 0x76, 0x07, 0xC0, 0x0E, 0xFB, 0xF0, 0x01,
  0xCF, 0xFC, 0x00, 0x78, 0xFE, 0x00, 0x0F, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07,
  0x00, 0x7F, 0xC6, 0x01, 0xFF, 0xCE, 0x01, 0xE0, 0xEE, 0x03, 0xC0, 0x6E,
  0x07, 0x80, 0x7E, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0xC0, 0xE0, 0x07, 0xC0,
  0xF0, 0x0F, 0xC0, 0xF0, 0x1F, 0x80, 0x78, 0x3B, 0x80, 0x7E, 0xF3, 0x80,
  0x3F, 0xE7, 0x80, 0x1F, 0xC7, 0x80, 0x07, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC3, 0xF0, 0x1C, 0x7E, 0x01, 0xCF, 0xE0, 0x1D,
  0xE2, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0x80, 0x7F, 0xFE, 0x07, 0xC0, 0xE0, 0x3C, 0x01, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x18, 0x07, 0xC0, 0xF9, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC0, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF9, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x00, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xF8, 0x1C, 0x01,
  0xE0, 0x38, 0x07, 0xC0, 0x78, 0x1B, 0x80, 0xFD, 0xF7, 0x00, 0xFF, 0xCE,
  0x00, 0xFE, 0x18, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7,
  0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x0E,
  0x03, 0xC1, 0xC0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x1E, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xE0,
  0x03, 0xC0, 0x0E, 0xE0, 0x07, 0xC0, 0x1E, 0xE0, 0x07, 0xC0, 0x1C, 0xE0,
  0x07, 0xC0, 0x1C, 0xE0, 0x0F, 0xC0, 0x3C, 0xE0, 0x0F, 0xC0, 0x38, 0xE0,
  0x1D, 0xC0, 0x38, 0xE0, 0x1D, 0xC0, 0x70, 0xE0, 0x1D, 0xC0, 0x70, 0xE0,
  0x39, 0xC0, 0xF0, 0xE0, 0x39, 0xC0, 0xE0, 0xE0, 0x71, 0xC0, 0xE0, 0xE0,
  0x71, 0xC1, 0xC0, 0xE0, 0x71, 0xC1, 0xC0, 0xE0, 0xE1, 0xC3, 0xC0, 0xE0,
  0xE1, 0xC3, 0x80, 0xE1, 0xC1, 0xC3, 0x80, 0xE1, 0xC1, 0x87, 0x00, 0xE1,
  0xC1, 0x87, 0x00, 0xE3, 0x81, 0x87, 0x00, 0xE3, 0x83, 0x8E, 0x00, 0xE7,
  0x03, 0x8E, 0x00, 0xE7, 0x03, 0x9C, 0x00, 0xE7, 0x03, 0x9C, 0x00, 0xEE,
  0x03, 0x9C, 0x00, 0xEE, 0x03, 0xB8, 0x00, 0xFC, 0x03, 0xB8, 0x00, 0xFC,
  0x03, 0xB8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03,
  0x80, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x27,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x02, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xD0, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 46, 14, 1, -46 },
  { 82, 16, 16, 19, 6, -46 },
  { 114, 27, 46, 26, 0, -46 },
  { 270, 25, 53, 24, 0, -49 },
  { 436, 31, 48, 37, 3, -47 },
  { 622, 24, 48, 24, -1, -47 },
  { 766, 7, 16, 11, 6, -46 },
  { 780, 19, 56, 16, 1, -46 },
  { 913, 19, 56, 16, -5, -46 },
  { 1046, 18, 19, 22, 7, -49 },
  { 1089, 23, 30, 27, 2, -38 },
  { 1176, 10, 15, 12, -3, -7 },
  { 1195, 14, 3, 17, 1, -19 },
  { 1201, 5, 6, 12, 1, -6 },
  { 1205, 28, 46, 20, -3, -46 },
  { 1366, 23, 48, 24, 1, -47 },
  { 1504, 14, 46, 24, 7, -46 },
  { 1585, 26, 47, 24, -2, -47 },
  { 1738, 25, 48, 24, -1, -47 },
  { 1888, 25, 47, 24, -1, -47 },
  { 2035, 25, 47, 24, -1, -46 },
  { 2182, 23, 48, 24, 2, -47 },
  { 2320, 24, 46, 24, 2, -46 },
  { 2458, 26, 48, 24, -1, -47 },
  { 2614, 24, 48, 24, 0, -47 },
  { 2758, 11, 35, 12, 0, -35 },
  { 2807, 15, 43, 12, -3, -35 },
  { 2888, 23, 28, 27, 2, -37 },
  { 2969, 23, 17, 27, 2, -31 },
  { 3018, 23, 28, 27, 2, -37 },
  { 3099, 19, 47, 17, 1, -47 },
  { 3211, 33, 53, 36, 2, -47 },
  { 3430, 23, 47, 24, -4, -47 },
  { 3566, 27, 46, 26, 0, -46 },
  { 3722, 26, 48, 24, 2, -47 },
  { 3878, 27, 46, 28, 0, -46 },
  { 4034, 26, 46, 23, 0, -46 },
  { 4184, 26, 46, 21, 0, -46 },
  { 4334, 30, 48, 31, 2, -47 },
  { 4514, 31, 46, 30, 0, -46 },
  { 4693, 22, 46, 14, -4, -46 },
  { 4820, 22, 58, 12, -9, -46 },
  { 4980, 29, 46, 24, 0, -46 },
  { 5147, 16, 46, 21, 0, -46 },
  { 5239, 41, 46, 40, 0, -46 },
  { 5475, 33, 46, 32, 0, -46 },
  { 5665, 27, 48, 31, 2, -47 },
  { 5827, 26, 46, 25, 0, -46 },
  { 5977, 27, 58, 31, 2, -47 },
  { 6173, 26, 46, 25, 0, -46 },
  { 6323, 27, 48, 23, -2, -47 },
  { 6485, 22, 46, 21, 4, -46 },
  { 6612, 29, 47, 29, 2, -46 },
  { 6783, 24, 46, 24, 6, -46 },
  { 6921, 41, 46, 41, 5, -46 },
  { 7157, 31, 46, 22, -4, -46 },
  { 7336, 23, 46, 21, 4, -46 },
  { 7469, 28, 46, 21, -3, -46 },
  { 7630, 23, 57, 18, -1, -47 },
  { 7794, 9, 47, 21, 7, -47 },
  { 7847, 24, 57, 18, -4, -47 },
  { 8018, 24, 23, 26, 1, -46 },
  { 8087, 18, 2, 18, -5, 6 },
  { 8092, 8, 11, 15, 9, -50 },
  { 8103, 24, 36, 26, 2, -35 },
  { 8211, 24, 50, 26, 0, -49 },
  { 8361, 19, 36, 19, 2, -35 },
  { 8447, 27, 50, 26, 2, -49 },
  { 8616, 20, 36, 23, 2, -35 },
  { 8706, 29, 66, 13, -8, -50 },
  { 8946, 27, 51, 26, -1, -35 },
  { 9119, 23, 49, 25, 0, -49 },
  { 9260, 14, 47, 11, 0, -47 },
  { 9343, 23, 63, 12, -9, -47 },
  { 9525, 24, 49, 21, 0, -49 },
  { 9672, 14, 49, 11, 0, -49 },
  { 9758, 36, 35, 38, 0, -35 },
  { 9916, 23, 35, 25, 0, -35 },
  { 10017, 21, 36, 25, 2, -35 },
  { 10112, 27, 50, 26, -3, -35 },
  { 10281, 24, 50, 26, 2, -35 },
  { 10431, 20, 35, 17, 0, -35 },
  { 10519, 21, 36, 19, -1, -35 },
  { 10614, 14, 44, 14, 1, -43 },
  { 10691, 23, 36, 25, 2, -35 },
  { 10795, 19, 35, 20, 4, -35 },
  { 10879, 32, 35, 33, 4, -35 },
  { 11019, 26, 35, 20, -3, -35 },
  { 11133, 31, 51, 21, -7, -35 },
  { 11331, 21, 35, 17, -2, -35 },
  { 11423, 23, 56, 21, 2, -46 },
  { 11584, 3, 66, 23, 10, -50 },
  { 11609, 23, 56, 21, -4, -46 },
  { 11770, 23, 6, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC65PT7B_H_
