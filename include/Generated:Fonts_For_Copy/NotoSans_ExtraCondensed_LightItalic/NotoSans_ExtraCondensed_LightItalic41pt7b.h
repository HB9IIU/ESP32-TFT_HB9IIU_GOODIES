#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x00,
  0x00, 0x00, 0x40, 0xE0, 0xE0, 0xC0, 0x31, 0xCC, 0x67, 0x19, 0x86, 0x63,
  0x18, 0xC6, 0x33, 0x0C, 0xC2, 0x31, 0x80, 0x00, 0x61, 0x80, 0x21, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x08,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0xC2, 0x00, 0x43, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x04, 0x30, 0x3F, 0xFF, 0x1F,
  0xFF, 0x81, 0x84, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x21, 0x80,
  0x30, 0xC0, 0x18, 0x40, 0x08, 0x60, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0x26, 0x0E, 0x60, 0x0C,
  0x40, 0x0C, 0x40, 0x18, 0x40, 0x18, 0x40, 0x0C, 0xC0, 0x0C, 0x80, 0x0E,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0x70, 0x01,
  0x30, 0x03, 0x30, 0x02, 0x18, 0x02, 0x18, 0x02, 0x18, 0x02, 0x30, 0x06,
  0x30, 0x84, 0x60, 0xFF, 0xC0, 0x7F, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x0C, 0x19, 0x81, 0x83, 0x08,
  0x18, 0x30, 0x83, 0x02, 0x08, 0x30, 0x61, 0x86, 0x06, 0x18, 0x60, 0x61,
  0x8C, 0x0C, 0x18, 0xC0, 0xC1, 0x98, 0x0C, 0x11, 0x80, 0xC3, 0x31, 0xCC,
  0x33, 0x3E, 0xC2, 0x66, 0x2C, 0x66, 0xC3, 0xCC, 0xCC, 0x37, 0x8C, 0xC3,
  0x31, 0x98, 0x30, 0x19, 0x82, 0x03, 0x18, 0x60, 0x31, 0x06, 0x06, 0x30,
  0x60, 0x63, 0x06, 0x0C, 0x30, 0xC0, 0xC3, 0x0C, 0x18, 0x30, 0x81, 0x83,
  0x18, 0x30, 0x3B, 0x07, 0x01, 0xE0, 0x00, 0x60, 0x03, 0xF0, 0x0E, 0x60,
  0x18, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x38, 0x0C,
  0x60, 0x19, 0xC0, 0x33, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xC0,
  0x1D, 0x80, 0x73, 0x0C, 0xC6, 0x33, 0x0E, 0x66, 0x0C, 0xD8, 0x1B, 0x30,
  0x36, 0x60, 0x38, 0xC0, 0x71, 0x80, 0xC3, 0x03, 0xC7, 0x0D, 0x8F, 0xF3,
  0x0F, 0xC7, 0x00, 0x33, 0x76, 0x66, 0x64, 0xCC, 0x00, 0x70, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x02, 0x06, 0x20,
  0xF6, 0x31, 0xFF, 0x07, 0x00, 0xF0, 0x3B, 0x07, 0x18, 0x61, 0x80, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x31, 0x86, 0x38, 0xC3, 0x18, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x07, 0xE0, 0x3B, 0x81,
  0x87, 0x0E, 0x0C, 0x30, 0x31, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0xC0, 0x33,
  0x00, 0xCC, 0x07, 0x70, 0x1D, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x1B,
  0x80, 0xEC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x18,
  0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x38, 0xE0, 0x7F, 0x00, 0xF8, 0x00, 0x03,
  0x83, 0xC3, 0xC3, 0x67, 0x37, 0x19, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x01, 0xFC,
  0x07, 0x8E, 0x02, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x78, 0x01, 0xFC,
  0x07, 0x8E, 0x02, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x80, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0B, 0x00, 0x1E, 0x00, 0x16, 0x00, 0x36, 0x00, 0x66,
  0x00, 0x6E, 0x00, 0xCC, 0x01, 0x8C, 0x01, 0x8C, 0x03, 0x0C, 0x03, 0x1C,
  0x06, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30,
  0x60, 0x30, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0D, 0xC0, 0x1F, 0xF0, 0x0C, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x80, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0x88,
  0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x3E, 0x0D, 0xFE, 0x1E, 0x1C, 0x38, 0x18,
  0x70, 0x39, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x61, 0x80, 0xC3, 0x83, 0x83, 0x0E, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0x8E, 0x06, 0x06, 0x0C, 0x06, 0x0C,
  0x07, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x0C, 0x0E,
  0x18, 0x06, 0x38, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x1C, 0xE0, 0x38,
  0x60, 0x70, 0x30, 0x60, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xE0, 0x60, 0x7F, 0xC0, 0x3F,
  0x80, 0x00, 0x60, 0x03, 0xF0, 0x1E, 0x70, 0x30, 0x60, 0xE0, 0xE1, 0x80,
  0xC7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0x80, 0x73,
  0x00, 0xC6, 0x03, 0x8E, 0x07, 0x0C, 0x1E, 0x1C, 0x6C, 0x1F, 0xB8, 0x1E,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x06, 0x1C,
  0x38, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x87, 0x0E, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00,
  0xC0, 0x00, 0x07, 0x01, 0xFC, 0x1C, 0xE1, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0x87, 0x00, 0x70, 0x1C, 0x06, 0x00, 0x60, 0x60, 0x01,
  0x03, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x3F, 0x18, 0x83,
  0x98, 0xCC, 0x30, 0x86, 0x61, 0x8C, 0x32, 0x18, 0x61, 0xB0, 0xC3, 0x09,
  0x8C, 0x10, 0xCC, 0x61, 0x86, 0x43, 0x0C, 0x36, 0x18, 0x61, 0x30, 0x86,
  0x19, 0x8C, 0x30, 0xCC, 0x61, 0x84, 0x61, 0x14, 0x63, 0x0D, 0xB6, 0x18,
  0x79, 0xE0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x03, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x60,
  0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x30, 0x18, 0x60, 0x30, 0xC0, 0xC1, 0x81, 0x83, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x70, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x30,
  0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xC1, 0xC0, 0xE0, 0x70, 0x60, 0x38, 0x30, 0x1C, 0x18, 0x0E,
  0x0C, 0x06, 0x0E, 0x03, 0x06, 0x01, 0x83, 0x01, 0x81, 0x81, 0xC0, 0xC3,
  0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x30, 0x30, 0x18, 0x0C, 0x1C, 0x06, 0x0E,
  0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x38,
  0x60, 0x18, 0x30, 0x1C, 0x18, 0x3C, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0x03, 0xE6, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0xC1, 0xC0, 0xE0, 0x60, 0x60, 0x38, 0x30, 0x0C,
  0x18, 0x06, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x1C,
  0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x71, 0xC0, 0x70,
  0xC0, 0x30, 0x60, 0x38, 0x30, 0x38, 0x18, 0x78, 0x1F, 0xF8, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0xF8, 0x07, 0xC7, 0x81, 0xE0, 0x20, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFC, 0x60,
  0x3F, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0,
  0x0C, 0x38, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0xC1, 0xC0,
  0x30, 0x1C, 0x06, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x70,
  0x30, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0C,
  0x06, 0x00, 0xC0, 0x60, 0x0C, 0x0E, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x0C, 0x01, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0x80,
  0x30, 0x18, 0x03, 0x03, 0x80, 0x30, 0x30, 0x07, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x03, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x0C, 0x0E, 0x00, 0xC0, 0xC0, 0x1C, 0x00, 0x03, 0xFC,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x1F, 0x00, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x0F, 0xC0, 0x3E, 0x00, 0x03, 0x00, 0xE0, 0x60, 0x30, 0x0C, 0x0E, 0x03,
  0x83, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x0E,
  0x30, 0x01, 0x8E, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x3F,
  0x00, 0x06, 0xF0, 0x00, 0xF6, 0x00, 0x1C, 0xC0, 0x07, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x70, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x03,
  0x80, 0x60, 0x70, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03,
  0x80, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x78,
  0x1F, 0x00, 0x1E, 0x06, 0xC0, 0x0F, 0x81, 0xB0, 0x03, 0x60, 0x6C, 0x00,
  0xF8, 0x1B, 0x00, 0x6C, 0x0E, 0xC0, 0x1B, 0x03, 0x30, 0x0C, 0xC0, 0xCC,
  0x03, 0x30, 0x33, 0x01, 0x9C, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x31, 0x81,
  0x8C, 0x0C, 0x60, 0x63, 0x06, 0x18, 0x18, 0xC1, 0x8C, 0x0E, 0x30, 0xE3,
  0x03, 0x0C, 0x30, 0xC0, 0xC3, 0x1C, 0x30, 0x30, 0xC6, 0x1C, 0x0C, 0x31,
  0x86, 0x07, 0x0C, 0xC1, 0x81, 0x83, 0x30, 0x60, 0x60, 0xD8, 0x18, 0x18,
  0x1E, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x01, 0xC0, 0xC0, 0xC0, 0x60, 0x30,
  0x00, 0x03, 0x80, 0x38, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x0F, 0x80, 0x60,
  0x6C, 0x03, 0x03, 0x60, 0x38, 0x1B, 0x01, 0x80, 0xD8, 0x0C, 0x0E, 0xC0,
  0x60, 0x63, 0x07, 0x03, 0x18, 0x30, 0x18, 0xC1, 0x80, 0xC6, 0x0C, 0x0C,
  0x30, 0x60, 0x61, 0x87, 0x03, 0x06, 0x30, 0x18, 0x31, 0x81, 0xC1, 0x8C,
  0x0C, 0x0C, 0x60, 0x60, 0x67, 0x03, 0x03, 0xB0, 0x18, 0x0D, 0x81, 0xC0,
  0x6C, 0x0C, 0x03, 0x60, 0x60, 0x1E, 0x03, 0x00, 0xF0, 0x18, 0x03, 0x81,
  0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x1C,
  0x70, 0x0E, 0x0E, 0x07, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x1C, 0x70, 0x07,
  0x18, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x9C,
  0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x30,
  0x60, 0x0C, 0x18, 0x06, 0x06, 0x03, 0x81, 0xC1, 0xC0, 0x3F, 0xE0, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0x0E, 0x07, 0x07, 0x06, 0x03,
  0x06, 0x03, 0x06, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x07, 0x0C, 0x06,
  0x0C, 0x06, 0x0C, 0x0E, 0x1C, 0x1C, 0x18, 0x78, 0x1F, 0xF0, 0x1F, 0xC0,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0x80, 0x1C, 0x70, 0x0E, 0x0E, 0x07, 0x01, 0x81,
  0x80, 0x60, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0xC6, 0x00, 0x73, 0x80,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x9C, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x03, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x07, 0x38,
  0x01, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x06, 0x03,
  0x81, 0xC1, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x03, 0xF8, 0x03, 0xFE, 0x03, 0x0E, 0x07, 0x07, 0x06, 0x03, 0x06, 0x03,
  0x06, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x06,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1F, 0xF8, 0x1F, 0xE0, 0x18, 0xC0, 0x38, 0xC0,
  0x30, 0xC0, 0x30, 0xE0, 0x30, 0x60, 0x30, 0x60, 0x70, 0x60, 0x60, 0x60,
  0x60, 0x70, 0x60, 0x70, 0x60, 0x30, 0xE0, 0x30, 0xC0, 0x30, 0x00, 0x38,
  0x00, 0xFF, 0xC0, 0xF9, 0xE0, 0xE0, 0x20, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x10, 0x1E, 0x0F, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC1, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x07, 0x0C,
  0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x03, 0x06, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x0C, 0x38, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x0E, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x0C, 0x38, 0x07, 0x0E, 0x01, 0x83, 0x80, 0x60, 0xE0, 0x38, 0x38, 0x0C,
  0x07, 0x06, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xE0, 0x07, 0xE0, 0x06,
  0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30,
  0x60, 0x30, 0x60, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x60, 0xC0,
  0x61, 0x80, 0x61, 0x80, 0x63, 0x80, 0x63, 0x00, 0x67, 0x00, 0x66, 0x00,
  0x66, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x58, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x01, 0xF8, 0x07, 0x00,
  0x6E, 0x01, 0xC0, 0x3B, 0x80, 0x70, 0x0C, 0xE0, 0x3C, 0x03, 0x38, 0x0F,
  0x01, 0x8E, 0x06, 0xC0, 0x63, 0x81, 0xB0, 0x38, 0xC0, 0x6C, 0x0C, 0x30,
  0x33, 0x03, 0x0C, 0x0C, 0xC1, 0x83, 0x03, 0x30, 0x60, 0xC1, 0x8C, 0x38,
  0x30, 0x63, 0x0C, 0x0C, 0x30, 0xC3, 0x03, 0x0C, 0x31, 0x80, 0xC3, 0x0C,
  0x60, 0x31, 0x83, 0x38, 0x0C, 0x60, 0xCC, 0x03, 0x30, 0x33, 0x00, 0xCC,
  0x09, 0x80, 0x33, 0x02, 0x60, 0x0D, 0x80, 0xB8, 0x03, 0x60, 0x6C, 0x00,
  0xF0, 0x1B, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x78,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x30, 0x38, 0x06, 0x06,
  0x00, 0xC1, 0xC0, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x31, 0x80, 0x06, 0x60,
  0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x03, 0x38, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00,
  0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C,
  0x03, 0x80, 0xE0, 0x1D, 0x80, 0xE6, 0x03, 0x18, 0x1C, 0x60, 0x61, 0x83,
  0x86, 0x0C, 0x18, 0x70, 0x61, 0x81, 0x8E, 0x07, 0x30, 0x0D, 0xC0, 0x36,
  0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xC3, 0x06, 0x18, 0x61, 0x86,
  0x18, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x1B, 0x00, 0x66, 0x00, 0xC6,
  0x03, 0x0C, 0x06, 0x18, 0x18, 0x18, 0x30, 0x30, 0xC0, 0x73, 0x80, 0x66,
  0x00, 0xDC, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xE0, 0xE3, 0x18, 0x63, 0x0C,
  0x03, 0xE6, 0x0F, 0xEC, 0x38, 0x58, 0xE0, 0xF1, 0x81, 0xC7, 0x01, 0x8C,
  0x03, 0x18, 0x0E, 0x70, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x03,
  0x9C, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xE3, 0x83, 0x83,
  0x0F, 0x07, 0xF6, 0x07, 0xCC, 0x00, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0xF0, 0x3B, 0xF0, 0x68, 0x70, 0xE0, 0x61, 0xC0, 0xC3, 0x01, 0x8E, 0x03,
  0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x00, 0xE6, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x70, 0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x81, 0x87, 0x06,
  0x1B, 0xBC, 0x33, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x01, 0xF3, 0x01,
  0xFD, 0x81, 0xC2, 0xC1, 0xC1, 0xC0, 0xC0, 0x60, 0xE0, 0x30, 0x60, 0x18,
  0x30, 0x1C, 0x38, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x87, 0x01,
  0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x38, 0x30, 0x1C, 0x1C,
  0x1C, 0x06, 0x1E, 0x03, 0xFB, 0x00, 0xF9, 0x80, 0x03, 0xE0, 0x3F, 0x83,
  0x8E, 0x38, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0xCE, 0x06, 0x60, 0x63, 0x0E,
  0x1F, 0xE1, 0xFC, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x87, 0xBC, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF9, 0x80, 0xFE, 0xC0, 0xE1, 0x60,
  0xE0, 0xF0, 0x60, 0x30, 0x70, 0x18, 0x30, 0x0C, 0x18, 0x0E, 0x1C, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x80, 0xE1, 0x80, 0x60, 0xC0,
  0x30, 0x60, 0x38, 0x30, 0x1C, 0x18, 0x0E, 0x0E, 0x0E, 0x03, 0x0F, 0x01,
  0xFD, 0x80, 0x7C, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x06, 0x0E, 0x03, 0xFE, 0x00, 0x7C,
  0x00, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0D, 0xF0, 0x3F, 0xF0, 0x68, 0x60,
  0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x0E, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60,
  0x70, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x1C, 0x30, 0x30,
  0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x06, 0x1C, 0x0C, 0x30, 0x18, 0x00,
  0x01, 0x01, 0xC0, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x0F, 0x80, 0x38, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x0C, 0x38, 0x30, 0x60, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x18,
  0x0E, 0x60, 0x19, 0xC0, 0x33, 0x00, 0x6E, 0x00, 0xFC, 0x03, 0xD8, 0x07,
  0x30, 0x0C, 0x60, 0x18, 0xE0, 0x70, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06,
  0x06, 0x0C, 0x1C, 0x1C, 0x30, 0x18, 0x00, 0x01, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x07, 0x03, 0x00, 0x04, 0xF8, 0xF8, 0x1B, 0xFB, 0xF8,
  0x3C, 0x3C, 0x30, 0x70, 0x70, 0x70, 0xC0, 0xE0, 0xE1, 0x81, 0x81, 0x87,
  0x03, 0x03, 0x0C, 0x06, 0x06, 0x18, 0x1C, 0x0C, 0x30, 0x30, 0x38, 0x60,
  0x60, 0x61, 0xC0, 0xC0, 0xC3, 0x01, 0x81, 0x86, 0x06, 0x03, 0x0C, 0x0C,
  0x0E, 0x38, 0x18, 0x18, 0x60, 0x30, 0x30, 0xC0, 0xE0, 0x61, 0x81, 0x80,
  0xC3, 0x03, 0x03, 0x0E, 0x06, 0x06, 0x18, 0x0C, 0x0C, 0x00, 0x04, 0xF8,
  0x1B, 0xF8, 0x3C, 0x30, 0x70, 0x70, 0xE0, 0xE1, 0x81, 0x87, 0x03, 0x0C,
  0x06, 0x18, 0x0C, 0x30, 0x38, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03,
  0x0C, 0x0E, 0x38, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x03, 0x0E,
  0x06, 0x18, 0x0C, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xE1, 0x87, 0x06, 0x18,
  0x1C, 0xE0, 0x73, 0x01, 0xDC, 0x07, 0x60, 0x1D, 0x80, 0x66, 0x01, 0x98,
  0x06, 0xE0, 0x1B, 0x00, 0xEC, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x01, 0x8E,
  0x0E, 0x18, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0x01, 0x9E, 0x01, 0x9F, 0x80,
  0xD0, 0xE0, 0x78, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x1C, 0x06, 0x0E, 0x03,
  0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x60,
  0x18, 0x30, 0x0C, 0x18, 0x0C, 0x1C, 0x06, 0x0E, 0x07, 0x07, 0x03, 0x03,
  0x83, 0x03, 0xFF, 0x81, 0x9F, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xE6, 0x0F, 0xEC, 0x38, 0x58, 0xE0, 0xF1, 0x80, 0xC7, 0x01,
  0x8C, 0x03, 0x18, 0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCE,
  0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xE3, 0x83,
  0x87, 0x0F, 0x07, 0xF6, 0x07, 0xCC, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x04, 0xF0, 0xDF, 0x0D, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0xF0,
  0x1F, 0xF0, 0xE0, 0x83, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x20, 0x70, 0xFF, 0x81, 0xFC,
  0x00, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC1, 0xFD, 0xFC, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x7C, 0x3E, 0x00, 0x0C, 0x0E, 0x38, 0x18,
  0x60, 0x30, 0xC0, 0x61, 0x81, 0xC3, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30,
  0x18, 0x60, 0x71, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x18,
  0x70, 0x30, 0xC0, 0x61, 0x81, 0xC3, 0x03, 0x87, 0x0A, 0x0F, 0xFC, 0x0F,
  0x98, 0x00, 0xC0, 0x3E, 0x01, 0xB0, 0x1D, 0x80, 0xCC, 0x0E, 0x60, 0x63,
  0x03, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xC0, 0x8E, 0x04, 0x60, 0x23,
  0x01, 0x30, 0x09, 0x80, 0x58, 0x02, 0xC0, 0x16, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x00, 0x60, 0x70, 0x36, 0x07, 0x03, 0x60, 0x70, 0x76, 0x0F, 0x06,
  0x60, 0xF0, 0x6E, 0x1B, 0x0C, 0xE1, 0xB0, 0xCE, 0x13, 0x0C, 0xE3, 0x31,
  0x8C, 0x33, 0x18, 0xC6, 0x33, 0x0C, 0x63, 0x30, 0xC4, 0x33, 0x0C, 0xC3,
  0x60, 0xCC, 0x26, 0x0D, 0x82, 0xC0, 0xD8, 0x2C, 0x0D, 0x02, 0xC0, 0xF0,
  0x38, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x06, 0x03, 0x07,
  0x07, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x30, 0x01,
  0xB0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30,
  0x60, 0x60, 0x70, 0xE0, 0x30, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x00, 0xC0, 0xE0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x34, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x01, 0xF0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x18, 0x00, 0xFE, 0x07,
  0x9F, 0x3C, 0x07, 0xE8, 0x03, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 10, 10, 12, 4, -29 },
  { 43, 17, 29, 16, 0, -29 },
  { 105, 16, 33, 15, 0, -31 },
  { 171, 20, 30, 23, 2, -30 },
  { 246, 15, 30, 15, 0, -30 },
  { 303, 4, 10, 7, 4, -29 },
  { 308, 12, 35, 10, 1, -29 },
  { 361, 12, 35, 10, -3, -29 },
  { 414, 12, 12, 14, 4, -31 },
  { 432, 15, 19, 17, 1, -24 },
  { 468, 6, 9, 7, -2, -4 },
  { 475, 9, 2, 11, 1, -12 },
  { 478, 3, 4, 7, 1, -4 },
  { 480, 18, 29, 13, -2, -29 },
  { 546, 14, 30, 15, 1, -30 },
  { 599, 9, 29, 15, 4, -29 },
  { 632, 16, 30, 15, -1, -30 },
  { 692, 16, 30, 15, -1, -30 },
  { 752, 16, 30, 15, -1, -30 },
  { 812, 16, 29, 15, -1, -29 },
  { 870, 15, 30, 15, 1, -30 },
  { 927, 16, 29, 15, 1, -29 },
  { 985, 16, 30, 15, 0, -30 },
  { 1045, 15, 30, 15, 0, -30 },
  { 1102, 7, 22, 7, 0, -22 },
  { 1122, 9, 27, 7, -2, -22 },
  { 1153, 15, 17, 17, 1, -23 },
  { 1185, 15, 11, 17, 1, -20 },
  { 1206, 15, 17, 17, 1, -23 },
  { 1238, 12, 30, 11, 1, -30 },
  { 1283, 21, 33, 22, 1, -29 },
  { 1370, 15, 29, 15, -3, -29 },
  { 1425, 17, 29, 16, 0, -29 },
  { 1487, 16, 30, 15, 2, -30 },
  { 1547, 17, 29, 18, 0, -29 },
  { 1609, 16, 29, 14, 0, -29 },
  { 1667, 16, 29, 13, 0, -29 },
  { 1725, 19, 30, 19, 1, -30 },
  { 1797, 20, 29, 19, 0, -29 },
  { 1870, 14, 29, 9, -2, -29 },
  { 1921, 14, 36, 7, -6, -29 },
  { 1984, 19, 29, 15, 0, -29 },
  { 2053, 10, 29, 13, 0, -29 },
  { 2090, 26, 29, 25, 0, -29 },
  { 2185, 21, 29, 20, 0, -29 },
  { 2262, 18, 30, 19, 1, -30 },
  { 2330, 16, 29, 16, 0, -29 },
  { 2388, 18, 37, 19, 1, -30 },
  { 2472, 16, 29, 16, 0, -29 },
  { 2530, 17, 30, 15, -1, -30 },
  { 2594, 13, 29, 13, 3, -29 },
  { 2642, 18, 29, 18, 1, -29 },
  { 2708, 16, 29, 15, 3, -29 },
  { 2766, 26, 29, 26, 3, -29 },
  { 2861, 19, 29, 14, -2, -29 },
  { 2930, 14, 29, 13, 3, -29 },
  { 2981, 18, 29, 13, -2, -29 },
  { 3047, 15, 36, 11, -1, -29 },
  { 3115, 6, 29, 14, 4, -29 },
  { 3137, 15, 36, 11, -3, -29 },
  { 3205, 15, 15, 16, 1, -29 },
  { 3234, 11, 1, 12, -3, 4 },
  { 3236, 5, 6, 9, 6, -31 },
  { 3240, 15, 22, 16, 1, -22 },
  { 3282, 15, 31, 16, 0, -31 },
  { 3341, 12, 22, 12, 1, -22 },
  { 3374, 17, 31, 16, 1, -31 },
  { 3440, 13, 22, 15, 1, -22 },
  { 3476, 18, 41, 8, -5, -31 },
  { 3569, 17, 32, 16, -1, -22 },
  { 3637, 15, 31, 16, 0, -31 },
  { 3696, 9, 30, 7, 0, -30 },
  { 3730, 14, 40, 7, -5, -30 },
  { 3800, 15, 31, 13, 0, -31 },
  { 3859, 9, 31, 7, 0, -31 },
  { 3894, 23, 22, 24, 0, -22 },
  { 3958, 15, 22, 16, 0, -22 },
  { 4000, 14, 22, 16, 1, -22 },
  { 4039, 17, 31, 16, -2, -22 },
  { 4105, 15, 32, 16, 1, -22 },
  { 4165, 12, 22, 10, 0, -22 },
  { 4198, 14, 22, 12, -1, -22 },
  { 4237, 9, 27, 9, 1, -27 },
  { 4268, 15, 22, 16, 1, -22 },
  { 4310, 13, 22, 12, 2, -22 },
  { 4346, 20, 22, 21, 2, -22 },
  { 4401, 16, 22, 13, -2, -22 },
  { 4445, 19, 32, 13, -4, -22 },
  { 4521, 13, 22, 11, -1, -22 },
  { 4557, 15, 35, 13, 1, -29 },
  { 4623, 2, 41, 15, 6, -31 },
  { 4634, 15, 35, 13, -3, -29 },
  { 4700, 15, 5, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC41PT7B_H_
