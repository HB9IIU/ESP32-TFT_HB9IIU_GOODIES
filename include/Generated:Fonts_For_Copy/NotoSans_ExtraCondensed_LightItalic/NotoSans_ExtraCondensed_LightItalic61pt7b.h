#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x00, 0x1C, 0x1C, 0x70, 0x73, 0xC3, 0xCE, 0x0F, 0x38, 0x38, 0xE0, 0xE3,
  0x83, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x1C, 0x60, 0x63,
  0x83, 0x8E, 0x0E, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x30,
  0x00, 0x30, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E,
  0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0x80, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x60, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01,
  0xC0, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0x38, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x30,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7E, 0x01,
  0xE3, 0x0E, 0x03, 0xC3, 0x00, 0x03, 0x83, 0x00, 0x03, 0x82, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x8C, 0x00, 0x03, 0x8C, 0x00, 0x03, 0xCC, 0x00, 0x01,
  0xEC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x37, 0x80, 0x00, 0x37, 0x80, 0x00,
  0x33, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x61, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xC0, 0xE0, 0x00,
  0xC1, 0xC0, 0x00, 0xC1, 0xC0, 0x80, 0xC3, 0x80, 0xC0, 0xC7, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x1F, 0xC0, 0x06,
  0x01, 0xEE, 0x00, 0x70, 0x1C, 0x38, 0x03, 0x00, 0xC1, 0xC0, 0x38, 0x0E,
  0x0E, 0x01, 0x80, 0x60, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x38, 0x1C,
  0x0E, 0x01, 0x80, 0xE0, 0x60, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x30,
  0x07, 0x01, 0x83, 0x80, 0x30, 0x1C, 0x18, 0x03, 0x80, 0xE1, 0xC0, 0x1C,
  0x07, 0x0C, 0x00, 0xE0, 0x38, 0xE0, 0x07, 0x03, 0x86, 0x06, 0x38, 0x1C,
  0x70, 0xFD, 0xC0, 0xE7, 0x1F, 0xEE, 0x0E, 0x38, 0xE3, 0xF0, 0x73, 0x8E,
  0x1F, 0x87, 0x1C, 0x60, 0xFC, 0x39, 0xC7, 0x03, 0xF7, 0x8E, 0x30, 0x3B,
  0xF8, 0xE3, 0x81, 0xCF, 0x87, 0x1C, 0x0E, 0x00, 0x70, 0xC0, 0x70, 0x03,
  0x8E, 0x03, 0x80, 0x38, 0x70, 0x1C, 0x01, 0xC3, 0x80, 0xC0, 0x1C, 0x18,
  0x0E, 0x00, 0xE0, 0xC0, 0x70, 0x0E, 0x0E, 0x03, 0x80, 0x70, 0x70, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x07, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x0E, 0x01, 0xC3, 0x80, 0xE0, 0x07,
  0x38, 0x07, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xC3,
  0xC0, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0xF0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x73, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x9C,
  0x00, 0x1E, 0x3C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x70, 0xE3, 0xC0, 0xE1,
  0xC7, 0x01, 0xE7, 0x0E, 0x01, 0xCE, 0x38, 0x03, 0xBC, 0x70, 0x07, 0x70,
  0xE0, 0x07, 0xE1, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1C, 0x01, 0xF0, 0x38, 0x07, 0xF0, 0x78, 0x1C, 0xE0, 0xF8,
  0xF9, 0xC0, 0xFF, 0xE3, 0xC0, 0xFF, 0x03, 0x80, 0x30, 0x00, 0x00, 0x1C,
  0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0xC1, 0xC0, 0xF1, 0xC0, 0xF9, 0x83, 0x3F, 0xBF,
  0x0F, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x38, 0x70,
  0xF0, 0x70, 0x60, 0x38, 0x20, 0x38, 0x00, 0x10, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x27, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xF0, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x78, 0x07,
  0x03, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07,
  0x1E, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0,
  0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x07, 0x80,
  0x78, 0x78, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xF1, 0xFE, 0x3C,
  0xE7, 0x8E, 0xF0, 0xEE, 0x1C, 0x41, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x78, 0x1E, 0x00, 0x20, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xF0, 0x3E, 0x00, 0xC0, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x80, 0x1F, 0x00, 0xF0,
  0x7E, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xDC, 0x00,
  0x01, 0x9C, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x01,
  0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x01, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x80,
  0x1F, 0x00, 0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x73, 0xFE, 0x01, 0xCF, 0xFE, 0x03,
  0xB8, 0x3C, 0x07, 0xE0, 0x3C, 0x0F, 0x80, 0x78, 0x3E, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0, 0x01,
  0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x1E, 0x00,
  0x7C, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0E, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xF0,
  0xF0, 0x00, 0x71, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xE7, 0x80, 0x07, 0xC3, 0xC0, 0x0F, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xF0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0x1F,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x38,
  0x0F, 0x00, 0xF0, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x38, 0x03, 0xE0, 0xE0,
  0x1F, 0x83, 0xC0, 0xFE, 0x07, 0xFF, 0x70, 0x1F, 0xF9, 0xC0, 0x3F, 0xC7,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x03, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x38, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x18, 0x1E, 0x04, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF8, 0x07,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x60, 0x03, 0x80, 0xE1,
  0xC0, 0x3F, 0xC1, 0xC3, 0x00, 0xFF, 0x83, 0x8E, 0x03, 0x87, 0x07, 0x1C,
  0x0E, 0x0C, 0x0C, 0x70, 0x38, 0x38, 0x18, 0xE0, 0x70, 0x70, 0x31, 0x81,
  0xC0, 0xE0, 0xE3, 0x03, 0x81, 0x81, 0xCE, 0x0E, 0x07, 0x03, 0x9C, 0x1C,
  0x0E, 0x07, 0x30, 0x30, 0x1C, 0x0C, 0x60, 0x60, 0x30, 0x39, 0xC1, 0xC0,
  0xE0, 0x73, 0x83, 0x81, 0xC0, 0xE7, 0x07, 0x03, 0x81, 0x8E, 0x0C, 0x0E,
  0x07, 0x18, 0x18, 0x1C, 0x0C, 0x30, 0x30, 0x38, 0x18, 0x60, 0x60, 0xF0,
  0x70, 0xC0, 0xC1, 0xE1, 0xC1, 0x81, 0xC6, 0xC3, 0x03, 0x03, 0xDD, 0xDE,
  0x06, 0x03, 0xF1, 0xF8, 0x0C, 0x03, 0xC3, 0xC0, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x10, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x70, 0x00,
  0x39, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07,
  0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00,
  0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x0F, 0xC0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x1E, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x7E, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1E, 0x03, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x01,
  0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0x70, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xC0, 0x40, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x01, 0x00, 0x0F, 0xCF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xC3, 0xF8,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x0F, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x01, 0xC0, 0x3E, 0x00, 0x70, 0x3F, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x0E,
  0x00, 0x7C, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x07, 0x00, 0x1F, 0xF0, 0x70, 0x01,
  0xFF, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x78,
  0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x70, 0x01, 0xFE, 0x7F,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x07,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x10, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x00,
  0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFD,
  0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xB8, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x07, 0x70, 0x00, 0x1D, 0xE0, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x1C, 0xC0,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x0E, 0x78, 0x03, 0x8E, 0x00, 0x3C, 0xE0, 0x07, 0x1C,
  0x00, 0x71, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x03, 0x8F,
  0x00, 0x70, 0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC3,
  0xC0, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0x38, 0x38, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x03, 0x81, 0xC1, 0xC0,
  0xF0, 0x07, 0x03, 0x83, 0x81, 0xC0, 0x0E, 0x07, 0x0E, 0x03, 0x80, 0x3C,
  0x0E, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x78, 0x0E, 0x00, 0xE0, 0x18, 0xE0,
  0x3C, 0x01, 0xC0, 0x3B, 0xC0, 0x70, 0x03, 0x80, 0x77, 0x00, 0xE0, 0x0F,
  0x00, 0xEE, 0x01, 0xC0, 0x1C, 0x01, 0xF8, 0x07, 0x80, 0x38, 0x03, 0xF0,
  0x0E, 0x00, 0x70, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x70, 0x03, 0xE0,
  0x00, 0xE0, 0x0F, 0xC0, 0x01, 0xC0, 0x1F, 0x80, 0x03, 0x80, 0x3F, 0x00,
  0x0F, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0xEE, 0x00, 0x38, 0x03, 0xDC, 0x00,
  0x70, 0x07, 0x38, 0x01, 0xE0, 0x0E, 0x70, 0x03, 0xC0, 0x1C, 0xE0, 0x07,
  0x00, 0x39, 0xE0, 0x0E, 0x00, 0xF1, 0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x78,
  0x03, 0x87, 0x00, 0xE0, 0x07, 0x0E, 0x01, 0xC0, 0x1E, 0x1C, 0x03, 0x80,
  0x38, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x1E, 0x00, 0xE0, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0xE0, 0x0E, 0x03, 0x81, 0xC0, 0x1C,
  0x03, 0x87, 0x80, 0x38, 0x07, 0x0E, 0x00, 0x70, 0x0E, 0x1C, 0x01, 0xE0,
  0x1C, 0x38, 0x03, 0x80, 0x38, 0xF0, 0x07, 0x00, 0x71, 0xC0, 0x0E, 0x00,
  0x73, 0x80, 0x3C, 0x00, 0xE7, 0x00, 0x70, 0x01, 0xCE, 0x00, 0xE0, 0x03,
  0x9C, 0x01, 0xC0, 0x07, 0x70, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0x00, 0x0F,
  0xC0, 0x1C, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0x38,
  0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00,
  0xF0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x71, 0xFC, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x0F, 0x03, 0xC0,
  0x0F, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1E, 0x03, 0x80,
  0x1C, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x07, 0x03,
  0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0,
  0x1C, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0,
  0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xC0, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x71, 0xFC,
  0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x1E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x38,
  0x07, 0x00, 0x78, 0x07, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x07, 0x80, 0x38, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x03, 0x80, 0x78, 0x03, 0x80, 0x70, 0x03, 0xC0,
  0x70, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF8,
  0x1E, 0x00, 0x78, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x02, 0x00, 0x0F, 0x00, 0x60, 0x07,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0F,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x3C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x1C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x78,
  0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x70, 0x03, 0x80, 0xE0,
  0x07, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x78,
  0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x01,
  0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x1E, 0xE0, 0x00, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xF0, 0x00, 0x73, 0x80,
  0x03, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x80, 0x03, 0x8E, 0x00, 0x0F, 0x00,
  0x0F, 0x1C, 0x00, 0x3E, 0x00, 0x1C, 0x38, 0x00, 0x6C, 0x00, 0x38, 0x70,
  0x01, 0xD8, 0x00, 0xF0, 0xE0, 0x03, 0xB0, 0x01, 0xC1, 0xC0, 0x06, 0x60,
  0x07, 0x83, 0x80, 0x1D, 0xC0, 0x0E, 0x07, 0x00, 0x3B, 0x80, 0x1C, 0x0E,
  0x00, 0xE7, 0x00, 0x78, 0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x38, 0x03, 0x9C,
  0x03, 0xC0, 0x70, 0x0E, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0xE0, 0x3C, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x07, 0x01, 0xC3,
  0x81, 0xE0, 0x0E, 0x07, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x0E, 0x07, 0x00,
  0x38, 0x38, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x70, 0xF0, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0x07, 0x0C, 0x03, 0x8F, 0x00, 0x0E, 0x38, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x0E, 0x38, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x31, 0xC0,
  0x00, 0xE7, 0x00, 0x67, 0x80, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0x03, 0xB8,
  0x01, 0x9C, 0x00, 0x07, 0xE0, 0x03, 0x70, 0x00, 0x0F, 0xC0, 0x0E, 0xE0,
  0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x7B, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x1E,
  0x1C, 0x00, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x07, 0x81, 0xC0,
  0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xE0,
  0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x70, 0xF0, 0x00,
  0xE1, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xE1, 0xE1, 0xC3, 0x83,
  0x87, 0x07, 0x0E, 0x0C, 0x0C, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x70, 0x1F,
  0xF9, 0xC0, 0xF8, 0x77, 0x07, 0x80, 0xF8, 0x1C, 0x03, 0xE0, 0xF0, 0x07,
  0x87, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0xF8, 0x38, 0x03, 0xC0, 0xF0, 0x1F,
  0x03, 0xC0, 0xDC, 0x07, 0xCF, 0x70, 0x1F, 0xF9, 0xC0, 0x3F, 0x86, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x73, 0xFC, 0x00, 0xEF,
  0xFC, 0x03, 0xB8, 0x3C, 0x07, 0x60, 0x78, 0x0F, 0x80, 0x70, 0x1E, 0x00,
  0xE0, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F,
  0x07, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0,
  0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x7C, 0x01,
  0xC0, 0xF8, 0x07, 0x01, 0xF8, 0x1E, 0x03, 0x38, 0xF8, 0x0E, 0x7F, 0xE0,
  0x1C, 0x7F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0x02, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x04, 0x07, 0xC7, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0xE0, 0x03, 0xFC, 0x70, 0x03,
  0xFF, 0x38, 0x03, 0xE1, 0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x78, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00,
  0xF0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x03, 0x80,
  0x1E, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x3C,
  0x0D, 0xC0, 0x0F, 0x1C, 0xE0, 0x07, 0xFE, 0x70, 0x01, 0xFC, 0x30, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xE0,
  0xE0, 0x78, 0x1C, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0E, 0x1C, 0x01,
  0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x1E,
  0x1C, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x08, 0x1F, 0x0F, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xE2, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x8F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF1, 0xC0, 0x0F, 0xFC, 0xE0, 0x0F,
  0x87, 0x60, 0x0F, 0x01, 0xF0, 0x07, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x1E, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0x70, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x07, 0x00,
  0x7C, 0x03, 0x80, 0x7C, 0x01, 0xC0, 0x3E, 0x00, 0xF0, 0x37, 0x00, 0x3E,
  0x7B, 0x80, 0x1F, 0xFB, 0xC0, 0x07, 0xF1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x10, 0x03, 0xC0, 0x0F, 0x0F, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x0F, 0x80, 0x1C, 0xFF,
  0x00, 0x77, 0xFE, 0x03, 0xB8, 0x78, 0x0F, 0xC0, 0xF0, 0x3E, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x03, 0x81, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x38, 0x01,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x03, 0x81,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x83, 0x80,
  0x1C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x11, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x40, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x70, 0x07, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x78, 0x00, 0x39, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xEF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xEF, 0x00, 0x0F, 0x8E, 0x00, 0x1E, 0x1C, 0x00,
  0x3C, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x81, 0xE0, 0x07,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x73, 0xFC,
  0x3F, 0xC0, 0x19, 0xFF, 0x9F, 0xF8, 0x0E, 0xE1, 0xEE, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x0E,
  0x00, 0xF0, 0x0E, 0x07, 0x80, 0x38, 0x03, 0x81, 0xE0, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x0E, 0x0F, 0x00, 0x70, 0x07,
  0x83, 0x80, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x70, 0x38, 0x03, 0xC0,
  0x1C, 0x0E, 0x00, 0xE0, 0x0F, 0x07, 0x80, 0x38, 0x03, 0x81, 0xC0, 0x0E,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x07, 0x83, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x70, 0x38,
  0x03, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x03, 0xC1,
  0xE0, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x03, 0x83, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x43, 0xE0, 0x06, 0x3F, 0xC0, 0x19, 0xFF, 0x80, 0xEE,
  0x1E, 0x03, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xE0, 0x0F,
  0x07, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x70, 0x78, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x03, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E,
  0x07, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0xE0, 0xF0, 0x0E,
  0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00,
  0x73, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0,
  0x7C, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0E, 0x7F, 0x80, 0x03, 0x3F, 0xF0, 0x01, 0xDC, 0x1E, 0x00,
  0x76, 0x03, 0x80, 0x1F, 0x00, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0x80,
  0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x38, 0x00, 0x78,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xE0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xB0, 0x3C, 0x00,
  0xEE, 0x3E, 0x00, 0x3B, 0xFF, 0x00, 0x1E, 0x7F, 0x80, 0x07, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC,
  0x70, 0x1F, 0xF9, 0xC0, 0xF0, 0x76, 0x07, 0x80, 0xF8, 0x1C, 0x03, 0xE0,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0xF8, 0x38, 0x03, 0xC0,
  0xE0, 0x1F, 0x03, 0xC0, 0xDC, 0x07, 0xCF, 0x70, 0x1F, 0xFB, 0xC0, 0x3F,
  0x8E, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x43, 0xC0, 0x63, 0xF0, 0x19, 0xFC,
  0x0E, 0xF1, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0x20, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x08, 0x03, 0xC0, 0xF0,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x1F, 0xF8,
  0xFF, 0xC9, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x81, 0xFC,
  0x0F, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x03, 0xC3, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x03, 0xC3,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0xF8,
  0x38, 0x07, 0x81, 0xC0, 0x7C, 0x0E, 0x07, 0xE0, 0x7C, 0xF7, 0x03, 0xFF,
  0x38, 0x0F, 0xF1, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0xF8, 0x01, 0xEE,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80,
  0x70, 0xE0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x3C, 0x0E, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0xF0, 0x03, 0xB8,
  0x00, 0xEE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x1D, 0xC0,
  0x1F, 0x00, 0x77, 0x00, 0x7C, 0x03, 0x9C, 0x01, 0xE0, 0x0E, 0x70, 0x0F,
  0x80, 0x71, 0xC0, 0x36, 0x01, 0xC7, 0x01, 0xD8, 0x07, 0x1C, 0x07, 0x60,
  0x38, 0x70, 0x19, 0x80, 0xE1, 0xC0, 0xE6, 0x07, 0x87, 0x03, 0x98, 0x1C,
  0x1C, 0x1C, 0x60, 0x70, 0x70, 0x71, 0x83, 0x81, 0xC1, 0x86, 0x0E, 0x07,
  0x0E, 0x38, 0x38, 0x1C, 0x38, 0xE1, 0xC0, 0x71, 0xC3, 0x87, 0x01, 0xC7,
  0x0E, 0x38, 0x07, 0x18, 0x38, 0xE0, 0x1C, 0xE0, 0xE3, 0x80, 0x73, 0x83,
  0x9C, 0x01, 0x9C, 0x0E, 0x70, 0x06, 0x70, 0x3B, 0x80, 0x19, 0x80, 0xEE,
  0x00, 0xEE, 0x03, 0xB8, 0x03, 0xB8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xC7,
  0x00, 0x03, 0x87, 0x00, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07,
  0x00, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x08, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x90, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x04, 0xFF, 0x80, 0x17, 0xFF, 0x00, 0xFC,
  0x3F, 0x8F, 0xC0, 0x3F, 0xFA, 0x00, 0x3F, 0xC8, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 44, 13, 1, -44 },
  { 73, 14, 16, 18, 6, -44 },
  { 101, 25, 44, 24, 0, -44 },
  { 239, 24, 50, 22, 0, -46 },
  { 389, 29, 45, 34, 3, -44 },
  { 553, 23, 45, 23, -1, -44 },
  { 683, 6, 16, 10, 6, -44 },
  { 695, 18, 54, 15, 1, -44 },
  { 817, 17, 54, 15, -4, -44 },
  { 932, 16, 18, 21, 7, -46 },
  { 968, 22, 29, 25, 2, -36 },
  { 1048, 9, 14, 11, -3, -6 },
  { 1064, 13, 3, 16, 1, -18 },
  { 1069, 4, 6, 11, 1, -6 },
  { 1072, 26, 44, 19, -3, -44 },
  { 1215, 21, 45, 22, 1, -44 },
  { 1334, 12, 44, 22, 7, -44 },
  { 1400, 24, 44, 22, -2, -44 },
  { 1532, 24, 45, 22, -1, -44 },
  { 1667, 24, 44, 22, -1, -44 },
  { 1799, 24, 45, 22, -1, -44 },
  { 1934, 23, 45, 22, 1, -44 },
  { 2064, 23, 44, 22, 2, -44 },
  { 2191, 24, 45, 22, -1, -44 },
  { 2326, 22, 45, 22, 0, -44 },
  { 2450, 11, 33, 11, 0, -33 },
  { 2496, 14, 41, 11, -3, -33 },
  { 2568, 22, 26, 25, 2, -35 },
  { 2640, 22, 15, 25, 2, -29 },
  { 2682, 22, 26, 25, 2, -35 },
  { 2754, 18, 44, 16, 1, -44 },
  { 2853, 31, 49, 33, 2, -44 },
  { 3043, 22, 44, 22, -4, -44 },
  { 3164, 25, 44, 25, 0, -44 },
  { 3302, 25, 45, 22, 2, -44 },
  { 3443, 26, 44, 27, 0, -44 },
  { 3586, 24, 44, 21, 0, -44 },
  { 3718, 24, 44, 20, 0, -44 },
  { 3850, 28, 45, 29, 2, -44 },
  { 4008, 29, 44, 28, 0, -44 },
  { 4168, 20, 44, 13, -3, -44 },
  { 4278, 22, 55, 11, -9, -44 },
  { 4430, 28, 44, 23, 0, -44 },
  { 4584, 15, 44, 20, 0, -44 },
  { 4667, 39, 44, 38, 0, -44 },
  { 4882, 31, 44, 30, 0, -44 },
  { 5053, 26, 45, 29, 2, -44 },
  { 5200, 24, 44, 23, 0, -44 },
  { 5332, 26, 54, 29, 2, -44 },
  { 5508, 24, 44, 24, 0, -44 },
  { 5640, 26, 45, 22, -2, -44 },
  { 5787, 20, 44, 19, 4, -44 },
  { 5897, 27, 45, 27, 2, -44 },
  { 6049, 23, 44, 23, 5, -44 },
  { 6176, 39, 44, 38, 4, -44 },
  { 6391, 29, 44, 21, -4, -44 },
  { 6551, 21, 44, 20, 4, -44 },
  { 6667, 26, 44, 20, -3, -44 },
  { 6810, 22, 54, 17, -1, -44 },
  { 6959, 9, 44, 20, 6, -44 },
  { 7009, 22, 54, 17, -4, -44 },
  { 7158, 23, 23, 24, 1, -44 },
  { 7225, 18, 3, 17, -5, 5 },
  { 7232, 7, 10, 14, 9, -47 },
  { 7241, 22, 34, 24, 2, -33 },
  { 7335, 23, 47, 24, 0, -46 },
  { 7471, 18, 34, 18, 2, -33 },
  { 7548, 25, 47, 24, 2, -46 },
  { 7695, 19, 34, 22, 2, -33 },
  { 7776, 28, 62, 13, -8, -47 },
  { 7993, 25, 48, 24, -1, -33 },
  { 8143, 22, 46, 23, 0, -46 },
  { 8270, 13, 44, 11, 0, -44 },
  { 8342, 21, 59, 11, -8, -44 },
  { 8497, 23, 46, 20, 0, -46 },
  { 8630, 13, 46, 10, 0, -46 },
  { 8705, 34, 33, 35, 0, -33 },
  { 8846, 22, 33, 23, 0, -33 },
  { 8937, 20, 34, 23, 2, -33 },
  { 9022, 26, 47, 24, -3, -33 },
  { 9175, 22, 47, 24, 2, -33 },
  { 9305, 18, 33, 16, 0, -33 },
  { 9380, 20, 34, 18, -1, -33 },
  { 9465, 13, 41, 13, 1, -40 },
  { 9532, 21, 33, 24, 2, -32 },
  { 9619, 18, 32, 19, 4, -32 },
  { 9691, 30, 32, 31, 3, -32 },
  { 9811, 24, 32, 19, -3, -32 },
  { 9907, 28, 47, 19, -6, -32 },
  { 10072, 20, 32, 16, -2, -32 },
  { 10152, 21, 54, 19, 2, -44 },
  { 10294, 3, 62, 22, 9, -47 },
  { 10318, 22, 54, 19, -4, -44 },
  { 10467, 22, 7, 25, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC61PT7B_H_
