#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x60, 0x70, 0x18, 0x00, 0x73, 0xB1, 0x98, 0xCC,
  0x64, 0x36, 0x33, 0x19, 0x8C, 0x86, 0x42, 0x00, 0x00, 0xC3, 0x00, 0xC6,
  0x00, 0x86, 0x01, 0x84, 0x01, 0x8C, 0x01, 0x0C, 0x03, 0x0C, 0x03, 0x08,
  0x1F, 0xFF, 0x02, 0x18, 0x06, 0x10, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x20,
  0x0C, 0x60, 0x08, 0x60, 0x18, 0x40, 0xFF, 0xF8, 0x10, 0xC0, 0x30, 0x80,
  0x31, 0x80, 0x21, 0x80, 0x61, 0x80, 0x61, 0x00, 0x63, 0x00, 0x43, 0x00,
  0xC6, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x07, 0x80, 0x3F, 0xE1,
  0xC9, 0x83, 0x10, 0x0C, 0x60, 0x18, 0x80, 0x31, 0x00, 0x62, 0x00, 0xC4,
  0x00, 0xD8, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xC0,
  0x09, 0x80, 0x11, 0x80, 0x23, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x30, 0x84,
  0x61, 0xEF, 0x83, 0xFE, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xC0, 0x61, 0x90, 0x30, 0xC6, 0x08, 0x21, 0x86,
  0x18, 0x61, 0x06, 0x10, 0xC1, 0x04, 0x20, 0xC3, 0x18, 0x30, 0xC4, 0x0C,
  0x33, 0x03, 0x08, 0x84, 0x86, 0x67, 0xA1, 0x93, 0x3C, 0x4D, 0x8F, 0x36,
  0x63, 0x79, 0x90, 0xC8, 0xCC, 0x30, 0x33, 0x0C, 0x18, 0x83, 0x06, 0x20,
  0x83, 0x18, 0x60, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x18, 0xC3,
  0x03, 0x61, 0x80, 0xF0, 0x00, 0x40, 0x07, 0xC0, 0x33, 0x01, 0x8C, 0x06,
  0x30, 0x18, 0xC0, 0x63, 0x01, 0x0C, 0x04, 0x20, 0x19, 0x80, 0x6C, 0x01,
  0xB0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x06, 0xC0, 0x33, 0x0D, 0xC6, 0x66,
  0x19, 0xB0, 0x64, 0xC0, 0xF3, 0x03, 0xCC, 0x0E, 0x30, 0x38, 0xC0, 0xE3,
  0x07, 0x8F, 0xF6, 0x1F, 0x8C, 0x76, 0x66, 0x6C, 0xCC, 0xC8, 0x00, 0xE0,
  0x10, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x62, 0x0F,
  0x44, 0x3F, 0xC3, 0x00, 0xF0, 0x32, 0x0C, 0x61, 0x06, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x71, 0x86, 0x30, 0xC2, 0x18, 0xC0,
  0xFF, 0xFF, 0x7F, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x1F, 0x81, 0xDC, 0x0C, 0x30, 0xC1, 0x8C, 0x0C, 0x60,
  0x63, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0xC0, 0x76, 0x03, 0x30, 0x19,
  0x80, 0xD8, 0x06, 0xC0, 0x36, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60,
  0x63, 0x03, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x1F, 0x80, 0xF8, 0x00, 0x07,
  0x0F, 0x1F, 0x3E, 0x66, 0xC6, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x60, 0xC0, 0x00, 0x20, 0x07, 0xF0, 0x1E, 0x70, 0x10, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x20, 0x07, 0xF0, 0x1C,
  0x70, 0x20, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x61, 0x01, 0xC3, 0xDF, 0x07, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x58, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x80,
  0x33, 0x00, 0x64, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x63,
  0x01, 0x86, 0x02, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x81, 0x83,
  0xFF, 0xEF, 0xFF, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xFF, 0x00, 0xDF, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x80, 0xE1, 0xEF, 0x83, 0xFC, 0x00, 0x00, 0x10, 0x03, 0xF0, 0x3C, 0x41,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0xE0, 0x6F, 0xC1, 0xE3, 0x87, 0x06, 0x38, 0x1C, 0xE0, 0x33,
  0x00, 0xCC, 0x07, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x30,
  0xC0, 0xC3, 0x86, 0x07, 0x70, 0x0F, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x71,
  0xC3, 0x83, 0x0C, 0x0C, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x30,
  0x60, 0xC1, 0x83, 0x9C, 0x06, 0xE0, 0x0E, 0x00, 0xF8, 0x07, 0x30, 0x30,
  0xE1, 0x81, 0x86, 0x07, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30,
  0x1C, 0xC0, 0x63, 0x83, 0x87, 0xBC, 0x0F, 0xE0, 0x00, 0x40, 0x0F, 0xC0,
  0x73, 0x83, 0x86, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C,
  0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x83, 0x86, 0x36,
  0x1F, 0x98, 0x1C, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x0D, 0xE0, 0x3F, 0x00, 0x0E, 0x1C, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x41,
  0xC3, 0x86, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x00, 0x04, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x02, 0x03, 0xF0, 0xE7, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x30, 0x06, 0x03,
  0x01, 0x80, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x08, 0xC1, 0xE1,
  0x10, 0x7E, 0x26, 0x18, 0x84, 0x86, 0x31, 0xB0, 0x86, 0x36, 0x30, 0xC6,
  0xC6, 0x10, 0xD0, 0x86, 0x16, 0x30, 0xC2, 0xC6, 0x18, 0xD8, 0xC6, 0x1B,
  0x18, 0xC2, 0x63, 0x18, 0xCC, 0x65, 0x31, 0x8F, 0xBC, 0x30, 0xC3, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x86, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x40, 0x0F,
  0x00, 0x3C, 0x01, 0xB0, 0x06, 0xC0, 0x13, 0x00, 0xCC, 0x03, 0x30, 0x18,
  0xC0, 0x63, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC1, 0xFF, 0x07, 0xFC, 0x38,
  0x30, 0xC0, 0xC3, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0x70,
  0x0D, 0x80, 0x3E, 0x00, 0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x06, 0x0E, 0x06,
  0x06, 0x06, 0x07, 0x06, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C,
  0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x1F, 0xE0, 0x1F, 0xF0, 0x18, 0x30, 0x38,
  0x18, 0x30, 0x18, 0x30, 0x18, 0x30, 0x18, 0x30, 0x18, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x30, 0x60, 0x70, 0x60, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0xFF, 0x01, 0xE6, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x06,
  0x0E, 0x06, 0x06, 0x06, 0x07, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x06, 0x18,
  0x06, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x60,
  0x18, 0x60, 0x38, 0x60, 0x70, 0x60, 0xE0, 0x61, 0xC0, 0xFF, 0x80, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0xFF, 0x03, 0xFE, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xE0,
  0x1E, 0x3C, 0x0E, 0x02, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x03, 0xE1, 0x81, 0xF8, 0x60, 0x06, 0x38, 0x01, 0x8C,
  0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x38, 0x03, 0x06, 0x00, 0xC1, 0x80,
  0x60, 0x60, 0x18, 0x0C, 0x06, 0x03, 0xEF, 0x80, 0x3F, 0xC0, 0x03, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60,
  0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x60,
  0x0C, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x06,
  0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x80, 0x07,
  0xF8, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xE0, 0x3F, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0xF8,
  0x07, 0x80, 0x00, 0x03, 0x03, 0x83, 0x01, 0x81, 0x81, 0x80, 0xC1, 0xC0,
  0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x60,
  0x03, 0x70, 0x03, 0x30, 0x01, 0xB8, 0x00, 0xFC, 0x00, 0x76, 0x00, 0x73,
  0x00, 0x31, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x06, 0x0C, 0x03,
  0x07, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x1C,
  0x00, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x7F, 0xFF, 0xE0, 0x03, 0x80, 0x07, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x36, 0x0D, 0x80, 0x36, 0x0D, 0x80, 0x6E, 0x0D, 0x80, 0x6C, 0x0D,
  0x80, 0x6C, 0x09, 0x80, 0xCC, 0x19, 0x80, 0xCC, 0x19, 0x81, 0x98, 0x19,
  0x81, 0x98, 0x19, 0x83, 0x18, 0x30, 0x83, 0x18, 0x30, 0x86, 0x18, 0x30,
  0x86, 0x30, 0x30, 0xCC, 0x30, 0x30, 0xCC, 0x30, 0x60, 0xD8, 0x30, 0x60,
  0xD8, 0x30, 0x60, 0xF0, 0x60, 0x60, 0xF0, 0x60, 0x60, 0xF0, 0x60, 0xC0,
  0xE0, 0x60, 0xC0, 0xE0, 0xC0, 0x03, 0x00, 0x60, 0xF0, 0x0C, 0x1E, 0x01,
  0x83, 0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x01, 0x83, 0x20, 0x30, 0x66, 0x06,
  0x0C, 0xC1, 0x81, 0x98, 0x30, 0x33, 0x06, 0x0C, 0x60, 0xC1, 0x84, 0x18,
  0x30, 0xC6, 0x06, 0x18, 0xC1, 0x83, 0x18, 0x30, 0x63, 0x06, 0x0C, 0xC0,
  0xC0, 0xD8, 0x18, 0x1B, 0x06, 0x03, 0x60, 0xC0, 0x6C, 0x18, 0x0F, 0x03,
  0x01, 0xE0, 0x60, 0x1C, 0x18, 0x03, 0x83, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0xFC, 0x03, 0xCE, 0x07, 0x07, 0x06, 0x03, 0x0C, 0x03, 0x1C, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03,
  0x60, 0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xE0, 0x18, 0x60, 0x30, 0x60, 0x30,
  0x70, 0x60, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xF8, 0x18, 0x30,
  0x30, 0x70, 0x60, 0x60, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18,
  0x18, 0x30, 0x30, 0xC0, 0xE1, 0x83, 0x83, 0x0E, 0x07, 0xF8, 0x1F, 0xC0,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0xFC, 0x03, 0xCE, 0x07, 0x07, 0x06, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03, 0x60,
  0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xE0, 0x18, 0x60, 0x38, 0x60, 0x30, 0x70,
  0x60, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x18, 0x30, 0x30,
  0x70, 0x60, 0x60, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x18,
  0x30, 0x30, 0xC0, 0xC1, 0x83, 0x83, 0xFE, 0x07, 0xF0, 0x1C, 0xC0, 0x31,
  0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x61, 0x80, 0xC3, 0x01, 0xC0, 0x00, 0x10, 0x01, 0xFF,
  0x03, 0xCE, 0x07, 0x02, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x80, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x18,
  0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x01, 0x86, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18,
  0x06, 0x1C, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0xC0, 0xC0,
  0x60, 0xE0, 0x3D, 0xE0, 0x0F, 0xE0, 0x00, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x03,
  0x0C, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x0C, 0x30, 0x30, 0xC0, 0xC6,
  0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xDC, 0x03, 0x60, 0x0D, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x18, 0x07, 0xC0, 0x38,
  0x06, 0xC0, 0x38, 0x0E, 0xC0, 0x38, 0x0C, 0xC0, 0x78, 0x0C, 0xC0, 0x78,
  0x18, 0xC0, 0xD8, 0x18, 0xC0, 0xD8, 0x18, 0xC0, 0x98, 0x30, 0xC1, 0x98,
  0x30, 0xC1, 0x98, 0x60, 0xC3, 0x18, 0x60, 0xC3, 0x18, 0x60, 0xC3, 0x10,
  0xC0, 0xC6, 0x10, 0xC0, 0xC6, 0x11, 0x80, 0xCC, 0x11, 0x80, 0xCC, 0x11,
  0x80, 0xCC, 0x13, 0x00, 0xD8, 0x13, 0x00, 0xD8, 0x36, 0x00, 0xD0, 0x36,
  0x00, 0xF0, 0x36, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x38,
  0x00, 0xC0, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x60, 0xE0, 0x18, 0x30, 0x06,
  0x1C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x31,
  0x80, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x30,
  0x18, 0x0C, 0x0C, 0x03, 0x00, 0xC0, 0x3E, 0x01, 0xB0, 0x18, 0xC1, 0xC6,
  0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x70, 0x63, 0x03, 0x30, 0x19, 0x80, 0xD8,
  0x06, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFC, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0xC6, 0x31, 0x84, 0x21, 0x8C, 0x63, 0x18,
  0xC2, 0x18, 0xC6, 0x31, 0x8C, 0x21, 0x8C, 0x63, 0x18, 0xC6, 0x01, 0xF8,
  0x10, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x1F, 0xC0, 0xFC, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xB0, 0x06,
  0x60, 0x31, 0x80, 0xC6, 0x06, 0x0C, 0x18, 0x30, 0xC0, 0xC6, 0x01, 0x98,
  0x06, 0xC0, 0x1B, 0x00, 0x30, 0xFF, 0xFF, 0xFC, 0xCC, 0x66, 0x23, 0x01,
  0x80, 0x1F, 0xB0, 0xE6, 0xC7, 0x0A, 0x18, 0x18, 0xC0, 0x63, 0x01, 0x9C,
  0x06, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C,
  0x06, 0x30, 0x18, 0xC0, 0xE3, 0x03, 0x8E, 0x1C, 0x1D, 0xB0, 0x3C, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x20, 0x37, 0xE0, 0xD1, 0x83, 0x83, 0x0C, 0x0C, 0x70,
  0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x40, 0x33, 0x00, 0xCC, 0x06, 0x30,
  0x18, 0xC0, 0x67, 0x01, 0x98, 0x0C, 0x60, 0x31, 0xC1, 0x85, 0x0E, 0x36,
  0x70, 0xCF, 0x80, 0x00, 0x80, 0xFC, 0x38, 0x8E, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x3D, 0x83, 0xF0, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x01, 0x0C, 0x07, 0xEC, 0x0E, 0x6C, 0x1C, 0x38, 0x18, 0x18, 0x30, 0x18,
  0x30, 0x18, 0x70, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xE0, 0xC0, 0xC0,
  0xE1, 0xC0, 0x76, 0xC0, 0x3C, 0xC0, 0x00, 0x80, 0x7E, 0x0E, 0x71, 0x83,
  0x18, 0x33, 0x03, 0x30, 0x66, 0x06, 0x60, 0xC6, 0x38, 0xFF, 0x0F, 0x80,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x38,
  0x3F, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00,
  0x60, 0x01, 0xFB, 0x03, 0x9B, 0x07, 0x0A, 0x06, 0x06, 0x0C, 0x06, 0x0C,
  0x06, 0x18, 0x0E, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x18, 0x30, 0x18, 0x30, 0x38, 0x30, 0x38, 0x30, 0x70, 0x38,
  0x70, 0x1D, 0xB0, 0x1F, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x81, 0xC0, 0xFF, 0x80, 0x7E, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x60, 0x37, 0xE0, 0xF1, 0x83, 0x87, 0x0C, 0x1C, 0x70, 0x61,
  0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0x63, 0x03, 0x0C, 0x0C, 0x30, 0x30,
  0xC0, 0xC2, 0x03, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06, 0x30, 0x10,
  0xC0, 0xC0, 0x02, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x0E, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x70, 0xC1, 0x83, 0x0C, 0x0C, 0x60, 0x63, 0x81, 0x8C, 0x06, 0x60, 0x1B,
  0x00, 0x5C, 0x03, 0x70, 0x0F, 0x60, 0x39, 0x80, 0xC6, 0x06, 0x18, 0x18,
  0x60, 0x61, 0x81, 0x87, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0xC0, 0x03, 0x03,
  0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x60, 0xC0, 0xC0, 0x00, 0x20, 0x40, 0x6F, 0xCF, 0x83, 0xCE, 0xCE, 0x1C,
  0x38, 0x30, 0xC1, 0xC1, 0x8E, 0x0C, 0x0C, 0x60, 0x60, 0x63, 0x03, 0x06,
  0x18, 0x18, 0x30, 0xC1, 0x81, 0x8C, 0x0C, 0x0C, 0x60, 0x60, 0x63, 0x03,
  0x06, 0x18, 0x10, 0x31, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x60, 0x60, 0x43,
  0x03, 0x06, 0x18, 0x30, 0x31, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x6F, 0xC3, 0xC6, 0x1C, 0x30, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x03,
  0x18, 0x18, 0xC0, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x19, 0x80, 0xCC,
  0x0C, 0x60, 0x63, 0x03, 0x18, 0x19, 0x81, 0x8C, 0x0C, 0x00, 0x00, 0x80,
  0x3F, 0x03, 0x9C, 0x30, 0x61, 0x83, 0x18, 0x1C, 0xC0, 0x6C, 0x07, 0x60,
  0x33, 0x01, 0x98, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x3B, 0x01, 0x98, 0x0C,
  0xC0, 0xC6, 0x06, 0x38, 0x60, 0xEE, 0x03, 0xE0, 0x00, 0x00, 0x08, 0x03,
  0x3E, 0x03, 0x46, 0x03, 0x83, 0x03, 0x83, 0x07, 0x03, 0x07, 0x03, 0x06,
  0x03, 0x06, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C,
  0x06, 0x0C, 0x06, 0x1C, 0x0C, 0x1C, 0x0C, 0x1C, 0x18, 0x1C, 0x38, 0x36,
  0xF0, 0x33, 0xE0, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x1F,
  0xB0, 0xE6, 0xC7, 0x0A, 0x18, 0x18, 0xC0, 0x63, 0x01, 0x98, 0x06, 0x60,
  0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x30,
  0x18, 0xC0, 0xE3, 0x07, 0x8E, 0x1C, 0x1D, 0xB0, 0x7C, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x21, 0xBC, 0x3E, 0x87, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x3F, 0xC3, 0x8C,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x20, 0x61, 0xEF, 0x07, 0xF0, 0x00, 0x04, 0x0C, 0x0C, 0x0C, 0x18, 0x7F,
  0x7F, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE8, 0xF0, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x30, 0x33, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x03, 0x18,
  0x18, 0xC0, 0xC6, 0x06, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC1, 0xC6, 0x1E,
  0x3F, 0xA0, 0xF9, 0x00, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x19, 0x83,
  0x30, 0x66, 0x18, 0xC3, 0x18, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0xB0, 0x36,
  0x06, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x00, 0xC0, 0xE0, 0x78, 0x1C,
  0x1B, 0x03, 0x83, 0x60, 0xF0, 0xCC, 0x16, 0x19, 0x86, 0xC3, 0x30, 0xD8,
  0xC6, 0x13, 0x18, 0xC6, 0x66, 0x18, 0xCC, 0xC3, 0x31, 0x98, 0x66, 0x36,
  0x0C, 0x86, 0xC1, 0xB0, 0x90, 0x36, 0x16, 0x07, 0x82, 0xC0, 0xF0, 0x70,
  0x1C, 0x0E, 0x03, 0x81, 0x80, 0x70, 0x30, 0x00, 0x06, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x30,
  0x0C, 0x60, 0x38, 0x60, 0x60, 0xC1, 0x81, 0x87, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x18, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x38,
  0x07, 0xC0, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x0F, 0x00,
  0xE0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0xC0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x1F, 0x00, 0xE0, 0x00, 0x7E, 0x07, 0x9E, 0x78,
  0x1F, 0x80, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 27, 8, 0, -27 },
  { 32, 9, 10, 11, 4, -27 },
  { 44, 16, 27, 15, 0, -27 },
  { 98, 15, 31, 14, 0, -29 },
  { 157, 18, 28, 21, 2, -28 },
  { 220, 14, 28, 14, 0, -28 },
  { 269, 4, 10, 6, 4, -27 },
  { 274, 11, 33, 9, 1, -27 },
  { 320, 11, 33, 10, -3, -27 },
  { 366, 11, 12, 13, 4, -29 },
  { 383, 14, 17, 16, 1, -22 },
  { 413, 6, 9, 7, -2, -4 },
  { 420, 8, 2, 10, 1, -11 },
  { 422, 2, 4, 7, 1, -4 },
  { 423, 17, 27, 12, -2, -27 },
  { 481, 13, 28, 14, 1, -28 },
  { 527, 8, 27, 14, 4, -27 },
  { 554, 15, 28, 14, -1, -28 },
  { 607, 15, 28, 14, -1, -28 },
  { 660, 15, 27, 14, -1, -27 },
  { 711, 15, 27, 14, -1, -27 },
  { 762, 14, 28, 14, 1, -28 },
  { 811, 14, 27, 14, 1, -27 },
  { 859, 14, 28, 14, 0, -28 },
  { 908, 14, 28, 14, 0, -28 },
  { 957, 7, 20, 7, 0, -20 },
  { 975, 9, 25, 7, -2, -20 },
  { 1004, 14, 17, 16, 1, -22 },
  { 1034, 14, 10, 16, 1, -18 },
  { 1052, 14, 17, 16, 1, -22 },
  { 1082, 11, 28, 10, 1, -28 },
  { 1121, 19, 30, 21, 1, -27 },
  { 1193, 14, 27, 14, -3, -27 },
  { 1241, 16, 27, 15, 0, -27 },
  { 1295, 16, 28, 14, 1, -28 },
  { 1351, 16, 27, 17, 0, -27 },
  { 1405, 15, 27, 13, 0, -27 },
  { 1456, 15, 27, 13, 0, -27 },
  { 1507, 18, 28, 18, 1, -28 },
  { 1570, 18, 27, 18, 0, -27 },
  { 1631, 13, 27, 8, -2, -27 },
  { 1675, 13, 34, 7, -5, -27 },
  { 1731, 17, 27, 14, 0, -27 },
  { 1789, 9, 27, 12, 0, -27 },
  { 1820, 24, 27, 23, 0, -27 },
  { 1901, 19, 27, 19, 0, -27 },
  { 1966, 16, 28, 18, 1, -28 },
  { 2022, 15, 27, 14, 0, -27 },
  { 2073, 16, 34, 18, 1, -28 },
  { 2141, 15, 27, 15, 0, -27 },
  { 2192, 16, 28, 14, -1, -28 },
  { 2248, 12, 27, 12, 3, -27 },
  { 2289, 17, 27, 17, 1, -27 },
  { 2347, 14, 27, 14, 3, -27 },
  { 2395, 24, 27, 24, 3, -27 },
  { 2476, 18, 27, 13, -2, -27 },
  { 2537, 13, 27, 12, 3, -27 },
  { 2581, 16, 27, 12, -2, -27 },
  { 2635, 14, 33, 11, -1, -27 },
  { 2693, 5, 27, 13, 4, -27 },
  { 2710, 13, 33, 11, -2, -27 },
  { 2764, 14, 14, 15, 1, -27 },
  { 2789, 11, 2, 11, -3, 3 },
  { 2792, 4, 6, 9, 6, -29 },
  { 2795, 14, 21, 15, 1, -21 },
  { 2832, 14, 29, 15, 0, -29 },
  { 2883, 11, 21, 11, 1, -21 },
  { 2912, 16, 29, 15, 1, -29 },
  { 2970, 12, 21, 13, 1, -21 },
  { 3002, 17, 38, 8, -5, -29 },
  { 3083, 16, 30, 15, -1, -21 },
  { 3143, 14, 29, 15, 0, -29 },
  { 3194, 8, 28, 7, 0, -28 },
  { 3222, 13, 37, 7, -5, -28 },
  { 3283, 14, 29, 13, 0, -29 },
  { 3334, 8, 29, 6, 0, -29 },
  { 3363, 21, 21, 22, 0, -21 },
  { 3419, 13, 21, 15, 0, -21 },
  { 3454, 13, 21, 15, 1, -21 },
  { 3489, 16, 30, 15, -2, -21 },
  { 3549, 14, 30, 15, 1, -21 },
  { 3602, 11, 21, 10, 0, -21 },
  { 3631, 13, 21, 11, -1, -21 },
  { 3666, 8, 25, 8, 1, -25 },
  { 3691, 13, 20, 15, 1, -20 },
  { 3724, 11, 20, 12, 2, -20 },
  { 3752, 19, 20, 19, 2, -20 },
  { 3800, 15, 20, 12, -2, -20 },
  { 3838, 18, 29, 12, -4, -20 },
  { 3904, 12, 20, 10, -1, -20 },
  { 3934, 13, 33, 12, 1, -27 },
  { 3988, 2, 38, 13, 6, -29 },
  { 3998, 13, 33, 12, -2, -27 },
  { 4052, 14, 4, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC38PT7B_H_
