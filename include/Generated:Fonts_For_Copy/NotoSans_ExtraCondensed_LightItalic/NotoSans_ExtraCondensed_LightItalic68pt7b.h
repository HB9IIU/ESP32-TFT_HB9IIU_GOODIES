#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x1C,
  0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x78,
  0x1C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xC0, 0x60, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x31, 0xF0, 0x0F, 0x0C,
  0x18, 0x07, 0x83, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x1E, 0x60, 0x00, 0x03, 0xD8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x67, 0x80, 0x00, 0x18, 0xF0,
  0x00, 0x06, 0x1C, 0x00, 0x01, 0x87, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x0F, 0x02, 0x01, 0x83, 0x80,
  0xC0, 0x61, 0xE0, 0x3E, 0x33, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x0E, 0x00,
  0xFF, 0x80, 0x0E, 0x00, 0xF1, 0xE0, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00,
  0x70, 0x38, 0x03, 0x80, 0x38, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0,
  0x1C, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0xE0,
  0x07, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xF0, 0x70, 0x03, 0x80, 0x70, 0x38,
  0x01, 0xC0, 0x38, 0x38, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x70, 0x0E, 0x1C,
  0x00, 0x38, 0x0E, 0x0E, 0x00, 0x3C, 0x07, 0x0E, 0x00, 0x1C, 0x03, 0x87,
  0x03, 0x0E, 0x01, 0xC7, 0x0F, 0xE7, 0x01, 0xC3, 0x8F, 0xFB, 0x80, 0xE3,
  0x87, 0x1D, 0xC0, 0xE1, 0xC7, 0x07, 0xE0, 0x71, 0xC7, 0x03, 0xF0, 0x70,
  0xE3, 0x81, 0xDC, 0x78, 0xE3, 0x80, 0xEF, 0xF8, 0x71, 0xC0, 0x73, 0xF8,
  0x70, 0xE0, 0x38, 0xF8, 0x38, 0xE0, 0x1C, 0x00, 0x38, 0x70, 0x0E, 0x00,
  0x1C, 0x38, 0x0E, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x0E, 0x1C, 0x03, 0x80,
  0x0E, 0x0E, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0xE0, 0x07, 0x03, 0x80, 0xF0,
  0x07, 0x83, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x03, 0xC0, 0xE0, 0x1C,
  0x01, 0xC0, 0x70, 0x1C, 0x01, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x0F,
  0x00, 0xF0, 0x0E, 0x07, 0x00, 0x70, 0x07, 0x07, 0x80, 0x78, 0x03, 0xC3,
  0x80, 0x38, 0x00, 0xE3, 0x80, 0x3C, 0x00, 0x7F, 0xC0, 0x1C, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x70, 0x78, 0xF0,
  0x38, 0x78, 0x38, 0x3C, 0x78, 0x1E, 0x1E, 0x38, 0x0F, 0x0E, 0x3C, 0x03,
  0x8F, 0x1C, 0x01, 0xC7, 0x1E, 0x00, 0xF3, 0x8F, 0x00, 0x7B, 0xC7, 0x00,
  0x1D, 0xC3, 0x80, 0x0F, 0xE1, 0xC0, 0x07, 0xE1, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x0E, 0x00, 0x7F, 0x07,
  0x80, 0x7F, 0x83, 0xE0, 0x79, 0xC0, 0xFF, 0xF8, 0xF0, 0x7F, 0xF8, 0x78,
  0x0F, 0xF0, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x38, 0xF1, 0xE3, 0xC7,
  0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x80,
  0xE0, 0x1C, 0x1C, 0x07, 0xE3, 0x00, 0x3F, 0x63, 0xE1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x60, 0x03, 0xCE, 0x00, 0xF0,
  0xE0, 0x3C, 0x1C, 0x0F, 0x03, 0xC0, 0x40, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x0F, 0x03,
  0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78,
  0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xEE,
  0x0F, 0x9C, 0x3C, 0x79, 0xF0, 0xF1, 0xC1, 0xE1, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0x80, 0x3C,
  0x00, 0x20, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x70, 0x07, 0x80, 0x10, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x27, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x80, 0x07, 0xC0, 0x30, 0x03, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0x70,
  0x00, 0x07, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x0E, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1E,
  0x00, 0x38, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x1E,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x13, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x18, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x08, 0x00, 0x7C, 0x01,
  0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x20, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x87, 0xE0, 0x03, 0xCF, 0xFC, 0x01, 0xCF,
  0xFF, 0x00, 0xEF, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7E, 0x00, 0xF0, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01,
  0xC0, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0xF0, 0x03, 0xC0, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x07, 0x00,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x00,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0F,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x87, 0xC0,
  0x0F, 0x81, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x0E,
  0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0,
  0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF8, 0x38, 0x00, 0x7C, 0x1E,
  0x00, 0x7C, 0x0F, 0x00, 0x7E, 0x07, 0xC0, 0x77, 0x01, 0xE0, 0x7F, 0x80,
  0xFF, 0xFB, 0xC0, 0x3F, 0xF9, 0xC0, 0x0F, 0xF0, 0xE0, 0x00, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x78,
  0x3E, 0x02, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x03, 0xFC, 0x1C, 0x1C, 0x03,
  0xFF, 0x07, 0x0E, 0x01, 0xF3, 0xC1, 0xC3, 0x80, 0xF0, 0xE0, 0x71, 0xC0,
  0x38, 0x38, 0x1C, 0x70, 0x1C, 0x0E, 0x07, 0x1C, 0x0E, 0x03, 0x81, 0xCE,
  0x03, 0x81, 0xC0, 0x73, 0x81, 0xC0, 0x70, 0x1C, 0xE0, 0x70, 0x1C, 0x06,
  0x70, 0x1C, 0x07, 0x03, 0x9C, 0x0E, 0x03, 0x80, 0xE7, 0x03, 0x80, 0xE0,
  0x39, 0xC0, 0xE0, 0x38, 0x0E, 0x70, 0x70, 0x0E, 0x07, 0x38, 0x1C, 0x07,
  0x01, 0xCE, 0x07, 0x01, 0xC0, 0x73, 0x81, 0xC0, 0x70, 0x18, 0xE0, 0x70,
  0x3C, 0x0E, 0x38, 0x1C, 0x0F, 0x03, 0x8E, 0x07, 0x07, 0x81, 0xC3, 0x81,
  0xC1, 0xE0, 0x70, 0xE0, 0x70, 0xF8, 0x38, 0x38, 0x1C, 0x37, 0x1C, 0x0E,
  0x07, 0xF9, 0xFF, 0x03, 0x80, 0xFE, 0x3F, 0x80, 0xE0, 0x1F, 0x07, 0x80,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x77, 0x00, 0x00, 0x77,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xC7, 0x00, 0x03, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x07, 0x87,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x07,
  0x00, 0x38, 0x07, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x07,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07,
  0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0x78, 0x00, 0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x38, 0x07, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x78, 0x1F, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0F,
  0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x80, 0x78, 0x03, 0xF0, 0x07, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0xE0, 0x03, 0xE0, 0x08,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x02, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0x80, 0xFC, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x7C,
  0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0xC0, 0x07,
  0x80, 0x7C, 0x00, 0x38, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x3E,
  0x00, 0x04, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x78, 0x00, 0x7F, 0xE0, 0x78, 0x00,
  0x7F, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x43, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x03, 0xDF, 0x80, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xB8, 0x00, 0x01, 0xFE, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x03, 0xDC,
  0x00, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x00, 0x3B, 0xC0, 0x0E, 0x70, 0x00,
  0x0F, 0x78, 0x01, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x00, 0x79,
  0xC0, 0x0F, 0x38, 0x00, 0x0E, 0x78, 0x01, 0xC7, 0x00, 0x03, 0xCF, 0x00,
  0x38, 0xE0, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x01, 0xE3,
  0x80, 0x03, 0x87, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00,
  0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x00, 0xE0,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x1C, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x3C, 0x1C, 0x00, 0xF0,
  0x38, 0x07, 0x03, 0x80, 0x1E, 0x07, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x00, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x03, 0xC0, 0x70, 0x78, 0x0E, 0x00, 0x78, 0x0E, 0x0E, 0x03, 0xC0,
  0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x01, 0xC0, 0x38, 0x70, 0x0F, 0x00, 0x78,
  0x07, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xE3, 0x80, 0x38, 0x01, 0xE0, 0x1C,
  0xF0, 0x0F, 0x00, 0x38, 0x03, 0x9C, 0x01, 0xE0, 0x07, 0x00, 0x73, 0x80,
  0x38, 0x01, 0xE0, 0x0E, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0xFC, 0x01, 0xE0,
  0x07, 0x80, 0x3F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xFC, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x00,
  0x70, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x1F, 0xC0, 0x00, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x01, 0xDC,
  0x00, 0x1E, 0x00, 0x77, 0x00, 0x07, 0x80, 0x3D, 0xC0, 0x01, 0xC0, 0x0F,
  0x78, 0x00, 0x70, 0x03, 0xDE, 0x00, 0x3C, 0x00, 0xE3, 0x80, 0x0F, 0x00,
  0x38, 0xE0, 0x03, 0xC0, 0x1E, 0x38, 0x00, 0xE0, 0x07, 0x8E, 0x00, 0x38,
  0x01, 0xE3, 0xC0, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x80, 0x1C, 0x1C, 0x01,
  0xE0, 0x0F, 0x07, 0x00, 0x70, 0x03, 0xC1, 0xC0, 0x1C, 0x00, 0xE0, 0x70,
  0x0F, 0x00, 0x38, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0xE0, 0x38, 0x01, 0xE0, 0x38, 0x1E, 0x00, 0x70, 0x0E, 0x07, 0x80, 0x1C,
  0x03, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0x3C, 0x1C, 0x00,
  0xF0, 0x07, 0x0F, 0x00, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x00, 0x70, 0xF0,
  0x07, 0x80, 0x1E, 0x38, 0x01, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0x00, 0xE7,
  0x80, 0x1C, 0x00, 0x39, 0xE0, 0x0F, 0x00, 0x0E, 0x78, 0x03, 0xC0, 0x03,
  0x9C, 0x00, 0xF0, 0x00, 0xF7, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x0E, 0x00,
  0x07, 0xF0, 0x07, 0x80, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x78,
  0x00, 0x1F, 0x80, 0x1C, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x01, 0xF8, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x78,
  0x00, 0x78, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78,
  0x07, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00,
  0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x03, 0xF0,
  0x07, 0x81, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0,
  0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x1F, 0x00, 0x78, 0x03, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x1C,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0xE0, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x03,
  0xC0, 0x70, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x3C, 0x00, 0xE0,
  0x1E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x78, 0x00,
  0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xEE,
  0x00, 0x01, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xF0, 0x00,
  0x78, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0xC0, 0x03, 0xC1,
  0xC0, 0x03, 0xB8, 0x00, 0x78, 0x38, 0x00, 0x77, 0x00, 0x0E, 0x07, 0x00,
  0x1E, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x9C, 0x00, 0x70, 0x1C, 0x00, 0x73,
  0x80, 0x1E, 0x03, 0x80, 0x1C, 0x70, 0x03, 0xC0, 0x70, 0x03, 0x8E, 0x00,
  0x70, 0x1E, 0x00, 0xF1, 0xC0, 0x1E, 0x03, 0xC0, 0x1C, 0x38, 0x03, 0x80,
  0x78, 0x03, 0x87, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x1C, 0x03, 0x80, 0x3C, 0x07, 0x83, 0x80, 0xF0, 0x07, 0x80, 0xE0,
  0x70, 0x1C, 0x00, 0xF0, 0x1C, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x00, 0x78, 0x3C, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0,
  0x1C, 0x3C, 0x00, 0x1E, 0x38, 0x03, 0x87, 0x00, 0x03, 0xC7, 0x00, 0x71,
  0xE0, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x00, 0x0F, 0x38, 0x01, 0xC7, 0x00,
  0x01, 0xE7, 0x00, 0x39, 0xE0, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0xEF, 0x00, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x00, 0x1D, 0xC0,
  0x03, 0xB8, 0x00, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x1E, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x38, 0x01, 0xE0,
  0x70, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07,
  0x01, 0xE0, 0x0F, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9E,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x0E,
  0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x03, 0xC0,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0x78,
  0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x06, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0xE1, 0xC0, 0x3F, 0xF9, 0xE0, 0x3F, 0xBE, 0xE0, 0x1E, 0x07, 0x70,
  0x1E, 0x01, 0xB8, 0x1E, 0x00, 0xFC, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x81, 0xE0, 0x0F, 0x80,
  0xF0, 0x0D, 0xC0, 0x3C, 0x0E, 0xE0, 0x1F, 0xFE, 0x70, 0x07, 0xFE, 0x38,
  0x01, 0xFE, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0xE3, 0xFC,
  0x00, 0xF3, 0xFF, 0x00, 0x7B, 0xEF, 0xC0, 0x3B, 0x81, 0xE0, 0x1D, 0x80,
  0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x07, 0x03, 0xC0,
  0x03, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x38, 0x00, 0x3C,
  0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xF8, 0x03, 0xC0, 0xEC, 0x03,
  0xC0, 0x77, 0x03, 0xC0, 0x39, 0xEF, 0xE0, 0x18, 0xFF, 0xE0, 0x1C, 0x3F,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0x8E, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x40, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x3F, 0xC7, 0x80, 0x0F, 0xFE, 0x70, 0x01, 0xFD, 0xF7, 0x00, 0x1E,
  0x07, 0x70, 0x03, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0xDC, 0x00, 0x78, 0x1D, 0xC0, 0x07, 0xEF, 0x9C, 0x00, 0x3F,
  0xF1, 0x80, 0x01, 0xFE, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xF3, 0xE0, 0x3E, 0x07, 0x81,
  0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xE0,
  0x0F, 0x8F, 0x00, 0xF8, 0x78, 0x1F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x10, 0x0F, 0xC7, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0x00, 0x1F, 0xFC,
  0xF0, 0x03, 0xFB, 0xEE, 0x00, 0x3C, 0x0E, 0xE0, 0x07, 0x80, 0x6E, 0x00,
  0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x01, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x3C,
  0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x1E,
  0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x01, 0xB8, 0x00, 0xF0, 0x3B,
  0x80, 0x0F, 0xFF, 0x78, 0x00, 0x7F, 0xE7, 0x80, 0x03, 0xFC, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x80, 0x0F, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0xE3, 0xFC, 0x00,
  0xE7, 0xFE, 0x01, 0xEF, 0xFF, 0x01, 0xDC, 0x0F, 0x01, 0xF8, 0x0F, 0x01,
  0xF0, 0x07, 0x01, 0xE0, 0x07, 0x03, 0xE0, 0x07, 0x03, 0xC0, 0x0F, 0x03,
  0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07,
  0x80, 0x1E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F,
  0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x1E,
  0x00, 0x38, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C,
  0x00, 0x70, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38,
  0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70,
  0x01, 0xE0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x70,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0E,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xC1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x38, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xFC, 0x00, 0x0F, 0x7E, 0x00,
  0x07, 0x7F, 0x00, 0x03, 0xF3, 0x80, 0x01, 0xF1, 0xC0, 0x01, 0xF8, 0xE0,
  0x00, 0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x07,
  0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0x80,
  0x78, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0xC0, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x1F, 0xE0, 0xFF, 0x00,
  0x73, 0xFF, 0x8F, 0xFC, 0x03, 0xBE, 0xFC, 0xF3, 0xF0, 0x1D, 0x81, 0xFE,
  0x07, 0x80, 0xF8, 0x07, 0xE0, 0x1C, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x7C,
  0x01, 0xF0, 0x07, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0xF0, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0xE0, 0x03, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE3, 0xFC,
  0x01, 0xC7, 0xFE, 0x01, 0xCF, 0xFF, 0x01, 0xDC, 0x0F, 0x01, 0xF8, 0x0F,
  0x01, 0xF0, 0x07, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x0F,
  0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E,
  0x07, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C,
  0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x38,
  0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78,
  0x3C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xF0,
  0x38, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x01, 0xE0,
  0x70, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7E, 0x7E, 0x03, 0xE0, 0x78, 0x0F,
  0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x1C, 0x78, 0x00,
  0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x73,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x00,
  0x03, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38,
  0x00, 0x78, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01,
  0xE0, 0x70, 0x0F, 0x01, 0xE0, 0x7C, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xC7,
  0xF8, 0x00, 0x1C, 0xFF, 0xC0, 0x03, 0x9E, 0x7E, 0x00, 0x3B, 0x81, 0xE0,
  0x03, 0xB0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7C,
  0x00, 0x70, 0x07, 0xC0, 0x07, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x07,
  0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x0E,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0xC0,
  0x3C, 0x00, 0xEE, 0x07, 0x80, 0x0E, 0x7F, 0xF8, 0x00, 0xE7, 0xFF, 0x00,
  0x1E, 0x3F, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0xE1, 0xC0, 0x3F, 0xF9, 0xE0, 0x3F, 0xBE,
  0xE0, 0x1E, 0x07, 0x70, 0x1E, 0x01, 0xB8, 0x1E, 0x00, 0xFC, 0x0F, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x78,
  0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x1F,
  0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x0D, 0xC0, 0x3C, 0x0F, 0xE0, 0x1F, 0xFE,
  0xF0, 0x07, 0xFE, 0x78, 0x01, 0xFE, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x0E, 0x3F, 0x01, 0xC7, 0xF0, 0x1C, 0xFF, 0x01, 0xDE, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x7E, 0x3E, 0x03, 0xE0, 0x18, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x80,
  0x0F, 0x03, 0x00, 0x78, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xE0, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x07, 0x80,
  0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x07, 0x00,
  0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1C, 0x00,
  0x78, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x3C, 0x00,
  0xF0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x00,
  0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x07, 0xC0, 0xE0, 0x07,
  0x80, 0xE0, 0x0F, 0x80, 0xF0, 0x1F, 0x80, 0xF0, 0x3B, 0x80, 0xFF, 0xF3,
  0x80, 0x7F, 0xE7, 0x00, 0x3F, 0xC7, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00,
  0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0,
  0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80,
  0x0E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x03,
  0xFC, 0x00, 0xF8, 0x01, 0xDE, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0x7E, 0x00,
  0xE7, 0x80, 0x3F, 0x00, 0x73, 0xC0, 0x3B, 0x80, 0x79, 0xE0, 0x1D, 0xC0,
  0x38, 0xF0, 0x0E, 0xE0, 0x3C, 0x78, 0x0E, 0x70, 0x1C, 0x3C, 0x07, 0x38,
  0x0E, 0x1C, 0x07, 0x9C, 0x0F, 0x0E, 0x03, 0x8E, 0x07, 0x07, 0x01, 0xC7,
  0x07, 0x83, 0x81, 0xC3, 0x83, 0x81, 0xC0, 0xE1, 0xC1, 0xC0, 0xE0, 0xF0,
  0xE1, 0xE0, 0x70, 0x70, 0xF0, 0xE0, 0x38, 0x38, 0x70, 0x70, 0x1C, 0x38,
  0x38, 0x70, 0x0E, 0x1C, 0x1C, 0x38, 0x07, 0x1E, 0x0E, 0x3C, 0x03, 0x8E,
  0x07, 0x1C, 0x01, 0xC7, 0x03, 0x8E, 0x00, 0xE7, 0x01, 0xCF, 0x00, 0x73,
  0x80, 0xE7, 0x00, 0x3B, 0xC0, 0x77, 0x80, 0x1D, 0xC0, 0x3B, 0x80, 0x0E,
  0xE0, 0x1D, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC1, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E,
  0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x5F, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFA, 0x00,
  0x0F, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 49, 15, 1, -49 },
  { 93, 16, 18, 20, 7, -49 },
  { 129, 28, 49, 27, 0, -49 },
  { 301, 26, 56, 25, 0, -52 },
  { 483, 33, 50, 38, 3, -49 },
  { 690, 25, 50, 26, -1, -49 },
  { 847, 7, 18, 11, 7, -49 },
  { 863, 20, 60, 17, 1, -49 },
  { 1013, 20, 60, 17, -5, -49 },
  { 1163, 19, 21, 23, 7, -52 },
  { 1213, 24, 32, 28, 2, -40 },
  { 1309, 10, 16, 12, -3, -7 },
  { 1329, 15, 3, 18, 1, -20 },
  { 1335, 5, 6, 12, 1, -6 },
  { 1339, 29, 49, 21, -3, -49 },
  { 1517, 24, 50, 25, 1, -49 },
  { 1667, 15, 49, 25, 7, -49 },
  { 1759, 27, 49, 25, -2, -49 },
  { 1925, 26, 50, 25, -1, -49 },
  { 2088, 26, 49, 25, -1, -49 },
  { 2248, 27, 50, 25, -1, -49 },
  { 2417, 25, 50, 25, 2, -49 },
  { 2574, 26, 49, 25, 2, -49 },
  { 2734, 27, 50, 25, -1, -49 },
  { 2903, 25, 50, 25, 0, -49 },
  { 3060, 12, 36, 12, 0, -36 },
  { 3114, 15, 45, 12, -3, -36 },
  { 3199, 25, 29, 28, 2, -39 },
  { 3290, 24, 18, 28, 2, -33 },
  { 3344, 25, 29, 28, 2, -39 },
  { 3435, 20, 49, 18, 1, -49 },
  { 3558, 34, 55, 37, 2, -49 },
  { 3792, 24, 49, 25, -4, -49 },
  { 3939, 28, 49, 27, 0, -49 },
  { 4111, 27, 50, 25, 3, -49 },
  { 4280, 29, 49, 30, 0, -49 },
  { 4458, 27, 49, 24, 0, -49 },
  { 4624, 27, 49, 22, 0, -49 },
  { 4790, 32, 50, 32, 2, -49 },
  { 4990, 33, 49, 31, 0, -49 },
  { 5193, 23, 49, 14, -4, -49 },
  { 5334, 24, 61, 12, -10, -49 },
  { 5517, 31, 49, 26, 0, -49 },
  { 5707, 17, 49, 22, 0, -49 },
  { 5812, 43, 49, 42, 0, -49 },
  { 6076, 34, 49, 33, 0, -49 },
  { 6285, 29, 50, 32, 2, -49 },
  { 6467, 27, 49, 26, 0, -49 },
  { 6633, 29, 61, 32, 2, -49 },
  { 6855, 27, 49, 26, 0, -49 },
  { 7021, 29, 50, 24, -2, -49 },
  { 7203, 23, 49, 22, 4, -49 },
  { 7344, 30, 50, 30, 2, -49 },
  { 7532, 25, 49, 25, 6, -49 },
  { 7686, 43, 49, 43, 5, -49 },
  { 7950, 32, 49, 23, -4, -49 },
  { 8146, 23, 49, 22, 5, -49 },
  { 8287, 29, 49, 22, -3, -49 },
  { 8465, 25, 60, 19, -2, -49 },
  { 8653, 10, 49, 22, 7, -49 },
  { 8715, 24, 60, 19, -4, -49 },
  { 8895, 26, 25, 27, 1, -49 },
  { 8977, 20, 3, 19, -6, 6 },
  { 8985, 8, 11, 15, 10, -52 },
  { 8996, 25, 38, 27, 2, -37 },
  { 9115, 25, 53, 27, 0, -52 },
  { 9281, 20, 38, 20, 2, -37 },
  { 9376, 28, 53, 27, 2, -52 },
  { 9562, 21, 38, 24, 2, -37 },
  { 9662, 31, 68, 14, -9, -52 },
  { 9926, 28, 53, 27, -1, -37 },
  { 10112, 24, 52, 26, 0, -52 },
  { 10268, 14, 49, 12, 0, -49 },
  { 10354, 23, 65, 12, -9, -49 },
  { 10541, 25, 52, 22, 0, -52 },
  { 10704, 15, 52, 11, 0, -52 },
  { 10802, 37, 37, 39, 0, -37 },
  { 10974, 24, 37, 26, 0, -37 },
  { 11085, 22, 38, 26, 2, -37 },
  { 11190, 28, 53, 27, -3, -37 },
  { 11376, 25, 53, 27, 2, -37 },
  { 11542, 20, 37, 17, 0, -37 },
  { 11635, 22, 38, 20, -1, -37 },
  { 11740, 15, 46, 14, 1, -45 },
  { 11827, 24, 37, 26, 2, -36 },
  { 11938, 20, 36, 21, 4, -36 },
  { 12028, 33, 36, 34, 4, -36 },
  { 12177, 27, 36, 21, -3, -36 },
  { 12299, 32, 52, 22, -7, -36 },
  { 12507, 22, 36, 17, -2, -36 },
  { 12606, 24, 60, 22, 2, -49 },
  { 12786, 4, 68, 24, 10, -52 },
  { 12820, 24, 60, 22, -4, -49 },
  { 13000, 25, 7, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC68PT7B_H_
