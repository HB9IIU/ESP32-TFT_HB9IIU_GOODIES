#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x00, 0x38, 0x73, 0x87, 0x38, 0x73, 0x86, 0x30, 0x67,
  0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x0C, 0x61, 0xCE, 0x18, 0xC1, 0x80,
  0x00, 0x1C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x38, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60,
  0xE0, 0x01, 0x83, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x07, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x38,
  0x00, 0x60, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x30, 0x60, 0x01,
  0xC1, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x07,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x0E, 0x00,
  0x18, 0x30, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x3E, 0xCF, 0x03, 0x8C, 0x20, 0x70, 0x80, 0x06, 0x08, 0x00, 0x61, 0x80,
  0x0E, 0x18, 0x00, 0xE1, 0x80, 0x0E, 0x10, 0x00, 0x61, 0x00, 0x07, 0x30,
  0x00, 0x73, 0x00, 0x03, 0xB0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x05, 0xC0, 0x00, 0x4E, 0x00, 0x0C, 0xE0, 0x00,
  0xC7, 0x00, 0x0C, 0x70, 0x00, 0x87, 0x00, 0x08, 0x70, 0x01, 0x87, 0x00,
  0x18, 0x70, 0x01, 0x86, 0x08, 0x10, 0xE0, 0xC3, 0x1C, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x03,
  0x01, 0xDC, 0x03, 0x81, 0xC6, 0x01, 0x80, 0xC3, 0x01, 0xC0, 0xC1, 0xC0,
  0xC0, 0x60, 0xE0, 0xE0, 0x70, 0x60, 0x60, 0x30, 0x30, 0x70, 0x18, 0x18,
  0x30, 0x1C, 0x0C, 0x38, 0x0E, 0x06, 0x18, 0x06, 0x07, 0x1C, 0x03, 0x03,
  0x0C, 0x01, 0x81, 0x8E, 0x00, 0xC0, 0xC6, 0x0C, 0x60, 0xE7, 0x1F, 0x70,
  0x63, 0x1D, 0xF8, 0x73, 0x9C, 0x6C, 0x31, 0x9C, 0x36, 0x39, 0xCC, 0x1B,
  0xF8, 0xC6, 0x0C, 0xF8, 0xE7, 0x06, 0x10, 0x63, 0x03, 0x00, 0x71, 0x81,
  0x80, 0x31, 0xC0, 0xC0, 0x38, 0xC0, 0xE0, 0x18, 0x60, 0x70, 0x1C, 0x30,
  0x30, 0x0C, 0x18, 0x18, 0x0E, 0x0C, 0x1C, 0x06, 0x0E, 0x0E, 0x07, 0x07,
  0x06, 0x03, 0x03, 0x87, 0x03, 0x80, 0xC3, 0x01, 0x80, 0x63, 0x81, 0xC0,
  0x3F, 0x81, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x60,
  0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x60, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0xE0, 0x07, 0x18, 0x00, 0x67, 0x00, 0x0D, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x3C, 0xC1,
  0xC7, 0x1C, 0x31, 0xC3, 0x8E, 0x70, 0x71, 0xCE, 0x06, 0x33, 0x80, 0xEE,
  0x70, 0x1D, 0xCE, 0x01, 0xB1, 0x80, 0x3E, 0x30, 0x07, 0x86, 0x00, 0xF0,
  0xC0, 0x1E, 0x1C, 0x07, 0xC3, 0x81, 0xF8, 0x78, 0x73, 0x87, 0xFC, 0x70,
  0x7F, 0x0E, 0x03, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x61,
  0x86, 0x38, 0xC0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x83, 0x03, 0x8C, 0x0F, 0xB1, 0xC7, 0xFF, 0x07, 0xF8, 0x3C, 0x01, 0xD8,
  0x0E, 0x60, 0x70, 0xC3, 0x83, 0x84, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x0E, 0x18, 0x70, 0xC3,
  0x86, 0x00, 0xFF, 0xFF, 0xFC, 0x6F, 0xFE, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0x8E, 0x01,
  0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x06, 0x38, 0x01, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x03, 0x9C, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0xE0, 0xE0, 0x38, 0x38, 0x1C, 0x06, 0x0E, 0x01, 0xC7, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xE3,
  0xDC, 0xF3, 0x3C, 0xE6, 0x1C, 0x43, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xC1, 0xE0, 0x04, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x1C, 0x0E, 0x01,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x80, 0x3C, 0x0C, 0x07, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x6E, 0x00,
  0x0C, 0xE0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x9C, 0x00, 0x31, 0xC0,
  0x06, 0x1C, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x01, 0xC3, 0x80, 0x18, 0x38,
  0x03, 0x03, 0x80, 0x70, 0x30, 0x06, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x70, 0x38, 0x06, 0x03, 0x00, 0xE0, 0x70, 0x0E, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x20,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x04, 0x00, 0xE0, 0x30, 0x1E, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC7, 0xC0, 0x3B, 0xFC, 0x06, 0xF7,
  0xC0, 0xD8, 0x3C, 0x3E, 0x03, 0x87, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x00,
  0xC3, 0x80, 0x38, 0x60, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1C,
  0x0C, 0x03, 0x81, 0xC0, 0xE0, 0x3C, 0x38, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x80, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x18, 0x0E,
  0x00, 0xE0, 0x70, 0x07, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0, 0x1C,
  0x06, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x38,
  0x70, 0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00,
  0x3D, 0xC0, 0x07, 0x87, 0x00, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x60, 0x03, 0x83, 0x80, 0x38,
  0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xE1, 0xE0,
  0x38, 0x1C, 0x0E, 0x01, 0x81, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x0E,
  0x03, 0xE0, 0xE0, 0xDC, 0x1F, 0xFB, 0x01, 0xFC, 0xE0, 0x1F, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x41, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x70, 0x78, 0x3C, 0x1C, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x80,
  0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0xF0, 0x7F, 0xF0, 0x60, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x0F, 0xC1, 0x86,
  0x03, 0xF8, 0x30, 0xC0, 0xE3, 0x0E, 0x30, 0x30, 0xE1, 0xC6, 0x0E, 0x1C,
  0x39, 0xC1, 0x83, 0x06, 0x30, 0x70, 0x60, 0xC6, 0x0C, 0x1C, 0x18, 0xC1,
  0x83, 0x83, 0x38, 0x70, 0x60, 0xE6, 0x0C, 0x0C, 0x18, 0xC1, 0x83, 0x83,
  0x18, 0x30, 0x70, 0x63, 0x0E, 0x0C, 0x1C, 0x61, 0xC3, 0x83, 0x1C, 0x38,
  0x70, 0x63, 0x87, 0x0E, 0x18, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0xD8, 0xC1,
  0xC1, 0xF1, 0xF0, 0x38, 0x1C, 0x3C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x03,
  0xB8, 0x00, 0x67, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x18, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x70, 0x7C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x06, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38,
  0x1C, 0x01, 0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80,
  0x78, 0x1C, 0x07, 0x80, 0xC0, 0x78, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x1C, 0x0F, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xF0,
  0x70, 0x0F, 0x03, 0x80, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xE0,
  0x60, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x30,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x1C, 0x7F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x78, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x70, 0x30, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xC1, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x03,
  0xC0, 0x70, 0x1E, 0x01, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xF8, 0x0E, 0x01, 0xE0, 0x02, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0xF0, 0xE0, 0x07, 0xF0, 0xE0, 0x0F,
  0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01,
  0x80, 0x78, 0x03, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x70,
  0x00, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x06,
  0x00, 0x1C, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0x80,
  0x07, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x02, 0x3C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03,
  0x83, 0x80, 0x03, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x1E,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0D, 0x80, 0x01,
  0xF8, 0x06, 0xC0, 0x00, 0xDC, 0x07, 0x60, 0x00, 0xEC, 0x03, 0xB0, 0x00,
  0x7E, 0x01, 0xD8, 0x00, 0x77, 0x00, 0xCC, 0x00, 0x3B, 0x80, 0xE6, 0x00,
  0x39, 0xC0, 0x73, 0x00, 0x1C, 0xC0, 0x39, 0x80, 0x1C, 0xE0, 0x18, 0xE0,
  0x0E, 0x70, 0x0C, 0x70, 0x06, 0x38, 0x0E, 0x38, 0x07, 0x18, 0x07, 0x1C,
  0x03, 0x0C, 0x03, 0x8E, 0x03, 0x8E, 0x01, 0x87, 0x01, 0x87, 0x00, 0xC3,
  0x81, 0xC3, 0x80, 0xE1, 0xC0, 0xC1, 0x80, 0x70, 0xE0, 0xE1, 0xC0, 0x38,
  0x70, 0x60, 0xE0, 0x18, 0x38, 0x70, 0x70, 0x1C, 0x0C, 0x38, 0x38, 0x0E,
  0x06, 0x38, 0x18, 0x07, 0x03, 0x1C, 0x1C, 0x03, 0x81, 0x9C, 0x0E, 0x01,
  0x80, 0xCE, 0x07, 0x01, 0xC0, 0x66, 0x03, 0x80, 0xE0, 0x37, 0x01, 0x80,
  0x70, 0x1B, 0x01, 0xC0, 0x30, 0x0F, 0x80, 0xE0, 0x18, 0x07, 0x80, 0x70,
  0x1C, 0x03, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x3C, 0x00, 0x70, 0x1F, 0x00, 0x1C, 0x07, 0xC0, 0x07, 0x01, 0xF0,
  0x01, 0x80, 0x6C, 0x00, 0xE0, 0x1B, 0x00, 0x38, 0x0E, 0xE0, 0x0E, 0x03,
  0xB8, 0x03, 0x00, 0xEE, 0x00, 0xC0, 0x31, 0x80, 0x70, 0x1C, 0x60, 0x1C,
  0x07, 0x18, 0x07, 0x01, 0xC7, 0x01, 0x80, 0x71, 0xC0, 0xE0, 0x18, 0x70,
  0x38, 0x0E, 0x0C, 0x0E, 0x03, 0x83, 0x03, 0x80, 0xE0, 0xE0, 0xC0, 0x30,
  0x38, 0x70, 0x0C, 0x0E, 0x1C, 0x07, 0x03, 0x87, 0x01, 0xC0, 0x61, 0xC0,
  0x70, 0x18, 0x60, 0x18, 0x07, 0x38, 0x0E, 0x01, 0xCE, 0x03, 0x80, 0x73,
  0x80, 0xE0, 0x0C, 0xC0, 0x38, 0x03, 0x30, 0x0C, 0x00, 0xDC, 0x07, 0x00,
  0x3F, 0x01, 0xC0, 0x0F, 0xC0, 0x70, 0x03, 0xE0, 0x1C, 0x00, 0x78, 0x06,
  0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0x78,
  0x0E, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x63, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x07, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1E, 0x0F,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x01, 0xC7, 0xE0, 0x1C, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x70, 0x38, 0x03, 0x03, 0x80, 0x30, 0x38, 0x03, 0x03,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0,
  0x60, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x0E, 0x0F, 0x80, 0xFF, 0xF0,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0xE0,
  0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x03,
  0x8C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x30,
  0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xC7,
  0xE0, 0x1C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x70, 0x38,
  0x03, 0x03, 0x80, 0x30, 0x38, 0x07, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x60, 0x1E, 0x0E, 0x01, 0xC0,
  0xE0, 0x78, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x18, 0x01, 0x81, 0xC0, 0x38, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x0E, 0x0E, 0x00, 0x60, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xE0,
  0x70, 0x1C, 0x01, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x20, 0x07, 0x81, 0xC0, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xDF,
  0xFF, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x0C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x18,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x30, 0x00,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1,
  0x80, 0x06, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x0C, 0x0C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x60, 0x38, 0x03,
  0x80, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x07, 0x87, 0x80, 0x1F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0,
  0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0C,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x63,
  0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0,
  0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0xC0, 0x0E, 0xE0,
  0x07, 0xC0, 0x1C, 0xE0, 0x07, 0xC0, 0x1C, 0xE0, 0x0F, 0xC0, 0x18, 0xE0,
  0x0D, 0xC0, 0x38, 0xE0, 0x1D, 0x80, 0x38, 0xE0, 0x1D, 0x80, 0x70, 0xE0,
  0x19, 0x80, 0x70, 0xE0, 0x39, 0x80, 0x60, 0xE0, 0x31, 0x80, 0xE0, 0xE0,
  0x71, 0x80, 0xE0, 0xE0, 0x71, 0x81, 0xC0, 0xE0, 0x61, 0x81, 0xC0, 0xE0,
  0xE1, 0x81, 0x80, 0xE0, 0xC1, 0x83, 0x80, 0xE1, 0xC1, 0x83, 0x80, 0xE1,
  0xC1, 0x87, 0x00, 0xE1, 0x81, 0x87, 0x00, 0xE3, 0x81, 0x86, 0x00, 0xE3,
  0x01, 0x8E, 0x00, 0xE3, 0x01, 0x8E, 0x00, 0xE7, 0x01, 0x9C, 0x00, 0xE6,
  0x03, 0x9C, 0x00, 0xEE, 0x03, 0x98, 0x00, 0xEE, 0x03, 0xB8, 0x00, 0xEC,
  0x03, 0xB8, 0x00, 0xDC, 0x03, 0xB0, 0x00, 0xD8, 0x03, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x30,
  0x38, 0x00, 0x30, 0x38, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x1B,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x86,
  0x00, 0x03, 0x86, 0x00, 0x07, 0x06, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03,
  0xB0, 0x03, 0x98, 0x01, 0xCC, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0,
  0x70, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x06, 0x1C, 0x03,
  0x0E, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xE0, 0x60,
  0x60, 0x60, 0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38,
  0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03, 0x9C,
  0x00, 0x63, 0x80, 0x1C, 0x70, 0x03, 0x07, 0x00, 0xE0, 0xE0, 0x18, 0x0C,
  0x07, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x03, 0x0E, 0x00, 0x71, 0x80, 0x0E,
  0x70, 0x00, 0xEC, 0x00, 0x1F, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE3, 0x8E, 0x1C, 0x70, 0xC1, 0x87, 0x00, 0x7C, 0x70, 0x1F, 0xE6, 0x03,
  0xE7, 0x60, 0x78, 0x3E, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x0C, 0x01, 0xC1,
  0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x83, 0x80, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0x70, 0x07,
  0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x1E, 0x07, 0x03, 0xE0, 0x70, 0x3C, 0x07, 0x86, 0xC0, 0x3F,
  0xCC, 0x01, 0xF8, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x39, 0xF8, 0x06, 0x7F, 0x80, 0xDC, 0xF0, 0x3E, 0x07, 0x07, 0x80, 0xE0,
  0xF0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x60, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8C,
  0x00, 0xE1, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x07, 0x06, 0x81, 0xE0, 0xD8,
  0x78, 0x3B, 0xFE, 0x06, 0x3F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x01,
  0xFF, 0x03, 0xE6, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x20, 0x3F, 0xE0, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x70, 0x07, 0xF9, 0x80, 0x3E, 0x7E,
  0x01, 0xE0, 0xF8, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x1C, 0x07,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x18, 0x0E, 0x00,
  0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xC0,
  0x60, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0,
  0x0E, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x18, 0x0F, 0x80, 0x70, 0x2C,
  0x01, 0xE1, 0xB0, 0x03, 0xFC, 0xC0, 0x07, 0xE3, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0x80, 0xF1, 0xC0, 0xE0, 0x60, 0xF0, 0x38, 0x70,
  0x1C, 0x70, 0x0C, 0x38, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x0E, 0x03, 0x8E,
  0x07, 0x87, 0x0F, 0x83, 0xFF, 0x81, 0xFE, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x08, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x1C, 0x01, 0xFE, 0x60, 0x0F, 0x9D, 0x80, 0x78,
  0x3E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x30, 0x07, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x38, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x30, 0x18, 0x01,
  0xC0, 0x60, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x80,
  0xE0, 0x0E, 0x03, 0x80, 0x78, 0x06, 0x03, 0xE0, 0x1C, 0x0F, 0x00, 0x78,
  0xEC, 0x00, 0xFF, 0x70, 0x01, 0xF9, 0xC0, 0x01, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x80, 0x38, 0x03, 0x03, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x39, 0xF8, 0x06,
  0x7F, 0x80, 0xDC, 0xF0, 0x3E, 0x0E, 0x07, 0x80, 0xE0, 0xE0, 0x18, 0x1C,
  0x03, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x60,
  0x0C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0x80,
  0x30, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x30, 0x06, 0x06, 0x00,
  0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x03,
  0x07, 0x00, 0xE0, 0x00, 0x40, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x1C, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x03, 0x0E,
  0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x67, 0x00, 0x1D, 0xE0,
  0x03, 0xFC, 0x00, 0x7D, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x01, 0xC1, 0x80, 0x30, 0x38, 0x06, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x30, 0x38, 0x07, 0x07, 0x00, 0xE0,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x03, 0x1F, 0x07, 0xE0, 0x19,
  0xFC, 0x7F, 0x80, 0xDC, 0xF7, 0x3C, 0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x1E,
  0x03, 0x83, 0x80, 0xF0, 0x1C, 0x1C, 0x07, 0x00, 0xC1, 0xC0, 0x38, 0x06,
  0x0E, 0x01, 0xC0, 0x70, 0x70, 0x0E, 0x03, 0x83, 0x80, 0x60, 0x1C, 0x18,
  0x07, 0x00, 0xE1, 0xC0, 0x38, 0x06, 0x0E, 0x01, 0xC0, 0x70, 0x70, 0x0C,
  0x03, 0x83, 0x80, 0xE0, 0x1C, 0x18, 0x07, 0x00, 0xC1, 0xC0, 0x38, 0x06,
  0x0E, 0x01, 0xC0, 0x70, 0x70, 0x0C, 0x03, 0x83, 0x00, 0xE0, 0x1C, 0x18,
  0x07, 0x00, 0xC1, 0xC0, 0x38, 0x0E, 0x0E, 0x01, 0x80, 0x70, 0x70, 0x0C,
  0x03, 0x83, 0x00, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0xC1, 0xC0, 0x38, 0x0E,
  0x00, 0x03, 0x1F, 0x00, 0xCF, 0xF0, 0x37, 0x3C, 0x1F, 0x07, 0x07, 0x80,
  0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x30, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x18, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x06,
  0x0C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3C, 0x70, 0x1C,
  0x0E, 0x0E, 0x03, 0x83, 0x80, 0x61, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x18, 0xC0, 0x06, 0x70, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x60, 0x03, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x86, 0x01, 0xC1, 0x80, 0x70, 0x70, 0x38,
  0x1E, 0x1C, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC3,
  0xE0, 0x06, 0x7F, 0x80, 0x37, 0x1C, 0x03, 0xE0, 0x70, 0x1F, 0x03, 0x80,
  0xF0, 0x1C, 0x07, 0x00, 0x60, 0x38, 0x03, 0x03, 0x80, 0x18, 0x1C, 0x00,
  0xC0, 0xE0, 0x0E, 0x06, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x78, 0x07, 0x03, 0xC0,
  0x70, 0x1E, 0x07, 0x80, 0xD8, 0x78, 0x06, 0x7F, 0x80, 0x73, 0xF8, 0x03,
  0x82, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7C, 0x70, 0x1F, 0xE6,
  0x03, 0xEF, 0x60, 0x78, 0x3E, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x0C, 0x01,
  0xC1, 0xC0, 0x1C, 0x18, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x83, 0x80,
  0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0x60,
  0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0x1E, 0x06, 0x03, 0xE0, 0x70, 0x3C, 0x07, 0x8E, 0xC0,
  0x3F, 0xDC, 0x01, 0xF9, 0xC0, 0x04, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x1F, 0x03, 0x3E, 0x03, 0x7E, 0x07, 0xE0, 0x06, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1,
  0xE1, 0xC0, 0xE0, 0x20, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x80, 0x70,
  0x60, 0x78, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x40, 0x00, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x03, 0xF9, 0xFF, 0x3F, 0xE1, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xFC, 0x0F, 0x80, 0x40, 0x00, 0x07, 0x00,
  0xE0, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03,
  0x83, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x60, 0x0E,
  0x0C, 0x01, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0x80, 0x30,
  0x70, 0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x06, 0x01, 0xC0,
  0xC0, 0x38, 0x38, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x7C, 0x0E, 0x1B, 0x01,
  0xFE, 0x60, 0x1F, 0x8C, 0x00, 0x80, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x37, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x71,
  0xC0, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x60, 0x71,
  0xC0, 0xE3, 0x01, 0xCE, 0x03, 0x98, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0xE0, 0x0E, 0x01, 0xF8, 0x07, 0x80, 0xEE, 0x01, 0xC0, 0x3B, 0x80, 0xF0,
  0x0C, 0xE0, 0x3C, 0x07, 0x38, 0x0F, 0x01, 0x8E, 0x06, 0xC0, 0xE3, 0x81,
  0xB0, 0x38, 0xE0, 0xEC, 0x0C, 0x38, 0x33, 0x07, 0x0E, 0x0C, 0xC1, 0x83,
  0x87, 0x30, 0x60, 0xE1, 0x8C, 0x38, 0x38, 0xE3, 0x0C, 0x0E, 0x30, 0xC7,
  0x03, 0x8C, 0x31, 0xC0, 0xE7, 0x0C, 0x60, 0x39, 0x83, 0x38, 0x0E, 0xE0,
  0xCC, 0x03, 0xB0, 0x37, 0x00, 0xCC, 0x0D, 0xC0, 0x37, 0x03, 0x60, 0x0D,
  0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x70, 0x38, 0x07,
  0x03, 0x80, 0xE0, 0x18, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01, 0xC3,
  0x00, 0x1C, 0x70, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3B, 0x00, 0x03, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x00,
  0xE1, 0x80, 0x1C, 0x18, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x0C, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x60, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x1C, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x38, 0x00, 0x60, 0x38, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xC0, 0x00,
  0x71, 0xC0, 0x00, 0x71, 0x80, 0x00, 0x73, 0x80, 0x00, 0x73, 0x80, 0x00,
  0x73, 0x00, 0x00, 0x77, 0x00, 0x00, 0x76, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x5F, 0xF0, 0x1E, 0x3F, 0x1F, 0x03, 0xFF, 0x80,
  0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 37, 11, 1, -37 },
  { 52, 12, 13, 16, 5, -37 },
  { 72, 22, 37, 21, 0, -37 },
  { 174, 20, 43, 19, 0, -40 },
  { 282, 25, 39, 29, 2, -38 },
  { 404, 19, 39, 20, 0, -38 },
  { 497, 6, 13, 9, 5, -37 },
  { 507, 15, 45, 13, 1, -37 },
  { 592, 15, 45, 13, -4, -37 },
  { 677, 14, 16, 18, 6, -40 },
  { 705, 18, 24, 22, 2, -30 },
  { 759, 7, 12, 9, -2, -5 },
  { 770, 11, 2, 14, 1, -15 },
  { 773, 4, 5, 9, 1, -5 },
  { 776, 22, 37, 16, -2, -37 },
  { 878, 18, 39, 19, 1, -38 },
  { 966, 11, 37, 19, 6, -37 },
  { 1017, 21, 38, 19, -2, -38 },
  { 1117, 20, 39, 19, -1, -38 },
  { 1215, 20, 38, 19, -1, -38 },
  { 1310, 21, 38, 19, -1, -37 },
  { 1410, 19, 39, 19, 1, -38 },
  { 1503, 19, 37, 19, 2, -37 },
  { 1591, 21, 39, 19, -1, -38 },
  { 1694, 19, 39, 19, 0, -38 },
  { 1787, 9, 28, 9, 0, -28 },
  { 1819, 11, 35, 9, -2, -28 },
  { 1868, 18, 23, 22, 2, -30 },
  { 1920, 18, 13, 22, 2, -25 },
  { 1950, 18, 23, 22, 2, -30 },
  { 2002, 15, 38, 14, 1, -38 },
  { 2074, 27, 42, 29, 1, -37 },
  { 2216, 19, 37, 19, -3, -37 },
  { 2304, 21, 37, 21, 0, -37 },
  { 2402, 21, 39, 19, 2, -38 },
  { 2505, 22, 37, 23, 0, -37 },
  { 2607, 21, 37, 18, 0, -37 },
  { 2705, 21, 37, 17, 0, -37 },
  { 2803, 24, 39, 25, 2, -38 },
  { 2920, 25, 37, 24, 0, -37 },
  { 3036, 18, 37, 11, -3, -37 },
  { 3120, 18, 46, 9, -7, -37 },
  { 3224, 24, 37, 20, 0, -37 },
  { 3335, 13, 37, 17, 0, -37 },
  { 3396, 33, 37, 32, 0, -37 },
  { 3549, 26, 37, 25, 0, -37 },
  { 3670, 22, 39, 24, 2, -38 },
  { 3778, 20, 37, 20, 0, -37 },
  { 3871, 22, 47, 24, 2, -38 },
  { 4001, 20, 37, 20, 0, -37 },
  { 4094, 21, 39, 19, -1, -38 },
  { 4197, 18, 37, 17, 3, -37 },
  { 4281, 22, 38, 23, 2, -37 },
  { 4386, 20, 37, 19, 4, -37 },
  { 4479, 32, 37, 33, 4, -37 },
  { 4627, 24, 37, 18, -3, -37 },
  { 4738, 17, 37, 17, 4, -37 },
  { 4817, 22, 37, 17, -2, -37 },
  { 4919, 19, 45, 14, -1, -37 },
  { 5026, 8, 37, 17, 5, -37 },
  { 5063, 19, 45, 14, -3, -37 },
  { 5170, 19, 19, 21, 1, -37 },
  { 5216, 15, 2, 15, -4, 5 },
  { 5220, 6, 8, 12, 8, -40 },
  { 5226, 20, 29, 21, 1, -28 },
  { 5299, 19, 41, 21, 0, -40 },
  { 5397, 16, 29, 15, 1, -28 },
  { 5455, 22, 41, 21, 1, -40 },
  { 5568, 17, 29, 18, 1, -28 },
  { 5630, 24, 52, 11, -7, -40 },
  { 5786, 22, 40, 21, -1, -28 },
  { 5896, 19, 40, 20, 0, -40 },
  { 5991, 11, 38, 9, 0, -38 },
  { 6044, 18, 50, 9, -7, -38 },
  { 6157, 19, 40, 17, 0, -40 },
  { 6252, 11, 40, 9, 0, -40 },
  { 6307, 29, 28, 30, 0, -28 },
  { 6409, 18, 28, 20, 0, -28 },
  { 6472, 18, 29, 20, 1, -28 },
  { 6538, 21, 40, 21, -2, -28 },
  { 6643, 20, 40, 21, 1, -28 },
  { 6743, 16, 28, 13, 0, -28 },
  { 6799, 17, 29, 15, -1, -28 },
  { 6861, 11, 35, 11, 1, -34 },
  { 6910, 19, 29, 20, 1, -28 },
  { 6979, 15, 28, 16, 3, -28 },
  { 7032, 26, 28, 26, 3, -28 },
  { 7123, 20, 28, 16, -2, -28 },
  { 7193, 24, 41, 16, -5, -28 },
  { 7316, 17, 28, 13, -2, -28 },
  { 7376, 19, 45, 17, 1, -37 },
  { 7483, 2, 52, 18, 8, -40 },
  { 7496, 18, 45, 17, -3, -37 },
  { 7598, 18, 5, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC52PT7B_H_
