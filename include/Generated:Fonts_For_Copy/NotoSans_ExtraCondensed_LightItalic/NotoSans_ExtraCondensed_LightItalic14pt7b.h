#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x10, 0x56, 0xAA, 0x14, 0xA2, 0x9F, 0x29, 0x4F,
  0x94, 0xA2, 0x80, 0x10, 0x9E, 0xA5, 0x10, 0xC6, 0x37, 0x90, 0x80, 0x66,
  0xAA, 0xAC, 0xDF, 0xB3, 0x55, 0x56, 0x60, 0x31, 0x4C, 0x62, 0x32, 0xB2,
  0x97, 0x80, 0x5A, 0x12, 0x24, 0x44, 0x88, 0x88, 0x84, 0x11, 0x11, 0x11,
  0x11, 0x22, 0x48, 0x59, 0xE2, 0x21, 0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80,
  0x04, 0x10, 0x82, 0x10, 0x42, 0x08, 0x42, 0x00, 0x39, 0x52, 0x94, 0xC6,
  0x32, 0x93, 0x00, 0x75, 0x6A, 0xA0, 0x38, 0x42, 0x11, 0x08, 0x88, 0x87,
  0x80, 0x78, 0x42, 0x13, 0x08, 0x42, 0x17, 0x00, 0x08, 0xC6, 0x55, 0x2A,
  0x5F, 0x11, 0x00, 0x39, 0x10, 0x87, 0x08, 0x22, 0x17, 0x00, 0x19, 0x10,
  0x87, 0x26, 0x31, 0x93, 0x00, 0x7C, 0x20, 0x84, 0x10, 0x82, 0x08, 0x43,
  0x00, 0x3A, 0x52, 0x93, 0x2A, 0x51, 0x97, 0x80, 0x3A, 0x52, 0x94, 0xBC,
  0x22, 0x17, 0x00, 0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x09, 0xB0, 0xC1,
  0x04, 0xF8, 0x01, 0xF0, 0xC1, 0x06, 0x32, 0x60, 0x71, 0x11, 0x24, 0x40,
  0x08, 0x1E, 0x45, 0x0A, 0xF5, 0x75, 0x6A, 0xD5, 0x95, 0x01, 0xE0, 0x08,
  0x46, 0x32, 0x95, 0x69, 0x4C, 0x40, 0x38, 0x94, 0x52, 0x71, 0x24, 0xA2,
  0x8B, 0xC0, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x87, 0x00, 0x38, 0x94, 0x51,
  0x45, 0x14, 0xA2, 0x93, 0x80, 0x3C, 0x84, 0x10, 0x71, 0x04, 0x20, 0x83,
  0xC0, 0x3C, 0x84, 0x10, 0x41, 0xC4, 0x20, 0x82, 0x00, 0x1E, 0x41, 0x02,
  0x04, 0x11, 0xA1, 0x42, 0x48, 0xF0, 0x22, 0x45, 0x12, 0x27, 0xC8, 0x92,
  0x44, 0x89, 0x10, 0x38, 0x84, 0x42, 0x10, 0x84, 0x47, 0x00, 0x08, 0x44,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x88, 0x00, 0x24, 0xA4, 0x94, 0x61, 0x85,
  0x24, 0x92, 0x40, 0x25, 0x24, 0x94, 0x9C, 0x20, 0x90, 0xD8, 0xCA, 0x65,
  0x32, 0xA9, 0x55, 0x34, 0x9A, 0x49, 0x00, 0x22, 0x45, 0x4A, 0xA5, 0x4A,
  0x95, 0x4A, 0x89, 0x10, 0x1C, 0x94, 0x51, 0x45, 0x18, 0x62, 0x89, 0xC0,
  0x38, 0x94, 0x52, 0x49, 0xC4, 0x20, 0x82, 0x00, 0x1C, 0x94, 0x51, 0x45,
  0x18, 0x62, 0x89, 0xC1, 0x04, 0x38, 0x94, 0x52, 0x49, 0xC5, 0x24, 0x92,
  0x40, 0x3A, 0x10, 0x82, 0x08, 0x42, 0x17, 0x00, 0xF9, 0x10, 0x84, 0x21,
  0x10, 0x84, 0x00, 0x22, 0x49, 0x12, 0x24, 0x48, 0x92, 0x44, 0x88, 0xE0,
  0x8C, 0x65, 0x29, 0x52, 0x98, 0xC4, 0x00, 0x88, 0xC4, 0xA6, 0x53, 0x2A,
  0xA5, 0x53, 0x31, 0x98, 0xC8, 0x44, 0x00, 0x12, 0x28, 0x60, 0xC1, 0x02,
  0x0C, 0x28, 0x49, 0x10, 0x8C, 0xA5, 0x4A, 0x21, 0x10, 0x84, 0x00, 0x1C,
  0x10, 0x82, 0x10, 0x42, 0x10, 0x43, 0xC0, 0x39, 0x08, 0x84, 0x21, 0x08,
  0x84, 0x21, 0x80, 0xA5, 0x55, 0x50, 0x18, 0x42, 0x11, 0x08, 0x42, 0x11,
  0x09, 0xC0, 0x11, 0x8A, 0x98, 0x80, 0xF0, 0xA4, 0x14, 0xA4, 0x92, 0x8A,
  0x29, 0x1C, 0x21, 0x08, 0xA6, 0xA5, 0x29, 0x8C, 0xBC, 0x19, 0x10, 0x88,
  0x42, 0x0C, 0x04, 0x10, 0x45, 0x29, 0x24, 0xA2, 0x8A, 0x47, 0x00, 0x11,
  0x52, 0xAE, 0x42, 0x0E, 0x06, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x18, 0x00, 0x14, 0xA4, 0x92, 0x8A, 0x29, 0x1C, 0x10,
  0x4E, 0x00, 0x21, 0x08, 0xA6, 0xA5, 0x29, 0x94, 0xA4, 0x20, 0x24, 0x94,
  0x90, 0x08, 0x00, 0x21, 0x08, 0x44, 0x21, 0x08, 0x4C, 0x00, 0x21, 0x08,
  0x84, 0xA9, 0x8C, 0xA4, 0xA4, 0x24, 0xA4, 0x92, 0x92, 0x00, 0x12, 0x6D,
  0x49, 0x49, 0x4A, 0x92, 0x92, 0x92, 0x13, 0x52, 0x94, 0xCA, 0x52, 0x13,
  0x52, 0x98, 0xC6, 0x4C, 0x08, 0xD2, 0x49, 0x25, 0x14, 0x9E, 0x41, 0x08,
  0x00, 0x14, 0xA4, 0x92, 0x8A, 0x29, 0x1C, 0x10, 0x41, 0x00, 0x16, 0x44,
  0x48, 0x88, 0x34, 0x44, 0x22, 0x2E, 0x2D, 0x24, 0xA4, 0xC0, 0x4A, 0x52,
  0x99, 0x4B, 0xC0, 0x9A, 0xAC, 0xC8, 0x80, 0x97, 0x6A, 0xD6, 0xCD, 0x92,
  0x24, 0x00, 0x2C, 0xA1, 0x04, 0x31, 0x4D, 0x00, 0x24, 0xA2, 0x8A, 0x30,
  0xC2, 0x08, 0x43, 0x00, 0x72, 0x24, 0x48, 0xE0, 0x18, 0x88, 0x42, 0x13,
  0x08, 0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x10, 0x44, 0x21, 0x08, 0x64, 0x21,
  0x09, 0x80, 0x6C, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 4, 4, 4, 1, -10 },
  { 7, 6, 10, 6, 0, -10 },
  { 15, 5, 12, 5, 0, -11 },
  { 23, 6, 10, 8, 1, -10 },
  { 31, 5, 10, 5, 0, -10 },
  { 38, 2, 4, 2, 1, -10 },
  { 39, 4, 12, 3, 0, -10 },
  { 45, 4, 12, 4, -1, -10 },
  { 51, 3, 5, 5, 2, -11 },
  { 53, 5, 6, 6, 0, -8 },
  { 57, 2, 3, 3, -1, -1 },
  { 58, 3, 1, 4, 0, -4 },
  { 59, 1, 1, 2, 0, -1 },
  { 60, 6, 10, 4, -1, -10 },
  { 68, 5, 10, 5, 0, -10 },
  { 75, 2, 10, 5, 2, -10 },
  { 78, 5, 10, 5, 0, -10 },
  { 85, 5, 10, 5, 0, -10 },
  { 92, 5, 10, 5, 0, -10 },
  { 99, 5, 10, 5, 0, -10 },
  { 106, 5, 10, 5, 0, -10 },
  { 113, 6, 10, 5, 0, -10 },
  { 121, 5, 10, 5, 0, -10 },
  { 128, 5, 10, 5, 0, -10 },
  { 135, 2, 7, 3, 0, -7 },
  { 137, 3, 9, 3, -1, -7 },
  { 141, 5, 6, 6, 0, -8 },
  { 145, 5, 4, 6, 0, -7 },
  { 148, 5, 6, 6, 0, -8 },
  { 152, 4, 10, 4, 0, -10 },
  { 157, 7, 11, 8, 0, -10 },
  { 167, 5, 10, 5, -1, -10 },
  { 174, 6, 10, 6, 0, -10 },
  { 182, 5, 10, 5, 1, -10 },
  { 189, 6, 10, 6, 0, -10 },
  { 197, 6, 10, 5, 0, -10 },
  { 205, 6, 10, 5, 0, -10 },
  { 213, 7, 10, 7, 0, -10 },
  { 222, 7, 10, 6, 0, -10 },
  { 231, 5, 10, 3, -1, -10 },
  { 238, 5, 13, 2, -2, -10 },
  { 247, 6, 10, 5, 0, -10 },
  { 255, 3, 10, 4, 0, -10 },
  { 259, 9, 10, 9, 0, -10 },
  { 271, 7, 10, 7, 0, -10 },
  { 280, 6, 10, 7, 0, -10 },
  { 288, 6, 10, 5, 0, -10 },
  { 296, 6, 12, 7, 0, -10 },
  { 305, 6, 10, 5, 0, -10 },
  { 313, 5, 10, 5, 0, -10 },
  { 320, 5, 10, 4, 1, -10 },
  { 327, 7, 10, 6, 0, -10 },
  { 336, 5, 10, 5, 1, -10 },
  { 343, 9, 10, 9, 1, -10 },
  { 355, 7, 10, 5, -1, -10 },
  { 364, 5, 10, 5, 1, -10 },
  { 371, 6, 10, 4, -1, -10 },
  { 379, 5, 12, 4, 0, -10 },
  { 387, 2, 10, 5, 1, -10 },
  { 390, 5, 12, 4, -1, -10 },
  { 398, 5, 5, 6, 0, -10 },
  { 402, 4, 1, 4, -1, 1 },
  { 403, 2, 3, 3, 2, -11 },
  { 404, 6, 8, 6, 0, -8 },
  { 410, 5, 11, 6, 0, -11 },
  { 417, 5, 8, 4, 0, -8 },
  { 422, 6, 11, 6, 0, -11 },
  { 431, 5, 8, 5, 0, -8 },
  { 436, 7, 14, 3, -2, -11 },
  { 449, 6, 11, 6, 0, -8 },
  { 458, 5, 11, 5, 0, -11 },
  { 465, 3, 10, 2, 0, -10 },
  { 469, 5, 13, 2, -2, -10 },
  { 478, 5, 11, 5, 0, -11 },
  { 485, 3, 11, 2, 0, -11 },
  { 490, 8, 8, 8, 0, -8 },
  { 498, 5, 8, 5, 0, -8 },
  { 503, 5, 8, 5, 0, -8 },
  { 508, 6, 11, 6, -1, -8 },
  { 517, 6, 11, 6, 0, -8 },
  { 526, 4, 8, 4, 0, -8 },
  { 530, 4, 8, 4, 0, -8 },
  { 534, 3, 9, 3, 0, -9 },
  { 538, 5, 7, 5, 0, -7 },
  { 543, 4, 7, 4, 1, -7 },
  { 547, 7, 7, 7, 1, -7 },
  { 554, 6, 7, 4, -1, -7 },
  { 560, 6, 10, 4, -1, -7 },
  { 568, 4, 7, 4, 0, -7 },
  { 572, 5, 12, 4, 0, -10 },
  { 580, 1, 14, 5, 2, -11 },
  { 582, 5, 12, 4, -1, -10 },
  { 590, 5, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC14PT7B_H_
