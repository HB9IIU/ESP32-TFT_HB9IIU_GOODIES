#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_ExtraCondensed_LightItalic6pt7b, 6, "NotoSans_ExtraCondensed_LightItalic6pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic7pt7b, 7, "NotoSans_ExtraCondensed_LightItalic7pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic8pt7b, 8, "NotoSans_ExtraCondensed_LightItalic8pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic9pt7b, 9, "NotoSans_ExtraCondensed_LightItalic9pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic10pt7b, 10, "NotoSans_ExtraCondensed_LightItalic10pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic11pt7b, 11, "NotoSans_ExtraCondensed_LightItalic11pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic12pt7b, 12, "NotoSans_ExtraCondensed_LightItalic12pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic13pt7b, 13, "NotoSans_ExtraCondensed_LightItalic13pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic14pt7b, 14, "NotoSans_ExtraCondensed_LightItalic14pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic15pt7b, 15, "NotoSans_ExtraCondensed_LightItalic15pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic16pt7b, 16, "NotoSans_ExtraCondensed_LightItalic16pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic17pt7b, 17, "NotoSans_ExtraCondensed_LightItalic17pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic18pt7b, 18, "NotoSans_ExtraCondensed_LightItalic18pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic19pt7b, 19, "NotoSans_ExtraCondensed_LightItalic19pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic20pt7b, 20, "NotoSans_ExtraCondensed_LightItalic20pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic21pt7b, 21, "NotoSans_ExtraCondensed_LightItalic21pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic22pt7b, 22, "NotoSans_ExtraCondensed_LightItalic22pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic23pt7b, 23, "NotoSans_ExtraCondensed_LightItalic23pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic24pt7b, 24, "NotoSans_ExtraCondensed_LightItalic24pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic25pt7b, 25, "NotoSans_ExtraCondensed_LightItalic25pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic26pt7b, 26, "NotoSans_ExtraCondensed_LightItalic26pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic27pt7b, 27, "NotoSans_ExtraCondensed_LightItalic27pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic28pt7b, 28, "NotoSans_ExtraCondensed_LightItalic28pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic29pt7b, 29, "NotoSans_ExtraCondensed_LightItalic29pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic30pt7b, 30, "NotoSans_ExtraCondensed_LightItalic30pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic31pt7b, 31, "NotoSans_ExtraCondensed_LightItalic31pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic32pt7b, 32, "NotoSans_ExtraCondensed_LightItalic32pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic33pt7b, 33, "NotoSans_ExtraCondensed_LightItalic33pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic34pt7b, 34, "NotoSans_ExtraCondensed_LightItalic34pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic35pt7b, 35, "NotoSans_ExtraCondensed_LightItalic35pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic36pt7b, 36, "NotoSans_ExtraCondensed_LightItalic36pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic37pt7b, 37, "NotoSans_ExtraCondensed_LightItalic37pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic38pt7b, 38, "NotoSans_ExtraCondensed_LightItalic38pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic39pt7b, 39, "NotoSans_ExtraCondensed_LightItalic39pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic40pt7b, 40, "NotoSans_ExtraCondensed_LightItalic40pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic41pt7b, 41, "NotoSans_ExtraCondensed_LightItalic41pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic42pt7b, 42, "NotoSans_ExtraCondensed_LightItalic42pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic43pt7b, 43, "NotoSans_ExtraCondensed_LightItalic43pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic44pt7b, 44, "NotoSans_ExtraCondensed_LightItalic44pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic45pt7b, 45, "NotoSans_ExtraCondensed_LightItalic45pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic46pt7b, 46, "NotoSans_ExtraCondensed_LightItalic46pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic47pt7b, 47, "NotoSans_ExtraCondensed_LightItalic47pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic48pt7b, 48, "NotoSans_ExtraCondensed_LightItalic48pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic49pt7b, 49, "NotoSans_ExtraCondensed_LightItalic49pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic50pt7b, 50, "NotoSans_ExtraCondensed_LightItalic50pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic51pt7b, 51, "NotoSans_ExtraCondensed_LightItalic51pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic52pt7b, 52, "NotoSans_ExtraCondensed_LightItalic52pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic53pt7b, 53, "NotoSans_ExtraCondensed_LightItalic53pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic54pt7b, 54, "NotoSans_ExtraCondensed_LightItalic54pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic55pt7b, 55, "NotoSans_ExtraCondensed_LightItalic55pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic56pt7b, 56, "NotoSans_ExtraCondensed_LightItalic56pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic57pt7b, 57, "NotoSans_ExtraCondensed_LightItalic57pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic58pt7b, 58, "NotoSans_ExtraCondensed_LightItalic58pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic59pt7b, 59, "NotoSans_ExtraCondensed_LightItalic59pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic60pt7b, 60, "NotoSans_ExtraCondensed_LightItalic60pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic61pt7b, 61, "NotoSans_ExtraCondensed_LightItalic61pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic62pt7b, 62, "NotoSans_ExtraCondensed_LightItalic62pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic63pt7b, 63, "NotoSans_ExtraCondensed_LightItalic63pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic64pt7b, 64, "NotoSans_ExtraCondensed_LightItalic64pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic65pt7b, 65, "NotoSans_ExtraCondensed_LightItalic65pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic66pt7b, 66, "NotoSans_ExtraCondensed_LightItalic66pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic67pt7b, 67, "NotoSans_ExtraCondensed_LightItalic67pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic68pt7b, 68, "NotoSans_ExtraCondensed_LightItalic68pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic69pt7b, 69, "NotoSans_ExtraCondensed_LightItalic69pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic70pt7b, 70, "NotoSans_ExtraCondensed_LightItalic70pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic71pt7b, 71, "NotoSans_ExtraCondensed_LightItalic71pt7b" },
  { &NotoSans_ExtraCondensed_LightItalic72pt7b, 72, "NotoSans_ExtraCondensed_LightItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
