#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C,
  0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x30, 0xE0, 0x1E, 0x1C, 0x08, 0x07,
  0x06, 0x00, 0x03, 0xC1, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x18, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x0C, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1E,
  0x60, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xF0,
  0x00, 0x01, 0x9E, 0x00, 0x00, 0x67, 0x80, 0x00, 0x18, 0xF0, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x30, 0x78, 0x00,
  0x0C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x70,
  0x00, 0x18, 0x3C, 0x00, 0x06, 0x0E, 0x03, 0x03, 0x8F, 0x80, 0xF0, 0xCF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0x38, 0x03, 0xDE,
  0x00, 0x38, 0x07, 0x0E, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x38, 0x0E,
  0x07, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x0E,
  0x0E, 0x00, 0x70, 0x0E, 0x1C, 0x00, 0x70, 0x1C, 0x1C, 0x00, 0xE0, 0x1C,
  0x38, 0x00, 0xE0, 0x1C, 0x38, 0x00, 0xE0, 0x3C, 0x70, 0x7C, 0xE0, 0x38,
  0x71, 0xFE, 0xE0, 0x38, 0xE3, 0xFF, 0xE0, 0x70, 0xE3, 0x87, 0xE0, 0x71,
  0xC7, 0x07, 0xE0, 0xE3, 0xC7, 0x07, 0x70, 0xE3, 0x8E, 0x07, 0x7B, 0xC7,
  0x8E, 0x07, 0x7F, 0x87, 0x1C, 0x07, 0x3F, 0x0F, 0x1C, 0x07, 0x0C, 0x0E,
  0x1C, 0x07, 0x00, 0x1E, 0x38, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x3C,
  0x38, 0x07, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x78, 0x78, 0x0E, 0x00, 0x70,
  0x70, 0x0E, 0x00, 0xF0, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x1E, 0x01, 0xE0,
  0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x00, 0x70, 0x38, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x00,
  0x70, 0xF0, 0x0E, 0x00, 0x79, 0xE0, 0x1C, 0x00, 0x3F, 0xC0, 0x1C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x78, 0xF0,
  0x78, 0x78, 0x38, 0x3C, 0x78, 0x1C, 0x1C, 0x3C, 0x0F, 0x0E, 0x3C, 0x07,
  0x8F, 0x1C, 0x01, 0xC7, 0x1E, 0x00, 0xE7, 0x8F, 0x00, 0x7B, 0x87, 0x00,
  0x3D, 0xC3, 0x80, 0x0F, 0xC1, 0xC0, 0x07, 0xE1, 0xE0, 0x03, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xFC, 0x0E, 0x00, 0x7E, 0x07,
  0x80, 0x77, 0x83, 0xE0, 0x7B, 0xC0, 0xFF, 0xF8, 0xE0, 0x7F, 0xF8, 0x78,
  0x0F, 0xF0, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0xF1, 0xE3, 0x87,
  0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xC0,
  0xC0, 0x1E, 0x18, 0x07, 0xE3, 0x02, 0x1F, 0xE7, 0xE0, 0xFF, 0xFC, 0x07,
  0xFC, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x1E, 0x60, 0x07, 0x8E, 0x01, 0xE0,
  0xE0, 0x78, 0x1C, 0x06, 0x03, 0xC0, 0x40, 0x38, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xC3,
  0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x01, 0xE0, 0x0E,
  0x03, 0x80, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x78, 0x00, 0xE0,
  0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x70, 0x00,
  0x78, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x70, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0xE0, 0x0F, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1E, 0xE1, 0xF3, 0x8F, 0x9E,
  0x7C, 0x7B, 0xE1, 0xC6, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xC0, 0x78, 0x00, 0x60, 0x07, 0x80, 0x08, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0x18, 0x01, 0xE0, 0x04, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x07, 0xC0, 0x30, 0x03,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x78, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x71, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x78,
  0x00, 0xE0, 0x1C, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x38, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x02, 0x00,
  0x1F, 0x00, 0xC0, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0x40, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x7F, 0x80, 0x39, 0xFF,
  0xC0, 0x3B, 0xFF, 0xE0, 0x7F, 0x81, 0xE0, 0x7E, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0x70, 0xF8, 0x00, 0x70, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x03,
  0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x01,
  0xC0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0F,
  0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x0E, 0x00, 0x1F, 0x0E, 0x00, 0x1F, 0x0E, 0x00, 0x1E, 0x0E,
  0x00, 0x3E, 0x0F, 0x00, 0x7E, 0x0F, 0x00, 0x7E, 0x07, 0x81, 0xFE, 0x07,
  0xE7, 0xDC, 0x03, 0xFF, 0x9C, 0x01, 0xFE, 0x3C, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x1E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0x03,
  0xE0, 0x40, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x07, 0x80, 0x70, 0x70, 0x07, 0xFC, 0x1C, 0x38, 0x07, 0xFE, 0x07, 0x0E,
  0x03, 0xC3, 0x81, 0xC7, 0x00, 0xE0, 0xE0, 0x71, 0xC0, 0x70, 0x38, 0x1C,
  0x70, 0x38, 0x1C, 0x06, 0x38, 0x0E, 0x07, 0x03, 0x8E, 0x07, 0x01, 0xC0,
  0xE3, 0x81, 0xC0, 0x70, 0x38, 0xC0, 0x60, 0x38, 0x0E, 0x70, 0x38, 0x0E,
  0x03, 0x9C, 0x0E, 0x03, 0x80, 0xC7, 0x03, 0x80, 0xE0, 0x71, 0xC1, 0xC0,
  0x70, 0x1C, 0xE0, 0x70, 0x1C, 0x07, 0x38, 0x1C, 0x07, 0x03, 0x8E, 0x07,
  0x03, 0xC0, 0xE3, 0x81, 0xC0, 0xE0, 0x38, 0xE0, 0x70, 0x38, 0x1C, 0x38,
  0x1C, 0x1E, 0x07, 0x0E, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC3, 0x60, 0xE0,
  0xE0, 0x70, 0xD8, 0x70, 0x38, 0x1E, 0x67, 0x78, 0x0E, 0x03, 0xF9, 0xFC,
  0x03, 0x80, 0xFC, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x01,
  0xF0, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x77, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0xC7, 0x00, 0x03, 0x87, 0x00,
  0x07, 0x87, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x00,
  0x3C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x1C, 0x1F, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0xF0,
  0x07, 0xC0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01,
  0xC0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x0F,
  0x80, 0x38, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0x87, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0,
  0x78, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xF8, 0x07, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xF8, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0x87, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0,
  0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0xC0, 0x38, 0x00, 0xF8, 0x03,
  0x80, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0xFC, 0x00, 0x70, 0x7F,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF8,
  0x03, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC1, 0xE0,
  0x01, 0xFF, 0x83, 0xC0, 0x07, 0xFE, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x43, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xBC, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x0E, 0xF0, 0x03, 0x9C, 0x00, 0x03,
  0xDC, 0x00, 0x73, 0x80, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x00, 0x1E, 0xF0,
  0x03, 0xCE, 0x00, 0x03, 0x9E, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0xC0, 0x0E,
  0x38, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x38, 0xE0,
  0x00, 0xF3, 0xC0, 0x0F, 0x1C, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0x80, 0x07,
  0x8E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x78,
  0x01, 0xE1, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x1C,
  0x01, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x0E,
  0x07, 0x80, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x00, 0x70, 0x3C, 0x0E, 0x07, 0x80, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0x03,
  0xC0, 0x70, 0x70, 0x1C, 0x00, 0x70, 0x0E, 0x1E, 0x03, 0x80, 0x0E, 0x01,
  0xC3, 0x80, 0x70, 0x03, 0xC0, 0x38, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x1C,
  0x03, 0xC0, 0x0F, 0x00, 0xE7, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0xE0, 0x0E,
  0x00, 0x38, 0x03, 0xBC, 0x03, 0xC0, 0x0F, 0x00, 0x77, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0x00,
  0x3F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x38, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x01, 0xE0, 0x07, 0xF0,
  0x00, 0x78, 0x01, 0xDC, 0x00, 0x1C, 0x00, 0xF7, 0x00, 0x07, 0x00, 0x3D,
  0xC0, 0x03, 0xC0, 0x0E, 0x70, 0x00, 0xF0, 0x03, 0x9E, 0x00, 0x3C, 0x00,
  0xE7, 0x80, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0x80, 0x1E, 0x38, 0x01, 0xE0,
  0x07, 0x0E, 0x00, 0x78, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0x70, 0xF0, 0x07,
  0x00, 0x3C, 0x3C, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0xF0, 0x03, 0x81, 0xC0,
  0x3C, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0x78, 0x1C, 0x03, 0x80, 0x1E, 0x07,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x78, 0x01, 0xC0, 0x38, 0x1E, 0x00, 0x70,
  0x0E, 0x07, 0x00, 0x3C, 0x03, 0x81, 0xC0, 0x0F, 0x00, 0xE0, 0xF0, 0x03,
  0x80, 0x3C, 0x3C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x01, 0xC3, 0x80,
  0x1E, 0x00, 0x70, 0xE0, 0x07, 0x80, 0x1C, 0x78, 0x01, 0xC0, 0x07, 0x9E,
  0x00, 0x70, 0x01, 0xE7, 0x00, 0x3C, 0x00, 0x39, 0xC0, 0x0F, 0x00, 0x0E,
  0x70, 0x03, 0xC0, 0x03, 0xBC, 0x00, 0xE0, 0x00, 0xEF, 0x00, 0x38, 0x00,
  0x3F, 0x80, 0x1E, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x78,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xE3, 0xFC, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x07,
  0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x70,
  0x0F, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0x70, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70,
  0x00, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00,
  0xE0, 0x07, 0xC0, 0x38, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x81, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x70, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xE1, 0xFC, 0x00, 0x78,
  0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x03, 0xE0,
  0x1E, 0x03, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0x70,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00,
  0x78, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x1C,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0x01, 0xE0, 0x07, 0xC0, 0x02, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x01, 0xF0, 0x0F, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF2, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0,
  0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE1,
  0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xE3,
  0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x80, 0x00,
  0xE7, 0x00, 0x01, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x70,
  0x00, 0x3E, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xC7, 0x00, 0x07,
  0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xF8, 0x00, 0x78, 0x70, 0x00, 0xEE, 0x00,
  0x1E, 0x1C, 0x00, 0x3B, 0x80, 0x07, 0x07, 0x00, 0x0E, 0xE0, 0x03, 0xC1,
  0xC0, 0x07, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xCE, 0x00, 0x78, 0x3C, 0x00,
  0x73, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x38,
  0x03, 0xC0, 0xF0, 0x07, 0x9E, 0x00, 0xE0, 0x3C, 0x01, 0xC7, 0x80, 0x78,
  0x0F, 0x00, 0x71, 0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x87, 0x00, 0xE0, 0x0F, 0x01, 0xC1,
  0xC0, 0x78, 0x03, 0xC0, 0x70, 0x70, 0x1E, 0x00, 0xF0, 0x38, 0x1C, 0x07,
  0x00, 0x3C, 0x0E, 0x07, 0x03, 0xC0, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x03,
  0xC1, 0xC0, 0x70, 0x78, 0x00, 0xF0, 0x70, 0x1C, 0x1E, 0x00, 0x3C, 0x38,
  0x07, 0x07, 0x00, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x70,
  0xE0, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x00, 0x3C, 0x70, 0x07, 0x1E, 0x00,
  0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x00, 0xE7,
  0x80, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x01,
  0xDE, 0x00, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x1F, 0xC0,
  0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xB8, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x3D, 0xC0,
  0x00, 0xF7, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC0, 0xE0, 0x0E, 0x03,
  0x80, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x81,
  0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80,
  0x07, 0x1C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xDE, 0x00, 0x07,
  0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x07,
  0x80, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x00,
  0x1C, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC3, 0xC0,
  0x00, 0xF1, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF1, 0xE1, 0xE3, 0xC3, 0x87,
  0x87, 0x0E, 0x0E, 0x0C, 0x00, 0x1F, 0x83, 0x00, 0x7F, 0xC7, 0x00, 0xFF,
  0xE7, 0x01, 0xF0, 0xE7, 0x03, 0xE0, 0x7F, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00,
  0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00,
  0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x07,
  0xC0, 0xF0, 0x0D, 0xC0, 0x78, 0x19, 0xC0, 0x7F, 0xFB, 0xC0, 0x3F, 0xF3,
  0x80, 0x1F, 0xC3, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC3, 0xF0, 0x01, 0xE7, 0xFE,
  0x00, 0xF7, 0xFF, 0x00, 0x77, 0x87, 0xC0, 0x3B, 0x01, 0xE0, 0x1F, 0x00,
  0x70, 0x1F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E,
  0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x0F, 0x03, 0xF0, 0x07, 0x81, 0xD8, 0x07, 0x80, 0xEE, 0x07,
  0x80, 0x77, 0xDF, 0x80, 0x31, 0xFF, 0x80, 0x38, 0x7F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x04,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x08,
  0x07, 0xF7, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x70, 0x00, 0x7F, 0xC7, 0x00, 0x0F,
  0xFE, 0x70, 0x01, 0xF0, 0xEF, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x38, 0x07,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00,
  0x1E, 0x00, 0xE0, 0x03, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x0D, 0xC0, 0x07, 0x81, 0x9C, 0x00, 0x7E,
  0xFB, 0x80, 0x03, 0xFF, 0x38, 0x00, 0x1F, 0xC3, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xC1, 0xE0,
  0x3C, 0x07, 0x03, 0xC0, 0x3C, 0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x1E, 0x1C,
  0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x03, 0xF0, 0x73, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xE8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x02, 0x01, 0xF8, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x43, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0xE0, 0x01, 0xFF, 0x1C, 0x00, 0x7F, 0xF3, 0x80, 0x1F, 0x0E,
  0x70, 0x07, 0x80, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x00, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x3E, 0x01, 0xC0, 0x07,
  0xC0, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x7E, 0x00, 0xF0, 0x0D, 0xC0, 0x0F,
  0x07, 0x78, 0x01, 0xFB, 0xEE, 0x00, 0x1F, 0xF9, 0xC0, 0x01, 0xFE, 0x38,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x04, 0x00, 0x78, 0x00, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0xE7, 0xFC, 0x01, 0xEF,
  0xFE, 0x01, 0xDC, 0x1F, 0x01, 0xF8, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xE0,
  0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0E, 0x03, 0x80,
  0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0E, 0x00,
  0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1E, 0x00,
  0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00,
  0xE0, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0xF0, 0x03, 0xC0, 0x00, 0x08, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x10, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x00, 0x38, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03,
  0x80, 0x07, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE1,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1C,
  0xF0, 0x00, 0x1E, 0xFC, 0x00, 0x0E, 0xFE, 0x00, 0x07, 0xEF, 0x00, 0x03,
  0xF3, 0x80, 0x03, 0xF1, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x70, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0xE3, 0xF8, 0x1F, 0xC0, 0x0E, 0x3F, 0xE1, 0xFF, 0x00, 0x73, 0xFF, 0x9F,
  0xFC, 0x03, 0xB8, 0x3D, 0xC1, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0x80, 0xF8,
  0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x0F,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0xE0, 0x07,
  0x80, 0x1C, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x0F, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x80,
  0x1C, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x0F, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x1C, 0x00, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0x1C, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0x1C, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x1C, 0x00, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xE1,
  0xF8, 0x01, 0xC7, 0xFC, 0x01, 0xCF, 0xFE, 0x01, 0xDC, 0x1E, 0x01, 0xF8,
  0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xC0,
  0x0F, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00,
  0x1C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00,
  0x70, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x78, 0x3E, 0x03, 0xC0, 0x78,
  0x1E, 0x00, 0xE0, 0x70, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xCF, 0x00,
  0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00, 0x1E,
  0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x1C,
  0x03, 0xC0, 0x78, 0x1E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x3F, 0x00, 0x01, 0xCF, 0xFC, 0x00,
  0x39, 0xFF, 0xC0, 0x03, 0x9C, 0x3E, 0x00, 0x3B, 0x01, 0xE0, 0x03, 0xF0,
  0x0E, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x1C,
  0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x03,
  0xC0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x0E, 0xE0, 0xF8, 0x00,
  0xE7, 0xFF, 0x00, 0x0E, 0x7F, 0xE0, 0x01, 0xE3, 0xFC, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0x00, 0x7F, 0xC7, 0x00, 0xFF, 0xE7,
  0x01, 0xF0, 0xF7, 0x03, 0xC0, 0x7F, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0x3E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x03, 0xE0, 0xE0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x0D, 0xC0, 0x78, 0x1B, 0xC0, 0x7F, 0xFB, 0x80, 0x3F, 0xF3, 0x80,
  0x1F, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xC3, 0xF0, 0x1C, 0x7F, 0x01, 0xCF, 0xE0, 0x1D,
  0xF2, 0x01, 0xDC, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xF8, 0x0E, 0x03, 0xC0, 0x10, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x20, 0x03,
  0xC0, 0xC0, 0x1E, 0x03, 0xF7, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1E, 0x00,
  0x78, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07,
  0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x78, 0x00, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x1E,
  0x00, 0x38, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x3E,
  0x0E, 0x00, 0x78, 0x1C, 0x01, 0xF0, 0x38, 0x03, 0xE0, 0x78, 0x0D, 0xC0,
  0xF0, 0x3F, 0x81, 0xFF, 0xEE, 0x01, 0xFF, 0x9C, 0x01, 0xFE, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00,
  0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0xE0,
  0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x1C, 0x0E,
  0x03, 0xC0, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00,
  0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xF0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xF8, 0x01, 0xF0, 0x03, 0xBC, 0x00, 0xF8, 0x03, 0xDE, 0x00, 0x7C,
  0x01, 0xEF, 0x00, 0x7C, 0x00, 0xE7, 0x80, 0x3E, 0x00, 0xF3, 0x80, 0x3B,
  0x00, 0x71, 0xC0, 0x1D, 0x80, 0x38, 0xE0, 0x0F, 0xC0, 0x3C, 0x70, 0x0E,
  0xE0, 0x1C, 0x38, 0x07, 0x70, 0x1E, 0x1C, 0x07, 0x38, 0x0E, 0x0E, 0x03,
  0x9C, 0x07, 0x07, 0x01, 0xCE, 0x07, 0x83, 0x81, 0xC7, 0x03, 0x81, 0xC0,
  0xE3, 0x83, 0xC0, 0xE0, 0xE1, 0xC1, 0xC0, 0x70, 0x70, 0xE0, 0xE0, 0x38,
  0x38, 0x70, 0xF0, 0x1C, 0x38, 0x38, 0x70, 0x0E, 0x1C, 0x1C, 0x38, 0x07,
  0x1C, 0x0E, 0x38, 0x03, 0x8E, 0x07, 0x1C, 0x01, 0xC7, 0x03, 0x9E, 0x00,
  0xE7, 0x01, 0xCE, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x3B, 0x80, 0x77, 0x00,
  0x1D, 0xC0, 0x3B, 0x80, 0x0E, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x01, 0xC0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x81,
  0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x87,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x02,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x9F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFC, 0x03,
  0xF0, 0x7F, 0x9F, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x80, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 48, 15, 1, -48 },
  { 85, 16, 17, 20, 6, -48 },
  { 119, 28, 48, 26, 0, -48 },
  { 287, 26, 55, 25, 0, -51 },
  { 466, 32, 50, 38, 3, -49 },
  { 666, 25, 50, 25, -1, -49 },
  { 823, 7, 17, 11, 7, -48 },
  { 838, 20, 59, 17, 1, -48 },
  { 986, 19, 59, 17, -5, -48 },
  { 1127, 19, 20, 23, 7, -51 },
  { 1175, 24, 31, 28, 2, -39 },
  { 1268, 10, 16, 12, -3, -7 },
  { 1288, 15, 4, 17, 1, -20 },
  { 1296, 5, 6, 12, 1, -6 },
  { 1300, 29, 48, 21, -3, -48 },
  { 1474, 23, 50, 25, 1, -49 },
  { 1618, 14, 48, 25, 7, -48 },
  { 1702, 27, 49, 25, -2, -49 },
  { 1868, 26, 50, 25, -1, -49 },
  { 2031, 26, 48, 25, -1, -48 },
  { 2187, 26, 49, 25, -1, -48 },
  { 2347, 24, 50, 25, 2, -49 },
  { 2497, 25, 48, 25, 2, -48 },
  { 2647, 26, 50, 25, -1, -49 },
  { 2810, 24, 50, 25, 0, -49 },
  { 2960, 12, 36, 12, 0, -36 },
  { 3014, 15, 45, 12, -3, -36 },
  { 3099, 24, 29, 28, 2, -38 },
  { 3186, 24, 17, 28, 2, -32 },
  { 3237, 24, 29, 28, 2, -38 },
  { 3324, 20, 49, 18, 1, -49 },
  { 3447, 34, 54, 37, 2, -48 },
  { 3677, 24, 48, 24, -4, -48 },
  { 3821, 27, 48, 27, 0, -48 },
  { 3983, 27, 50, 24, 2, -49 },
  { 4152, 28, 48, 29, 0, -48 },
  { 4320, 26, 48, 24, 0, -48 },
  { 4476, 27, 48, 22, 0, -48 },
  { 4638, 31, 50, 32, 2, -49 },
  { 4832, 32, 48, 31, 0, -48 },
  { 5024, 23, 48, 14, -4, -48 },
  { 5162, 24, 60, 12, -10, -48 },
  { 5342, 30, 48, 25, 0, -48 },
  { 5522, 16, 48, 21, 0, -48 },
  { 5618, 43, 48, 41, 0, -48 },
  { 5876, 34, 48, 33, 0, -48 },
  { 6080, 28, 50, 31, 2, -49 },
  { 6255, 26, 48, 25, 0, -48 },
  { 6411, 28, 60, 31, 2, -49 },
  { 6621, 26, 48, 26, 0, -48 },
  { 6777, 28, 50, 24, -2, -49 },
  { 6952, 23, 48, 21, 4, -48 },
  { 7090, 30, 49, 30, 2, -48 },
  { 7274, 24, 48, 25, 6, -48 },
  { 7418, 42, 48, 42, 5, -48 },
  { 7670, 31, 48, 23, -4, -48 },
  { 7856, 22, 48, 22, 5, -48 },
  { 7988, 29, 48, 21, -3, -48 },
  { 8162, 24, 59, 19, -1, -48 },
  { 8339, 10, 48, 22, 7, -48 },
  { 8399, 24, 59, 19, -4, -48 },
  { 8576, 25, 24, 26, 1, -48 },
  { 8651, 19, 3, 19, -5, 6 },
  { 8659, 7, 10, 15, 10, -51 },
  { 8668, 24, 37, 27, 2, -36 },
  { 8779, 25, 52, 26, 0, -51 },
  { 8942, 20, 37, 20, 2, -36 },
  { 9035, 28, 52, 27, 2, -51 },
  { 9217, 21, 37, 24, 2, -36 },
  { 9315, 31, 67, 14, -9, -51 },
  { 9575, 27, 52, 27, -1, -36 },
  { 9751, 24, 51, 26, 0, -51 },
  { 9904, 14, 49, 12, 0, -49 },
  { 9990, 23, 65, 12, -9, -49 },
  { 10177, 25, 51, 22, 0, -51 },
  { 10337, 14, 51, 11, 0, -51 },
  { 10427, 37, 36, 39, 0, -36 },
  { 10594, 24, 36, 26, 0, -36 },
  { 10702, 22, 37, 26, 2, -36 },
  { 10804, 28, 51, 26, -3, -36 },
  { 10983, 24, 52, 27, 2, -36 },
  { 11139, 20, 36, 17, 0, -36 },
  { 11229, 22, 37, 20, -1, -36 },
  { 11331, 15, 45, 14, 1, -44 },
  { 11416, 23, 37, 26, 2, -36 },
  { 11523, 20, 36, 20, 4, -36 },
  { 11613, 33, 36, 34, 4, -36 },
  { 11762, 26, 36, 21, -3, -36 },
  { 11879, 32, 52, 21, -7, -36 },
  { 12087, 21, 36, 17, -2, -36 },
  { 12182, 24, 59, 21, 2, -48 },
  { 12359, 3, 67, 24, 10, -51 },
  { 12385, 23, 59, 21, -4, -48 },
  { 12555, 24, 7, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC67PT7B_H_
