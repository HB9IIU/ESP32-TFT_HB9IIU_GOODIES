#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x38, 0xE1, 0xCE, 0x0E,
  0x70, 0xE3, 0x87, 0x1C, 0x38, 0xC1, 0xCE, 0x0C, 0x70, 0xE3, 0x87, 0x18,
  0x38, 0xC1, 0x86, 0x0C, 0x70, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x70,
  0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xE0, 0x03,
  0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x70, 0x01, 0xC1, 0x80, 0x06, 0x06,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x0C, 0x1C, 0x00,
  0x70, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0xE0,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0x07, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x30,
  0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x83, 0x80, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xE0, 0x78, 0x8E, 0x03, 0x8C, 0x10, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x07, 0x10, 0x00, 0x3D, 0x80, 0x00, 0xEC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x6E, 0x00,
  0x03, 0x38, 0x00, 0x11, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x38, 0x00, 0x61,
  0xC0, 0x02, 0x0E, 0x00, 0x10, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x38, 0x20,
  0x63, 0x81, 0xC2, 0x3C, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xC0, 0x06, 0x01, 0xF8, 0x01, 0x80, 0xE7, 0x00, 0xC0,
  0x71, 0xC0, 0x30, 0x18, 0x30, 0x18, 0x0E, 0x0C, 0x0E, 0x03, 0x03, 0x03,
  0x01, 0xC0, 0xC1, 0xC0, 0x70, 0x70, 0x60, 0x18, 0x1C, 0x38, 0x0E, 0x07,
  0x0C, 0x03, 0x81, 0x87, 0x00, 0xE0, 0x61, 0x80, 0x30, 0x18, 0xE0, 0x0C,
  0x0E, 0x30, 0x03, 0x03, 0x1C, 0x10, 0xC0, 0xC6, 0x1F, 0x30, 0x73, 0x8F,
  0xEC, 0x18, 0xC7, 0x1B, 0x0E, 0x73, 0x86, 0xC3, 0x18, 0xC1, 0xB9, 0xCE,
  0x70, 0x7F, 0xE3, 0x18, 0x19, 0xF1, 0xC6, 0x06, 0x00, 0x63, 0x81, 0x80,
  0x38, 0xE0, 0x60, 0x0C, 0x30, 0x18, 0x07, 0x0C, 0x0E, 0x01, 0x87, 0x03,
  0x80, 0xE1, 0xC0, 0xC0, 0x30, 0x70, 0x30, 0x1C, 0x18, 0x1C, 0x06, 0x06,
  0x06, 0x03, 0x81, 0x81, 0x80, 0xC0, 0x60, 0xE0, 0x70, 0x1C, 0x30, 0x18,
  0x07, 0x18, 0x0E, 0x00, 0xFE, 0x07, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1C, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0x70, 0x0C, 0x0C, 0x03, 0x83, 0x80, 0x70, 0x70,
  0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x18, 0x70, 0x03, 0x1C, 0x00, 0x73, 0x00,
  0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x76, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x30, 0xEE,
  0x07, 0x19, 0xC0, 0xE7, 0x70, 0x1C, 0xEE, 0x01, 0xF9, 0xC0, 0x3F, 0x30,
  0x07, 0xC6, 0x00, 0x78, 0xC0, 0x0E, 0x18, 0x03, 0xC3, 0x80, 0xFC, 0x70,
  0x3B, 0x8F, 0x0E, 0x70, 0xFF, 0x8E, 0x0F, 0xE0, 0xE0, 0x30, 0x00, 0x1C,
  0x73, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0x80, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x0C, 0x18, 0x1E, 0x30, 0x1F, 0xC7, 0x8F,
  0xFF, 0x03, 0xE0, 0x0F, 0x00, 0x36, 0x01, 0xC6, 0x07, 0x8E, 0x1E, 0x0C,
  0x08, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38,
  0x30, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x6F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xF0, 0xE0, 0x1C, 0x1C, 0x07, 0x01,
  0xC0, 0xC0, 0x38, 0x38, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x86, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x07,
  0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x07,
  0x9E, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x3C,
  0x0F, 0x83, 0xF0, 0xEC, 0x3B, 0x9E, 0x77, 0x8E, 0xE1, 0x88, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x38, 0x1E, 0x00, 0x40, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7E, 0xFC, 0x03,
  0x80, 0xE0, 0x10, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x81, 0x00,
  0x3C, 0x0E, 0x07, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1B, 0x00, 0x01, 0xF8, 0x00, 0x0D, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x60,
  0x00, 0x67, 0x00, 0x07, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x0C, 0x00, 0x38,
  0x60, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0xC0, 0x0C, 0x0C, 0x00,
  0xE0, 0xE0, 0x06, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0xC0,
  0x0C, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0x87, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x81, 0x00, 0x3C, 0x0E, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x60,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x39, 0xFE, 0x03, 0xBF,
  0xF0, 0x36, 0x07, 0x07, 0xC0, 0x70, 0x78, 0x03, 0x87, 0x80, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x60,
  0xE0, 0x0E, 0x06, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x38, 0x78,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0x7C, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x81,
  0xC0, 0x1C, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x03, 0x80, 0x18, 0x1C, 0x01,
  0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x03, 0x80, 0x38, 0x38, 0x00, 0xE7, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x1C, 0x03, 0x80,
  0xF0, 0x3C, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xF0, 0x0E, 0x03, 0xC1, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x1C, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00,
  0x60, 0x60, 0x06, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x71, 0xC0,
  0x06, 0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x01, 0xE1, 0xC0, 0x1E, 0x1C, 0x03, 0xE1, 0xC0, 0x3E, 0x0E, 0x06, 0xC0,
  0xF1, 0xDC, 0x07, 0xF9, 0xC0, 0x3F, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x83, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x00, 0x00, 0x30, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0C, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xC0, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x60, 0x1F, 0x87, 0x0E, 0x07, 0xF8, 0x70, 0xC0,
  0xE3, 0x87, 0x1C, 0x1C, 0x38, 0x71, 0x81, 0x83, 0x07, 0x18, 0x38, 0x30,
  0x73, 0x83, 0x07, 0x06, 0x30, 0x70, 0x70, 0x63, 0x06, 0x06, 0x06, 0x30,
  0x60, 0x60, 0xE7, 0x0E, 0x0E, 0x0E, 0x60, 0xE0, 0xE0, 0xC6, 0x0C, 0x0C,
  0x0C, 0x60, 0xC0, 0xC1, 0xC6, 0x0C, 0x1C, 0x18, 0x60, 0xC1, 0xC1, 0x8E,
  0x0C, 0x3C, 0x30, 0xE0, 0xC3, 0xC3, 0x0E, 0x0C, 0x6C, 0x60, 0xE0, 0xEE,
  0xCE, 0x0E, 0x0F, 0xCF, 0xC0, 0xE0, 0x78, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x67,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x18,
  0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x38, 0x07, 0x03, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07,
  0x38, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x77, 0x00, 0x07, 0xF0, 0x00,
  0x70, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x30, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01,
  0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x3C, 0x07, 0x01, 0xE0,
  0x1C, 0x7E, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0E, 0x07, 0x80, 0x38,
  0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x0E, 0x06, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00,
  0x78, 0x1C, 0x07, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3C, 0x02,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x18, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x06, 0x07, 0xC0, 0x1C, 0x07, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x83,
  0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x70,
  0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x7C, 0x03, 0x81, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0xE0, 0x1E,
  0x00, 0x10, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xFF,
  0x0E, 0x00, 0x7F, 0x87, 0x00, 0x3F, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x60, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xF0, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x38, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00,
  0x60, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x01,
  0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x87, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0x38, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0xB8, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x06, 0xE0, 0x00, 0x6E, 0x01, 0xB8,
  0x00, 0x3B, 0x80, 0xEE, 0x00, 0x0E, 0xC0, 0x3B, 0x80, 0x07, 0x70, 0x0E,
  0xE0, 0x01, 0xDC, 0x03, 0x38, 0x00, 0xE7, 0x01, 0xCE, 0x00, 0x39, 0xC0,
  0x73, 0x80, 0x1C, 0xE0, 0x1C, 0xE0, 0x07, 0x38, 0x07, 0x38, 0x03, 0x8E,
  0x01, 0x8E, 0x00, 0xE3, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x1C,
  0x70, 0x0E, 0x18, 0x06, 0x1C, 0x03, 0x86, 0x03, 0x87, 0x00, 0xC1, 0x80,
  0xC1, 0xC0, 0x70, 0x60, 0x70, 0x60, 0x1C, 0x18, 0x18, 0x38, 0x07, 0x06,
  0x0E, 0x0E, 0x01, 0x81, 0xC3, 0x83, 0x80, 0xE0, 0x71, 0xC0, 0xE0, 0x38,
  0x1C, 0x70, 0x70, 0x0E, 0x07, 0x38, 0x1C, 0x03, 0x81, 0xCE, 0x07, 0x00,
  0xC0, 0x77, 0x01, 0xC0, 0x70, 0x1D, 0xC0, 0x60, 0x1C, 0x07, 0xE0, 0x38,
  0x07, 0x01, 0xF8, 0x0E, 0x01, 0xC0, 0x7C, 0x03, 0x80, 0x60, 0x1F, 0x00,
  0xE0, 0x38, 0x07, 0x80, 0x30, 0x0E, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70,
  0x1F, 0x00, 0x0C, 0x03, 0xF0, 0x03, 0x80, 0x7E, 0x00, 0x70, 0x0D, 0xC0,
  0x0E, 0x01, 0xB8, 0x01, 0xC0, 0x73, 0x00, 0x30, 0x0E, 0x60, 0x0E, 0x01,
  0xCE, 0x01, 0xC0, 0x31, 0xC0, 0x38, 0x0E, 0x38, 0x07, 0x01, 0xC3, 0x01,
  0xC0, 0x38, 0x60, 0x38, 0x07, 0x0E, 0x07, 0x00, 0xC1, 0xC0, 0xE0, 0x38,
  0x38, 0x18, 0x07, 0x07, 0x07, 0x00, 0xE0, 0x60, 0xE0, 0x1C, 0x0C, 0x1C,
  0x03, 0x01, 0xC3, 0x80, 0xE0, 0x38, 0x60, 0x1C, 0x07, 0x1C, 0x03, 0x80,
  0xE3, 0x80, 0x70, 0x0C, 0x70, 0x1C, 0x01, 0x8E, 0x03, 0x80, 0x39, 0x80,
  0x70, 0x07, 0x70, 0x0E, 0x00, 0xEE, 0x01, 0x80, 0x1D, 0xC0, 0x70, 0x01,
  0xB8, 0x0E, 0x00, 0x3E, 0x01, 0xC0, 0x07, 0xC0, 0x38, 0x00, 0xF8, 0x06,
  0x00, 0x1F, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x3C,
  0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x07, 0x00, 0x70, 0x1C, 0x07,
  0x80, 0x3C, 0x3C, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0x83, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0x80, 0x38,
  0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x38, 0x07, 0x03,
  0x80, 0x70, 0x1C, 0x0F, 0x80, 0xE7, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x3C, 0x0E, 0x00, 0x70,
  0x78, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x03, 0x83, 0x80, 0x1E, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x80, 0x3C, 0x3C,
  0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0x83, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0xF0, 0x1C, 0x1F, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x30, 0xE0, 0x03, 0x83, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x30, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7C,
  0x06, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x20, 0x07, 0x80, 0xF0, 0x7C, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x06, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x60,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x80, 0xF0, 0x07, 0x87,
  0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00,
  0x38, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0,
  0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x1C, 0x0C, 0x01, 0xC0, 0xC0, 0x1C, 0x0C,
  0x03, 0x80, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0x70, 0x0C, 0x0E, 0x00,
  0xC0, 0xE0, 0x0C, 0x0E, 0x00, 0xC1, 0xC0, 0x0C, 0x1C, 0x00, 0xC3, 0x80,
  0x0C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x0C, 0xE0,
  0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0xDC, 0x00, 0x0D, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0x38, 0x00, 0xE6, 0x00, 0x1E, 0x00,
  0x39, 0x80, 0x07, 0x80, 0x0E, 0x60, 0x03, 0xE0, 0x07, 0x18, 0x00, 0xF0,
  0x01, 0xC6, 0x00, 0x3C, 0x00, 0xE3, 0x80, 0x1F, 0x00, 0x38, 0xE0, 0x06,
  0xC0, 0x0E, 0x38, 0x03, 0xB0, 0x07, 0x0E, 0x00, 0xEC, 0x01, 0xC3, 0x80,
  0x33, 0x00, 0xE0, 0xE0, 0x1C, 0xC0, 0x38, 0x38, 0x06, 0x30, 0x0E, 0x0E,
  0x03, 0x8C, 0x07, 0x03, 0x80, 0xE3, 0x01, 0xC0, 0xE0, 0x30, 0xC0, 0x60,
  0x38, 0x1C, 0x30, 0x38, 0x0E, 0x06, 0x0C, 0x0E, 0x03, 0x83, 0x83, 0x07,
  0x00, 0xE0, 0xE1, 0xC1, 0xC0, 0x38, 0x30, 0x70, 0x60, 0x0E, 0x1C, 0x1C,
  0x38, 0x03, 0x87, 0x07, 0x0E, 0x00, 0xE3, 0x81, 0xC7, 0x00, 0x38, 0xE0,
  0x71, 0xC0, 0x0E, 0x30, 0x1C, 0x60, 0x03, 0x9C, 0x07, 0x38, 0x00, 0xE7,
  0x01, 0xCE, 0x00, 0x39, 0x80, 0x77, 0x00, 0x0E, 0xE0, 0x1D, 0xC0, 0x03,
  0xB0, 0x07, 0x60, 0x00, 0xFC, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x6E, 0x00,
  0x0F, 0x80, 0x1B, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03,
  0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x1C, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x00,
  0x60, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x03,
  0x80, 0xC1, 0xC0, 0x30, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xC1, 0x83, 0x07,
  0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x18, 0x30,
  0x60, 0xE1, 0xC3, 0x87, 0x06, 0x0C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x83,
  0x06, 0x0C, 0x1C, 0x38, 0x70, 0xE0, 0xC1, 0x80, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x6C, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x07, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x01, 0x80, 0xC0,
  0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x0C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0xC7, 0x1C, 0x38,
  0x61, 0x83, 0x00, 0x7E, 0x30, 0x1F, 0xF3, 0x03, 0xE7, 0x70, 0x38, 0x1F,
  0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01,
  0xE1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x07,
  0x01, 0xE0, 0x70, 0x1E, 0x07, 0x03, 0xE0, 0x78, 0x6E, 0x03, 0xFC, 0xE0,
  0x1F, 0x8C, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x8F, 0x80, 0x3B, 0xFC, 0x03, 0x79, 0xE0, 0x36, 0x0E, 0x07, 0xC0, 0x70,
  0x78, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x87, 0x80, 0x70, 0x78,
  0x07, 0x06, 0xC0, 0xE0, 0x6E, 0x1C, 0x0E, 0x7F, 0x80, 0xE3, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x1F, 0x18, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC1, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x07, 0xE7,
  0x00, 0x3F, 0xEE, 0x00, 0xF9, 0xDC, 0x01, 0xC0, 0xF8, 0x07, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x1E, 0x07,
  0x80, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x06, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x18, 0x00, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x1E,
  0x03, 0x80, 0x3C, 0x03, 0x00, 0xF0, 0x07, 0x01, 0x60, 0x0E, 0x07, 0xC0,
  0x1E, 0x1B, 0x80, 0x1F, 0xE7, 0x00, 0x1F, 0x8C, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0xF9, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7,
  0x03, 0xC7, 0x03, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFC, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x06, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3C, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x8C, 0x01, 0xFF, 0x30, 0x0F,
  0x9D, 0xC0, 0x38, 0x1F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xE0, 0x38, 0x03,
  0x81, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0x80, 0x1E, 0x06, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x06, 0x01, 0xE0, 0x1C,
  0x07, 0x80, 0x70, 0x3E, 0x01, 0xE1, 0xB8, 0x03, 0xFC, 0xE0, 0x07, 0xE3,
  0x00, 0x04, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x08, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x39, 0xF8, 0x07, 0x7F, 0x80, 0xDE,
  0xF8, 0x1F, 0x07, 0x07, 0xC0, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x0E, 0x0C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x30, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x70,
  0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x30, 0x3C, 0x07, 0x03,
  0x80, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x06, 0x1C, 0x00, 0xE3,
  0x80, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0C, 0xF0, 0x01, 0xDF, 0x00, 0x1F,
  0xF0, 0x01, 0xF7, 0x00, 0x1E, 0x70, 0x01, 0xC3, 0x00, 0x38, 0x38, 0x03,
  0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x30, 0x38, 0x07, 0x01, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C,
  0x00, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x00, 0x03, 0x9F, 0x83, 0xF0, 0x0C, 0xFF, 0x3F, 0xE0, 0x37,
  0x3C, 0xE7, 0x80, 0xF0, 0x3E, 0x0F, 0x07, 0x80, 0xF0, 0x1C, 0x1E, 0x03,
  0xC0, 0x70, 0x70, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x06, 0x0E, 0x00, 0xC0,
  0x38, 0x38, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x0E,
  0x0C, 0x01, 0xC0, 0x30, 0x70, 0x06, 0x01, 0xC1, 0xC0, 0x38, 0x07, 0x07,
  0x00, 0xE0, 0x1C, 0x1C, 0x03, 0x80, 0x70, 0x60, 0x0C, 0x01, 0x83, 0x80,
  0x70, 0x0E, 0x0E, 0x01, 0xC0, 0x38, 0x38, 0x07, 0x00, 0xE0, 0xE0, 0x1C,
  0x03, 0x83, 0x00, 0x60, 0x0C, 0x1C, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x01,
  0xC1, 0xC0, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x18, 0x38, 0x03, 0x00, 0xE0,
  0xE0, 0x1C, 0x03, 0x80, 0x03, 0x1F, 0x80, 0x67, 0xF8, 0x0D, 0xEF, 0x81,
  0xF0, 0x70, 0x7C, 0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x0F,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xC0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0C, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3E, 0x78, 0x1E, 0x0F, 0x07, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x06, 0x70, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x01, 0xCE, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x1C, 0x1C, 0x0F, 0x07,
  0x87, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0xE3, 0xE0,
  0x03, 0x3F, 0xC0, 0x0C, 0xC7, 0x80, 0x36, 0x0E, 0x01, 0xF0, 0x1C, 0x07,
  0x80, 0x70, 0x1E, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xE0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x0E,
  0x07, 0x80, 0x70, 0x1E, 0x01, 0xC0, 0x7C, 0x0E, 0x01, 0xB8, 0xF0, 0x06,
  0x7F, 0x80, 0x38, 0xFC, 0x00, 0xE0, 0xC0, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x30, 0x1F, 0xF3, 0x03, 0xE7, 0x70, 0x38, 0x1F,
  0x07, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00,
  0xE1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x60,
  0x03, 0x86, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x06,
  0x01, 0xE0, 0x70, 0x1E, 0x07, 0x03, 0xE0, 0x78, 0x6E, 0x03, 0xFC, 0xE0,
  0x1F, 0x8C, 0x00, 0x41, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03,
  0x1F, 0x03, 0x3F, 0x03, 0x7F, 0x03, 0x60, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x3C, 0x78, 0x1C, 0x02, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x20, 0x1E, 0x0E, 0x0F, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x01, 0x00, 0x00, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x0F, 0xF3, 0xFE, 0x3F, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0x00, 0x07,
  0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0x60, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70,
  0x0E, 0x0E, 0x01, 0xC1, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0xC0,
  0x38, 0x38, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x00,
  0xE0, 0xE0, 0x1C, 0x18, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x3C, 0x1E, 0x0D,
  0x81, 0xC3, 0xF0, 0x3F, 0xEE, 0x03, 0xF9, 0x80, 0x08, 0x00, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xC0, 0xE1, 0xC0, 0xE1, 0x80, 0xE3, 0x80, 0xE3, 0x80, 0xE7,
  0x00, 0xE7, 0x00, 0xE6, 0x00, 0xEE, 0x00, 0xEC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00,
  0xFC, 0x01, 0xC0, 0x3B, 0x80, 0x78, 0x07, 0x70, 0x0F, 0x00, 0xCE, 0x03,
  0xE0, 0x39, 0xC0, 0x6C, 0x07, 0x38, 0x0D, 0x81, 0xC7, 0x03, 0xB0, 0x38,
  0xE0, 0x66, 0x06, 0x1C, 0x1C, 0xC1, 0xC3, 0x83, 0x98, 0x38, 0x70, 0x63,
  0x0E, 0x0E, 0x1C, 0x61, 0xC1, 0xC3, 0x1C, 0x30, 0x38, 0xE3, 0x8E, 0x07,
  0x1C, 0x71, 0xC0, 0xE3, 0x0E, 0x30, 0x1C, 0xE1, 0xCE, 0x03, 0x98, 0x39,
  0x80, 0x77, 0x07, 0x70, 0x0E, 0xE0, 0xEE, 0x01, 0xD8, 0x1D, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0D, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xE7, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xEE,
  0x00, 0x0E, 0x70, 0x00, 0x71, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03,
  0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x60, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xC1, 0xE0, 0x7F, 0xF8, 0x03, 0xFD,
  0x00, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 39, 12, 1, -39 },
  { 55, 13, 14, 16, 5, -39 },
  { 78, 22, 39, 21, 0, -39 },
  { 186, 21, 44, 20, 0, -41 },
  { 302, 26, 40, 30, 3, -39 },
  { 432, 19, 40, 20, 0, -39 },
  { 527, 6, 14, 9, 5, -39 },
  { 538, 16, 48, 13, 1, -39 },
  { 634, 16, 48, 14, -4, -39 },
  { 730, 15, 16, 18, 6, -41 },
  { 760, 19, 25, 22, 2, -32 },
  { 820, 8, 13, 10, -2, -6 },
  { 833, 12, 3, 14, 1, -16 },
  { 838, 4, 5, 10, 1, -5 },
  { 841, 24, 39, 17, -3, -39 },
  { 958, 19, 40, 20, 1, -39 },
  { 1053, 11, 39, 20, 6, -39 },
  { 1107, 22, 39, 20, -2, -39 },
  { 1215, 21, 40, 20, -1, -39 },
  { 1320, 21, 39, 20, -1, -39 },
  { 1423, 21, 40, 20, -1, -39 },
  { 1528, 20, 40, 20, 1, -39 },
  { 1628, 20, 39, 20, 2, -39 },
  { 1726, 21, 40, 20, -1, -39 },
  { 1831, 20, 40, 20, 0, -39 },
  { 1931, 9, 29, 10, 0, -29 },
  { 1964, 13, 36, 10, -3, -29 },
  { 2023, 19, 23, 22, 2, -31 },
  { 2078, 19, 14, 22, 2, -26 },
  { 2112, 19, 23, 22, 2, -31 },
  { 2167, 16, 39, 14, 1, -39 },
  { 2245, 28, 44, 30, 1, -39 },
  { 2399, 20, 39, 20, -4, -39 },
  { 2497, 22, 39, 22, 0, -39 },
  { 2605, 22, 40, 20, 2, -39 },
  { 2715, 23, 39, 24, 0, -39 },
  { 2828, 21, 39, 19, 0, -39 },
  { 2931, 21, 39, 18, 0, -39 },
  { 3034, 25, 40, 25, 2, -39 },
  { 3159, 26, 39, 25, 0, -39 },
  { 3286, 18, 39, 12, -3, -39 },
  { 3374, 19, 49, 10, -8, -39 },
  { 3491, 24, 39, 20, 0, -39 },
  { 3608, 13, 39, 17, 0, -39 },
  { 3672, 34, 39, 33, 0, -39 },
  { 3838, 27, 39, 26, 0, -39 },
  { 3970, 22, 40, 25, 2, -39 },
  { 4080, 21, 39, 20, 0, -39 },
  { 4183, 22, 48, 25, 2, -39 },
  { 4315, 21, 39, 21, 0, -39 },
  { 4418, 22, 40, 19, -1, -39 },
  { 4528, 17, 39, 17, 4, -39 },
  { 4611, 23, 40, 24, 2, -39 },
  { 4726, 20, 39, 20, 5, -39 },
  { 4824, 34, 39, 34, 4, -39 },
  { 4990, 25, 39, 18, -3, -39 },
  { 5112, 18, 39, 17, 4, -39 },
  { 5200, 23, 39, 17, -2, -39 },
  { 5313, 20, 48, 15, -1, -39 },
  { 5433, 7, 39, 18, 6, -39 },
  { 5468, 19, 48, 15, -3, -39 },
  { 5582, 20, 20, 21, 1, -39 },
  { 5632, 15, 2, 15, -4, 5 },
  { 5636, 6, 8, 12, 8, -41 },
  { 5642, 20, 30, 22, 1, -29 },
  { 5717, 20, 42, 21, 0, -41 },
  { 5822, 15, 30, 16, 2, -29 },
  { 5879, 23, 42, 22, 1, -41 },
  { 6000, 17, 30, 19, 1, -29 },
  { 6064, 25, 54, 11, -7, -41 },
  { 6233, 22, 42, 22, -1, -29 },
  { 6349, 19, 41, 21, 0, -41 },
  { 6447, 11, 39, 9, 0, -39 },
  { 6501, 18, 52, 10, -7, -39 },
  { 6618, 20, 41, 18, 0, -41 },
  { 6721, 12, 41, 9, 0, -41 },
  { 6783, 30, 29, 31, 0, -29 },
  { 6892, 19, 29, 21, 0, -29 },
  { 6961, 18, 30, 21, 1, -29 },
  { 7029, 22, 41, 21, -2, -29 },
  { 7142, 20, 42, 22, 1, -29 },
  { 7247, 16, 29, 14, 0, -29 },
  { 7305, 18, 30, 16, -1, -29 },
  { 7373, 12, 36, 11, 1, -35 },
  { 7427, 19, 30, 21, 1, -29 },
  { 7499, 16, 29, 16, 3, -29 },
  { 7557, 27, 29, 27, 3, -29 },
  { 7655, 21, 29, 17, -2, -29 },
  { 7732, 26, 42, 17, -6, -29 },
  { 7869, 18, 29, 14, -2, -29 },
  { 7935, 19, 48, 17, 2, -39 },
  { 8049, 3, 54, 19, 8, -41 },
  { 8070, 19, 48, 17, -3, -39 },
  { 8184, 19, 6, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC54PT7B_H_
