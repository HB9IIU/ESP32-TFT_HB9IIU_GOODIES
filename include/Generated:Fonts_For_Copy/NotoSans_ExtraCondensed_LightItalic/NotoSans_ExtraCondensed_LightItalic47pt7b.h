#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x30, 0xE6, 0x19, 0xC3,
  0x38, 0xE6, 0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xC1, 0x98, 0x63, 0x0C, 0x61,
  0x88, 0x30, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00, 0xC1,
  0x80, 0x0C, 0x30, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x01, 0x86, 0x00, 0x38,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00,
  0x30, 0xE0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3D, 0xBC, 0x1C, 0x42, 0x06, 0x10, 0x03,
  0x8C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0xE6,
  0x00, 0x19, 0x80, 0x07, 0x40, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x2E, 0x00, 0x09, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x10, 0xC0, 0x04, 0x30, 0x03, 0x0C, 0x00, 0xC7, 0x08, 0x23,
  0x83, 0x8B, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x18, 0x0F, 0x80,
  0x70, 0x31, 0x80, 0xC0, 0xC3, 0x03, 0x81, 0x86, 0x06, 0x06, 0x0C, 0x18,
  0x0C, 0x18, 0x30, 0x38, 0x30, 0xC0, 0x60, 0x61, 0x80, 0xC0, 0xC6, 0x01,
  0x83, 0x0C, 0x03, 0x06, 0x30, 0x0E, 0x0C, 0x60, 0x18, 0x19, 0x82, 0x30,
  0x63, 0x1F, 0x60, 0xCC, 0x76, 0xC3, 0x99, 0x87, 0x86, 0x63, 0x0D, 0x9C,
  0xCC, 0x1B, 0xF3, 0x18, 0x33, 0x86, 0x60, 0x60, 0x18, 0xC1, 0xC0, 0x31,
  0x83, 0x00, 0xC3, 0x06, 0x01, 0x8E, 0x0C, 0x06, 0x18, 0x18, 0x0C, 0x30,
  0x70, 0x30, 0x60, 0xC0, 0x60, 0xC1, 0x81, 0x81, 0x87, 0x03, 0x03, 0x0C,
  0x0C, 0x06, 0x38, 0x18, 0x0E, 0xE0, 0x60, 0x0F, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x73, 0x80, 0x30, 0xC0, 0x38, 0x60, 0x18,
  0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC7, 0x00,
  0x63, 0x00, 0x33, 0x80, 0x1B, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0x30, 0x03, 0x98, 0x73, 0x8E, 0x3B, 0x87, 0x19, 0x81,
  0x9D, 0xC0, 0xCC, 0xE0, 0x76, 0x60, 0x1F, 0x30, 0x0F, 0x18, 0x07, 0x8C,
  0x03, 0x86, 0x03, 0xC3, 0x81, 0xF1, 0xC3, 0xB8, 0x7F, 0x8C, 0x1F, 0x87,
  0x00, 0x39, 0x9C, 0xE7, 0x31, 0x8C, 0xE6, 0x31, 0x8C, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x06,
  0x30, 0x79, 0x84, 0xFF, 0xE0, 0xFE, 0x0F, 0x00, 0xE8, 0x0E, 0x60, 0xE3,
  0x86, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xCE, 0x03, 0x87,
  0x07, 0x07, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x1C, 0x03,
  0x18, 0x03, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x06,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x30,
  0xC0, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0x61, 0xC0, 0x7F, 0x80, 0x3F, 0x00,
  0x00, 0xC0, 0xF0, 0x7C, 0x3E, 0x1D, 0x8E, 0xEF, 0x39, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x07, 0x8F, 0x00, 0x40, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3C, 0x38, 0x0C,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x83, 0x01, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0xCC, 0x00, 0x33, 0x80, 0x06, 0x70, 0x01, 0x8C, 0x00,
  0x71, 0x80, 0x0C, 0x30, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x18, 0x30, 0x07,
  0x06, 0x00, 0xC1, 0xC0, 0x30, 0x38, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x70,
  0x18, 0x0C, 0x07, 0x03, 0x00, 0xE0, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x08, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x06, 0x07, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3C, 0x20, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x87, 0x00, 0xCF, 0xE0, 0xEE,
  0xF8, 0x7C, 0x1C, 0x3C, 0x06, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x0E, 0x03, 0x87, 0x01, 0x81, 0x81, 0xC0, 0xE1, 0xC0, 0x3F,
  0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3C, 0x78,
  0x1C, 0x0E, 0x06, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x60, 0xE0, 0x38, 0x18, 0x0C, 0x07, 0x07, 0x01, 0xC3,
  0x80, 0x3B, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0xE7, 0x00,
  0x70, 0xE0, 0x38, 0x1C, 0x1C, 0x07, 0x06, 0x00, 0xC3, 0x80, 0x38, 0xC0,
  0x0E, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x07,
  0x0E, 0x01, 0x81, 0xC1, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0xF1, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x70, 0x1C, 0x38,
  0x0E, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x71,
  0x80, 0x38, 0xC0, 0x1C, 0x60, 0x1E, 0x30, 0x0E, 0x18, 0x0F, 0x0E, 0x07,
  0x87, 0x8F, 0xC1, 0xFE, 0xE0, 0x7C, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x07, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x07,
  0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xE0, 0xE0,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x07, 0xE0, 0xFF, 0x87, 0x1E, 0x20, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x38, 0x3C, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x0F, 0xC3, 0x18, 0x1D, 0xC3, 0x18, 0x30, 0xC3,
  0x38, 0x60, 0xC3, 0x30, 0x61, 0x83, 0x30, 0xC1, 0x83, 0x30, 0xC1, 0x86,
  0x60, 0xC3, 0x86, 0x61, 0x83, 0x06, 0x61, 0x83, 0x06, 0x61, 0x83, 0x06,
  0x61, 0x87, 0x0C, 0xC3, 0x86, 0x0C, 0xC3, 0x86, 0x18, 0xC3, 0x8E, 0x18,
  0xC3, 0x8A, 0x30, 0xC1, 0x9B, 0x70, 0xC1, 0xF3, 0xE0, 0xC0, 0x40, 0x80,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x08, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x00, 0x39, 0x80, 0x18,
  0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x06, 0x01,
  0x83, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x7F, 0xF8,
  0x3F, 0xFC, 0x18, 0x0E, 0x1C, 0x07, 0x0C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x00, 0x73, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x07,
  0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x60, 0x60, 0x1C, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x70,
  0x38, 0x0E, 0x03, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xE1, 0xC0,
  0x18, 0x38, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0xE0, 0xE0, 0x1C, 0x18, 0x07, 0x03, 0x07, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xC3, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC1, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x18, 0x3C, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x00, 0x60, 0x30, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0xC3, 0x80, 0x18, 0x38, 0x03,
  0x83, 0x00, 0x38, 0x30, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01,
  0xC0, 0x60, 0x78, 0x06, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x02,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x3E,
  0x3E, 0x03, 0x80, 0x20, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xFE, 0x38, 0x07, 0xF1, 0xC0, 0x03, 0x8C, 0x00, 0x1C,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x30, 0x03, 0x81,
  0xC0, 0x18, 0x07, 0x80, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xC0, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x07,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x18, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x60,
  0x03, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x0C, 0x01, 0xC0, 0x60,
  0x1C, 0x03, 0x01, 0xC0, 0x38, 0x0C, 0x01, 0xC0, 0xE0, 0x0C, 0x0E, 0x00,
  0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0C, 0x30,
  0x00, 0x63, 0x80, 0x07, 0x38, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x0D,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xD8, 0x00, 0x3C, 0xC0, 0x01, 0xC7, 0x00,
  0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x38, 0x01, 0x81,
  0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x30, 0x07, 0x01, 0x80, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x0C, 0x07, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x01, 0xFF,
  0xEF, 0xFE, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x0D, 0x80, 0x03,
  0xE0, 0x36, 0x00, 0x1F, 0x80, 0xD8, 0x00, 0x6C, 0x07, 0x60, 0x03, 0xB0,
  0x1D, 0x80, 0x0D, 0xC0, 0x66, 0x00, 0x77, 0x01, 0x98, 0x01, 0x9C, 0x06,
  0x60, 0x0E, 0x60, 0x39, 0x80, 0x31, 0x80, 0xE6, 0x01, 0xCE, 0x03, 0x18,
  0x06, 0x38, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xE3, 0x01, 0xC7, 0x03,
  0x0C, 0x07, 0x1C, 0x1C, 0x70, 0x18, 0x70, 0x61, 0xC0, 0x61, 0xC3, 0x86,
  0x03, 0x87, 0x0C, 0x18, 0x0E, 0x1C, 0x70, 0xE0, 0x30, 0x31, 0x83, 0x80,
  0xC0, 0xCE, 0x0E, 0x03, 0x03, 0x30, 0x30, 0x1C, 0x0D, 0xC0, 0xC0, 0x70,
  0x36, 0x07, 0x01, 0x80, 0xF8, 0x1C, 0x06, 0x03, 0xC0, 0x60, 0x18, 0x0F,
  0x01, 0x80, 0xE0, 0x38, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x06, 0x01, 0xE0, 0x06, 0x03, 0xE0,
  0x0E, 0x03, 0x60, 0x0E, 0x03, 0x60, 0x0E, 0x03, 0x60, 0x0C, 0x07, 0x70,
  0x0C, 0x07, 0x70, 0x1C, 0x06, 0x30, 0x1C, 0x06, 0x30, 0x18, 0x06, 0x30,
  0x18, 0x0E, 0x30, 0x18, 0x0E, 0x38, 0x38, 0x0C, 0x38, 0x38, 0x0C, 0x18,
  0x30, 0x0C, 0x18, 0x30, 0x1C, 0x18, 0x70, 0x1C, 0x1C, 0x70, 0x18, 0x1C,
  0x70, 0x18, 0x0C, 0x60, 0x38, 0x0C, 0x60, 0x38, 0x0C, 0xE0, 0x38, 0x0C,
  0xE0, 0x30, 0x0E, 0xC0, 0x30, 0x0E, 0xC0, 0x70, 0x06, 0xC0, 0x70, 0x07,
  0xC0, 0x60, 0x07, 0xC0, 0x60, 0x07, 0x80, 0x60, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0xE0, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0x8F, 0x01,
  0xC0, 0xE0, 0x70, 0x0E, 0x0C, 0x01, 0xC3, 0x80, 0x18, 0xE0, 0x03, 0x1C,
  0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xE0,
  0x01, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xFC, 0x00, 0x1B, 0x80,
  0x03, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x1C, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xC1, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x18, 0x1C, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x1C, 0x1C, 0x03, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x0C, 0x0F, 0x01, 0x83, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xF0, 0x07, 0x8F, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x0C, 0x01,
  0xC3, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x07,
  0x60, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0xEE, 0x00, 0x1D,
  0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0xE3,
  0x00, 0x1C, 0x60, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x03,
  0x83, 0xC0, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xC1, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x07, 0x07, 0x00, 0xC0,
  0xE0, 0x18, 0x1C, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x1C, 0x1C, 0x03, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x0C, 0x0F, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0E,
  0x30, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x06, 0x0C, 0x01, 0xC1, 0x80, 0x38,
  0x30, 0x06, 0x07, 0x00, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x18, 0x07, 0x03, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x80, 0x00,
  0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xCF, 0x81, 0xE0, 0x20, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x20, 0x0F,
  0x06, 0x03, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0E,
  0x0E, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0xC1, 0xC0,
  0x0E, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0xC1,
  0xC0, 0x0E, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01,
  0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x07, 0x03, 0x00, 0x38, 0x38,
  0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x07, 0x03, 0x00, 0x38,
  0x18, 0x01, 0x81, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x30, 0x06, 0x01, 0xC0,
  0x70, 0x0F, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x33, 0x80,
  0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0E, 0x30, 0x0E, 0x18, 0x07, 0x0C,
  0x03, 0x06, 0x03, 0x83, 0x01, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x30, 0x70, 0x18, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8E,
  0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x0D, 0x80, 0x06,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x1D, 0x80, 0x0E, 0x00, 0x76, 0x00, 0x38, 0x01, 0x98, 0x01,
  0xE0, 0x0E, 0x60, 0x07, 0x80, 0x31, 0x80, 0x3E, 0x01, 0xC6, 0x00, 0xF8,
  0x07, 0x18, 0x03, 0xC0, 0x18, 0x60, 0x1B, 0x00, 0xE1, 0x80, 0x6C, 0x03,
  0x06, 0x03, 0xB0, 0x1C, 0x18, 0x0C, 0xC0, 0x70, 0x60, 0x33, 0x01, 0x81,
  0x81, 0xCC, 0x0E, 0x06, 0x06, 0x30, 0x30, 0x18, 0x38, 0xC1, 0xC0, 0x60,
  0xC3, 0x07, 0x01, 0x83, 0x0C, 0x18, 0x06, 0x1C, 0x30, 0xE0, 0x18, 0x60,
  0xC3, 0x00, 0x63, 0x83, 0x1C, 0x01, 0x8C, 0x0C, 0x70, 0x06, 0x30, 0x31,
  0x80, 0x19, 0xC0, 0xCE, 0x00, 0x66, 0x03, 0x30, 0x01, 0x98, 0x0D, 0xC0,
  0x06, 0xC0, 0x37, 0x00, 0x1B, 0x00, 0xD8, 0x00, 0xFC, 0x03, 0xE0, 0x03,
  0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0,
  0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x03, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x03,
  0x38, 0x00, 0x0C, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x18, 0xC0, 0x00, 0xE3,
  0x00, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00,
  0x1C, 0x0E, 0x00, 0x60, 0x38, 0x03, 0x80, 0xE0, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x18, 0x00, 0x60, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x30, 0x38, 0x30, 0x30, 0x30, 0x70, 0x30,
  0x60, 0x30, 0xE0, 0x30, 0xC0, 0x31, 0xC0, 0x39, 0x80, 0x3B, 0x80, 0x3B,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x40, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1C,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x20, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1B, 0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x0E, 0x38, 0x06, 0x0C, 0x07,
  0x06, 0x03, 0x03, 0x83, 0x80, 0xC1, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x0C,
  0xC0, 0x07, 0xE0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xE7, 0x18, 0xE3,
  0x1C, 0x61, 0x01, 0xF9, 0xC0, 0xFF, 0x60, 0x70, 0xD8, 0x38, 0x16, 0x0C,
  0x07, 0x87, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0C, 0x01,
  0xC7, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x86, 0x00, 0xE3,
  0x80, 0x30, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xE0, 0xE0,
  0x38, 0x18, 0x1E, 0x07, 0x0D, 0x81, 0xFE, 0x60, 0x3F, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE7,
  0xC0, 0x67, 0xF0, 0x36, 0x1C, 0x1E, 0x0E, 0x1E, 0x03, 0x0E, 0x01, 0x87,
  0x00, 0xC3, 0x80, 0x61, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x0E,
  0x30, 0x07, 0x18, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00,
  0x63, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x78, 0x18, 0x3C, 0x1C, 0x3B,
  0xFC, 0x18, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x04, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x1F, 0x98, 0x03, 0xFD, 0x80, 0x70, 0xD8, 0x0E,
  0x07, 0x80, 0xC0, 0x78, 0x1C, 0x07, 0x01, 0x80, 0x70, 0x38, 0x07, 0x03,
  0x80, 0x70, 0x30, 0x07, 0x07, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x0E, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C,
  0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x58, 0x07, 0x0D,
  0x80, 0x7F, 0x98, 0x03, 0xF3, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1C, 0x38,
  0x70, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x06, 0x30, 0x1C, 0xE0,
  0x71, 0xC1, 0xC3, 0xFF, 0x07, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x08, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xE2, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x70,
  0x0F, 0xF6, 0x01, 0xC3, 0x60, 0x38, 0x16, 0x03, 0x01, 0xE0, 0x70, 0x1C,
  0x06, 0x01, 0xC0, 0xE0, 0x1C, 0x0C, 0x01, 0xC0, 0xC0, 0x1C, 0x1C, 0x01,
  0x81, 0xC0, 0x18, 0x18, 0x03, 0x81, 0x80, 0x38, 0x18, 0x03, 0x83, 0x80,
  0x30, 0x38, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0x81, 0xE0, 0x1C, 0x3E, 0x01, 0xFE, 0xE0, 0x0F, 0xCC, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x0E, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xEF, 0xC0, 0x6F, 0xF0, 0x36, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x0E, 0x03, 0x87, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x70,
  0xE0, 0x38, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x07, 0x0E, 0x03,
  0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38, 0x60,
  0x18, 0x30, 0x0C, 0x38, 0x0E, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x3C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x70, 0x70,
  0x30, 0x30, 0x38, 0x18, 0x38, 0x1C, 0x38, 0x0E, 0x18, 0x06, 0x1C, 0x03,
  0x1C, 0x01, 0x9C, 0x01, 0xCC, 0x00, 0xEE, 0x00, 0x6F, 0x00, 0x3D, 0x80,
  0x1E, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83,
  0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x38, 0x0C, 0x1C,
  0x07, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x06,
  0x7E, 0x3F, 0x81, 0xBF, 0xDF, 0xE0, 0x78, 0x76, 0x1C, 0x1C, 0x0F, 0x07,
  0x0F, 0x03, 0x81, 0xC3, 0x80, 0xE0, 0x70, 0xE0, 0x30, 0x1C, 0x30, 0x0C,
  0x06, 0x0C, 0x07, 0x01, 0x87, 0x01, 0xC0, 0x61, 0xC0, 0x60, 0x38, 0x60,
  0x18, 0x0E, 0x18, 0x0E, 0x03, 0x06, 0x03, 0x80, 0xC3, 0x80, 0xC0, 0x70,
  0xE0, 0x30, 0x1C, 0x30, 0x0C, 0x06, 0x0C, 0x07, 0x01, 0x83, 0x01, 0xC0,
  0x61, 0xC0, 0x60, 0x38, 0x70, 0x18, 0x0E, 0x18, 0x06, 0x03, 0x06, 0x03,
  0x80, 0xC3, 0x80, 0xE0, 0x30, 0xE0, 0x30, 0x1C, 0x00, 0x06, 0x7E, 0x03,
  0x7F, 0x81, 0xB0, 0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x0C,
  0x18, 0x06, 0x0C, 0x03, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x00, 0xC1, 0x80,
  0x60, 0xC0, 0x30, 0xE0, 0x38, 0x70, 0x1C, 0x30, 0x0C, 0x18, 0x06, 0x0C,
  0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x70,
  0xE0, 0x38, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x06, 0x1C,
  0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70,
  0x07, 0x70, 0x06, 0x60, 0x06, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0x60, 0x70, 0x70,
  0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x01, 0x8F, 0x80, 0x33, 0xF8, 0x06, 0xC3,
  0x80, 0xF0, 0x30, 0x3C, 0x06, 0x07, 0x80, 0xC0, 0xE0, 0x18, 0x1C, 0x03,
  0x03, 0x00, 0x60, 0xE0, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0E,
  0x0C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x06, 0x0E, 0x01, 0xC1, 0x80, 0x38,
  0x30, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x3C, 0x0E, 0x06, 0x83, 0x80,
  0xDF, 0xE0, 0x39, 0xF8, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF9, 0xC0, 0xFF, 0x60,
  0x70, 0xD8, 0x38, 0x16, 0x0C, 0x07, 0x87, 0x01, 0xC1, 0x80, 0x70, 0xE0,
  0x1C, 0x30, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x06,
  0x18, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x38, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x18, 0x1E, 0x07, 0x0F, 0x81, 0xFE,
  0xE0, 0x3F, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x06, 0x7C, 0x1B, 0xF0, 0x6C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x01, 0xFC, 0x0F, 0xFC, 0x1C, 0x18, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x30, 0x38, 0x7F, 0xE0, 0x7F, 0x80, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x83, 0xFC, 0xFF, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x3F,
  0x07, 0xC0, 0x0E, 0x03, 0x87, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x61, 0xC0,
  0x70, 0xE0, 0x38, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x07, 0x0E,
  0x03, 0x86, 0x01, 0x83, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38,
  0x60, 0x18, 0x30, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x07, 0x07,
  0x83, 0x86, 0xC0, 0xFF, 0x60, 0x7E, 0x30, 0x00, 0xC0, 0x1F, 0x00, 0xEC,
  0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x01, 0x8C, 0x0E, 0x30, 0x30, 0xC1, 0xC3,
  0x07, 0x0C, 0x18, 0x30, 0xE0, 0xC3, 0x03, 0x1C, 0x0C, 0x60, 0x33, 0x80,
  0xCC, 0x03, 0x30, 0x0D, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x0F, 0x80, 0x70, 0x1B, 0x01, 0xE0,
  0x76, 0x03, 0xC0, 0xCC, 0x0D, 0x81, 0x98, 0x1B, 0x07, 0x30, 0x36, 0x0C,
  0x60, 0xCC, 0x38, 0xC1, 0x98, 0x61, 0x87, 0x30, 0xC3, 0x0C, 0xE3, 0x86,
  0x19, 0xC6, 0x0C, 0x63, 0x8C, 0x18, 0xC7, 0x30, 0x33, 0x8E, 0x60, 0x66,
  0x19, 0xC0, 0xCC, 0x33, 0x01, 0xB0, 0x66, 0x03, 0x60, 0xD8, 0x07, 0xC1,
  0xB0, 0x0F, 0x03, 0x60, 0x1E, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x01, 0xC0, 0xC0, 0x70, 0x38, 0x38, 0x0E,
  0x0C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x70, 0x01, 0xD8,
  0x00, 0x7E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0D, 0x80, 0x07, 0x70, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x70,
  0xC0, 0x18, 0x30, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0x80, 0x60, 0xE0, 0x18,
  0x00, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x38, 0x0E,
  0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x60, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x63,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x01, 0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x81,
  0xC3, 0xF7, 0x80, 0xFF, 0x80, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 34, 10, 1, -34 },
  { 44, 11, 13, 14, 5, -34 },
  { 62, 20, 34, 19, 0, -34 },
  { 147, 18, 39, 17, 0, -36 },
  { 235, 23, 35, 27, 2, -34 },
  { 336, 17, 34, 18, 0, -34 },
  { 409, 5, 13, 8, 5, -34 },
  { 418, 14, 41, 12, 1, -34 },
  { 490, 13, 41, 12, -3, -34 },
  { 557, 13, 14, 16, 5, -36 },
  { 580, 16, 22, 20, 2, -28 },
  { 624, 7, 11, 8, -2, -5 },
  { 634, 10, 2, 12, 1, -14 },
  { 637, 3, 4, 8, 1, -4 },
  { 639, 20, 34, 15, -2, -34 },
  { 724, 16, 34, 17, 1, -34 },
  { 792, 10, 34, 17, 5, -34 },
  { 835, 19, 34, 17, -2, -34 },
  { 916, 18, 34, 17, -1, -34 },
  { 993, 19, 34, 17, -1, -34 },
  { 1074, 19, 34, 17, -1, -34 },
  { 1155, 17, 34, 17, 1, -34 },
  { 1228, 17, 34, 17, 2, -34 },
  { 1301, 18, 34, 17, 0, -34 },
  { 1378, 17, 34, 17, 0, -34 },
  { 1451, 8, 25, 8, 0, -25 },
  { 1476, 10, 31, 8, -2, -25 },
  { 1515, 16, 20, 20, 2, -27 },
  { 1555, 16, 13, 20, 2, -23 },
  { 1581, 16, 20, 20, 2, -27 },
  { 1621, 13, 34, 12, 1, -34 },
  { 1677, 24, 38, 26, 1, -34 },
  { 1791, 17, 34, 17, -3, -34 },
  { 1864, 19, 34, 19, 0, -34 },
  { 1945, 19, 34, 17, 2, -34 },
  { 2026, 20, 34, 21, 0, -34 },
  { 2111, 19, 34, 17, 0, -34 },
  { 2192, 19, 34, 15, 0, -34 },
  { 2273, 21, 34, 22, 2, -34 },
  { 2363, 23, 34, 22, 0, -34 },
  { 2461, 16, 34, 10, -3, -34 },
  { 2529, 17, 43, 8, -7, -34 },
  { 2621, 21, 34, 18, 0, -34 },
  { 2711, 12, 34, 15, 0, -34 },
  { 2762, 30, 34, 29, 0, -34 },
  { 2890, 24, 34, 23, 0, -34 },
  { 2992, 19, 34, 22, 2, -34 },
  { 3073, 19, 34, 18, 0, -34 },
  { 3154, 19, 42, 22, 2, -34 },
  { 3254, 19, 34, 18, 0, -34 },
  { 3335, 19, 34, 17, -1, -34 },
  { 3416, 16, 34, 15, 3, -34 },
  { 3484, 21, 34, 21, 1, -34 },
  { 3574, 17, 34, 18, 4, -34 },
  { 3647, 30, 34, 29, 3, -34 },
  { 3775, 22, 34, 16, -3, -34 },
  { 3869, 16, 34, 15, 3, -34 },
  { 3937, 20, 34, 15, -2, -34 },
  { 4022, 17, 41, 13, -1, -34 },
  { 4110, 7, 34, 16, 5, -34 },
  { 4140, 17, 41, 13, -3, -34 },
  { 4228, 17, 17, 19, 1, -34 },
  { 4265, 14, 2, 13, -4, 4 },
  { 4269, 5, 8, 11, 7, -36 },
  { 4274, 18, 25, 19, 1, -25 },
  { 4331, 17, 36, 19, 0, -36 },
  { 4408, 14, 25, 14, 1, -25 },
  { 4452, 20, 36, 19, 1, -36 },
  { 4542, 15, 25, 17, 1, -25 },
  { 4589, 21, 47, 10, -6, -36 },
  { 4713, 20, 36, 19, -1, -25 },
  { 4803, 17, 36, 18, 0, -36 },
  { 4880, 10, 34, 8, 0, -34 },
  { 4923, 16, 45, 8, -6, -34 },
  { 5013, 17, 36, 15, 0, -36 },
  { 5090, 10, 36, 8, 0, -36 },
  { 5135, 26, 25, 27, 0, -25 },
  { 5217, 17, 25, 18, 0, -25 },
  { 5271, 16, 25, 18, 1, -25 },
  { 5321, 19, 36, 19, -2, -25 },
  { 5407, 18, 36, 19, 1, -25 },
  { 5488, 14, 25, 12, 0, -25 },
  { 5532, 15, 25, 14, -1, -25 },
  { 5579, 10, 31, 10, 1, -31 },
  { 5618, 17, 25, 18, 1, -25 },
  { 5672, 14, 25, 14, 3, -25 },
  { 5716, 23, 25, 24, 3, -25 },
  { 5788, 18, 25, 15, -2, -25 },
  { 5845, 22, 36, 15, -5, -25 },
  { 5944, 16, 25, 12, -2, -25 },
  { 5994, 17, 41, 15, 1, -34 },
  { 6082, 2, 47, 17, 7, -36 },
  { 6094, 16, 41, 15, -3, -34 },
  { 6176, 16, 5, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC47PT7B_H_
