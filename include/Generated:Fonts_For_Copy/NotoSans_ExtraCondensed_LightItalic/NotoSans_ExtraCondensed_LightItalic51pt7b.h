#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x1E, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x73, 0x87, 0x30, 0x63, 0x0E, 0x70, 0xE7, 0x0E,
  0x60, 0xC6, 0x0C, 0x61, 0xC6, 0x1C, 0xE1, 0x8C, 0x18, 0xC1, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07,
  0x06, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x1C, 0x18, 0x00, 0xC1, 0xC0,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x03, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x03, 0x83, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60,
  0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x3C, 0xC6, 0x07, 0x08, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0xE1, 0x80, 0x0E, 0x10, 0x00, 0xE1, 0x00, 0x0E, 0x30, 0x00,
  0x63, 0x00, 0x07, 0x30, 0x00, 0x3A, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x0D, 0xC0, 0x00, 0xCE,
  0x00, 0x0C, 0x60, 0x00, 0x87, 0x00, 0x08, 0x70, 0x01, 0x87, 0x00, 0x18,
  0x70, 0x01, 0x86, 0x00, 0x10, 0x60, 0x01, 0x0E, 0x0C, 0x31, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0,
  0x07, 0x03, 0x9C, 0x03, 0x01, 0x86, 0x03, 0x81, 0xC3, 0x01, 0x80, 0xC1,
  0x81, 0xC0, 0xE0, 0xC0, 0xC0, 0x60, 0x60, 0xE0, 0x30, 0x30, 0x60, 0x38,
  0x18, 0x60, 0x1C, 0x1C, 0x30, 0x0C, 0x0E, 0x30, 0x06, 0x06, 0x18, 0x03,
  0x03, 0x18, 0x01, 0x81, 0x8C, 0x01, 0xC1, 0x8C, 0x3C, 0xE0, 0xC6, 0x3F,
  0x70, 0xE6, 0x39, 0xF8, 0x63, 0x38, 0x6C, 0x73, 0x18, 0x37, 0x71, 0x9C,
  0x1B, 0xF1, 0x8C, 0x0C, 0xF0, 0xC6, 0x0E, 0x00, 0xC7, 0x07, 0x00, 0x63,
  0x03, 0x80, 0x61, 0x81, 0x80, 0x30, 0xC0, 0xC0, 0x30, 0xE0, 0x60, 0x18,
  0x70, 0x70, 0x18, 0x38, 0x30, 0x0C, 0x18, 0x18, 0x0C, 0x0C, 0x1C, 0x06,
  0x06, 0x0C, 0x06, 0x03, 0x0E, 0x07, 0x01, 0xC6, 0x03, 0x00, 0x7F, 0x03,
  0x80, 0x3F, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x0E,
  0x70, 0x07, 0x0C, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x38, 0x38, 0x0E, 0x0C,
  0x03, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E, 0x38, 0x03, 0x8C, 0x00,
  0xE7, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x07, 0x18, 0x33, 0x87, 0x1C, 0xC1, 0xC7,
  0x70, 0x71, 0x98, 0x0C, 0xEE, 0x03, 0xB3, 0x80, 0xFC, 0xC0, 0x1E, 0x30,
  0x07, 0x8C, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x3E, 0x38, 0x1F, 0x8F, 0x0E,
  0xE1, 0xFF, 0x1C, 0x3F, 0x87, 0x03, 0x00, 0x00, 0x39, 0xCE, 0x63, 0x39,
  0xCC, 0x63, 0x39, 0x8C, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0xC3, 0x03,
  0xCC, 0x07, 0xB3, 0x87, 0xFF, 0x07, 0x80, 0x3C, 0x01, 0x98, 0x0C, 0x60,
  0xF0, 0xC1, 0x83, 0x00, 0x0E, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x0E, 0x18, 0x70, 0xC3, 0x86, 0x00,
  0xFF, 0xFF, 0xFC, 0x6F, 0xFE, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0x0E, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70,
  0x1C, 0x18, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06,
  0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x9C,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C, 0x70, 0x07, 0x18, 0x01, 0xC6, 0x00,
  0x73, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x06, 0x0E, 0x03, 0x83, 0x80, 0xC0, 0xE0, 0x70, 0x18,
  0x38, 0x07, 0x1E, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0x00, 0x00, 0x01,
  0xC1, 0xF0, 0xFC, 0x76, 0x39, 0x9C, 0xEE, 0x3B, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xC0, 0xE0, 0x08, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x41, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x18, 0x0E, 0x01, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x08, 0x03, 0xC0, 0xC0,
  0x78, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x7E,
  0x00, 0x06, 0xE0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0x9C, 0x00, 0x39,
  0xC0, 0x03, 0x1C, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0x83, 0x80, 0x30, 0x30, 0x07, 0x03, 0x00, 0x60, 0x70, 0x0E,
  0x07, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0E, 0x07,
  0x00, 0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x80, 0x3C, 0x0C, 0x07, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFB, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x18, 0x01, 0xCF, 0xE0, 0x33, 0xFE, 0x06, 0xC1, 0xC1, 0xF0, 0x3C,
  0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x03, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0x60, 0x38, 0x0E, 0x07, 0x01,
  0xE3, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xFB, 0xE0, 0x1C, 0x0F, 0x01, 0x80,
  0x70, 0x38, 0x07, 0x03, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x07, 0x03, 0x00, 0x70, 0x30, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x01,
  0xC3, 0x80, 0x1C, 0x70, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x3D, 0xC0, 0x07, 0x1E, 0x00, 0xE0, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0x70,
  0x30, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03,
  0x8E, 0x00, 0x38, 0xE0, 0x03, 0x86, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00,
  0xE0, 0x3C, 0x1E, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xC0,
  0x70, 0x60, 0x0C, 0x38, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C,
  0x70, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x07, 0x18,
  0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x78, 0x78, 0x36, 0x0F, 0x3F, 0x83, 0xFE,
  0xE0, 0x3E, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x08, 0x3E, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0xE0, 0xF0, 0x78, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF0, 0x40, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00,
  0x60, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x1F, 0xC3, 0x0C, 0x0F, 0xF0, 0xC6,
  0x07, 0x1C, 0x31, 0x83, 0x86, 0x0C, 0x60, 0xC1, 0x83, 0x30, 0x70, 0xE0,
  0xCC, 0x18, 0x38, 0x73, 0x0E, 0x0C, 0x1D, 0xC3, 0x03, 0x06, 0x60, 0xC1,
  0xC1, 0x98, 0x30, 0x70, 0x66, 0x1C, 0x18, 0x31, 0x86, 0x06, 0x0C, 0x61,
  0x83, 0x83, 0x38, 0x60, 0xE1, 0x8E, 0x18, 0x78, 0x63, 0x86, 0x16, 0x30,
  0xC1, 0xCD, 0x9C, 0x30, 0x3E, 0x7E, 0x0C, 0x0F, 0x0F, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x20, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00,
  0x33, 0x00, 0x1C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30,
  0xC0, 0x1C, 0x30, 0x07, 0x0C, 0x03, 0x83, 0x00, 0xE0, 0xC0, 0x30, 0x30,
  0x1C, 0x0C, 0x07, 0x03, 0x03, 0x80, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x70, 0x3C, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x80, 0xC0, 0x1C, 0x0E,
  0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x18, 0x01, 0x81, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x18, 0x0F, 0x01, 0xC1,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0x83, 0xC0, 0x18, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x00, 0x38, 0x18, 0x01,
  0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x03, 0x00, 0x38, 0x38,
  0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x1E, 0x03, 0x0F, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0x02, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x10, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x70,
  0x78, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x80, 0xC0, 0x1C, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x03, 0x80, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00,
  0x30, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x61, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x1C, 0x18, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0x00, 0x38, 0x38, 0x03, 0x81,
  0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x3C, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF8, 0x07, 0x80, 0x60, 0x1E, 0x00, 0x40, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1F, 0xC7, 0x00,
  0x7F, 0x8E, 0x00, 0xFF, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x38, 0x00, 0xC0,
  0x70, 0x03, 0x80, 0xF0, 0x07, 0x00, 0xF8, 0x1E, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x0C,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C,
  0x06, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x70, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x01, 0x80,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x08, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x03, 0x80, 0x18, 0x0F, 0x00, 0x30, 0x1C, 0x00, 0xE0,
  0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0xF0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x37, 0xC0, 0x00,
  0x7B, 0x80, 0x01, 0xE3, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x76,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xB0, 0x00, 0x6E, 0x03, 0xB0, 0x00, 0xEE,
  0x03, 0x30, 0x00, 0xCC, 0x07, 0x30, 0x01, 0xDC, 0x07, 0x30, 0x01, 0x9C,
  0x07, 0x30, 0x03, 0x9C, 0x06, 0x30, 0x03, 0x18, 0x06, 0x30, 0x07, 0x18,
  0x0E, 0x30, 0x07, 0x38, 0x0E, 0x30, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x38,
  0x0C, 0x30, 0x1C, 0x30, 0x0C, 0x38, 0x1C, 0x70, 0x1C, 0x38, 0x38, 0x70,
  0x1C, 0x38, 0x38, 0x70, 0x1C, 0x38, 0x30, 0x70, 0x18, 0x38, 0x70, 0x60,
  0x38, 0x38, 0x60, 0xE0, 0x38, 0x38, 0xE0, 0xE0, 0x38, 0x38, 0xC0, 0xE0,
  0x30, 0x39, 0xC0, 0xC0, 0x30, 0x39, 0x80, 0xC0, 0x70, 0x1B, 0x81, 0xC0,
  0x70, 0x1B, 0x01, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0x60, 0x1F, 0x01, 0x80,
  0x60, 0x1E, 0x01, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x60, 0x1F, 0x00, 0x38, 0x07, 0xC0,
  0x0E, 0x01, 0xF0, 0x03, 0x80, 0x6C, 0x00, 0xE0, 0x3B, 0x00, 0x30, 0x0E,
  0xC0, 0x1C, 0x03, 0xB8, 0x07, 0x00, 0xCE, 0x01, 0xC0, 0x73, 0x80, 0x60,
  0x1C, 0x60, 0x18, 0x07, 0x18, 0x0E, 0x01, 0x86, 0x03, 0x80, 0x61, 0xC0,
  0xE0, 0x38, 0x70, 0x30, 0x0E, 0x1C, 0x0C, 0x03, 0x83, 0x07, 0x00, 0xC0,
  0xC1, 0xC0, 0x30, 0x38, 0x70, 0x1C, 0x0E, 0x18, 0x07, 0x03, 0x8E, 0x01,
  0xC0, 0x63, 0x80, 0x60, 0x18, 0xE0, 0x38, 0x06, 0x38, 0x0E, 0x01, 0xCC,
  0x03, 0x80, 0x77, 0x00, 0xE0, 0x1D, 0xC0, 0x30, 0x03, 0x70, 0x1C, 0x00,
  0xD8, 0x07, 0x00, 0x36, 0x01, 0xC0, 0x0F, 0x80, 0x60, 0x03, 0xE0, 0x18,
  0x00, 0xF8, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x03,
  0x80, 0xE0, 0x1E, 0x1E, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xC3, 0xE0, 0x1C, 0x0E, 0x01,
  0x80, 0x70, 0x18, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x30, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x60, 0x70, 0x0E,
  0x06, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x7F,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xC0, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x1C,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x30, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x80, 0xE0,
  0x1E, 0x1F, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xC3, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x70, 0x18, 0x07, 0x03,
  0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x30, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x01, 0xC0, 0xE0, 0x1C,
  0x0E, 0x03, 0x80, 0xE0, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x83, 0x80, 0x18, 0x38, 0x03, 0x81,
  0x80, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x0C, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xC0,
  0x60, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x04, 0x00, 0xF0, 0x38, 0x1F, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0x80, 0x0E, 0x06, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0C, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x60,
  0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xC0, 0x07,
  0x03, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x06,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00,
  0x70, 0x30, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xE1, 0xE0, 0x07, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC1,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0x83, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x00, 0x0E,
  0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0x80, 0x0E, 0xE0, 0x03, 0x80, 0x0E, 0xE0, 0x07, 0x80, 0x1C, 0xE0,
  0x07, 0x80, 0x1C, 0xE0, 0x07, 0x80, 0x18, 0xE0, 0x0D, 0x80, 0x38, 0xE0,
  0x0D, 0x80, 0x38, 0xE0, 0x1D, 0x80, 0x70, 0xE0, 0x19, 0x80, 0x70, 0xE0,
  0x19, 0x80, 0x60, 0xE0, 0x39, 0x80, 0xE0, 0xE0, 0x31, 0x80, 0xE0, 0xE0,
  0x71, 0x81, 0xC0, 0xE0, 0x61, 0x81, 0xC0, 0xE0, 0x61, 0x81, 0x80, 0xE0,
  0xE3, 0x83, 0x80, 0xE0, 0xC3, 0x83, 0x80, 0xE1, 0xC3, 0x87, 0x00, 0xE1,
  0x83, 0x87, 0x00, 0xE1, 0x83, 0x86, 0x00, 0xE3, 0x83, 0x8E, 0x00, 0xE3,
  0x03, 0x8E, 0x00, 0xE7, 0x03, 0x9C, 0x00, 0xE7, 0x03, 0x9C, 0x00, 0xE6,
  0x03, 0x98, 0x00, 0xCE, 0x03, 0x38, 0x00, 0xCC, 0x03, 0x38, 0x00, 0xCC,
  0x03, 0x30, 0x00, 0xDC, 0x03, 0x70, 0x00, 0xD8, 0x03, 0x60, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x30,
  0x38, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xC0, 0x00, 0x39, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xDC, 0x00, 0xE3,
  0x00, 0x70, 0xC0, 0x1C, 0x30, 0x0E, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x18, 0xE0,
  0x06, 0x38, 0x01, 0x9C, 0x00, 0x67, 0x00, 0x1B, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x70, 0x70,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1C,
  0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06,
  0x06, 0x06, 0x07, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x03, 0x18, 0x00,
  0xE3, 0x80, 0x18, 0x70, 0x07, 0x06, 0x00, 0xC0, 0xE0, 0x38, 0x1C, 0x06,
  0x01, 0xC1, 0xC0, 0x38, 0x70, 0x03, 0x0E, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x00, 0xDC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC7,
  0x0E, 0x38, 0x60, 0xC3, 0x00, 0x10, 0x00, 0x1F, 0x8C, 0x0F, 0xF9, 0x81,
  0xC3, 0x70, 0x70, 0x3C, 0x1C, 0x07, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x1C,
  0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xE3, 0x80,
  0x18, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x83, 0x01,
  0xE0, 0x70, 0x2C, 0x0F, 0x1D, 0x80, 0xFF, 0x70, 0x0F, 0xCE, 0x00, 0x40,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x31, 0xF8, 0x06, 0xFF, 0x81, 0xD8,
  0x70, 0x3E, 0x07, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00,
  0xC3, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x38,
  0x34, 0x0E, 0x06, 0xC3, 0xC1, 0xDF, 0xF0, 0x31, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x01, 0xFC, 0x0F, 0xF8, 0x3C, 0x10, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0,
  0x40, 0xFF, 0x80, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x04, 0x18, 0x00, 0xFC, 0xE0, 0x0F, 0xFB, 0x80, 0x78, 0x6E,
  0x01, 0xC0, 0xF0, 0x0E, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x70, 0x18, 0x01, 0xC0,
  0x60, 0x07, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0,
  0x1E, 0x03, 0x80, 0x78, 0x06, 0x03, 0xC0, 0x1C, 0x0B, 0x00, 0x70, 0xEC,
  0x00, 0xFF, 0x70, 0x01, 0xF9, 0x80, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0xFE, 0x03, 0xFF, 0x07, 0x87, 0x07, 0x03, 0x0E, 0x03, 0x1C, 0x03, 0x1C,
  0x07, 0x18, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x70, 0x1C, 0x70, 0x78, 0x7F,
  0xF0, 0x7F, 0xC0, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x78,
  0x10, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x90, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x71, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x9C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xF8, 0xC0, 0x3F, 0xEE, 0x01, 0xC3, 0x70, 0x1C, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07,
  0x03, 0x80, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x60, 0x70,
  0x03, 0x03, 0x80, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x60,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x01,
  0xE0, 0x1C, 0x1B, 0x00, 0xE1, 0xF8, 0x03, 0xFD, 0xC0, 0x0F, 0xCE, 0x00,
  0x10, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x08, 0x07, 0x80, 0x70,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x18, 0x03, 0x3F,
  0x80, 0xDF, 0xF0, 0x7E, 0x1C, 0x1E, 0x07, 0x07, 0x81, 0xC1, 0xC0, 0x70,
  0x70, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x60, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x30, 0x60, 0x1C, 0x38, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x07, 0x0E, 0x01, 0xC0, 0x00,
  0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x08, 0xE0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x1E,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x00, 0xC1, 0xC0,
  0x18, 0x70, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x18, 0xE0, 0x03, 0x38, 0x00,
  0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xEC, 0x00, 0x79, 0x80, 0x0E, 0x38, 0x03,
  0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x30, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x04, 0x03, 0x00,
  0x33, 0xF8, 0xFE, 0x03, 0x7F, 0x9F, 0xF0, 0x7C, 0x3F, 0x07, 0x07, 0x81,
  0xE0, 0x70, 0x70, 0x1E, 0x07, 0x07, 0x01, 0xC0, 0x70, 0xE0, 0x1C, 0x07,
  0x0E, 0x01, 0x80, 0x70, 0xE0, 0x18, 0x06, 0x0E, 0x03, 0x80, 0x60, 0xC0,
  0x38, 0x0E, 0x1C, 0x03, 0x80, 0xE1, 0xC0, 0x30, 0x0E, 0x1C, 0x07, 0x00,
  0xC1, 0x80, 0x70, 0x0C, 0x18, 0x07, 0x01, 0xC3, 0x80, 0x70, 0x1C, 0x38,
  0x06, 0x01, 0xC3, 0x80, 0xE0, 0x18, 0x30, 0x0E, 0x03, 0x83, 0x00, 0xE0,
  0x38, 0x70, 0x0C, 0x03, 0x87, 0x00, 0xC0, 0x30, 0x70, 0x1C, 0x03, 0x06,
  0x01, 0xC0, 0x70, 0xE0, 0x1C, 0x07, 0x0E, 0x01, 0x80, 0x70, 0x00, 0x04,
  0x00, 0xCF, 0xE0, 0x37, 0xFC, 0x1F, 0x07, 0x06, 0x81, 0xC1, 0xE0, 0x70,
  0x70, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x18, 0x30,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x18, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0x00, 0x18, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xF0, 0xE0, 0x70, 0x38,
  0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xE6, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x06, 0x60,
  0x07, 0x30, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x70, 0xC0, 0x30, 0x70, 0x38, 0x3C, 0x38, 0x0F, 0xF8, 0x03, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x06, 0x3F, 0x00, 0x37, 0xFC, 0x03,
  0xB0, 0xE0, 0x1F, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x06, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0xE0, 0x78, 0x07, 0x03, 0xC0, 0x70, 0x1A, 0x07, 0x00, 0xD8, 0x78, 0x06,
  0xFF, 0x80, 0x73, 0xF8, 0x03, 0x82, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0x8C, 0x0F, 0xFB, 0x81, 0xC3, 0x70, 0x70, 0x3C,
  0x1C, 0x07, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x30,
  0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x1C, 0x00, 0xC3,
  0x80, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x83, 0x01, 0xE0, 0x70, 0x6C, 0x0E,
  0x1F, 0x80, 0xFF, 0x70, 0x1F, 0xCE, 0x00, 0x41, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x06, 0x7C, 0x0D, 0xF8, 0x3F, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xE0,
  0x60, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x80, 0x70, 0x60, 0x78, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x81, 0xFF, 0x3F, 0xE1, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xFC, 0x0F, 0x80, 0x40, 0x00, 0x06, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07,
  0x0E, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xC1, 0x80, 0x70, 0x60, 0x1C, 0x38, 0x0F, 0x0E, 0x03, 0xC3, 0x81,
  0xE0, 0x70, 0xD8, 0x1F, 0xE6, 0x03, 0xF3, 0x80, 0x20, 0x00, 0xE0, 0x0F,
  0xC0, 0x1B, 0x80, 0x77, 0x00, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x61, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0x80, 0xE7, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x60, 0x0F,
  0xC0, 0x1F, 0x80, 0x36, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xB8, 0x0F, 0x01, 0xDC, 0x07,
  0x80, 0xEE, 0x07, 0xC0, 0x67, 0x03, 0x60, 0x73, 0x81, 0xB0, 0x31, 0xC1,
  0xD8, 0x38, 0xE0, 0xCC, 0x1C, 0x70, 0xE6, 0x0C, 0x38, 0x63, 0x0E, 0x1C,
  0x31, 0x86, 0x0E, 0x38, 0xC7, 0x07, 0x18, 0x63, 0x83, 0x9C, 0x31, 0x81,
  0x8C, 0x19, 0xC0, 0xC6, 0x0C, 0xC0, 0x67, 0x0E, 0x60, 0x33, 0x07, 0x70,
  0x1B, 0x83, 0xB0, 0x0D, 0x81, 0xF8, 0x06, 0xC0, 0xF8, 0x03, 0xE0, 0x6C,
  0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x18, 0x1C,
  0x01, 0x83, 0x80, 0x1C, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x00, 0xCE,
  0x00, 0x0D, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xB0, 0x00, 0x33, 0x00, 0x07,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x18, 0x03,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x0C, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x1C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x38, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x70, 0x00, 0x60, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60,
  0xC0, 0x00, 0x61, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63, 0x80, 0x00, 0x63,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x8E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x10,
  0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x5F, 0xE0, 0x1F, 0xFE, 0x0F, 0x07, 0xFF, 0x80, 0x7F, 0xA0,
  0x01, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 36, 11, 1, -36 },
  { 51, 12, 13, 15, 5, -36 },
  { 71, 21, 36, 20, 0, -36 },
  { 166, 20, 42, 19, 0, -39 },
  { 271, 25, 38, 29, 2, -37 },
  { 390, 18, 38, 19, 0, -37 },
  { 476, 5, 13, 8, 5, -36 },
  { 485, 15, 44, 13, 1, -36 },
  { 568, 15, 44, 13, -4, -36 },
  { 651, 14, 16, 17, 6, -39 },
  { 679, 18, 24, 21, 2, -30 },
  { 733, 7, 12, 9, -2, -5 },
  { 744, 11, 2, 13, 1, -15 },
  { 747, 4, 5, 9, 1, -5 },
  { 750, 22, 36, 16, -2, -36 },
  { 849, 18, 38, 19, 1, -37 },
  { 935, 10, 36, 19, 6, -36 },
  { 980, 21, 37, 19, -2, -37 },
  { 1078, 20, 38, 19, -1, -37 },
  { 1173, 20, 37, 19, -1, -37 },
  { 1266, 20, 37, 19, -1, -36 },
  { 1359, 19, 38, 19, 1, -37 },
  { 1450, 19, 36, 19, 2, -36 },
  { 1536, 20, 38, 19, -1, -37 },
  { 1631, 18, 38, 19, 0, -37 },
  { 1717, 9, 27, 9, 0, -27 },
  { 1748, 11, 34, 9, -2, -27 },
  { 1795, 18, 22, 21, 2, -29 },
  { 1845, 18, 14, 21, 2, -25 },
  { 1877, 18, 22, 21, 2, -29 },
  { 1927, 15, 37, 14, 1, -37 },
  { 1997, 26, 41, 28, 1, -37 },
  { 2131, 18, 37, 19, -3, -37 },
  { 2215, 21, 36, 21, 0, -36 },
  { 2310, 20, 38, 18, 2, -37 },
  { 2405, 21, 36, 22, 0, -36 },
  { 2500, 20, 36, 18, 0, -36 },
  { 2590, 20, 36, 17, 0, -36 },
  { 2680, 23, 38, 24, 2, -37 },
  { 2790, 24, 36, 24, 0, -36 },
  { 2898, 17, 36, 11, -3, -36 },
  { 2975, 18, 45, 9, -7, -36 },
  { 3077, 23, 36, 19, 0, -36 },
  { 3181, 13, 36, 16, 0, -36 },
  { 3240, 32, 36, 31, 0, -36 },
  { 3384, 26, 36, 25, 0, -36 },
  { 3501, 21, 38, 24, 2, -37 },
  { 3601, 20, 36, 19, 0, -36 },
  { 3691, 21, 46, 24, 2, -37 },
  { 3812, 20, 36, 20, 0, -36 },
  { 3902, 21, 38, 18, -1, -37 },
  { 4002, 17, 36, 16, 3, -36 },
  { 4079, 22, 37, 23, 2, -36 },
  { 4181, 19, 36, 19, 4, -36 },
  { 4267, 32, 36, 32, 4, -36 },
  { 4411, 24, 36, 17, -3, -36 },
  { 4519, 18, 36, 16, 3, -36 },
  { 4600, 21, 36, 16, -2, -36 },
  { 4695, 19, 45, 14, -1, -37 },
  { 4802, 8, 37, 17, 5, -37 },
  { 4839, 18, 45, 14, -3, -37 },
  { 4941, 19, 18, 20, 1, -36 },
  { 4984, 14, 3, 14, -4, 4 },
  { 4990, 6, 8, 12, 7, -39 },
  { 4996, 19, 29, 20, 1, -28 },
  { 5065, 19, 40, 20, 0, -39 },
  { 5160, 15, 29, 15, 1, -28 },
  { 5215, 22, 40, 20, 1, -39 },
  { 5325, 16, 29, 18, 1, -28 },
  { 5383, 23, 51, 11, -6, -39 },
  { 5530, 21, 40, 20, -1, -28 },
  { 5635, 18, 39, 20, 0, -39 },
  { 5723, 11, 37, 9, 0, -37 },
  { 5774, 18, 49, 9, -7, -37 },
  { 5885, 19, 39, 17, 0, -39 },
  { 5978, 11, 39, 9, 0, -39 },
  { 6032, 28, 28, 30, 0, -28 },
  { 6130, 18, 28, 20, 0, -28 },
  { 6193, 17, 29, 20, 1, -28 },
  { 6255, 21, 40, 20, -2, -28 },
  { 6360, 19, 40, 20, 1, -28 },
  { 6455, 15, 28, 13, 0, -28 },
  { 6508, 17, 29, 15, -1, -28 },
  { 6570, 11, 35, 11, 1, -34 },
  { 6619, 18, 28, 20, 1, -27 },
  { 6682, 15, 27, 16, 3, -27 },
  { 6733, 25, 27, 26, 3, -27 },
  { 6818, 20, 27, 16, -2, -27 },
  { 6886, 24, 39, 16, -5, -27 },
  { 7003, 17, 27, 13, -2, -27 },
  { 7061, 18, 44, 16, 1, -36 },
  { 7160, 2, 51, 18, 8, -39 },
  { 7173, 18, 44, 16, -3, -36 },
  { 7272, 18, 6, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC51PT7B_H_
