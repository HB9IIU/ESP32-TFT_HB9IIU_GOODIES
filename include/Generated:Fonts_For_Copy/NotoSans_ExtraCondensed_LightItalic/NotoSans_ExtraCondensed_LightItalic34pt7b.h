#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0xE0, 0x33, 0x23, 0x63, 0x62, 0x62, 0x46, 0x46, 0xC4, 0xC4, 0x01, 0x8C,
  0x06, 0x20, 0x10, 0x80, 0xC6, 0x03, 0x10, 0x08, 0x40, 0x23, 0x0F, 0xFF,
  0x04, 0x20, 0x11, 0x80, 0xC6, 0x02, 0x10, 0x08, 0xC0, 0x63, 0x01, 0x88,
  0x3F, 0xFC, 0x31, 0x80, 0xC4, 0x02, 0x10, 0x18, 0xC0, 0x62, 0x01, 0x08,
  0x04, 0x60, 0x31, 0x80, 0x00, 0x40, 0x02, 0x00, 0x30, 0x07, 0xE0, 0xFF,
  0x86, 0x44, 0x62, 0x03, 0x20, 0x11, 0x00, 0xC8, 0x06, 0x40, 0x1A, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x06, 0xC0, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x06, 0x63, 0x26, 0x1F, 0xE0, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x00, 0x0C, 0x02, 0x1E, 0x04, 0x32, 0x0C, 0x62, 0x08, 0x62, 0x18,
  0x42, 0x10, 0xC2, 0x30, 0xC2, 0x20, 0x86, 0x60, 0x86, 0x40, 0x84, 0xCE,
  0x84, 0x9F, 0x8D, 0xB3, 0x99, 0x23, 0xF3, 0x63, 0x22, 0x63, 0x06, 0x43,
  0x04, 0xC3, 0x0C, 0xC2, 0x08, 0xC2, 0x18, 0xC6, 0x10, 0xC4, 0x30, 0xCC,
  0x20, 0xC8, 0x60, 0x78, 0x00, 0x80, 0x3E, 0x06, 0x60, 0x46, 0x0C, 0x60,
  0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xD8, 0x0D, 0x00, 0x60, 0x0E, 0x01,
  0xE0, 0x32, 0x36, 0x33, 0x63, 0x3C, 0x16, 0xC1, 0xEC, 0x1C, 0xC1, 0xCC,
  0x1C, 0xC3, 0xCE, 0xEC, 0x7C, 0x60, 0x32, 0x66, 0x64, 0x44, 0xC0, 0x01,
  0xC0, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x00,
  0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x22,
  0x19, 0x07, 0xB8, 0xF0, 0xF0, 0xC8, 0xC6, 0x21, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0x8C, 0xC6,
  0x62, 0x00, 0xFF, 0xFC, 0x7D, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x01, 0x80, 0xF8, 0x39, 0x86, 0x31, 0x82, 0x20, 0x4C,
  0x09, 0x81, 0x20, 0x6C, 0x0D, 0x81, 0xB0, 0x34, 0x07, 0x80, 0xF0, 0x36,
  0x06, 0xC0, 0xD8, 0x1A, 0x06, 0x40, 0xC8, 0x11, 0x86, 0x31, 0x87, 0x70,
  0x7C, 0x00, 0x0E, 0x38, 0xF3, 0x6C, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60,
  0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0x00,
  0xC0, 0x1F, 0xC0, 0x61, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xC0, 0x1F, 0xC0, 0x61,
  0x81, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x30,
  0xE0, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x58,
  0x03, 0x60, 0x09, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x63, 0x01, 0x08,
  0x0C, 0x60, 0x61, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x07, 0xFF,
  0x20, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03,
  0xFC, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x6C, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x0E, 0x38, 0x3F, 0xC0, 0x00, 0x60, 0x3F, 0x07, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x67, 0x87, 0xFC, 0x70,
  0xCE, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1,
  0x8C, 0x18, 0xC3, 0x06, 0x70, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x01, 0xC0,
  0x3F, 0x83, 0x8C, 0x18, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x02, 0x18,
  0x30, 0x63, 0x03, 0x30, 0x0F, 0x00, 0x70, 0x0E, 0xC0, 0xC6, 0x0C, 0x18,
  0xC0, 0xC6, 0x03, 0x30, 0x19, 0x00, 0xC8, 0x04, 0x60, 0x63, 0x03, 0x0E,
  0x70, 0x3F, 0x00, 0x00, 0x80, 0x7E, 0x0E, 0x70, 0xC3, 0x18, 0x31, 0x81,
  0x30, 0x13, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x07, 0x30, 0x73, 0x0E,
  0x1F, 0xE0, 0xE6, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0x08, 0xE0, 0xF8, 0x00, 0x0C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0xE3, 0x00, 0x03, 0x07, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x30, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70, 0x1E,
  0x07, 0x80, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x02,
  0x07, 0xF1, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x60, 0x00, 0x00, 0xFE, 0x01, 0xC1, 0x81,
  0x80, 0x41, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x04, 0x41, 0xC2, 0x61, 0xF1,
  0x21, 0x98, 0xB1, 0x88, 0x58, 0x84, 0x68, 0xC6, 0x34, 0x63, 0x16, 0x21,
  0x0B, 0x10, 0x8D, 0x98, 0xC6, 0x8C, 0x62, 0x46, 0x73, 0x21, 0x2B, 0x10,
  0xE7, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xB0, 0x1B, 0x01, 0xB0, 0x13, 0x03, 0x30, 0x33, 0x06, 0x30, 0x63, 0x0C,
  0x30, 0xC3, 0x0F, 0xF1, 0x83, 0x18, 0x33, 0x03, 0x30, 0x33, 0x03, 0x60,
  0x36, 0x03, 0xC0, 0x3C, 0x03, 0x07, 0xF0, 0x18, 0xE0, 0x41, 0xC3, 0x03,
  0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC2, 0x06, 0x18, 0x18, 0x60, 0xC1, 0xFE,
  0x07, 0xF0, 0x30, 0xE0, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x20, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x18, 0x60, 0x61, 0x03, 0x0F, 0xF8, 0x3F, 0x80, 0x00,
  0x70, 0x07, 0xF0, 0x30, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0E, 0x60, 0x1F, 0x80, 0x07, 0xF0, 0x19, 0xE0, 0x41,
  0x83, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC2, 0x03, 0x18, 0x0C, 0x60,
  0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x20,
  0x19, 0x80, 0xC6, 0x03, 0x18, 0x18, 0x60, 0xC1, 0x06, 0x0F, 0xF0, 0x3F,
  0x00, 0x07, 0xF8, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xF8, 0x3F, 0xC3, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x43,
  0xFC, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0xFF, 0x03,
  0x86, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0xFC, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0,
  0x30, 0x60, 0x30, 0x60, 0x30, 0x38, 0xE0, 0x1F, 0xE0, 0x06, 0x03, 0x06,
  0x03, 0x04, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x08,
  0x06, 0x18, 0x04, 0x18, 0x0C, 0x1F, 0xFC, 0x1F, 0xFC, 0x30, 0x0C, 0x30,
  0x08, 0x30, 0x18, 0x30, 0x18, 0x20, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60,
  0x30, 0x60, 0x30, 0x40, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0x07, 0xF0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xE0, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0xF8, 0x0F, 0x00, 0x06, 0x06, 0x0C, 0x18, 0x10, 0x60,
  0x60, 0xC0, 0xC3, 0x01, 0x8C, 0x03, 0x38, 0x04, 0x60, 0x19, 0x80, 0x36,
  0x00, 0x6C, 0x00, 0xB8, 0x03, 0xF0, 0x07, 0x60, 0x0C, 0x40, 0x18, 0xC0,
  0x21, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x30,
  0x30, 0x60, 0x70, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x40, 0xFF, 0xFF, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x58, 0x3C, 0x03, 0x40, 0xF0, 0x0B, 0x02, 0xC0,
  0x6C, 0x19, 0x01, 0xB0, 0x64, 0x0C, 0xC1, 0x90, 0x32, 0x04, 0x41, 0x98,
  0x31, 0x06, 0x60, 0xC4, 0x31, 0x83, 0x10, 0xC4, 0x0C, 0x46, 0x30, 0x21,
  0x98, 0xC1, 0x86, 0x43, 0x06, 0x1B, 0x0C, 0x18, 0x68, 0x20, 0x61, 0xE1,
  0x81, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x60, 0x07, 0x01, 0x83,
  0x80, 0xC1, 0xC0, 0x61, 0xE0, 0x20, 0xD0, 0x30, 0x68, 0x18, 0x36, 0x0C,
  0x13, 0x06, 0x19, 0x82, 0x0C, 0xC3, 0x06, 0x21, 0x82, 0x10, 0xC3, 0x0C,
  0x41, 0x86, 0x60, 0xC3, 0x30, 0x61, 0x98, 0x20, 0x4C, 0x30, 0x24, 0x18,
  0x1E, 0x0C, 0x0F, 0x06, 0x07, 0x82, 0x03, 0xC3, 0x00, 0xC1, 0x80, 0x60,
  0x00, 0x40, 0x0F, 0xE0, 0x71, 0xC3, 0x83, 0x0C, 0x0C, 0x60, 0x31, 0x80,
  0x4C, 0x01, 0x30, 0x0C, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80,
  0x3C, 0x00, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0,
  0x63, 0x01, 0x86, 0x0C, 0x1C, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x33, 0x81,
  0x06, 0x18, 0x30, 0xC0, 0x86, 0x04, 0x30, 0x61, 0x03, 0x18, 0x18, 0xC0,
  0xC6, 0x0C, 0x30, 0xC3, 0xFC, 0x1F, 0xC0, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x0F, 0xE0, 0x71, 0xC3, 0x83, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0x4C,
  0x01, 0x30, 0x0C, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x3C,
  0x00, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x63,
  0x01, 0x86, 0x0C, 0x1C, 0xE0, 0x3F, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x33, 0x81, 0x06, 0x18,
  0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C,
  0x31, 0xC3, 0xFC, 0x18, 0x80, 0xC6, 0x06, 0x30, 0x21, 0x83, 0x0C, 0x18,
  0x60, 0xC1, 0x06, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x18, 0x00, 0x60, 0x0F,
  0xF0, 0x70, 0xC3, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x88,
  0x0C, 0x3D, 0xE0, 0xFF, 0x00, 0x7F, 0xE0, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x0C, 0x06, 0x18, 0x0C, 0x60, 0x10, 0xC0, 0x61, 0x80, 0xC3,
  0x01, 0x84, 0x03, 0x18, 0x04, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x00,
  0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x21, 0x80, 0xC3,
  0x01, 0x86, 0x02, 0x0C, 0x0C, 0x18, 0x18, 0x1C, 0xE0, 0x1F, 0x80, 0xC0,
  0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x18, 0xC1,
  0x8C, 0x30, 0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD8,
  0x0D, 0x80, 0xD0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x60,
  0x30, 0x0D, 0x80, 0xC0, 0x66, 0x07, 0x01, 0x98, 0x1C, 0x0C, 0x60, 0x50,
  0x31, 0x83, 0x40, 0xC6, 0x0F, 0x06, 0x18, 0x6C, 0x18, 0x61, 0xB0, 0xC1,
  0x04, 0xC3, 0x04, 0x33, 0x0C, 0x10, 0xCC, 0x60, 0x42, 0x31, 0x81, 0x18,
  0xCC, 0x04, 0x43, 0x30, 0x13, 0x0C, 0xC0, 0x4C, 0x36, 0x01, 0x20, 0xD8,
  0x05, 0x83, 0x40, 0x14, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0xC0, 0xE0, 0x0E,
  0x03, 0x80, 0x38, 0x0C, 0x00, 0x03, 0x03, 0x03, 0x06, 0x03, 0x0C, 0x03,
  0x0C, 0x03, 0x18, 0x01, 0x18, 0x01, 0x30, 0x01, 0xB0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x10, 0x40, 0x30, 0x40, 0x60,
  0x60, 0x60, 0x60, 0xC0, 0x60, 0x60, 0x36, 0x06, 0x60, 0x46, 0x0C, 0x60,
  0x86, 0x18, 0x21, 0x02, 0x30, 0x26, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03,
  0xF8, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0F, 0xE0, 0x00, 0xC2,
  0x10, 0xC6, 0x31, 0x84, 0x21, 0x0C, 0x63, 0x18, 0xC2, 0x10, 0xC6, 0x31,
  0x8C, 0x21, 0x03, 0xF0, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFC, 0x00, 0x03, 0x00,
  0x70, 0x07, 0x80, 0xD8, 0x0C, 0xC1, 0x8C, 0x10, 0xC3, 0x06, 0x20, 0x66,
  0x02, 0xC0, 0x3C, 0x03, 0xFF, 0xC0, 0xCC, 0x62, 0x30, 0x07, 0x91, 0xCD,
  0x18, 0x73, 0x07, 0x30, 0x66, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x04,
  0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x38, 0x67, 0x87, 0xD8,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0D, 0xE0, 0x51, 0x87, 0x0C, 0x38, 0x31, 0x81, 0x8C, 0x0C, 0x40,
  0x66, 0x02, 0x30, 0x31, 0x81, 0x88, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x31,
  0x83, 0x0E, 0x18, 0xD3, 0x86, 0xF8, 0x00, 0x07, 0xC7, 0x11, 0x80, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x62, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x07, 0x90, 0x73, 0xC1,
  0x87, 0x0C, 0x1C, 0x30, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0xC0, 0x63,
  0x01, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x07, 0x0C, 0x18, 0x30, 0xE0,
  0xE7, 0x81, 0xF6, 0x00, 0x07, 0xC7, 0x31, 0x84, 0xC1, 0x20, 0x58, 0x36,
  0x19, 0x0E, 0xFE, 0x3C, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x63, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x03, 0xF0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xE4, 0x1C, 0xD0, 0x61,
  0xC3, 0x07, 0x0C, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06, 0x30, 0x18, 0xC0,
  0x43, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC1, 0xC3, 0x06, 0x0C, 0x38, 0x39,
  0xE0, 0x7D, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x20,
  0x60, 0xEF, 0x01, 0xF8, 0x00, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0D, 0xE0, 0xA7, 0x1C, 0x31, 0x83, 0x18,
  0x31, 0x83, 0x10, 0x33, 0x02, 0x30, 0x63, 0x06, 0x20, 0x62, 0x04, 0x60,
  0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0x8C, 0x18, 0x02, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x41,
  0x83, 0x06, 0x0C, 0x10, 0x60, 0xC0, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x07, 0x80, 0xE0, 0x00, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x81, 0x0C, 0x30, 0x43, 0x06, 0x18, 0x31, 0x81,
  0x98, 0x0D, 0x80, 0x4C, 0x06, 0xC0, 0x3E, 0x01, 0xD8, 0x0C, 0xC0, 0xC6,
  0x06, 0x30, 0x31, 0x81, 0x84, 0x08, 0x30, 0xC1, 0x86, 0x0C, 0x00, 0x02,
  0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x04,
  0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x80, 0x0B, 0xE7,
  0xC1, 0x4F, 0x9C, 0x70, 0xE1, 0x8C, 0x18, 0x31, 0x83, 0x06, 0x30, 0x60,
  0x84, 0x08, 0x31, 0x83, 0x06, 0x30, 0x60, 0xC6, 0x0C, 0x10, 0x81, 0x02,
  0x30, 0x60, 0xC6, 0x0C, 0x18, 0xC1, 0x83, 0x18, 0x30, 0x42, 0x04, 0x18,
  0xC1, 0x83, 0x18, 0x30, 0x60, 0x09, 0xE0, 0xA7, 0x1C, 0x31, 0x83, 0x18,
  0x31, 0x83, 0x10, 0x33, 0x02, 0x30, 0x63, 0x06, 0x20, 0x66, 0x04, 0x60,
  0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0x8C, 0x18, 0x0F, 0xC3, 0x98, 0x61,
  0x98, 0x32, 0x06, 0xC0, 0xD8, 0x1A, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x60,
  0x6C, 0x0D, 0x81, 0x30, 0x66, 0x18, 0x67, 0x0F, 0xC0, 0x02, 0x78, 0x05,
  0x18, 0x1C, 0x10, 0x38, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x01, 0x86, 0x02,
  0x0C, 0x0C, 0x18, 0x18, 0x20, 0x30, 0xC0, 0x61, 0x81, 0x83, 0x03, 0x06,
  0x0C, 0x0C, 0x18, 0x34, 0xE0, 0x6F, 0x80, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x00, 0x07, 0x91,
  0xCD, 0x18, 0x73, 0x07, 0x30, 0x66, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C,
  0x04, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x38, 0xE7, 0x87,
  0xD8, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x09, 0xC2, 0xD1, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x00,
  0x0F, 0xC6, 0x33, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xCE, 0x3F, 0x00, 0x0C,
  0x10, 0x60, 0xC7, 0xE6, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x83, 0x04, 0x0D, 0x1E, 0x00, 0x18, 0x31, 0x03, 0x30, 0x23,
  0x06, 0x30, 0x62, 0x06, 0x60, 0x46, 0x0C, 0x60, 0xC6, 0x0C, 0x40, 0xCC,
  0x08, 0xC1, 0x8C, 0x18, 0xC3, 0x8C, 0x38, 0xED, 0x07, 0x90, 0xC0, 0xF0,
  0x2C, 0x1B, 0x04, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xC4, 0x33, 0x0C, 0x83,
  0x60, 0xD8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x30, 0x00, 0xC1, 0x81, 0xE0,
  0xC1, 0xB0, 0x60, 0xD8, 0x70, 0xCC, 0x28, 0x66, 0x34, 0x23, 0x12, 0x31,
  0x99, 0x18, 0xCC, 0x88, 0x64, 0x4C, 0x36, 0x24, 0x1A, 0x16, 0x0F, 0x0B,
  0x07, 0x85, 0x03, 0x83, 0x81, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0xE0, 0x00,
  0x06, 0x0C, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x02, 0x60, 0x09, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0x60, 0x0D, 0x80, 0x62,
  0x01, 0x8C, 0x0C, 0x30, 0x60, 0xC3, 0x83, 0x00, 0x03, 0x03, 0x80, 0x81,
  0x80, 0x40, 0x80, 0x20, 0xC0, 0x10, 0x60, 0x08, 0x60, 0x04, 0x30, 0x02,
  0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x16, 0x00,
  0x0B, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x98,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x03, 0x80, 0xE0, 0x07, 0x00, 0x10, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x1C, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x1F, 0xE1, 0x83, 0xF8, 0x0E,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 24, 7, 0, -24 },
  { 25, 8, 9, 10, 3, -24 },
  { 34, 14, 24, 13, 0, -24 },
  { 76, 13, 28, 12, 0, -26 },
  { 122, 16, 25, 19, 2, -25 },
  { 172, 12, 25, 13, 0, -25 },
  { 210, 4, 9, 6, 3, -24 },
  { 215, 10, 29, 8, 1, -24 },
  { 252, 9, 29, 9, -2, -24 },
  { 285, 9, 10, 12, 4, -26 },
  { 297, 12, 16, 14, 1, -20 },
  { 321, 5, 7, 6, -1, -3 },
  { 326, 7, 2, 9, 1, -10 },
  { 328, 3, 3, 6, 0, -3 },
  { 330, 15, 24, 11, -2, -24 },
  { 375, 11, 25, 12, 1, -25 },
  { 410, 7, 24, 12, 4, -24 },
  { 431, 14, 25, 12, -1, -25 },
  { 475, 14, 25, 12, -1, -25 },
  { 519, 14, 25, 12, -1, -25 },
  { 563, 14, 24, 12, -1, -24 },
  { 605, 12, 25, 12, 1, -25 },
  { 643, 13, 24, 12, 1, -24 },
  { 682, 13, 25, 12, 0, -25 },
  { 723, 12, 25, 12, 0, -25 },
  { 761, 6, 18, 6, 0, -18 },
  { 775, 8, 22, 6, -2, -18 },
  { 797, 12, 14, 14, 1, -19 },
  { 818, 12, 8, 14, 1, -16 },
  { 830, 12, 14, 14, 1, -19 },
  { 851, 10, 25, 9, 0, -25 },
  { 883, 17, 27, 19, 1, -24 },
  { 941, 12, 24, 12, -2, -24 },
  { 977, 14, 24, 14, 0, -24 },
  { 1019, 14, 25, 12, 1, -25 },
  { 1063, 14, 24, 15, 0, -24 },
  { 1105, 13, 24, 12, 0, -24 },
  { 1144, 13, 24, 11, 0, -24 },
  { 1183, 16, 25, 16, 1, -25 },
  { 1233, 16, 24, 16, 0, -24 },
  { 1281, 12, 24, 7, -2, -24 },
  { 1317, 12, 30, 6, -5, -24 },
  { 1362, 15, 24, 13, 0, -24 },
  { 1407, 8, 24, 11, 0, -24 },
  { 1431, 22, 24, 21, 0, -24 },
  { 1497, 17, 24, 17, 0, -24 },
  { 1548, 14, 25, 16, 1, -25 },
  { 1592, 13, 24, 13, 0, -24 },
  { 1631, 14, 31, 16, 1, -25 },
  { 1686, 13, 24, 13, 0, -24 },
  { 1725, 14, 25, 12, -1, -25 },
  { 1769, 11, 24, 11, 2, -24 },
  { 1802, 15, 24, 15, 1, -24 },
  { 1847, 12, 24, 13, 3, -24 },
  { 1883, 22, 24, 21, 2, -24 },
  { 1949, 16, 24, 11, -2, -24 },
  { 1997, 12, 24, 11, 2, -24 },
  { 2033, 14, 24, 11, -1, -24 },
  { 2075, 13, 29, 9, -1, -24 },
  { 2123, 5, 24, 11, 3, -24 },
  { 2138, 12, 29, 9, -2, -24 },
  { 2182, 12, 12, 13, 1, -24 },
  { 2200, 10, 1, 10, -3, 3 },
  { 2202, 4, 5, 8, 5, -26 },
  { 2205, 12, 18, 14, 1, -18 },
  { 2232, 13, 26, 13, 0, -26 },
  { 2275, 10, 18, 10, 1, -18 },
  { 2298, 14, 26, 14, 1, -26 },
  { 2344, 10, 18, 12, 1, -18 },
  { 2367, 15, 34, 7, -4, -26 },
  { 2431, 14, 26, 14, -1, -18 },
  { 2477, 12, 26, 13, 0, -26 },
  { 2516, 7, 25, 6, 0, -25 },
  { 2538, 11, 33, 6, -4, -25 },
  { 2584, 13, 26, 11, 0, -26 },
  { 2627, 7, 26, 6, 0, -26 },
  { 2650, 19, 18, 20, 0, -18 },
  { 2693, 12, 18, 13, 0, -18 },
  { 2720, 11, 18, 13, 1, -18 },
  { 2745, 15, 26, 13, -2, -18 },
  { 2794, 12, 26, 14, 1, -18 },
  { 2833, 10, 18, 9, 0, -18 },
  { 2856, 10, 18, 10, 0, -18 },
  { 2879, 7, 22, 7, 1, -22 },
  { 2899, 12, 18, 13, 1, -18 },
  { 2926, 10, 18, 10, 2, -18 },
  { 2949, 17, 18, 17, 2, -18 },
  { 2988, 14, 18, 11, -2, -18 },
  { 3020, 17, 26, 11, -4, -18 },
  { 3076, 11, 18, 9, -1, -18 },
  { 3101, 12, 29, 11, 1, -24 },
  { 3145, 2, 34, 12, 5, -26 },
  { 3154, 12, 29, 11, -2, -24 },
  { 3198, 12, 4, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC34PT7B_H_
