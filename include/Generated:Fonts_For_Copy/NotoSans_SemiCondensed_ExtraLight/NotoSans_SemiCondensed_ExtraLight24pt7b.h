#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF9, 0x80, 0x99, 0x99, 0x99, 0x08, 0x40, 0x84, 0x08, 0x40,
  0x88, 0x08, 0x8F, 0xFF, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10, 0x11, 0x0F,
  0xFE, 0x21, 0x02, 0x10, 0x21, 0x02, 0x20, 0x22, 0x00, 0x08, 0x07, 0x86,
  0x99, 0x20, 0x88, 0x22, 0x08, 0x81, 0x20, 0x38, 0x03, 0x00, 0xB0, 0x22,
  0x08, 0x82, 0x10, 0x88, 0x22, 0xEB, 0x07, 0x00, 0x80, 0x78, 0x10, 0x88,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x44, 0x10, 0x88, 0x21, 0x26, 0x42, 0x52,
  0x45, 0x22, 0xF2, 0x84, 0x09, 0x08, 0x12, 0x10, 0x44, 0x20, 0x88, 0x42,
  0x10, 0x84, 0x11, 0x10, 0x3C, 0x1F, 0x01, 0x08, 0x08, 0x40, 0x41, 0x02,
  0x10, 0x10, 0x80, 0x48, 0x01, 0x80, 0x34, 0x03, 0x30, 0x90, 0x85, 0x02,
  0x28, 0x0A, 0x40, 0x33, 0x01, 0x88, 0x12, 0x3F, 0x18, 0xFC, 0x19, 0x08,
  0x84, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x43, 0x08, 0x21, 0x80,
  0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x44, 0x80, 0x08,
  0x04, 0x02, 0x1D, 0x71, 0xC0, 0xA0, 0x48, 0x46, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x55, 0xA0,
  0xF8, 0xC0, 0x03, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x1F, 0x08, 0x64, 0x09, 0x02,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50,
  0x24, 0x08, 0x84, 0x1E, 0x00, 0x09, 0xD3, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x3F, 0x10, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0xC0, 0x7F, 0x20, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x18,
  0x3E, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x10, 0x0A, 0x06, 0xFF, 0x00,
  0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x81, 0x08,
  0x10, 0x82, 0x08, 0x40, 0x84, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFC, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x05, 0x06, 0xFC, 0x00, 0x0F, 0x84,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0xE2, 0xC4, 0xA0, 0xB0, 0x18, 0x06,
  0x01, 0x40, 0x50, 0x14, 0x08, 0x82, 0x1F, 0x00, 0xFF, 0xC0, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x00, 0x3F, 0x10, 0x24, 0x09, 0x02, 0x40,
  0x90, 0x22, 0x10, 0x78, 0x1E, 0x08, 0x64, 0x0A, 0x01, 0x80, 0x60, 0x14,
  0x05, 0x02, 0x3F, 0x00, 0x3E, 0x10, 0x44, 0x0A, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x41, 0x4D, 0xD0, 0x84, 0x02, 0x00, 0x80, 0x20, 0x10, 0x08,
  0x7C, 0x00, 0xC0, 0x18, 0x50, 0x00, 0x05, 0x5A, 0x00, 0x40, 0x60, 0x60,
  0x60, 0x60, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x04, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x00, 0xFC, 0x0C, 0x08, 0x10, 0x20,
  0x41, 0x04, 0x10, 0x40, 0x81, 0x02, 0x00, 0x00, 0x10, 0x20, 0x03, 0xF0,
  0x06, 0x06, 0x04, 0x00, 0x84, 0x00, 0x44, 0x00, 0x12, 0x0F, 0x89, 0x08,
  0x45, 0x08, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x50, 0x84, 0x28,
  0x43, 0x12, 0x1E, 0xF1, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0xFC, 0x00, 0x02, 0x00, 0x60, 0x05, 0x00, 0x90, 0x09, 0x00, 0x88,
  0x10, 0x81, 0x08, 0x10, 0x42, 0x04, 0x3F, 0xC2, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x18, 0x01, 0x80, 0x10, 0xFF, 0x20, 0x28, 0x0A, 0x01, 0x80, 0x60,
  0x28, 0x0A, 0x1C, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x02, 0xFF, 0x00, 0x0F, 0xE2, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x0F, 0xE0, 0xFF, 0x10, 0x32, 0x01, 0x40, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0, 0x14,
  0x0C, 0xFE, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x0F, 0xF8, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x81, 0xFC, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xB0, 0x04,
  0x80, 0x22, 0x01, 0x0F, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x1F, 0x00, 0x80, 0xE0, 0x68, 0x12, 0x08, 0x84, 0x22, 0x09,
  0x02, 0xC0, 0xA8, 0x32, 0x08, 0x42, 0x18, 0x82, 0x20, 0x48, 0x1A, 0x02,
  0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x07, 0x80, 0x0E, 0x80,
  0x2D, 0x00, 0x5A, 0x01, 0x32, 0x02, 0x64, 0x04, 0xC8, 0x11, 0x88, 0x23,
  0x10, 0x46, 0x11, 0x0C, 0x22, 0x18, 0x44, 0x30, 0x50, 0x60, 0xA0, 0xC1,
  0x81, 0x81, 0x02, 0xC0, 0x38, 0x06, 0x80, 0xD0, 0x19, 0x03, 0x30, 0x62,
  0x0C, 0x21, 0x84, 0x30, 0x46, 0x08, 0xC0, 0x98, 0x0B, 0x01, 0x60, 0x1C,
  0x03, 0x80, 0x20, 0x0F, 0xC0, 0xC0, 0xC2, 0x01, 0x10, 0x02, 0x40, 0x09,
  0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x02,
  0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0xFE, 0x40, 0xA0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x83, 0x7E, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xC0, 0xC2, 0x01, 0x10, 0x02,
  0x40, 0x09, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00,
  0x50, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x04, 0x86, 0x3F, 0x08, 0x42, 0x08, 0x83, 0x20, 0x48,
  0x0A, 0x02, 0x80, 0x40, 0x3F, 0x90, 0x04, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0xC0, 0x0E, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x20, 0x08, 0x06,
  0xFE, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x1B, 0x02,
  0x1F, 0x80, 0x80, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x20,
  0x42, 0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x90, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x40, 0x28, 0x08, 0x09, 0x02, 0x81, 0x20,
  0x50, 0x22, 0x0A, 0x04, 0x41, 0x41, 0x08, 0x44, 0x21, 0x08, 0x84, 0x11,
  0x10, 0x82, 0x22, 0x20, 0x48, 0x24, 0x09, 0x04, 0x80, 0xA0, 0x90, 0x14,
  0x14, 0x03, 0x01, 0x80, 0x60, 0x30, 0x04, 0x06, 0x00, 0x40, 0x68, 0x08,
  0x82, 0x08, 0x41, 0x10, 0x12, 0x02, 0x80, 0x30, 0x04, 0x01, 0x40, 0x28,
  0x08, 0x81, 0x08, 0x41, 0x10, 0x12, 0x02, 0x80, 0x20, 0x80, 0x68, 0x09,
  0x01, 0x10, 0x42, 0x08, 0x22, 0x04, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xC0, 0x20,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x10, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0xC0, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02,
  0x02, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0xF0, 0x04, 0x03, 0x01, 0x20, 0x48, 0x21, 0x08, 0x44, 0x09, 0x02, 0x80,
  0x60, 0x10, 0xFF, 0xC0, 0xC4, 0x30, 0x3E, 0x41, 0x01, 0x01, 0x01, 0x01,
  0x3F, 0x41, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x27, 0x8A, 0x13, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x01, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0xC1, 0x2F, 0x80, 0x0F, 0x30, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x47, 0x92, 0x15, 0x03, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x05, 0x03, 0x60, 0xCF, 0xD0, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C,
  0x07, 0xFF, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0xF8, 0x1E, 0x20, 0x81,
  0x02, 0x1F, 0x88, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x1E, 0x48, 0x54, 0x0D, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x50, 0x14, 0x0D, 0x85, 0x3E, 0x40, 0x10, 0x04, 0x01, 0x00, 0x90, 0x63,
  0xE0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xF2, 0x85, 0x82, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x8F, 0xFF,
  0x80, 0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13,
  0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x83, 0x82, 0x84, 0x88, 0x90, 0xB0,
  0xB0, 0xC8, 0x88, 0x84, 0x82, 0x82, 0x81, 0xFF, 0xFF, 0xC0, 0xBC, 0x79,
  0x85, 0x0B, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x9E,
  0x50, 0xB0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0x1E, 0x08, 0x64, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x14, 0x08, 0x82, 0x1F, 0x00, 0x9E, 0x28, 0x4C, 0x0A, 0x02,
  0x80, 0xA0, 0x28, 0x06, 0x02, 0x80, 0xA0, 0x2C, 0x0B, 0x04, 0xBE, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1E, 0x48, 0x54, 0x0D, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x0D, 0x85, 0x3E, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x9E, 0x8C, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x80, 0x3E, 0x41, 0x80, 0x80, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x01, 0x01, 0x82, 0xFC, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x07, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x78, 0x57, 0xC8, 0x80, 0xC0, 0x50,
  0x28, 0x24, 0x11, 0x08, 0x88, 0x44, 0x12, 0x0A, 0x05, 0x01, 0x80, 0x80,
  0x81, 0x02, 0x83, 0x05, 0x06, 0x0A, 0x14, 0x24, 0x24, 0x44, 0x48, 0x88,
  0x91, 0x12, 0x24, 0x24, 0x28, 0x28, 0x50, 0x60, 0xA0, 0xC0, 0x80, 0x81,
  0x00, 0x40, 0xD8, 0x22, 0x10, 0x44, 0x12, 0x03, 0x00, 0x40, 0x30, 0x12,
  0x04, 0x42, 0x11, 0x02, 0xC0, 0xC0, 0x80, 0x50, 0x24, 0x09, 0x02, 0x21,
  0x08, 0x42, 0x10, 0x48, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x0C, 0x0E, 0x00, 0xFE, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x08, 0x20, 0xC1, 0x04, 0x0F, 0xE0, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x8C, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x04, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0x60, 0xC4, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x08, 0xC0, 0x30, 0x33, 0x18, 0x10,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 4, 6, 8, 2, -17 },
  { 7, 12, 17, 14, 1, -17 },
  { 33, 10, 19, 12, 1, -18 },
  { 57, 15, 17, 17, 1, -17 },
  { 89, 13, 17, 14, 1, -17 },
  { 117, 1, 6, 4, 2, -17 },
  { 118, 5, 21, 6, 1, -17 },
  { 132, 4, 21, 6, 1, -17 },
  { 143, 9, 8, 11, 1, -18 },
  { 152, 10, 11, 12, 1, -14 },
  { 166, 2, 6, 5, 1, -3 },
  { 168, 5, 1, 7, 1, -7 },
  { 169, 1, 2, 5, 2, -2 },
  { 170, 8, 17, 8, 0, -17 },
  { 187, 10, 17, 12, 1, -17 },
  { 209, 5, 17, 12, 2, -17 },
  { 220, 10, 17, 12, 1, -17 },
  { 242, 10, 17, 12, 1, -17 },
  { 264, 12, 17, 12, 0, -17 },
  { 290, 9, 17, 12, 2, -17 },
  { 310, 10, 17, 12, 1, -17 },
  { 332, 10, 17, 12, 1, -17 },
  { 354, 10, 17, 12, 1, -17 },
  { 376, 10, 17, 12, 1, -17 },
  { 398, 1, 13, 5, 2, -13 },
  { 400, 2, 16, 5, 1, -13 },
  { 404, 10, 11, 12, 1, -14 },
  { 418, 10, 5, 12, 1, -11 },
  { 425, 10, 11, 12, 1, -14 },
  { 439, 7, 17, 9, 1, -17 },
  { 454, 17, 19, 19, 1, -17 },
  { 495, 12, 17, 12, 0, -17 },
  { 521, 10, 17, 13, 2, -17 },
  { 543, 11, 17, 13, 1, -17 },
  { 567, 11, 17, 15, 2, -17 },
  { 591, 8, 17, 12, 2, -17 },
  { 608, 8, 17, 11, 2, -17 },
  { 625, 13, 17, 16, 1, -17 },
  { 653, 11, 17, 15, 2, -17 },
  { 677, 4, 17, 7, 1, -17 },
  { 686, 5, 21, 5, -2, -17 },
  { 700, 10, 17, 12, 2, -17 },
  { 722, 8, 17, 11, 2, -17 },
  { 739, 15, 17, 19, 2, -17 },
  { 771, 11, 17, 15, 2, -17 },
  { 795, 14, 17, 16, 1, -17 },
  { 825, 9, 17, 12, 2, -17 },
  { 845, 14, 21, 16, 1, -17 },
  { 882, 10, 17, 13, 2, -17 },
  { 904, 10, 17, 12, 1, -17 },
  { 926, 11, 17, 11, 0, -17 },
  { 950, 11, 17, 15, 2, -17 },
  { 974, 12, 17, 12, 0, -17 },
  { 1000, 19, 17, 19, 0, -17 },
  { 1041, 11, 17, 11, 0, -17 },
  { 1065, 11, 17, 11, 0, -17 },
  { 1089, 10, 17, 12, 1, -17 },
  { 1111, 5, 21, 8, 2, -17 },
  { 1125, 8, 17, 8, 0, -17 },
  { 1142, 4, 21, 8, 1, -17 },
  { 1153, 10, 10, 12, 1, -17 },
  { 1166, 10, 1, 10, 0, 2 },
  { 1168, 4, 3, 6, 1, -18 },
  { 1170, 8, 13, 11, 1, -13 },
  { 1183, 10, 18, 13, 2, -18 },
  { 1206, 8, 13, 10, 1, -13 },
  { 1219, 10, 18, 13, 1, -18 },
  { 1242, 9, 13, 12, 1, -13 },
  { 1257, 7, 18, 6, 0, -18 },
  { 1273, 10, 19, 13, 1, -13 },
  { 1297, 9, 18, 13, 2, -18 },
  { 1318, 1, 17, 5, 2, -17 },
  { 1321, 4, 23, 5, -1, -17 },
  { 1333, 8, 18, 10, 2, -18 },
  { 1351, 1, 18, 5, 2, -18 },
  { 1354, 15, 13, 19, 2, -13 },
  { 1379, 9, 13, 13, 2, -13 },
  { 1394, 10, 13, 12, 1, -13 },
  { 1411, 10, 19, 13, 2, -13 },
  { 1435, 10, 19, 13, 1, -13 },
  { 1459, 6, 13, 8, 2, -13 },
  { 1469, 8, 13, 10, 1, -13 },
  { 1482, 6, 16, 7, 0, -16 },
  { 1494, 9, 13, 13, 2, -13 },
  { 1509, 9, 13, 10, 0, -13 },
  { 1524, 15, 13, 15, 0, -13 },
  { 1549, 10, 13, 10, 0, -13 },
  { 1566, 10, 19, 10, 0, -13 },
  { 1590, 7, 13, 9, 1, -13 },
  { 1602, 6, 21, 8, 1, -17 },
  { 1618, 1, 24, 12, 5, -18 },
  { 1621, 6, 21, 8, 1, -17 },
  { 1637, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT24PT7B_H_
