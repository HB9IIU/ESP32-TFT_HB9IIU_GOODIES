#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x09, 0x08, 0x84, 0x4F, 0xF1, 0x20, 0x90,
  0x49, 0xFF, 0x22, 0x12, 0x09, 0x04, 0x80, 0x11, 0xF9, 0x24, 0x92, 0x46,
  0x06, 0x14, 0x51, 0x65, 0x78, 0x40, 0xF1, 0x24, 0x49, 0x22, 0x48, 0x94,
  0xA5, 0x5F, 0xA4, 0x29, 0x12, 0x44, 0x92, 0x24, 0x87, 0x78, 0x22, 0x11,
  0x08, 0x82, 0x81, 0x81, 0x43, 0x12, 0x85, 0x41, 0x20, 0xCF, 0x90, 0xF0,
  0x2A, 0x49, 0x24, 0x92, 0x44, 0x88, 0x89, 0x22, 0x49, 0x24, 0xA5, 0x20,
  0x10, 0x4D, 0xCC, 0x31, 0x20, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08,
  0xF0, 0xF0, 0x80, 0x08, 0x42, 0x21, 0x08, 0x84, 0x42, 0x11, 0x00, 0x78,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0x11, 0xC0, 0x3E, 0x92,
  0x49, 0x24, 0x90, 0xF8, 0x08, 0x10, 0x20, 0x40, 0x82, 0x08, 0x20, 0x81,
  0x07, 0xF0, 0xF8, 0x08, 0x10, 0x20, 0x4F, 0x03, 0x02, 0x02, 0x04, 0x17,
  0xC0, 0x06, 0x06, 0x0A, 0x12, 0x12, 0x22, 0x42, 0x42, 0xFF, 0x02, 0x02,
  0x02, 0x7D, 0x02, 0x04, 0x08, 0x1F, 0x81, 0x01, 0x02, 0x04, 0x17, 0xC0,
  0x3E, 0x82, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x05, 0x11, 0xE0, 0xFE,
  0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x83, 0x00, 0x7D, 0x0A,
  0x0C, 0x24, 0xC6, 0x13, 0x42, 0x83, 0x06, 0x0B, 0xE0, 0x79, 0x0A, 0x14,
  0x18, 0x30, 0xD2, 0x99, 0x04, 0x08, 0x27, 0x80, 0x80, 0x80, 0x81, 0xE0,
  0x02, 0x18, 0xC6, 0x04, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x80,
  0xC0, 0x60, 0x30, 0xC6, 0x10, 0x40, 0xF8, 0x10, 0x41, 0x08, 0x42, 0x08,
  0x20, 0x00, 0x08, 0x1F, 0x84, 0x09, 0x00, 0xC3, 0x98, 0x93, 0x22, 0x64,
  0x4C, 0x89, 0x91, 0x31, 0xDE, 0x00, 0x20, 0x02, 0x08, 0x3E, 0x00, 0x08,
  0x0A, 0x05, 0x02, 0x82, 0x41, 0x10, 0x88, 0x7C, 0x41, 0x20, 0xA0, 0x50,
  0x10, 0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x21, 0x41, 0x83, 0x06, 0x17, 0xC0,
  0x3F, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F,
  0xF8, 0x84, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8,
  0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x21, 0xF0, 0xFC, 0x21, 0x08, 0x43,
  0xF0, 0x84, 0x21, 0x00, 0x3F, 0xA0, 0x10, 0x10, 0x08, 0x04, 0x02, 0x1F,
  0x01, 0x80, 0xA0, 0x50, 0x27, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x10, 0xE9, 0x24, 0x92, 0x49, 0x70, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x70, 0x85, 0x12, 0x45, 0x0A, 0x18, 0x28, 0x48, 0x91,
  0x12, 0x14, 0x30, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0x80,
  0x60, 0x3C, 0x0F, 0x05, 0xC1, 0x68, 0x5A, 0x26, 0x49, 0x94, 0x65, 0x18,
  0xC6, 0x21, 0x83, 0x07, 0x0D, 0x1A, 0x32, 0x64, 0xC5, 0x8B, 0x0E, 0x0C,
  0x10, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0,
  0x50, 0x47, 0xC0, 0xFA, 0x18, 0x61, 0x86, 0x2F, 0x20, 0x82, 0x08, 0x20,
  0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50,
  0x47, 0xC0, 0x40, 0x10, 0x04, 0xF9, 0x0A, 0x14, 0x28, 0x51, 0x3C, 0x48,
  0x89, 0x12, 0x14, 0x30, 0x7E, 0x08, 0x20, 0x81, 0xC0, 0x81, 0x04, 0x10,
  0x7E, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x3E, 0x81, 0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x88, 0x48, 0x14, 0x0A,
  0x06, 0x01, 0x00, 0x82, 0x0A, 0x18, 0x50, 0xC2, 0x8A, 0x14, 0x51, 0x12,
  0x48, 0x92, 0x45, 0x12, 0x28, 0xA0, 0xC3, 0x04, 0x18, 0x20, 0x80, 0xC3,
  0x42, 0x24, 0x24, 0x18, 0x10, 0x18, 0x28, 0x24, 0x42, 0x42, 0x81, 0x83,
  0x42, 0x42, 0x24, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x07, 0xF0, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x82, 0x10, 0x82, 0x10, 0x42, 0x10,
  0x42, 0x10, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x10, 0x50,
  0xA2, 0x24, 0x50, 0x60, 0x80, 0xFE, 0x88, 0x80, 0x78, 0x10, 0x41, 0x7E,
  0x18, 0x63, 0xF4, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x60, 0xC1, 0x83, 0x06,
  0x0E, 0x1B, 0xC0, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7C, 0x02, 0x04,
  0x08, 0x17, 0xB0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x37, 0xA0, 0x7A, 0x18,
  0x61, 0xFE, 0x08, 0x20, 0x7C, 0x39, 0x08, 0x4F, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x00, 0x7B, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x7A, 0x04, 0x08,
  0x2F, 0x80, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0xA0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0x9F, 0xF0, 0x20, 0x12, 0x49, 0x24, 0x92, 0x4F, 0x82, 0x08,
  0x20, 0x86, 0x29, 0x28, 0xD2, 0x48, 0xA2, 0x84, 0xFF, 0xF8, 0xBB, 0xD8,
  0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x20, 0xBD,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x7D, 0x0A, 0x0C, 0x18, 0x30,
  0x60, 0xC2, 0x78, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xBD, 0x02,
  0x04, 0x08, 0x00, 0x7B, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x7A, 0x04,
  0x08, 0x10, 0x20, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x80, 0x7C, 0x21, 0x83,
  0x04, 0x21, 0xF0, 0x42, 0x3C, 0x84, 0x21, 0x08, 0x42, 0x0E, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x7C, 0x83, 0x09, 0x12, 0x24, 0x85, 0x0A, 0x18,
  0x10, 0x84, 0x30, 0x89, 0x29, 0x25, 0x24, 0xA4, 0xA3, 0x0C, 0x61, 0x8C,
  0x20, 0x80, 0x42, 0x88, 0xA0, 0xC1, 0x05, 0x0A, 0x22, 0xC2, 0x83, 0x09,
  0x12, 0x24, 0x85, 0x0A, 0x18, 0x10, 0x20, 0x81, 0x0C, 0x00, 0xF8, 0x44,
  0x42, 0x21, 0x10, 0xF8, 0x34, 0x44, 0x44, 0x48, 0x44, 0x44, 0x42, 0x10,
  0xFF, 0xFF, 0x80, 0xC2, 0x22, 0x22, 0x21, 0x22, 0x22, 0x24, 0x80, 0xE3,
  0x38,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 4, 1, -12 },
  { 3, 3, 4, 6, 1, -12 },
  { 5, 9, 12, 10, 0, -12 },
  { 19, 6, 14, 9, 1, -13 },
  { 30, 10, 12, 12, 1, -12 },
  { 45, 9, 12, 10, 1, -12 },
  { 59, 1, 4, 3, 1, -12 },
  { 60, 3, 15, 5, 1, -12 },
  { 66, 3, 15, 5, 1, -12 },
  { 72, 6, 6, 8, 1, -13 },
  { 77, 7, 8, 9, 1, -10 },
  { 84, 1, 4, 3, 1, -2 },
  { 85, 4, 1, 5, 1, -5 },
  { 86, 1, 1, 4, 1, -1 },
  { 87, 5, 12, 6, 0, -12 },
  { 95, 7, 12, 9, 1, -12 },
  { 106, 3, 12, 9, 2, -12 },
  { 111, 7, 12, 9, 1, -12 },
  { 122, 7, 12, 9, 1, -12 },
  { 133, 8, 12, 9, 0, -12 },
  { 145, 7, 12, 9, 1, -12 },
  { 156, 7, 12, 9, 1, -12 },
  { 167, 7, 12, 9, 1, -12 },
  { 178, 7, 12, 9, 1, -12 },
  { 189, 7, 12, 9, 1, -12 },
  { 200, 1, 9, 4, 1, -9 },
  { 202, 1, 11, 4, 1, -9 },
  { 204, 7, 8, 9, 1, -10 },
  { 211, 7, 4, 9, 1, -8 },
  { 215, 7, 8, 9, 1, -10 },
  { 222, 6, 12, 6, 0, -12 },
  { 231, 11, 14, 13, 1, -12 },
  { 251, 9, 12, 9, 0, -12 },
  { 265, 7, 12, 9, 2, -12 },
  { 276, 8, 12, 9, 1, -12 },
  { 288, 8, 12, 11, 2, -12 },
  { 300, 5, 12, 8, 2, -12 },
  { 308, 5, 12, 8, 2, -12 },
  { 316, 9, 12, 11, 1, -12 },
  { 330, 7, 12, 11, 2, -12 },
  { 341, 3, 12, 5, 1, -12 },
  { 346, 3, 15, 4, -1, -12 },
  { 352, 7, 12, 9, 2, -12 },
  { 363, 5, 12, 8, 2, -12 },
  { 371, 10, 12, 13, 2, -12 },
  { 386, 7, 12, 11, 2, -12 },
  { 397, 9, 12, 11, 1, -12 },
  { 411, 6, 12, 9, 2, -12 },
  { 420, 9, 15, 11, 1, -12 },
  { 437, 7, 12, 9, 2, -12 },
  { 448, 6, 12, 8, 1, -12 },
  { 457, 8, 12, 8, 0, -12 },
  { 469, 8, 12, 11, 1, -12 },
  { 481, 9, 12, 9, 0, -12 },
  { 495, 13, 12, 14, 0, -12 },
  { 515, 8, 12, 8, 0, -12 },
  { 527, 8, 12, 8, 0, -12 },
  { 539, 7, 12, 8, 1, -12 },
  { 550, 4, 15, 5, 1, -12 },
  { 558, 5, 12, 6, 0, -12 },
  { 566, 4, 15, 5, 0, -12 },
  { 574, 7, 7, 9, 1, -12 },
  { 581, 7, 1, 7, 0, 1 },
  { 582, 3, 3, 4, 1, -13 },
  { 584, 6, 9, 8, 1, -9 },
  { 591, 7, 13, 9, 1, -13 },
  { 603, 6, 9, 7, 1, -9 },
  { 610, 7, 13, 9, 1, -13 },
  { 622, 6, 9, 8, 1, -9 },
  { 629, 5, 13, 4, 0, -13 },
  { 638, 7, 13, 9, 1, -9 },
  { 650, 7, 13, 9, 1, -13 },
  { 662, 1, 12, 3, 1, -12 },
  { 664, 3, 16, 3, -1, -12 },
  { 670, 6, 13, 7, 1, -13 },
  { 680, 1, 13, 3, 1, -13 },
  { 682, 11, 9, 13, 1, -9 },
  { 695, 7, 9, 9, 1, -9 },
  { 703, 7, 9, 9, 1, -9 },
  { 711, 7, 13, 9, 1, -9 },
  { 723, 7, 13, 9, 1, -9 },
  { 735, 5, 9, 6, 1, -9 },
  { 741, 5, 9, 7, 1, -9 },
  { 747, 5, 11, 5, 0, -11 },
  { 754, 6, 9, 9, 1, -9 },
  { 761, 7, 9, 7, 0, -9 },
  { 769, 11, 9, 11, 0, -9 },
  { 782, 7, 9, 7, 0, -9 },
  { 790, 7, 13, 7, 0, -9 },
  { 802, 5, 9, 7, 1, -9 },
  { 808, 4, 15, 6, 1, -12 },
  { 816, 1, 17, 8, 4, -13 },
  { 819, 4, 15, 6, 1, -12 },
  { 827, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT17PT7B_H_
