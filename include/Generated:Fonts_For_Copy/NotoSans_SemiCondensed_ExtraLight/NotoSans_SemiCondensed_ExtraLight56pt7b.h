#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight56pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x6F, 0xF7, 0xC0, 0xF8, 0x1B,
  0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x03,
  0x60, 0x6C, 0x0D, 0x80, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x18, 0x07,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x04,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xE2,
  0x0F, 0x0E, 0x08, 0x08, 0x70, 0x20, 0x01, 0x80, 0x80, 0x0C, 0x02, 0x00,
  0x30, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x30,
  0x08, 0x00, 0xE0, 0x20, 0x01, 0x80, 0x80, 0x03, 0x02, 0x00, 0x07, 0x08,
  0x00, 0x0F, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x2F, 0x80, 0x00, 0x8F, 0x00, 0x02, 0x0E, 0x00, 0x08, 0x1C, 0x00,
  0x20, 0x38, 0x00, 0x80, 0x60, 0x02, 0x01, 0x80, 0x08, 0x07, 0x00, 0x20,
  0x1C, 0x00, 0x80, 0x60, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00, 0x20, 0x38,
  0x00, 0x81, 0xCC, 0x02, 0x0E, 0x3F, 0x09, 0xF0, 0x7F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x73, 0x80,
  0x01, 0x80, 0x18, 0x18, 0x00, 0x30, 0x06, 0x03, 0x80, 0x0C, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x06, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x18,
  0x18, 0x00, 0x30, 0x03, 0x06, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x00, 0xC0,
  0x0C, 0x30, 0x10, 0x18, 0x01, 0x86, 0x1F, 0xC3, 0x00, 0x61, 0x87, 0x1C,
  0x30, 0x0C, 0x31, 0xC1, 0xC6, 0x01, 0x8E, 0x30, 0x18, 0xC0, 0x71, 0x86,
  0x01, 0x8C, 0x0C, 0x31, 0x80, 0x31, 0xE7, 0x0C, 0x30, 0x06, 0x0F, 0xC1,
  0x86, 0x00, 0xC0, 0x40, 0x60, 0xC0, 0x18, 0x00, 0x0C, 0x18, 0x01, 0x80,
  0x03, 0x03, 0x00, 0x30, 0x00, 0x60, 0x60, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0xC0, 0x03, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x18, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x30, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0x0E, 0x38, 0x01, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x06, 0x30, 0x07, 0x00, 0x33,
  0x00, 0x18, 0x03, 0x98, 0x00, 0x60, 0x19, 0xC0, 0x01, 0x80, 0xCC, 0x00,
  0x0E, 0x0E, 0x60, 0x00, 0x38, 0x63, 0x00, 0x00, 0xE7, 0x18, 0x00, 0x03,
  0x30, 0xC0, 0x00, 0x0F, 0x86, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x1F, 0x07, 0x00, 0x01, 0xDC, 0x1C, 0x00, 0x3C, 0x60, 0xF0,
  0x03, 0x81, 0x81, 0xFB, 0xF8, 0x0E, 0x07, 0xFF, 0x00, 0x38, 0x01, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0xE0, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x18, 0x04, 0x02, 0xF8, 0x20, 0xFB, 0xF1, 0x3F,
  0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x06,
  0x30, 0x00, 0x61, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0x80, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x61, 0x86,
  0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x6F,
  0xFF, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x7C, 0xF8, 0x03, 0x80,
  0x70, 0x0C, 0x00, 0xE0, 0x60, 0x01, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0E,
  0x30, 0x00, 0x19, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x07, 0x60,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x63,
  0x00, 0x03, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x30, 0x03, 0x80, 0xF0,
  0x1C, 0x01, 0xFB, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x0F, 0x01, 0xF0, 0x7B, 0x0E, 0x31, 0xC3, 0x38, 0x3F, 0x03, 0x40, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x00, 0x1F, 0xF8, 0x01, 0xF9, 0xF8, 0x1E, 0x00, 0x70, 0x60, 0x00, 0xE1,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x9F, 0x01,
  0xE0, 0x07, 0x87, 0x00, 0x07, 0x08, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x90, 0x00, 0x06, 0x3C, 0x00, 0x3C, 0x7F, 0xC7, 0xE0, 0x1F, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30,
  0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x67, 0xFC, 0x03, 0xFF, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC8, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0xF9,
  0xFC, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0xE0, 0x03, 0xFB, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0xC3, 0xFF, 0x03, 0x9F,
  0x0F, 0x87, 0x70, 0x03, 0x8C, 0xC0, 0x03, 0x9B, 0x00, 0x03, 0x3C, 0x00,
  0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0xB0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x71,
  0xC0, 0x00, 0xC1, 0x80, 0x03, 0x81, 0x80, 0x06, 0x03, 0x80, 0x38, 0x03,
  0xF1, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFC, 0x00, 0xFE, 0xFC, 0x07, 0x80, 0x38, 0x38, 0x00, 0x70,
  0xC0, 0x00, 0xC7, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x70, 0x00, 0x18, 0xC0, 0x00,
  0xE3, 0x80, 0x07, 0x07, 0x00, 0x18, 0x0E, 0x01, 0xC0, 0x1E, 0x0E, 0x00,
  0x1E, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0E, 0x3E, 0x00, 0xF0,
  0x3C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE6, 0x00, 0x01,
  0xB8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00,
  0x07, 0x70, 0x00, 0x18, 0xE0, 0x00, 0xC1, 0xC0, 0x0E, 0x03, 0xE1, 0xF0,
  0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xF8, 0x00,
  0xFD, 0xF8, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xC0, 0x01, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00,
  0x0F, 0x70, 0x00, 0x2C, 0xC0, 0x01, 0xB3, 0x80, 0x1C, 0xC7, 0xC1, 0xE3,
  0x07, 0xFE, 0x0C, 0x03, 0xC0, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x3F, 0x80, 0x3F, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x6F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x6F, 0xFF, 0x18, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x3F, 0xBF, 0x18,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x30, 0x00, 0xFF, 0xE0, 0x18, 0xC0,
  0x0F, 0x07, 0x80, 0x66, 0x00, 0x70, 0x06, 0x01, 0x98, 0x01, 0x80, 0x18,
  0x03, 0x60, 0x0C, 0x00, 0x60, 0x0F, 0x80, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0x80, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x38, 0x00, 0xC0,
  0x0F, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x0C,
  0x00, 0x30, 0x03, 0xC0, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x03, 0x00,
  0x3C, 0x03, 0x00, 0x0C, 0x01, 0xB0, 0x06, 0x00, 0x70, 0x06, 0xC0, 0x18,
  0x01, 0x40, 0x1B, 0x00, 0x60, 0x0D, 0x80, 0xC6, 0x00, 0xC0, 0x36, 0x07,
  0x18, 0x03, 0x83, 0x8C, 0x38, 0x60, 0x07, 0xFC, 0x3F, 0xC1, 0xC0, 0x07,
  0xC0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0x00, 0x07, 0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x98, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0xB0, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x71, 0x80, 0x03, 0xC3,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x76, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x98, 0x00, 0x3E, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFB,
  0xFC, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0C, 0x00, 0x3E, 0x03, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x3C,
  0x30, 0x00, 0x07, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0xF0, 0x30, 0x01, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xB0, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xE3, 0xFC, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x0C, 0x07, 0xC0,
  0x00, 0xE0, 0x0F, 0xF3, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x63, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC8, 0x3C, 0xFF, 0x8F, 0xE0, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B,
  0x00, 0x00, 0xE6, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x07, 0x01, 0x80, 0x1C, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x38,
  0x00, 0x60, 0xE0, 0x00, 0xC3, 0x80, 0x01, 0x8F, 0x00, 0x03, 0x1F, 0x00,
  0x06, 0x6E, 0x00, 0x0D, 0xCE, 0x00, 0x1F, 0x0C, 0x00, 0x3C, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x38, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0xC0, 0x00, 0xE1, 0x80, 0x00, 0xC3, 0x00, 0x01, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x60, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00,
  0x03, 0xBC, 0xC0, 0x00, 0x00, 0xCF, 0x30, 0x00, 0x00, 0x33, 0xCE, 0x00,
  0x00, 0x18, 0xF1, 0x80, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x01, 0x8F, 0x1C,
  0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x1C, 0x3C,
  0x18, 0x00, 0x06, 0x0F, 0x06, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x00, 0xE0,
  0xF0, 0x30, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0x0C, 0x0F, 0x03, 0x80, 0x06,
  0x03, 0xC0, 0x60, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x60, 0x3C, 0x07, 0x00,
  0x30, 0x0F, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x30, 0x07, 0x00, 0xF0, 0x06,
  0x01, 0x80, 0x3C, 0x01, 0x80, 0x60, 0x0F, 0x00, 0x60, 0x30, 0x03, 0xC0,
  0x0C, 0x0C, 0x00, 0xF0, 0x03, 0x03, 0x00, 0x3C, 0x00, 0xE1, 0x80, 0x0F,
  0x00, 0x18, 0x60, 0x03, 0xC0, 0x06, 0x18, 0x00, 0xF0, 0x01, 0xCC, 0x00,
  0x3C, 0x00, 0x33, 0x00, 0x0F, 0x00, 0x0D, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xD8, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x7C, 0xC0, 0x00,
  0x1F, 0x38, 0x00, 0x07, 0xC6, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x7C, 0x38,
  0x00, 0x1F, 0x06, 0x00, 0x07, 0xC1, 0xC0, 0x01, 0xF0, 0x30, 0x00, 0x7C,
  0x0E, 0x00, 0x1F, 0x01, 0xC0, 0x07, 0xC0, 0x30, 0x01, 0xF0, 0x0E, 0x00,
  0x7C, 0x01, 0x80, 0x1F, 0x00, 0x70, 0x07, 0xC0, 0x0C, 0x01, 0xF0, 0x01,
  0x80, 0x7C, 0x00, 0x70, 0x1F, 0x00, 0x0C, 0x07, 0xC0, 0x03, 0x81, 0xF0,
  0x00, 0x60, 0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x61,
  0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x18, 0xF0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1B, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x30, 0x01, 0xF1, 0x80, 0x03, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80, 0x03, 0xCC,
  0x00, 0x7C, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x03, 0x00, 0x1F, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x1E, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x70, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xE1, 0x80, 0x00, 0xE3,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x80, 0xFE,
  0xFF, 0x87, 0x80, 0x0C, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x8C, 0x00, 0x1E, 0x3F, 0xEF, 0xE0, 0x7F, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x00, 0x7F, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x38, 0x00, 0x03, 0x30, 0x00, 0x0F, 0x00,
  0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x1C, 0xE0, 0x00, 0x36, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x98, 0x00, 0x0C, 0x30,
  0x00, 0x33, 0x80, 0x03, 0x87, 0x00, 0x06, 0x30, 0x00, 0x60, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0xC1, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x30, 0x01,
  0x80, 0x60, 0x07, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0xE0, 0x0E, 0x01,
  0xC0, 0x18, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x01, 0x80, 0x30, 0x03, 0x00,
  0xE0, 0x30, 0x06, 0x00, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x01, 0x80,
  0xC0, 0x03, 0x03, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0x18,
  0x60, 0x01, 0xC7, 0x00, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x1C, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x70,
  0x00, 0x07, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0E,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x38,
  0x00, 0x38, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0xE0,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1E, 0x01, 0xC1, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x03,
  0xFF, 0xF0, 0xF8, 0x03, 0x1C, 0x00, 0x33, 0x80, 0x03, 0x70, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x60, 0x00, 0xF6, 0x00, 0x0B, 0x70, 0x01, 0xB3, 0x80, 0x33, 0x1F, 0x1E,
  0x30, 0xFF, 0xC3, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x07, 0xF8, 0x0C, 0x7F, 0xF8, 0x33,
  0x80, 0x70, 0xD8, 0x00, 0xE3, 0xC0, 0x01, 0xCF, 0x00, 0x03, 0x38, 0x00,
  0x0E, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33,
  0x80, 0x00, 0xCF, 0x00, 0x07, 0x36, 0x00, 0x38, 0x9C, 0x01, 0xC2, 0x3E,
  0x7E, 0x08, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x1E, 0x01, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x10, 0x7E, 0x7E, 0x03, 0xFF, 0x80, 0x0A, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x07, 0xF8, 0x30,
  0x7F, 0xF8, 0xC3, 0xC0, 0x73, 0x1C, 0x00, 0x6C, 0xE0, 0x00, 0xB3, 0x00,
  0x03, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x07,
  0x60, 0x00, 0x1D, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xC6, 0x00, 0x1B, 0x1E,
  0x00, 0xCC, 0x3F, 0x1E, 0x30, 0x3F, 0xF0, 0xC0, 0x1C, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0xC0, 0x70, 0x38, 0x01, 0xC1, 0x80, 0x06, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x7E, 0x7F, 0x00, 0xFF, 0xE0, 0x00, 0xA0, 0x00, 0x00, 0x7E, 0x01, 0xFF,
  0x03, 0xC1, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1F, 0xF8,
  0xFF, 0xF8, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0xFE,
  0x0C, 0x1F, 0xFE, 0x30, 0xF0, 0x1C, 0xC7, 0x00, 0x1B, 0x38, 0x00, 0x3C,
  0xC0, 0x00, 0xF7, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00,
  0x01, 0xD8, 0x00, 0x07, 0x30, 0x00, 0x3C, 0xE0, 0x00, 0xB1, 0x80, 0x06,
  0xC7, 0x80, 0x33, 0x0F, 0xCF, 0x8C, 0x0F, 0xFC, 0x30, 0x02, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x90, 0x00, 0x1C,
  0x70, 0x00, 0xE1, 0xFF, 0x7F, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F, 0xE0, 0xC7, 0xFF,
  0x8C, 0xE0, 0x3C, 0xD8, 0x00, 0xCF, 0x00, 0x0E, 0xF0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x4E,
  0xFE, 0x40, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x01, 0x00, 0xE0, 0x3C,
  0x0E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0xFE, 0x3F, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x03, 0xB0, 0x00, 0xE6, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0x83,
  0x00, 0x70, 0x60, 0x1C, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06,
  0x0C, 0x00, 0xC3, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x66, 0xC0, 0x0D,
  0x9C, 0x01, 0xE1, 0x80, 0x3C, 0x38, 0x07, 0x03, 0x80, 0xC0, 0x30, 0x18,
  0x07, 0x03, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0xE1, 0x80, 0x0C, 0x30,
  0x01, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x83,
  0xF8, 0x03, 0xFC, 0x21, 0xFF, 0x81, 0xFF, 0x88, 0xC0, 0x70, 0xC0, 0x72,
  0x60, 0x0E, 0x60, 0x0E, 0xB0, 0x01, 0xB0, 0x01, 0xF8, 0x00, 0x68, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x81, 0xFE, 0x08, 0x7F, 0xF8,
  0x8E, 0x03, 0xC9, 0x80, 0x0C, 0xB0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03,
  0x86, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x1B, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x70, 0x00,
  0x70, 0x70, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x81, 0xFE, 0x02, 0x1F, 0xFE, 0x08, 0xE0, 0x1C,
  0x27, 0x00, 0x38, 0x98, 0x00, 0x72, 0xC0, 0x00, 0xCE, 0x00, 0x03, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xF0, 0x00,
  0x33, 0xC0, 0x01, 0xCD, 0x80, 0x0E, 0x33, 0x00, 0x70, 0xC7, 0xDF, 0x83,
  0x0F, 0xFC, 0x0C, 0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x0C, 0x1F, 0xFE, 0x30, 0xF0, 0x1C, 0xC7,
  0x00, 0x1B, 0x38, 0x00, 0x2C, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xD8, 0x00,
  0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x3C,
  0xC0, 0x00, 0xB1, 0x80, 0x06, 0xC7, 0x80, 0x73, 0x0F, 0x8F, 0x8C, 0x0F,
  0xFC, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x81, 0xFC, 0x3F, 0xE3, 0x81, 0xB0, 0x0D, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x70, 0x07, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1A, 0x00, 0x07, 0x70, 0x01, 0xCF, 0xE7, 0xF0,
  0x7F, 0xF8, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xE3, 0x03, 0xFC, 0x01, 0x80,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xEC, 0x00, 0x0F, 0x60, 0x00, 0x5B, 0x80, 0x06, 0xCC, 0x00, 0x66, 0x70,
  0x07, 0x31, 0xF3, 0xF1, 0x87, 0xFE, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x76, 0x00, 0x01, 0x98, 0x00, 0x06, 0x70, 0x00, 0x38,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x38, 0x03,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x07, 0x01, 0x80, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x1C,
  0x60, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0D, 0x80, 0x07,
  0x80, 0x06, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x67, 0x00,
  0x33, 0x00, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x03, 0x0C,
  0x00, 0xC6, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x30, 0x60, 0x18, 0x60, 0x18,
  0x18, 0x06, 0x0C, 0x06, 0x06, 0x03, 0x83, 0x01, 0x81, 0xC0, 0xC0, 0xC0,
  0x60, 0x30, 0x30, 0x38, 0x30, 0x0C, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x01,
  0x83, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x18, 0x60, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x39, 0x80, 0x0C,
  0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00,
  0x1E, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x60, 0x00, 0x19, 0xC0, 0x00, 0xE3, 0x80,
  0x07, 0x06, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xE0, 0x18,
  0x01, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x60, 0x00,
  0x33, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x61, 0x80,
  0x03, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x80, 0x70, 0x0C,
  0x00, 0xC0, 0x60, 0x01, 0x83, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x70, 0x00,
  0x3B, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01,
  0xDC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00,
  0x38, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x87, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0x3C, 0x00, 0x0F,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x7E, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x0E, 0x00,
  0xF8, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x07, 0xC0, 0x7E, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF7,
  0xE0, 0x0F, 0x00, 0xF0, 0x7C, 0x00, 0x7F, 0xC8, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 40, 12, 4, -40 },
  { 21, 11, 14, 18, 4, -40 },
  { 41, 29, 40, 32, 1, -40 },
  { 186, 22, 46, 28, 3, -43 },
  { 313, 35, 42, 41, 3, -41 },
  { 497, 29, 42, 33, 3, -41 },
  { 650, 2, 14, 10, 4, -40 },
  { 654, 10, 49, 15, 3, -40 },
  { 716, 10, 49, 15, 2, -40 },
  { 778, 21, 21, 27, 3, -43 },
  { 834, 23, 26, 29, 3, -33 },
  { 909, 6, 13, 11, 2, -6 },
  { 919, 13, 2, 17, 2, -16 },
  { 923, 4, 4, 12, 4, -4 },
  { 925, 17, 40, 19, 1, -40 },
  { 1010, 22, 42, 28, 3, -41 },
  { 1126, 12, 40, 28, 5, -40 },
  { 1186, 22, 41, 28, 3, -41 },
  { 1299, 23, 42, 28, 2, -41 },
  { 1420, 27, 40, 28, 1, -40 },
  { 1555, 21, 41, 28, 4, -40 },
  { 1663, 23, 42, 28, 3, -41 },
  { 1784, 22, 40, 28, 3, -40 },
  { 1894, 22, 42, 28, 3, -41 },
  { 2010, 22, 42, 28, 3, -41 },
  { 2126, 4, 30, 12, 4, -30 },
  { 2141, 6, 37, 12, 2, -30 },
  { 2169, 23, 24, 29, 3, -32 },
  { 2238, 23, 13, 29, 3, -26 },
  { 2276, 23, 24, 29, 3, -32 },
  { 2345, 17, 41, 20, 2, -41 },
  { 2433, 38, 45, 44, 3, -40 },
  { 2647, 29, 40, 29, 0, -40 },
  { 2792, 23, 40, 31, 5, -40 },
  { 2907, 26, 42, 31, 3, -41 },
  { 3044, 26, 40, 35, 5, -40 },
  { 3174, 19, 40, 27, 5, -40 },
  { 3269, 19, 40, 25, 5, -40 },
  { 3364, 29, 42, 36, 3, -41 },
  { 3517, 25, 40, 35, 5, -40 },
  { 3642, 9, 40, 15, 3, -40 },
  { 3687, 12, 50, 12, -4, -40 },
  { 3762, 23, 40, 28, 5, -40 },
  { 3877, 19, 40, 25, 5, -40 },
  { 3972, 34, 40, 44, 5, -40 },
  { 4142, 26, 40, 36, 5, -40 },
  { 4272, 31, 42, 38, 3, -41 },
  { 4435, 21, 40, 29, 5, -40 },
  { 4540, 31, 51, 38, 3, -41 },
  { 4738, 23, 40, 29, 5, -40 },
  { 4853, 22, 42, 27, 3, -41 },
  { 4969, 25, 40, 25, 0, -40 },
  { 5094, 26, 41, 36, 5, -40 },
  { 5228, 28, 40, 28, 0, -40 },
  { 5368, 43, 40, 45, 1, -40 },
  { 5583, 26, 40, 26, 0, -40 },
  { 5713, 25, 40, 25, 0, -40 },
  { 5838, 23, 40, 27, 2, -40 },
  { 5953, 11, 49, 18, 5, -40 },
  { 6021, 17, 40, 19, 1, -40 },
  { 6106, 11, 49, 18, 2, -40 },
  { 6174, 25, 23, 29, 2, -40 },
  { 6246, 23, 2, 23, 0, 5 },
  { 6252, 10, 9, 14, 2, -43 },
  { 6264, 20, 31, 26, 2, -30 },
  { 6342, 22, 44, 30, 5, -43 },
  { 6463, 19, 31, 23, 3, -30 },
  { 6537, 22, 44, 30, 3, -43 },
  { 6658, 21, 31, 27, 3, -30 },
  { 6740, 16, 43, 15, 1, -43 },
  { 6826, 22, 44, 30, 3, -30 },
  { 6947, 20, 43, 29, 5, -43 },
  { 7055, 4, 41, 11, 4, -41 },
  { 7076, 10, 55, 11, -2, -41 },
  { 7145, 19, 43, 24, 5, -43 },
  { 7248, 2, 43, 11, 5, -43 },
  { 7259, 34, 30, 44, 5, -30 },
  { 7387, 20, 30, 29, 5, -30 },
  { 7462, 23, 31, 29, 3, -30 },
  { 7552, 22, 43, 30, 5, -30 },
  { 7671, 22, 43, 30, 3, -30 },
  { 7790, 13, 30, 19, 5, -30 },
  { 7839, 19, 31, 23, 2, -30 },
  { 7913, 14, 38, 16, 1, -37 },
  { 7980, 21, 31, 29, 4, -30 },
  { 8062, 22, 30, 22, 0, -30 },
  { 8145, 34, 30, 36, 1, -30 },
  { 8273, 22, 30, 24, 1, -30 },
  { 8356, 22, 44, 23, 0, -30 },
  { 8477, 18, 30, 22, 2, -30 },
  { 8545, 15, 49, 19, 2, -40 },
  { 8637, 2, 57, 27, 12, -43 },
  { 8652, 15, 49, 19, 2, -40 },
  { 8744, 23, 5, 29, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT56PT7B_H_
