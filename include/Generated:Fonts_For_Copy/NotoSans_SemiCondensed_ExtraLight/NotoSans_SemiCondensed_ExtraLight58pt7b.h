#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0xDB, 0x6C,
  0x90, 0x00, 0x01, 0xFF, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x10,
  0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xE1, 0xC3, 0x07,
  0x0E, 0x0C, 0x04, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x38, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0C, 0x00,
  0x0F, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xCF, 0x80, 0x03, 0x0F, 0x00, 0x0C, 0x0E, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x1C, 0x00,
  0xC0, 0x60, 0x03, 0x03, 0xB8, 0x0C, 0x3C, 0xFE, 0x37, 0xE0, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x01, 0xFE, 0x00, 0x03, 0x00,
  0x38, 0x30, 0x00, 0x30, 0x03, 0x01, 0x80, 0x06, 0x00, 0x70, 0x18, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x0E, 0x06,
  0x00, 0x0C, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x0E, 0x0C, 0x00, 0x0C, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x0C, 0x00, 0xC1, 0x87, 0xF0,
  0x60, 0x0C, 0x30, 0xF7, 0x86, 0x00, 0xC3, 0x0C, 0x1C, 0x60, 0x1C, 0x61,
  0x80, 0xC7, 0x01, 0x86, 0x18, 0x06, 0x30, 0x38, 0xC3, 0x00, 0x63, 0x87,
  0x0C, 0x30, 0x06, 0x1F, 0xE1, 0xC3, 0x00, 0x30, 0x7C, 0x18, 0x30, 0x03,
  0x00, 0x03, 0x83, 0x00, 0x30, 0x00, 0x30, 0x60, 0x03, 0x00, 0x03, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x60, 0x03, 0x00, 0x06, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x60, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x38, 0x06, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x0C,
  0x00, 0x1C, 0x0C, 0x00, 0xC0, 0x00, 0xE3, 0x80, 0x18, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x0C, 0x38, 0x07, 0x00, 0x18, 0xE0, 0x07, 0x00, 0x31, 0x80, 0x07,
  0x00, 0xC3, 0x00, 0x06, 0x01, 0x8E, 0x00, 0x06, 0x03, 0x18, 0x00, 0x0E,
  0x0C, 0x30, 0x00, 0x0E, 0x18, 0x60, 0x00, 0x0E, 0x70, 0xC0, 0x00, 0x0E,
  0xC1, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C,
  0x06, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x03, 0x9C, 0x0E, 0x00, 0x0E, 0x1C,
  0x0E, 0x00, 0x78, 0x18, 0x0F, 0xFF, 0xE0, 0x18, 0x0F, 0xFF, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0xE0,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x1C, 0x06, 0x03, 0xF8, 0x30, 0xF9, 0xF9, 0xBF, 0x00, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00,
  0x70, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x1C, 0x03, 0x80, 0x60, 0x38, 0x01,
  0x80, 0x40, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0x86, 0x18, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xC0, 0x07, 0x03, 0x00, 0x07, 0x06, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x70, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0x83, 0x80, 0x06, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x70, 0x03, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x7B,
  0x0F, 0x31, 0xC3, 0x38, 0x3F, 0x03, 0x60, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0xF8, 0x0F, 0x03, 0xC0, 0x07, 0x06, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0xF8, 0x0F, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x10,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x20, 0x00,
  0x1C, 0x70, 0x00, 0xF0, 0xFF, 0xBF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x80, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x38, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x63, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x72, 0x00, 0x03,
  0x8E, 0x00, 0x3C, 0x3F, 0xDF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x08, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0xFF, 0xC0, 0x63, 0xF7, 0xE0, 0x67, 0x00, 0x70,
  0xEC, 0x00, 0x38, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x38, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x70,
  0x03, 0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1A, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x06,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0F, 0x07, 0x80, 0x07,
  0x9E, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7D, 0xF0, 0x01, 0xC0,
  0xF0, 0x07, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x31, 0xC0, 0x00,
  0x73, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0F,
  0x00, 0x38, 0x0F, 0xC7, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3C, 0x0F, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x07, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0xE0, 0x00,
  0x1D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0xF7, 0x00, 0x01, 0x66,
  0x00, 0x06, 0xCE, 0x00, 0x39, 0x8F, 0x00, 0xE3, 0x07, 0xFF, 0x8E, 0x07,
  0xFC, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x3C, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xF7, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x1C, 0x73, 0xC7, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x31, 0xC6, 0x18, 0x63, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x3C, 0x07,
  0x90, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x70, 0x00, 0x63, 0x00,
  0x0F, 0xFF, 0x00, 0xC6, 0x00, 0x3C, 0x1E, 0x01, 0xDC, 0x00, 0xE0, 0x0C,
  0x01, 0xB0, 0x03, 0x80, 0x18, 0x03, 0x60, 0x06, 0x00, 0x30, 0x06, 0xC0,
  0x18, 0x00, 0xE0, 0x0D, 0x80, 0x30, 0x01, 0xC0, 0x1E, 0x00, 0xC0, 0x03,
  0x00, 0x3C, 0x01, 0x80, 0x06, 0x00, 0x78, 0x03, 0x00, 0x0C, 0x00, 0xF0,
  0x06, 0x00, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00,
  0x60, 0x07, 0x80, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x01, 0x80, 0x1E,
  0x00, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0x80, 0x0E, 0x00, 0xDC, 0x03, 0x80,
  0x14, 0x01, 0x98, 0x03, 0x00, 0x6C, 0x06, 0x30, 0x07, 0x01, 0x98, 0x1C,
  0x60, 0x07, 0x8F, 0x1C, 0x70, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0xC0, 0x03,
  0x80, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x03,
  0xF8, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1C,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xE0, 0x03, 0xF0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x00, 0x20, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x06, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03,
  0x80, 0x07, 0xE0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x7C, 0x00,
  0x1F, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xC0, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x81, 0xCF, 0xF8, 0xFF, 0x00,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00,
  0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0xC0, 0x00, 0xEE, 0xE0, 0x00,
  0xEC, 0xE0, 0x00, 0xF8, 0x70, 0x00, 0xF0, 0x30, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xC0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xEC,
  0x00, 0x00, 0x01, 0xBD, 0xC0, 0x00, 0x00, 0x37, 0xD8, 0x00, 0x00, 0x06,
  0xFB, 0x00, 0x00, 0x01, 0x9F, 0x70, 0x00, 0x00, 0x33, 0xE6, 0x00, 0x00,
  0x0E, 0x7C, 0xC0, 0x00, 0x01, 0x8F, 0x9C, 0x00, 0x00, 0x31, 0xF1, 0x80,
  0x00, 0x0E, 0x3E, 0x30, 0x00, 0x01, 0x87, 0xC3, 0x00, 0x00, 0x30, 0xF8,
  0x60, 0x00, 0x0C, 0x1F, 0x0E, 0x00, 0x01, 0x83, 0xE0, 0xC0, 0x00, 0x70,
  0x7C, 0x18, 0x00, 0x0C, 0x0F, 0x83, 0x80, 0x01, 0x81, 0xF0, 0x30, 0x00,
  0x70, 0x3E, 0x06, 0x00, 0x0C, 0x07, 0xC0, 0xE0, 0x01, 0x80, 0xF8, 0x0C,
  0x00, 0x70, 0x1F, 0x01, 0x80, 0x0C, 0x03, 0xE0, 0x18, 0x01, 0x80, 0x7C,
  0x03, 0x00, 0x60, 0x0F, 0x80, 0x70, 0x0C, 0x01, 0xF0, 0x06, 0x03, 0x80,
  0x3E, 0x00, 0xC0, 0x60, 0x07, 0xC0, 0x1C, 0x0C, 0x00, 0xF8, 0x01, 0x83,
  0x80, 0x1F, 0x00, 0x30, 0x60, 0x03, 0xE0, 0x07, 0x0C, 0x00, 0x7C, 0x00,
  0x63, 0x00, 0x0F, 0x80, 0x0E, 0x60, 0x01, 0xF0, 0x00, 0xCC, 0x00, 0x3E,
  0x00, 0x1B, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0x98, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x1F, 0x30, 0x00,
  0x03, 0xE7, 0x00, 0x00, 0x7C, 0x70, 0x00, 0x0F, 0x86, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x3E, 0x0C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0xF8, 0x18, 0x00,
  0x1F, 0x03, 0x80, 0x03, 0xE0, 0x38, 0x00, 0x7C, 0x03, 0x00, 0x0F, 0x80,
  0x70, 0x01, 0xF0, 0x06, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00,
  0xF8, 0x00, 0xC0, 0x1F, 0x00, 0x1C, 0x03, 0xE0, 0x01, 0x80, 0x7C, 0x00,
  0x38, 0x0F, 0x80, 0x03, 0x81, 0xF0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x07,
  0xC0, 0x00, 0x60, 0xF8, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0xC3, 0xE0, 0x00,
  0x1C, 0x7C, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x19, 0xF0, 0x00, 0x03, 0xBE,
  0x00, 0x00, 0x37, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0E, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x38, 0x00, 0x3C, 0xE0, 0x01,
  0xE3, 0x81, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xBE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0xE0, 0x01, 0xE0, 0xE0, 0x0F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x01,
  0xC0, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x3E, 0x03, 0xF0, 0xE0, 0x00, 0x43, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0xF0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x07, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x38, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x70, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x63, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0xE3, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x38, 0x00, 0x19, 0x80, 0x00, 0xC1, 0x80, 0x01, 0x8C,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x06, 0x00, 0x38,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x0E,
  0x00, 0x60, 0x70, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x18,
  0x0E, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x03, 0x81, 0x80, 0x1C, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x63, 0x80, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60,
  0x00, 0x63, 0x00, 0x00, 0xE6, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x37, 0x00, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x80, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x60,
  0x0C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x18, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x01, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x06,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x1C,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x3C, 0x03, 0xC1, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x3F, 0x01, 0xFF, 0xF0, 0xFF, 0x07, 0x1E, 0x00, 0x73, 0x80, 0x07,
  0x70, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xBE, 0x00,
  0x33, 0x70, 0x07, 0x33, 0xE3, 0xE3, 0x1F, 0xF8, 0x30, 0x38, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x3F, 0xE0, 0x30, 0xFF, 0xF0, 0x67, 0x00, 0xF0, 0xDC, 0x00, 0x71,
  0xB0, 0x00, 0x63, 0xC0, 0x00, 0xE7, 0x80, 0x00, 0xCE, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0x3C, 0x00, 0x0E, 0x78, 0x00, 0x18, 0xD8, 0x00, 0x71, 0x9C, 0x03, 0xC3,
  0x1F, 0x7F, 0x06, 0x1F, 0xF8, 0x00, 0x05, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0x07, 0x80, 0x20, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x10, 0x7F, 0x7E,
  0x01, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x1F, 0xE0, 0xC0, 0xFF, 0xF1,
  0x87, 0x80, 0x73, 0x1E, 0x00, 0x76, 0x38, 0x00, 0x6C, 0xE0, 0x00, 0x79,
  0x80, 0x00, 0xF7, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x76, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x9C, 0x00, 0x0B,
  0x1C, 0x00, 0x36, 0x1C, 0x01, 0xCC, 0x1F, 0x9F, 0x18, 0x1F, 0xF8, 0x30,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x70, 0x1E, 0x03,
  0x80, 0x18, 0x1C, 0x00, 0x30, 0xE0, 0x00, 0xE3, 0x00, 0x01, 0x9C, 0x00,
  0x06, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x02, 0x0F, 0x00, 0x18, 0x1F,
  0xDF, 0xE0, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xFF,
  0xC3, 0xFF, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x06, 0x07, 0xFF, 0x8C, 0x3C,
  0x03, 0x98, 0xE0, 0x03, 0xB1, 0x80, 0x03, 0x67, 0x00, 0x03, 0xCC, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x3C, 0xE0, 0x00, 0xD8, 0xE0,
  0x03, 0xB0, 0xE0, 0x0E, 0x60, 0xF8, 0xF8, 0xC0, 0xFF, 0xC1, 0x80, 0x18,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x40, 0x00, 0xE0, 0xF8, 0x07, 0x80, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0xFF, 0x83, 0x1F, 0xFE, 0x19, 0xC0, 0x38, 0xDC, 0x00, 0xE6,
  0xC0, 0x03, 0xBC, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x30, 0x6F,
  0xF6, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x01, 0x80, 0xF0, 0x3C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x21, 0xCF, 0xE3, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x1C, 0xC0, 0x07, 0x18, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x03, 0x81, 0x80, 0xE0, 0x30, 0x18,
  0x06, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x1E, 0x00, 0x67, 0xC0,
  0x0C, 0xDC, 0x01, 0xB1, 0xC0, 0x3C, 0x18, 0x07, 0x03, 0x80, 0xE0, 0x30,
  0x18, 0x07, 0x03, 0x00, 0x70, 0x60, 0x06, 0x0C, 0x00, 0xE1, 0x80, 0x0C,
  0x30, 0x00, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x03,
  0xE0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFC, 0x01, 0xFE, 0x0C, 0x7F, 0xF0, 0x7F, 0xF8, 0xCE,
  0x07, 0x8E, 0x03, 0xCD, 0x80, 0x18, 0xC0, 0x0C, 0xD0, 0x01, 0xD8, 0x00,
  0xEF, 0x00, 0x0F, 0x00, 0x06, 0xE0, 0x00, 0xF0, 0x00, 0x6E, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0xC0,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xC1, 0xFF,
  0x06, 0x1F, 0xFE, 0x33, 0x80, 0x79, 0xB8, 0x01, 0xCD, 0x80, 0x07, 0x78,
  0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xC1, 0xFF, 0x01, 0x87,
  0xFF, 0x83, 0x1C, 0x07, 0x86, 0x60, 0x03, 0x8D, 0x80, 0x03, 0x1E, 0x00,
  0x07, 0x3C, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB8,
  0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x19, 0xE0, 0x00, 0x73, 0x60,
  0x00, 0xC6, 0xE0, 0x03, 0x8C, 0xE0, 0x1E, 0x18, 0xFD, 0xF8, 0x30, 0x7F,
  0xC0, 0x60, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x06, 0x07, 0xFF, 0x8C,
  0x3C, 0x03, 0x98, 0xE0, 0x03, 0xB1, 0x80, 0x03, 0x67, 0x00, 0x03, 0xCC,
  0x00, 0x07, 0xB8, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0xB0, 0x00, 0x07, 0x70, 0x00, 0x1E, 0x60, 0x00, 0x2C, 0xE0, 0x00, 0xD8,
  0xE0, 0x03, 0x30, 0xE0, 0x0E, 0x60, 0xF9, 0xF8, 0xC0, 0xFF, 0xC1, 0x80,
  0x1C, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0x37, 0x00, 0xD8,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0xFC, 0x70, 0x03, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x00, 0x6E, 0x00, 0x3D, 0xFE, 0xFF, 0x0F, 0xFF,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0xCC, 0x0F, 0xF0, 0x02, 0x00,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x6C, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x1E, 0x70,
  0x01, 0x93, 0xC0, 0x38, 0x8F, 0xDF, 0x84, 0x1F, 0xF8, 0x20, 0x08, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xE7,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0xE0, 0x70, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x07, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x71, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x76,
  0x00, 0x0F, 0x00, 0x0C, 0xC0, 0x03, 0x70, 0x01, 0x9C, 0x00, 0x66, 0x00,
  0x31, 0x80, 0x0C, 0xC0, 0x0E, 0x30, 0x03, 0x98, 0x01, 0x86, 0x00, 0x63,
  0x80, 0x30, 0xE0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x01, 0xC1, 0x80,
  0x60, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x07, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x38, 0x0C, 0x0C, 0x07, 0x06, 0x01, 0xC1, 0x80, 0x60,
  0xC0, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x87, 0x00, 0x61, 0x80,
  0x18, 0xC0, 0x0E, 0x30, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x0E, 0xE0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x1B, 0x00,
  0x07, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x1C, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0xC0, 0x06,
  0x01, 0x80, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x80, 0xE0, 0x03, 0x03, 0x80,
  0x07, 0x06, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0E, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x30, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x18, 0x00,
  0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0,
  0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x02, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0xFE, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0x7F, 0xF0, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0x0F, 0xFE, 0x80,
  0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 41, 13, 5, -41 },
  { 17, 11, 15, 19, 4, -41 },
  { 38, 31, 41, 33, 1, -41 },
  { 197, 22, 47, 29, 3, -44 },
  { 327, 36, 43, 42, 3, -42 },
  { 521, 31, 43, 35, 3, -42 },
  { 688, 2, 15, 10, 4, -41 },
  { 692, 10, 50, 15, 3, -41 },
  { 755, 11, 50, 15, 2, -41 },
  { 824, 21, 21, 28, 3, -44 },
  { 880, 24, 27, 30, 3, -34 },
  { 961, 6, 13, 11, 2, -6 },
  { 971, 13, 2, 17, 2, -17 },
  { 975, 4, 4, 12, 4, -4 },
  { 977, 18, 41, 19, 1, -41 },
  { 1070, 23, 43, 29, 3, -42 },
  { 1194, 12, 41, 29, 5, -41 },
  { 1256, 23, 42, 29, 3, -42 },
  { 1377, 23, 43, 29, 3, -42 },
  { 1501, 28, 42, 29, 1, -42 },
  { 1648, 22, 42, 29, 4, -41 },
  { 1764, 24, 43, 29, 3, -42 },
  { 1893, 23, 41, 29, 3, -41 },
  { 2011, 23, 43, 29, 3, -42 },
  { 2135, 23, 43, 29, 3, -42 },
  { 2259, 4, 31, 12, 4, -31 },
  { 2275, 6, 38, 12, 2, -31 },
  { 2304, 24, 26, 30, 3, -34 },
  { 2382, 24, 14, 30, 3, -27 },
  { 2424, 24, 26, 30, 3, -34 },
  { 2502, 17, 42, 21, 2, -42 },
  { 2592, 39, 47, 45, 3, -41 },
  { 2822, 30, 41, 30, 0, -41 },
  { 2976, 24, 41, 32, 5, -41 },
  { 3099, 27, 43, 32, 3, -42 },
  { 3245, 27, 41, 36, 5, -41 },
  { 3384, 20, 41, 28, 5, -41 },
  { 3487, 20, 41, 26, 5, -41 },
  { 3590, 31, 43, 38, 3, -42 },
  { 3757, 26, 41, 37, 5, -41 },
  { 3891, 10, 41, 16, 3, -41 },
  { 3943, 12, 51, 13, -4, -41 },
  { 4020, 24, 41, 29, 5, -41 },
  { 4143, 20, 41, 26, 5, -41 },
  { 4246, 35, 41, 45, 5, -41 },
  { 4426, 27, 41, 37, 5, -41 },
  { 4565, 33, 43, 39, 3, -42 },
  { 4743, 22, 41, 30, 5, -41 },
  { 4856, 33, 52, 39, 3, -42 },
  { 5071, 24, 41, 30, 5, -41 },
  { 5194, 23, 43, 28, 3, -42 },
  { 5318, 26, 41, 26, 0, -41 },
  { 5452, 27, 42, 37, 5, -41 },
  { 5594, 29, 41, 29, 0, -41 },
  { 5743, 44, 41, 46, 1, -41 },
  { 5969, 26, 41, 27, 0, -41 },
  { 6103, 26, 41, 26, 0, -41 },
  { 6237, 24, 41, 28, 2, -41 },
  { 6360, 11, 50, 18, 5, -41 },
  { 6429, 18, 41, 19, 1, -41 },
  { 6522, 11, 50, 18, 2, -41 },
  { 6591, 26, 24, 30, 2, -42 },
  { 6669, 23, 2, 23, 0, 5 },
  { 6675, 10, 9, 14, 2, -44 },
  { 6687, 20, 32, 27, 3, -31 },
  { 6767, 23, 45, 31, 5, -44 },
  { 6897, 20, 32, 24, 3, -31 },
  { 6977, 23, 45, 31, 3, -44 },
  { 7107, 22, 32, 28, 3, -31 },
  { 7195, 17, 44, 15, 1, -44 },
  { 7289, 23, 45, 31, 3, -31 },
  { 7419, 21, 44, 30, 5, -44 },
  { 7535, 4, 42, 12, 4, -42 },
  { 7556, 10, 56, 12, -2, -42 },
  { 7626, 19, 44, 24, 5, -44 },
  { 7731, 2, 44, 12, 5, -44 },
  { 7742, 36, 31, 45, 5, -31 },
  { 7882, 21, 31, 30, 5, -31 },
  { 7964, 24, 32, 30, 3, -31 },
  { 8060, 23, 45, 31, 5, -31 },
  { 8190, 23, 45, 31, 3, -31 },
  { 8320, 14, 31, 20, 5, -31 },
  { 8375, 19, 32, 24, 2, -31 },
  { 8451, 14, 39, 17, 1, -38 },
  { 8520, 21, 32, 30, 4, -31 },
  { 8604, 23, 31, 23, 0, -31 },
  { 8694, 35, 31, 37, 1, -31 },
  { 8830, 23, 31, 25, 1, -31 },
  { 8920, 23, 45, 23, 0, -31 },
  { 9050, 18, 31, 23, 2, -31 },
  { 9120, 16, 50, 20, 2, -41 },
  { 9220, 2, 58, 28, 13, -44 },
  { 9235, 16, 50, 20, 2, -41 },
  { 9335, 24, 5, 30, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT58PT7B_H_
