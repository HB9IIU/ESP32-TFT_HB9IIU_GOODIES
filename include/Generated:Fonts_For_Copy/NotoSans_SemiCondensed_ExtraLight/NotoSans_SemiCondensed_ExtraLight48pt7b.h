#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight48pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x64, 0x92, 0x40, 0x00,
  0x07, 0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x02, 0x81, 0x40,
  0xA0, 0x50, 0x28, 0x10, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x04, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x0F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x08, 0x06, 0x00, 0x04, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0x30, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x04,
  0x03, 0xFF, 0xFF, 0xF8, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30,
  0x18, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x03, 0xFF,
  0x81, 0xE4, 0x7C, 0x70, 0x81, 0x1C, 0x10, 0x03, 0x02, 0x00, 0x60, 0x40,
  0x08, 0x08, 0x03, 0x01, 0x00, 0x20, 0x20, 0x06, 0x04, 0x00, 0xC0, 0x80,
  0x0C, 0x10, 0x01, 0xC2, 0x00, 0x1E, 0x40, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x04, 0xF0, 0x00, 0x87, 0x00, 0x10, 0x70, 0x02, 0x06,
  0x00, 0x40, 0x60, 0x08, 0x0C, 0x01, 0x01, 0x80, 0x20, 0x30, 0x04, 0x06,
  0x00, 0x80, 0xC0, 0x10, 0x30, 0x02, 0x0E, 0x60, 0x43, 0x8F, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x1C, 0x30, 0x01, 0x80, 0xC1,
  0x80, 0x18, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x06, 0x00, 0x80, 0x20, 0x30, 0x04, 0x01, 0x83, 0x00,
  0x20, 0x0C, 0x18, 0x01, 0x00, 0x60, 0x80, 0x08, 0x03, 0x0C, 0x00, 0x40,
  0x10, 0x40, 0x02, 0x00, 0x86, 0x1F, 0x18, 0x0C, 0x21, 0xFC, 0xC0, 0x63,
  0x18, 0x36, 0x03, 0x11, 0x81, 0x98, 0x31, 0x8C, 0x04, 0xE1, 0x88, 0x40,
  0x33, 0xF8, 0xC6, 0x01, 0x87, 0x06, 0x30, 0x0C, 0x00, 0x61, 0x80, 0x60,
  0x03, 0x0C, 0x03, 0x00, 0x30, 0x60, 0x08, 0x01, 0x83, 0x00, 0xC0, 0x18,
  0x18, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x06, 0x01, 0x00, 0x18, 0x30,
  0x18, 0x00, 0xE3, 0x01, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x20, 0x06, 0x00, 0x08, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x70, 0x60, 0x06,
  0x38, 0x1C, 0x01, 0x0C, 0x03, 0x80, 0xC6, 0x00, 0x60, 0x31, 0x80, 0x0C,
  0x0C, 0x40, 0x01, 0x86, 0x30, 0x00, 0x31, 0x8C, 0x00, 0x0E, 0xC3, 0x00,
  0x01, 0xF0, 0x40, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0xC0,
  0xC0, 0x03, 0x98, 0x38, 0x01, 0xC7, 0x07, 0xC3, 0xC0, 0xE0, 0x7F, 0xC0,
  0x1C, 0xFF, 0xFD, 0x55, 0x03, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x10, 0x10, 0x1F, 0x84, 0x3C, 0xFD, 0x7C, 0x03, 0xF8,
  0x00, 0x38, 0x00, 0x1B, 0x00, 0x04, 0x40, 0x03, 0x18, 0x01, 0x83, 0x00,
  0xC0, 0x60, 0x70, 0x1C, 0x08, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x46, 0x30, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x38, 0x38, 0x0C, 0x03, 0x83,
  0x00, 0x30, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0x40, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0,
  0x03, 0x0C, 0x00, 0x61, 0xC0, 0x18, 0x1C, 0x06, 0x01, 0xE3, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0xC0, 0x70, 0x74, 0x39, 0x18, 0x5C, 0x1E, 0x05, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x01, 0xF0, 0x01,
  0xFF, 0x80, 0xF0, 0x3C, 0x38, 0x01, 0x82, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0xF0, 0x1C, 0x70, 0x01, 0xC4, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0xC0, 0x03, 0x9F, 0x03, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x34, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x90, 0x00, 0x06, 0x20, 0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00,
  0xC1, 0x00, 0x03, 0x02, 0x00, 0x06, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20,
  0x10, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x40, 0x06, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x60, 0x02, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x10,
  0x18, 0x00, 0x20, 0x60, 0x00, 0x40, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x1F, 0xFF, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE6, 0x00, 0x38, 0xF8, 0x3C, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xF0, 0x0E, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0xFF, 0x06, 0x3F, 0xF0, 0xDC, 0x03,
  0x1A, 0x00, 0x33, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xA0, 0x00, 0x36, 0x00, 0x04, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C,
  0x18, 0x03, 0x81, 0xC1, 0xE0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x81, 0x80, 0x18, 0x30, 0x00, 0xC3,
  0x00, 0x04, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x62, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0xC0, 0xC0, 0x38, 0x06, 0x07,
  0x00, 0x39, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0x0E, 0x00, 0xE0,
  0x30, 0x18, 0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x36,
  0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0xC0, 0xF0, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x38, 0x1C, 0x0C, 0x01,
  0x83, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xD0, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xE6, 0x00, 0x14, 0xC0, 0x04,
  0x8E, 0x03, 0xB0, 0xFF, 0xC6, 0x07, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x04, 0x0F, 0x00,
  0xFF, 0xC0, 0x01, 0x80, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x31, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x23, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xE3, 0x80, 0xE2, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0xC0,
  0x06, 0x60, 0x07, 0xFC, 0x06, 0x60, 0x0E, 0x04, 0x02, 0x40, 0x18, 0x04,
  0x03, 0xC0, 0x30, 0x04, 0x03, 0xC0, 0x60, 0x04, 0x03, 0xC0, 0x60, 0x04,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x40, 0x0C, 0x03, 0x80, 0xC0, 0x0C,
  0x03, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0xC0, 0x0C,
  0x03, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0x40, 0x1C, 0x02, 0xC0, 0x60, 0x14,
  0x06, 0xC0, 0x60, 0x36, 0x04, 0xC0, 0x30, 0x66, 0x0C, 0xC0, 0x1F, 0xC3,
  0xF8, 0x60, 0x07, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x02, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x10, 0x10, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x7F, 0xFF, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x10, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xC0, 0xFF, 0xFC, 0x0C, 0x03,
  0xF8, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x03, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0C, 0x00, 0x38, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0,
  0x00, 0xCC, 0x00, 0x38, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xE0, 0x1E, 0x03, 0xC1, 0xC0, 0x01, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x04, 0x0F, 0x83, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0x80, 0xFE, 0x03, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x70, 0x60, 0x03, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x7F, 0xFF, 0xB0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x70, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x70, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x07, 0x80, 0x01, 0x80, 0xFC, 0x1F,
  0xC0, 0x1F, 0xFF, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x1C, 0x7F, 0xC0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x83, 0xBF, 0xC3, 0x00, 0xC0,
  0x00, 0x7C, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x03, 0x0C,
  0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0C, 0x07, 0x00,
  0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0xF0, 0x00, 0xCD, 0x80, 0x0D, 0x9C, 0x00, 0xF0, 0xC0, 0x0E, 0x06,
  0x00, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xB0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x05, 0xEC, 0x00, 0x00, 0x6F, 0x30,
  0x00, 0x03, 0x79, 0x80, 0x00, 0x13, 0xC4, 0x00, 0x01, 0x9E, 0x30, 0x00,
  0x0C, 0xF1, 0x80, 0x00, 0xC7, 0x86, 0x00, 0x06, 0x3C, 0x30, 0x00, 0x21,
  0xE1, 0x80, 0x03, 0x0F, 0x06, 0x00, 0x18, 0x78, 0x30, 0x00, 0x83, 0xC1,
  0x80, 0x0C, 0x1E, 0x06, 0x00, 0x60, 0xF0, 0x30, 0x06, 0x07, 0x80, 0x80,
  0x30, 0x3C, 0x06, 0x01, 0x81, 0xE0, 0x30, 0x18, 0x0F, 0x00, 0xC0, 0xC0,
  0x78, 0x06, 0x04, 0x03, 0xC0, 0x30, 0x60, 0x1E, 0x00, 0xC3, 0x00, 0xF0,
  0x06, 0x10, 0x07, 0x80, 0x31, 0x80, 0x3C, 0x00, 0xCC, 0x01, 0xE0, 0x06,
  0xC0, 0x0F, 0x00, 0x16, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x18, 0x00, 0xC0, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xD8, 0x00, 0x0F, 0x30, 0x00, 0x3C, 0xC0, 0x00,
  0xF1, 0x80, 0x03, 0xC7, 0x00, 0x0F, 0x0C, 0x00, 0x3C, 0x18, 0x00, 0xF0,
  0x60, 0x03, 0xC0, 0xC0, 0x0F, 0x03, 0x00, 0x3C, 0x06, 0x00, 0xF0, 0x1C,
  0x03, 0xC0, 0x30, 0x0F, 0x00, 0x60, 0x3C, 0x01, 0x80, 0xF0, 0x03, 0x03,
  0xC0, 0x0E, 0x0F, 0x00, 0x18, 0x3C, 0x00, 0x30, 0xF0, 0x00, 0xC3, 0xC0,
  0x01, 0x8F, 0x00, 0x07, 0x3C, 0x00, 0x0C, 0xF0, 0x00, 0x1B, 0xC0, 0x00,
  0x6F, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x07,
  0x80, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x07,
  0x00, 0x38, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x30,
  0x3F, 0x8C, 0x00, 0x73, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x07, 0x30,
  0x07, 0x8F, 0xFF, 0x83, 0xFE, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x07, 0x80,
  0x18, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x07, 0x00,
  0x38, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xF8,
  0x0C, 0x0F, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C,
  0x00, 0x30, 0xC0, 0x0E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00,
  0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x00,
  0xF8, 0x00, 0xFF, 0xF0, 0x38, 0x07, 0x0C, 0x00, 0x23, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x80, 0x03, 0x9F, 0x83, 0xE0, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x07, 0x00, 0x38, 0x0F, 0x83, 0xC0,
  0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x3E, 0x00, 0x03, 0x80, 0x01, 0x98, 0x00, 0x1C, 0x00, 0x0C, 0xC0,
  0x01, 0xE0, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x06, 0x30, 0x00, 0x6C, 0x00,
  0x30, 0xC0, 0x02, 0x60, 0x01, 0x86, 0x00, 0x33, 0x00, 0x0C, 0x30, 0x01,
  0x98, 0x00, 0xC1, 0x80, 0x0C, 0x60, 0x06, 0x06, 0x00, 0x43, 0x00, 0x30,
  0x30, 0x06, 0x18, 0x01, 0x81, 0x80, 0x30, 0xC0, 0x18, 0x0C, 0x01, 0x83,
  0x00, 0xC0, 0x30, 0x08, 0x18, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x0C,
  0x06, 0x06, 0x03, 0x00, 0x60, 0x30, 0x18, 0x18, 0x01, 0x81, 0x00, 0xC0,
  0xC0, 0x0C, 0x18, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x03, 0x06,
  0x00, 0xC3, 0x00, 0x0C, 0x20, 0x06, 0x18, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x00, 0x44, 0x00,
  0x33, 0x00, 0x03, 0x60, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x00,
  0xD8, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x0E, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x01,
  0xB0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x03,
  0x1C, 0x00, 0x0E, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x60, 0x18, 0x00, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF,
  0xF0, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x0C,
  0x60, 0x00, 0x22, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0xF0, 0x0F,
  0xFE, 0x0E, 0x03, 0x84, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xF0, 0x3F,
  0xF8, 0xF8, 0x0C, 0xE0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x16, 0xC0, 0x1B,
  0x38, 0x39, 0x8F, 0xF0, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x07, 0xE0, 0x63, 0xFF, 0x0C, 0xC0, 0x71,
  0xB0, 0x07, 0x3C, 0x00, 0x67, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0D, 0x80, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x0C, 0xF0, 0x01, 0x9B,
  0x00, 0xE2, 0x38, 0x78, 0x43, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x0E,
  0x02, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x07, 0x07, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x0F,
  0xC1, 0x87, 0xFE, 0x31, 0xC0, 0x66, 0x70, 0x06, 0xDC, 0x00, 0x5B, 0x00,
  0x0F, 0x60, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00,
  0x3B, 0x00, 0x0F, 0x70, 0x01, 0x67, 0x00, 0x4C, 0x78, 0x39, 0x83, 0xFC,
  0x30, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x0C, 0x30, 0x03,
  0x18, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x02, 0x0F, 0x07, 0x81, 0xFF, 0xC0,
  0x00, 0xF0, 0x0F, 0xF0, 0x70, 0x41, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xE0, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x8C, 0x70, 0x19,
  0x9C, 0x01, 0xB7, 0x00, 0x1E, 0xC0, 0x01, 0xD8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x03, 0xDC, 0x00, 0xD9,
  0xC0, 0x33, 0x1E, 0x0C, 0x60, 0xFF, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x31, 0x00, 0x0C, 0x3C, 0x07, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x7C, 0x18,
  0xFF, 0x8C, 0xC0, 0x66, 0xC0, 0x1B, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x30, 0x7D, 0xB0, 0x00, 0x01, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x03, 0x07, 0x07, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x06, 0x8E, 0xFC, 0x20, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0x80, 0xC3, 0x00, 0xC6, 0x00,
  0xC6, 0x00, 0xCF, 0x00, 0xDB, 0x00, 0xF1, 0x80, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x0F, 0x82, 0x3F, 0xE0, 0xFF, 0x89, 0xC1,
  0xC6, 0x07, 0x34, 0x03, 0xB0, 0x0E, 0xE0, 0x06, 0x80, 0x1B, 0x80, 0x1E,
  0x00, 0x6C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xF0, 0x43, 0xFE, 0x23, 0x01, 0xDB,
  0x00, 0x6F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC7, 0x00,
  0x18, 0xC0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x26, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x60, 0xC0, 0x18, 0x0E, 0x0E,
  0x00, 0xFF, 0x80, 0x01, 0xF8, 0x10, 0xFF, 0xC2, 0x30, 0x1C, 0x6C, 0x01,
  0xCF, 0x00, 0x19, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0x70, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x03, 0x3C, 0x00, 0x66, 0xC0, 0x18,
  0xCE, 0x1E, 0x18, 0xFF, 0x83, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE3,
  0x0E, 0x03, 0x31, 0xC0, 0x1B, 0x38, 0x00, 0xB3, 0x00, 0x0F, 0x30, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x73,
  0x00, 0x0B, 0x38, 0x01, 0xB1, 0xC0, 0x33, 0x0F, 0x0E, 0x30, 0x7F, 0xC3,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x03, 0xEC, 0x7F, 0xCC, 0x0D, 0x80, 0xF0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0xF0, 0x1F, 0xFE, 0x38,
  0x06, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x80, 0x0C, 0xF0, 0x3C, 0x7F, 0xF0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xFF, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x10, 0x7F, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3B, 0x00, 0x3D, 0xC0, 0x36,
  0x78, 0x71, 0x1F, 0xF0, 0x80, 0xC0, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x18,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x00, 0x98, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x28, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0x40, 0x04, 0xC0, 0x0B, 0x00, 0x66, 0x00, 0xD8, 0x03, 0x30,
  0x06, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x86, 0x03, 0x18, 0x0C, 0x30, 0x18,
  0xC0, 0x61, 0x80, 0xC2, 0x03, 0x0C, 0x04, 0x18, 0x10, 0x30, 0x60, 0xC1,
  0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x60, 0x21, 0x80, 0xC2, 0x01,
  0x8C, 0x06, 0x30, 0x0C, 0x60, 0x11, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x30,
  0x06, 0x40, 0x0D, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xB0, 0x03, 0x40, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0xE0, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x1C, 0x06, 0x03,
  0x03, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00, 0x6C, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3B, 0x00, 0x0C, 0x60,
  0x06, 0x18, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x70, 0x18, 0x18, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x19, 0x80, 0x07, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x03, 0x00, 0x60, 0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03,
  0x08, 0x00, 0x63, 0x00, 0x04, 0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x01,
  0x60, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x38, 0x00, 0x7E, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x0F, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x7C, 0x00,
  0x70, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0xC0, 0x07, 0x80, 0x7C, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x80, 0xF8, 0x04, 0x00,
  0x00, 0x3F, 0x80, 0x17, 0x3E, 0x01, 0xC0, 0x7C, 0x78, 0x00, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 34, 11, 4, -34 },
  { 14, 9, 12, 16, 3, -34 },
  { 28, 25, 34, 27, 1, -34 },
  { 135, 19, 39, 24, 2, -36 },
  { 228, 29, 35, 35, 3, -35 },
  { 355, 26, 35, 29, 2, -35 },
  { 469, 2, 12, 9, 3, -34 },
  { 472, 9, 42, 13, 2, -34 },
  { 520, 9, 42, 13, 2, -34 },
  { 568, 18, 17, 23, 2, -36 },
  { 607, 20, 22, 24, 2, -28 },
  { 662, 5, 11, 9, 2, -5 },
  { 669, 11, 2, 14, 2, -14 },
  { 672, 3, 3, 10, 4, -3 },
  { 674, 14, 34, 16, 1, -34 },
  { 734, 19, 35, 24, 3, -35 },
  { 818, 10, 34, 24, 4, -34 },
  { 861, 19, 35, 24, 2, -35 },
  { 945, 19, 35, 24, 2, -35 },
  { 1029, 23, 34, 24, 1, -34 },
  { 1127, 19, 34, 24, 3, -34 },
  { 1208, 19, 36, 24, 3, -35 },
  { 1294, 20, 34, 24, 2, -34 },
  { 1379, 20, 35, 24, 2, -35 },
  { 1467, 19, 36, 24, 2, -35 },
  { 1553, 3, 26, 10, 4, -26 },
  { 1563, 5, 32, 10, 2, -26 },
  { 1583, 20, 21, 24, 2, -28 },
  { 1636, 20, 12, 24, 2, -23 },
  { 1666, 20, 21, 24, 2, -28 },
  { 1719, 15, 35, 18, 1, -35 },
  { 1785, 32, 39, 38, 3, -34 },
  { 1941, 25, 34, 25, 0, -34 },
  { 2048, 20, 34, 27, 4, -34 },
  { 2133, 22, 35, 26, 3, -35 },
  { 2230, 23, 34, 30, 4, -34 },
  { 2328, 17, 34, 24, 4, -34 },
  { 2401, 17, 34, 21, 4, -34 },
  { 2474, 25, 35, 31, 3, -35 },
  { 2584, 22, 34, 30, 4, -34 },
  { 2678, 9, 34, 13, 2, -34 },
  { 2717, 10, 43, 11, -4, -34 },
  { 2771, 20, 34, 24, 4, -34 },
  { 2856, 17, 34, 22, 4, -34 },
  { 2929, 29, 34, 38, 4, -34 },
  { 3053, 22, 34, 31, 4, -34 },
  { 3147, 26, 35, 32, 3, -35 },
  { 3261, 18, 34, 25, 4, -34 },
  { 3338, 26, 43, 32, 3, -35 },
  { 3478, 20, 34, 25, 4, -34 },
  { 3563, 19, 35, 23, 2, -35 },
  { 3647, 21, 34, 22, 0, -34 },
  { 3737, 22, 34, 30, 4, -34 },
  { 3831, 24, 34, 24, 0, -34 },
  { 3933, 37, 34, 38, 1, -34 },
  { 4091, 22, 34, 22, 0, -34 },
  { 4185, 22, 34, 22, 0, -34 },
  { 4279, 20, 34, 23, 2, -34 },
  { 4364, 10, 42, 15, 4, -34 },
  { 4417, 14, 34, 16, 1, -34 },
  { 4477, 10, 42, 15, 1, -34 },
  { 4530, 21, 19, 24, 2, -34 },
  { 4580, 19, 2, 19, 0, 4 },
  { 4585, 8, 8, 12, 2, -37 },
  { 4593, 17, 26, 22, 2, -26 },
  { 4649, 19, 36, 26, 4, -36 },
  { 4735, 16, 26, 20, 3, -26 },
  { 4787, 19, 36, 26, 3, -36 },
  { 4873, 18, 26, 23, 3, -26 },
  { 4932, 14, 37, 13, 1, -37 },
  { 4997, 19, 38, 25, 3, -26 },
  { 5088, 17, 36, 25, 4, -36 },
  { 5165, 3, 35, 10, 3, -35 },
  { 5179, 8, 47, 10, -2, -35 },
  { 5226, 16, 36, 20, 4, -36 },
  { 5298, 2, 36, 10, 4, -36 },
  { 5307, 30, 26, 37, 4, -26 },
  { 5405, 17, 26, 25, 4, -26 },
  { 5461, 19, 26, 25, 3, -26 },
  { 5523, 19, 37, 25, 4, -26 },
  { 5611, 20, 37, 25, 2, -26 },
  { 5704, 12, 26, 16, 4, -26 },
  { 5743, 16, 26, 20, 2, -26 },
  { 5795, 12, 32, 14, 1, -32 },
  { 5843, 17, 25, 25, 4, -25 },
  { 5897, 19, 25, 19, 0, -25 },
  { 5957, 29, 25, 31, 1, -25 },
  { 6048, 18, 25, 21, 1, -25 },
  { 6105, 19, 37, 19, 0, -25 },
  { 6193, 15, 25, 19, 2, -25 },
  { 6240, 13, 42, 17, 2, -34 },
  { 6309, 1, 49, 23, 11, -37 },
  { 6316, 13, 42, 17, 2, -34 },
  { 6385, 20, 4, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT48PT7B_H_
