#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFD, 0x55, 0x55, 0x00, 0x7C, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x04, 0x01, 0x81, 0x00, 0x18, 0x10, 0x01, 0x01,
  0x00, 0x10, 0x30, 0x01, 0x03, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x30,
  0x20, 0x7F, 0xFF, 0xF0, 0x20, 0x60, 0x02, 0x06, 0x00, 0x20, 0x40, 0x06,
  0x04, 0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x0F,
  0xFF, 0xFC, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80,
  0x08, 0x18, 0x00, 0x81, 0x80, 0x08, 0x10, 0x01, 0x81, 0x00, 0x10, 0x10,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0xFF, 0xE3, 0x10, 0x8C, 0x20,
  0x30, 0x40, 0x60, 0x80, 0x81, 0x01, 0x02, 0x03, 0x04, 0x02, 0x08, 0x06,
  0x10, 0x07, 0x20, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x02, 0x70, 0x04,
  0x30, 0x08, 0x20, 0x10, 0x60, 0x20, 0xC0, 0x41, 0x80, 0x82, 0x01, 0x0D,
  0x02, 0x13, 0xC5, 0xC1, 0xFF, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x3E, 0x00, 0x60, 0x61, 0x00, 0x40, 0x41, 0x80, 0xC0,
  0xC0, 0x80, 0x80, 0xC0, 0x81, 0x80, 0x80, 0x81, 0x00, 0x80, 0x83, 0x00,
  0x80, 0xC2, 0x00, 0x80, 0xC6, 0x00, 0x80, 0x84, 0x00, 0x80, 0x8C, 0x30,
  0xC0, 0x88, 0xFC, 0xC0, 0x89, 0x84, 0x41, 0x91, 0x06, 0x61, 0x13, 0x02,
  0x3E, 0x23, 0x02, 0x08, 0x22, 0x02, 0x00, 0x62, 0x02, 0x00, 0x42, 0x03,
  0x00, 0xC2, 0x03, 0x00, 0x82, 0x02, 0x01, 0x82, 0x02, 0x01, 0x03, 0x02,
  0x03, 0x01, 0x02, 0x02, 0x01, 0x06, 0x06, 0x01, 0x8C, 0x04, 0x00, 0xF8,
  0x01, 0x00, 0x00, 0xFE, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x10, 0x18,
  0x03, 0x00, 0x80, 0x30, 0x08, 0x01, 0x01, 0x80, 0x10, 0x18, 0x01, 0x83,
  0x00, 0x08, 0x20, 0x00, 0x4E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0D,
  0x80, 0x03, 0x0C, 0x00, 0x60, 0x40, 0x24, 0x06, 0x06, 0xC0, 0x30, 0x4C,
  0x01, 0x84, 0x80, 0x0C, 0xC8, 0x00, 0x68, 0x80, 0x03, 0x8C, 0x00, 0x30,
  0xC0, 0x07, 0x86, 0x00, 0xCC, 0x38, 0x38, 0x61, 0xFE, 0x03, 0xFF, 0xC0,
  0x06, 0x18, 0x60, 0x83, 0x04, 0x18, 0x30, 0x41, 0x83, 0x06, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0x30, 0x60, 0x40, 0xC1, 0x81,
  0x03, 0x02, 0x06, 0x06, 0x06, 0xC0, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x06,
  0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0xC1, 0x83, 0x04, 0x18, 0x30, 0x41, 0x82, 0x0C, 0x30, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0x84, 0x73, 0xDF, 0x00, 0xE0,
  0x03, 0x00, 0x12, 0x00, 0xC4, 0x06, 0x18, 0x30, 0x30, 0x40, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x33, 0x32, 0x26,
  0x64, 0xC0, 0xFF, 0x80, 0x7C, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xC0, 0x60,
  0xC1, 0x80, 0xC2, 0x00, 0xCC, 0x00, 0x90, 0x01, 0x20, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x34, 0x00, 0x68, 0x00,
  0xD8, 0x01, 0x30, 0x06, 0x20, 0x0C, 0x60, 0x30, 0x70, 0xC0, 0x7F, 0x00,
  0x03, 0x07, 0x0D, 0x19, 0x61, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x00, 0x3F, 0xC1, 0xC0, 0xC2, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0x00, 0x7F, 0xC1,
  0x80, 0xE6, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x07, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0D, 0x00, 0x33, 0x00, 0xC3, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x6C,
  0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0x83, 0x00,
  0x60, 0xC0, 0x10, 0x30, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0xC0, 0x80,
  0x30, 0x60, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x3F, 0xFC, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF,
  0x06, 0x03, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x80,
  0x19, 0xC0, 0x61, 0xFF, 0x80, 0x00, 0x20, 0x07, 0xF8, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x1E, 0x0C, 0xFF, 0x1B, 0x01, 0xB8, 0x01, 0x70, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xB0, 0x03, 0x20, 0x04, 0x60, 0x18, 0x60, 0x60, 0x7F, 0x80, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x1F, 0xE0, 0xE0, 0x61, 0x00, 0x66, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0xC0, 0x18, 0xC0, 0x60, 0xC1, 0x80,
  0xEE, 0x00, 0x70, 0x03, 0xB8, 0x0C, 0x18, 0x30, 0x18, 0xC0, 0x1B, 0x00,
  0x1E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x40, 0x06,
  0xC0, 0x18, 0xE0, 0x60, 0x7F, 0x80, 0x01, 0x00, 0x3F, 0xC0, 0xC0, 0xC3,
  0x00, 0xC4, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x68, 0x01, 0xD8, 0x03, 0x98, 0x1B,
  0x1F, 0xE6, 0x06, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x03, 0x83, 0xFC, 0x00, 0xF4,
  0x00, 0x00, 0x00, 0x1F, 0x33, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x33, 0x32, 0x26, 0x44, 0xC0, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x04, 0x07, 0xF8, 0xC0, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1C, 0x01,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x30, 0x01, 0x80, 0x38,
  0x00, 0x10, 0x08, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x06, 0x60, 0x3F, 0xC0, 0x90, 0x18, 0x10, 0x24, 0x0C, 0x04,
  0x0F, 0x02, 0x01, 0x03, 0xC1, 0x80, 0x40, 0xF0, 0x60, 0x10, 0x38, 0x10,
  0x04, 0x0E, 0x04, 0x03, 0x03, 0x81, 0x00, 0xC0, 0xE0, 0x40, 0x30, 0x28,
  0x18, 0x0C, 0x0B, 0x06, 0x07, 0x06, 0xC0, 0xC1, 0x41, 0x10, 0x1D, 0x8D,
  0xC4, 0x03, 0xC1, 0xC1, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xF0, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x19, 0x80, 0x01, 0x18, 0x00,
  0x10, 0x80, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x60,
  0x04, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x03, 0x00, 0x80, 0x30, 0x0F, 0xFF,
  0x01, 0x80, 0x18, 0x10, 0x01, 0x81, 0x00, 0x08, 0x30, 0x00, 0xC2, 0x00,
  0x0C, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x6C, 0x00, 0x02, 0xC0,
  0x00, 0x30, 0xFF, 0xE1, 0x00, 0xF2, 0x00, 0x64, 0x00, 0x68, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x01,
  0x8F, 0xFC, 0x10, 0x3E, 0x20, 0x06, 0x40, 0x06, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0x80,
  0x19, 0x01, 0xE3, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xF0, 0x70, 0x08,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x18, 0x07, 0xFE, 0xFF, 0xC0, 0x40, 0x78,
  0x20, 0x07, 0x10, 0x01, 0xC8, 0x00, 0x64, 0x00, 0x1A, 0x00, 0x05, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x28, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x19, 0x00, 0x18, 0x80,
  0x18, 0x40, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFB, 0xFF, 0xD0,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFC,
  0x03, 0x80, 0x70, 0xE0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00, 0x16,
  0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x18, 0x00, 0x10, 0xC0, 0x01,
  0x07, 0x80, 0x70, 0x1F, 0xFC, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x06, 0xFC, 0x78, 0x80, 0x07,
  0x00, 0x1A, 0x00, 0x64, 0x01, 0x88, 0x06, 0x10, 0x18, 0x20, 0x60, 0x40,
  0xC0, 0x83, 0x01, 0x0C, 0x02, 0x30, 0x04, 0xC0, 0x0B, 0xC0, 0x14, 0xC0,
  0x31, 0x80, 0x61, 0x80, 0x81, 0x01, 0x03, 0x02, 0x03, 0x04, 0x02, 0x08,
  0x06, 0x10, 0x06, 0x20, 0x04, 0x40, 0x0C, 0x80, 0x0D, 0x00, 0x0A, 0x00,
  0x18, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xE8, 0x00, 0x05, 0xA0, 0x00, 0x36, 0xC0, 0x00, 0x99, 0x00,
  0x02, 0x66, 0x00, 0x19, 0x98, 0x00, 0x46, 0x20, 0x01, 0x18, 0xC0, 0x0C,
  0x63, 0x00, 0x21, 0x84, 0x01, 0x86, 0x18, 0x04, 0x18, 0x20, 0x10, 0x60,
  0x80, 0xC1, 0x83, 0x02, 0x06, 0x04, 0x08, 0x18, 0x18, 0x60, 0x60, 0x61,
  0x01, 0x80, 0x8C, 0x06, 0x03, 0x30, 0x18, 0x0C, 0x80, 0x60, 0x16, 0x01,
  0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3B, 0x00, 0x1C, 0x80, 0x0E, 0x60, 0x07,
  0x18, 0x03, 0x8C, 0x01, 0xC3, 0x00, 0xE0, 0x80, 0x70, 0x60, 0x38, 0x10,
  0x1C, 0x0C, 0x0E, 0x03, 0x07, 0x00, 0x83, 0x80, 0x61, 0xC0, 0x10, 0xE0,
  0x0C, 0x70, 0x03, 0x38, 0x01, 0x9C, 0x00, 0x6E, 0x00, 0x17, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x1F, 0xF8,
  0x01, 0x80, 0xE0, 0x18, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x10, 0x80,
  0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80, 0x00, 0x36,
  0x00, 0x01, 0x30, 0x00, 0x08, 0x80, 0x00, 0xC6, 0x00, 0x04, 0x18, 0x00,
  0x60, 0x60, 0x06, 0x01, 0xC0, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x82, 0x03,
  0x88, 0x03, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x01, 0xCF, 0xFC, 0x3F,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x1F, 0xF8, 0x01, 0x80, 0xE0, 0x18, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00,
  0x10, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x08, 0x80, 0x00, 0xC6, 0x00, 0x04,
  0x18, 0x00, 0x60, 0x60, 0x06, 0x01, 0xC0, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0xFF, 0xC1, 0x01, 0xE2, 0x00, 0xE4, 0x00, 0xC8, 0x00,
  0xD0, 0x01, 0xA0, 0x03, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x24,
  0x00, 0xC8, 0x03, 0x10, 0x3C, 0x3F, 0xE0, 0x40, 0xC0, 0x80, 0x81, 0x01,
  0x82, 0x01, 0x04, 0x03, 0x08, 0x03, 0x10, 0x06, 0x20, 0x06, 0x40, 0x0C,
  0x80, 0x0D, 0x00, 0x0A, 0x00, 0x18, 0x01, 0x80, 0x1F, 0xF8, 0xE0, 0x33,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x33, 0x00, 0xC7, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x26, 0x00,
  0x19, 0x80, 0x06, 0x30, 0x03, 0x07, 0x03, 0x80, 0x7F, 0x80, 0xC0, 0x00,
  0x68, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x40, 0x01,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x01, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x04, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x01, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x00, 0x41, 0x00, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x6C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x06, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xB0, 0x01,
  0xC0, 0x04, 0x80, 0x0E, 0x00, 0x64, 0x00, 0xD0, 0x03, 0x30, 0x04, 0x80,
  0x11, 0x80, 0x26, 0x00, 0x84, 0x01, 0x30, 0x0C, 0x20, 0x18, 0x80, 0x61,
  0x80, 0x84, 0x02, 0x0C, 0x04, 0x30, 0x10, 0x20, 0x21, 0x81, 0x81, 0x03,
  0x04, 0x0C, 0x0C, 0x10, 0x20, 0x40, 0x60, 0x81, 0x86, 0x01, 0x04, 0x0C,
  0x30, 0x08, 0x60, 0x21, 0x80, 0x62, 0x01, 0x08, 0x03, 0x10, 0x0C, 0xC0,
  0x08, 0x80, 0x66, 0x00, 0x4C, 0x01, 0x30, 0x03, 0x40, 0x09, 0x00, 0x1A,
  0x00, 0x78, 0x00, 0x50, 0x03, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x90, 0x01, 0x8C, 0x00, 0x83,
  0x00, 0xC1, 0x80, 0x40, 0x60, 0x60, 0x10, 0x20, 0x0C, 0x30, 0x02, 0x10,
  0x01, 0x98, 0x00, 0x48, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x80, 0x02, 0x40, 0x03, 0x30, 0x03, 0x08, 0x01, 0x06, 0x01, 0x81, 0x00,
  0x80, 0xC0, 0xC0, 0x20, 0x40, 0x18, 0x60, 0x04, 0x60, 0x03, 0x30, 0x00,
  0xF0, 0x00, 0x60, 0xC0, 0x01, 0xA0, 0x00, 0x98, 0x00, 0xC4, 0x00, 0x43,
  0x00, 0x60, 0x80, 0x20, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x18, 0x02, 0x0C,
  0x01, 0x84, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x1B, 0x00, 0x05, 0x00, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x58, 0x00, 0x64, 0x00,
  0x23, 0x00, 0x30, 0x80, 0x10, 0x60, 0x18, 0x10, 0x08, 0x0C, 0x0C, 0x02,
  0x04, 0x01, 0x86, 0x00, 0x42, 0x00, 0x33, 0x00, 0x0B, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x3F, 0xE3, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x78, 0x7F,
  0xCC, 0x06, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3E,
  0x01, 0x58, 0x32, 0x7F, 0x10, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC1, 0x81, 0x9F, 0xE3,
  0x60, 0x67, 0x80, 0x6A, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x05, 0x40, 0x1A, 0xC0, 0x64, 0xC1, 0x88, 0xFE, 0x00,
  0x07, 0xF8, 0xE0, 0x4C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x02, 0x1F, 0xF0, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x1F, 0xC4, 0x60, 0x49, 0x80, 0x56, 0x00, 0xE8, 0x00, 0xD0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x40, 0x06, 0xC0, 0x1C, 0xC0, 0x29,
  0xC1, 0x90, 0xFE, 0x20, 0x0F, 0xE0, 0x60, 0xC3, 0x01, 0x98, 0x03, 0x40,
  0x0D, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0xC3, 0xFE, 0x03, 0xF0, 0x61, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x0F, 0xF8, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0xE2, 0x30, 0x24, 0xC0, 0x2B, 0x00, 0x34, 0x00, 0x68, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xA0, 0x03, 0x60, 0x0A, 0x60, 0x14, 0x60, 0xC8, 0x7F,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x19,
  0x00, 0x33, 0xC3, 0xC1, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x3F, 0x8D,
  0x83, 0xB8, 0x06, 0xA0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xBC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xA6, 0xF0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01,
  0xB0, 0x19, 0x80, 0x8C, 0x08, 0x60, 0xC3, 0x0C, 0x18, 0xC0, 0xC4, 0x06,
  0x60, 0x35, 0x81, 0x64, 0x0E, 0x30, 0x60, 0x83, 0x06, 0x18, 0x18, 0xC0,
  0x46, 0x03, 0x30, 0x09, 0x80, 0x6C, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x8F, 0xC1, 0xF8, 0x90, 0x66, 0x0C, 0xA0, 0x34,
  0x06, 0xE0, 0x18, 0x02, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0x8F, 0xF2, 0x60, 0xEA, 0x01, 0xA8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x04, 0x40,
  0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60,
  0x04, 0x30, 0x0C, 0x18, 0x18, 0x0F, 0xF0, 0x8F, 0xF1, 0x30, 0x32, 0xC0,
  0x35, 0x00, 0x6C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x02, 0xE0, 0x0D, 0xE0, 0x33, 0x60, 0xE6, 0x7F, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xE2, 0x30, 0x64, 0xC0, 0x2B, 0x00, 0x74, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xA0, 0x03, 0x60, 0x0A, 0x60, 0x34,
  0xE0, 0xC8, 0x7F, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x8F, 0xCC, 0x2C,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x1F, 0xF9, 0x80, 0x98,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xB8, 0x1C, 0xFF, 0x80, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x07, 0xFC,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x0F, 0x80, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x1D, 0x80, 0xF7, 0x06, 0xCF, 0xF3, 0xC0, 0x06, 0x80,
  0x09, 0x00, 0x13, 0x00, 0x62, 0x00, 0x84, 0x01, 0x0C, 0x06, 0x08, 0x08,
  0x10, 0x10, 0x30, 0x60, 0x20, 0x80, 0x41, 0x00, 0xC6, 0x00, 0x88, 0x01,
  0x10, 0x03, 0x60, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x08, 0x00, 0xC0,
  0x18, 0x03, 0x40, 0x1C, 0x02, 0x60, 0x14, 0x02, 0x60, 0x14, 0x02, 0x20,
  0x34, 0x06, 0x20, 0x26, 0x04, 0x30, 0x22, 0x04, 0x30, 0x62, 0x04, 0x10,
  0x63, 0x0C, 0x10, 0x43, 0x08, 0x18, 0x41, 0x08, 0x08, 0xC1, 0x08, 0x08,
  0x81, 0x98, 0x0C, 0x80, 0x90, 0x0D, 0x80, 0x90, 0x05, 0x80, 0x90, 0x05,
  0x00, 0xF0, 0x05, 0x00, 0x60, 0x07, 0x00, 0x60, 0x02, 0x00, 0x60, 0xC0,
  0x0D, 0x80, 0x62, 0x01, 0x0C, 0x0C, 0x18, 0x20, 0x21, 0x80, 0xCC, 0x01,
  0x20, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x01, 0xA0, 0x0C, 0xC0, 0x21, 0x01,
  0x86, 0x04, 0x0C, 0x30, 0x11, 0x80, 0x64, 0x00, 0xB0, 0x03, 0xC0, 0x06,
  0x80, 0x0D, 0x80, 0x13, 0x00, 0x62, 0x00, 0xC6, 0x01, 0x04, 0x06, 0x08,
  0x0C, 0x18, 0x10, 0x10, 0x60, 0x20, 0xC0, 0x61, 0x00, 0x42, 0x00, 0x8C,
  0x01, 0x90, 0x01, 0x60, 0x02, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x04, 0xC0, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0F, 0xFF, 0x01,
  0xE0, 0x70, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x01, 0xC0, 0xE0, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x1C, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x1C, 0x01, 0xC1, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x00, 0x7E, 0x01, 0xC3, 0x83, 0x80, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 27, 8, 3, -27 },
  { 8, 7, 10, 12, 3, -27 },
  { 17, 20, 27, 22, 1, -27 },
  { 85, 15, 31, 19, 2, -29 },
  { 144, 24, 28, 28, 2, -28 },
  { 228, 20, 28, 23, 2, -28 },
  { 298, 1, 10, 7, 3, -27 },
  { 300, 7, 33, 10, 2, -27 },
  { 329, 7, 33, 10, 1, -27 },
  { 358, 14, 14, 18, 2, -29 },
  { 383, 16, 17, 19, 2, -22 },
  { 417, 4, 9, 7, 1, -4 },
  { 422, 9, 1, 11, 1, -11 },
  { 424, 2, 3, 8, 3, -3 },
  { 425, 11, 27, 13, 1, -27 },
  { 463, 15, 28, 19, 2, -28 },
  { 516, 8, 27, 19, 3, -27 },
  { 543, 15, 28, 19, 2, -28 },
  { 596, 15, 28, 19, 2, -28 },
  { 649, 18, 27, 19, 1, -27 },
  { 710, 15, 27, 19, 2, -27 },
  { 761, 15, 28, 19, 2, -28 },
  { 814, 15, 27, 19, 2, -27 },
  { 865, 15, 28, 19, 2, -28 },
  { 918, 15, 28, 19, 2, -28 },
  { 971, 2, 20, 8, 3, -20 },
  { 976, 4, 25, 8, 1, -20 },
  { 989, 16, 17, 19, 2, -22 },
  { 1023, 16, 9, 19, 2, -18 },
  { 1041, 16, 17, 19, 2, -22 },
  { 1075, 12, 28, 14, 1, -28 },
  { 1117, 26, 31, 30, 2, -27 },
  { 1218, 20, 27, 20, 0, -27 },
  { 1286, 15, 27, 21, 4, -27 },
  { 1337, 18, 28, 21, 2, -28 },
  { 1400, 17, 27, 24, 4, -27 },
  { 1458, 12, 27, 19, 4, -27 },
  { 1499, 13, 27, 17, 4, -27 },
  { 1543, 20, 28, 25, 2, -28 },
  { 1613, 17, 27, 24, 4, -27 },
  { 1671, 6, 27, 10, 2, -27 },
  { 1692, 8, 34, 8, -3, -27 },
  { 1726, 15, 27, 19, 4, -27 },
  { 1777, 12, 27, 17, 4, -27 },
  { 1818, 22, 27, 30, 4, -27 },
  { 1893, 17, 27, 24, 4, -27 },
  { 1951, 21, 28, 26, 2, -28 },
  { 2025, 14, 27, 20, 4, -27 },
  { 2073, 21, 34, 26, 2, -28 },
  { 2163, 15, 27, 20, 4, -27 },
  { 2214, 15, 28, 19, 2, -28 },
  { 2267, 17, 27, 17, 0, -27 },
  { 2325, 18, 27, 24, 3, -27 },
  { 2386, 19, 27, 19, 0, -27 },
  { 2451, 29, 27, 30, 1, -27 },
  { 2549, 17, 27, 17, 0, -27 },
  { 2607, 17, 27, 17, 0, -27 },
  { 2665, 16, 27, 19, 1, -27 },
  { 2719, 8, 33, 12, 3, -27 },
  { 2752, 11, 27, 13, 1, -27 },
  { 2790, 8, 33, 12, 1, -27 },
  { 2823, 17, 15, 19, 1, -27 },
  { 2855, 15, 2, 15, 0, 3 },
  { 2859, 6, 6, 9, 2, -29 },
  { 2864, 13, 20, 18, 2, -20 },
  { 2897, 15, 29, 20, 3, -29 },
  { 2952, 13, 20, 16, 2, -20 },
  { 2985, 15, 29, 20, 2, -29 },
  { 3040, 14, 20, 19, 2, -20 },
  { 3075, 12, 29, 10, 0, -29 },
  { 3119, 15, 29, 20, 2, -20 },
  { 3174, 14, 29, 20, 3, -29 },
  { 3225, 2, 28, 8, 3, -28 },
  { 3232, 6, 37, 8, -1, -28 },
  { 3260, 13, 29, 16, 3, -29 },
  { 3308, 2, 29, 8, 3, -29 },
  { 3316, 24, 20, 30, 3, -20 },
  { 3376, 14, 20, 20, 3, -20 },
  { 3411, 16, 20, 20, 2, -20 },
  { 3451, 15, 29, 20, 3, -20 },
  { 3506, 15, 29, 20, 2, -20 },
  { 3561, 9, 20, 13, 3, -20 },
  { 3584, 13, 20, 16, 1, -20 },
  { 3617, 9, 25, 11, 1, -25 },
  { 3646, 14, 20, 20, 3, -20 },
  { 3681, 15, 20, 15, 0, -20 },
  { 3719, 24, 20, 24, 0, -20 },
  { 3779, 14, 20, 16, 1, -20 },
  { 3814, 15, 29, 15, 0, -20 },
  { 3869, 12, 20, 15, 1, -20 },
  { 3899, 11, 33, 13, 1, -27 },
  { 3945, 2, 38, 18, 8, -29 },
  { 3955, 10, 33, 13, 2, -27 },
  { 3997, 16, 3, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT38PT7B_H_
