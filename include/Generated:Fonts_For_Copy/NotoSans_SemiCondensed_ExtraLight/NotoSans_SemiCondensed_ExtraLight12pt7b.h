#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x24, 0x48, 0xA3, 0xF2, 0x85, 0x37, 0x24, 0x50,
  0x6D, 0xCC, 0x65, 0x55, 0xE4, 0xC5, 0x52, 0xA5, 0xAB, 0xBD, 0x4A, 0x95,
  0x4E, 0x62, 0x49, 0x18, 0x42, 0x99, 0x62, 0xF4, 0xF0, 0x6A, 0xAA, 0xA4,
  0x89, 0x12, 0x49, 0x4A, 0x00, 0x4F, 0x4A, 0x21, 0x3E, 0x42, 0x10, 0x68,
  0xE0, 0x80, 0x11, 0x22, 0x24, 0x48, 0x80, 0x69, 0x99, 0x99, 0x99, 0xF0,
  0x2E, 0x92, 0x49, 0x20, 0xE1, 0x11, 0x12, 0x48, 0xF0, 0xE1, 0x11, 0x61,
  0x11, 0xF0, 0x08, 0x61, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF8, 0x88, 0xF1,
  0x11, 0xF0, 0x74, 0x21, 0x4D, 0x46, 0x31, 0xF0, 0xF1, 0x11, 0x22, 0x44,
  0x40, 0x69, 0x99, 0x69, 0x99, 0xF0, 0x69, 0x99, 0x97, 0x11, 0xE0, 0x84,
  0x40, 0x1A, 0x1B, 0x20, 0x83, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x00,
  0xE1, 0x11, 0x24, 0x40, 0x40, 0x3C, 0x42, 0x81, 0xBD, 0xA5, 0xA5, 0xA9,
  0x96, 0x80, 0x7C, 0x10, 0x43, 0x0A, 0x49, 0xE4, 0x61, 0x84, 0xF4, 0x63,
  0x1F, 0x46, 0x31, 0xF0, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x78, 0xF2, 0x28,
  0x61, 0x86, 0x18, 0x62, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88,
  0xF8, 0x88, 0x80, 0x3D, 0x08, 0x20, 0x9A, 0x18, 0x61, 0x7C, 0x8C, 0x63,
  0x1F, 0xC6, 0x31, 0x88, 0xEA, 0xAA, 0xC0, 0x24, 0x92, 0x49, 0x27, 0x00,
  0x8C, 0xA9, 0x4C, 0x52, 0x52, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x83,
  0x07, 0x0E, 0x3A, 0x75, 0x6A, 0xC9, 0x92, 0x86, 0x1C, 0x69, 0xA6, 0x59,
  0x63, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xE4, 0xE3, 0x19,
  0x72, 0x10, 0x80, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x68, 0x40, 0x80,
  0xF4, 0x63, 0x1D, 0x52, 0x52, 0x88, 0x78, 0x88, 0x61, 0x11, 0xF0, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x20, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78,
  0x86, 0x18, 0x52, 0x49, 0x23, 0x0C, 0x10, 0x88, 0xC4, 0x63, 0x29, 0x95,
  0x4A, 0x99, 0x4C, 0x46, 0x22, 0x00, 0x8A, 0x54, 0x62, 0x19, 0x49, 0x88,
  0x8C, 0x52, 0xA2, 0x10, 0x84, 0x20, 0x78, 0x42, 0x22, 0x11, 0x08, 0xF8,
  0xEA, 0xAA, 0xAC, 0x88, 0x44, 0x42, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27,
  0x80, 0x10, 0xC2, 0x92, 0xC4, 0xF8, 0xD0, 0xF1, 0x79, 0x9F, 0x84, 0x39,
  0x28, 0xC6, 0x31, 0xF0, 0xF8, 0x88, 0x8F, 0x11, 0x79, 0x99, 0x99, 0xF0,
  0xF9, 0xF8, 0x8F, 0x74, 0xE4, 0x44, 0x44, 0x40, 0xF9, 0x99, 0x9F, 0x11,
  0xE0, 0x88, 0xE9, 0x99, 0x99, 0x90, 0x9F, 0x80, 0x41, 0x55, 0x56, 0x88,
  0x9A, 0xAC, 0xAA, 0x90, 0xFF, 0x80, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x40,
  0xF9, 0x99, 0x99, 0xF4, 0x63, 0x18, 0xF8, 0xF4, 0x63, 0x18, 0xFA, 0x10,
  0x80, 0xF9, 0x99, 0x9F, 0x11, 0x10, 0xF2, 0x49, 0x00, 0xF8, 0x61, 0x1F,
  0x5D, 0x24, 0x93, 0x99, 0x99, 0x9F, 0x8C, 0x94, 0xA6, 0x10, 0x91, 0x9A,
  0x5A, 0x6A, 0x64, 0x24, 0xDA, 0x88, 0x45, 0x44, 0x8C, 0x94, 0xA6, 0x10,
  0x88, 0xC0, 0x71, 0x24, 0x4F, 0x12, 0x44, 0x4C, 0x44, 0x44, 0x30, 0xFF,
  0xF0, 0xC2, 0x22, 0x21, 0x22, 0x22, 0xC0, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 7, 9, 7, 0, -9 },
  { 12, 4, 10, 6, 1, -9 },
  { 17, 7, 9, 9, 1, -9 },
  { 25, 6, 9, 7, 1, -9 },
  { 32, 1, 4, 2, 1, -9 },
  { 33, 2, 11, 3, 1, -9 },
  { 36, 3, 11, 3, 0, -9 },
  { 41, 4, 4, 6, 1, -9 },
  { 43, 5, 6, 6, 1, -7 },
  { 47, 2, 3, 2, 0, -1 },
  { 48, 3, 1, 4, 0, -4 },
  { 49, 1, 1, 3, 1, -1 },
  { 50, 4, 9, 4, 0, -9 },
  { 55, 4, 9, 6, 1, -9 },
  { 60, 3, 9, 6, 1, -9 },
  { 64, 4, 9, 6, 1, -9 },
  { 69, 4, 9, 6, 1, -9 },
  { 74, 6, 9, 6, 0, -9 },
  { 81, 4, 9, 6, 1, -9 },
  { 86, 5, 9, 6, 1, -9 },
  { 92, 4, 9, 6, 1, -9 },
  { 97, 4, 9, 6, 1, -9 },
  { 102, 4, 9, 6, 1, -9 },
  { 107, 1, 6, 3, 1, -6 },
  { 108, 2, 8, 3, 0, -6 },
  { 110, 5, 5, 6, 1, -7 },
  { 114, 5, 3, 6, 1, -6 },
  { 116, 5, 5, 6, 1, -7 },
  { 120, 4, 9, 4, 0, -9 },
  { 125, 8, 10, 9, 1, -9 },
  { 135, 6, 9, 6, 0, -9 },
  { 142, 5, 9, 7, 1, -9 },
  { 148, 5, 9, 7, 1, -9 },
  { 154, 6, 9, 7, 1, -9 },
  { 161, 4, 9, 6, 1, -9 },
  { 166, 4, 9, 5, 1, -9 },
  { 171, 6, 9, 8, 1, -9 },
  { 178, 5, 9, 8, 1, -9 },
  { 184, 2, 9, 3, 1, -9 },
  { 187, 3, 11, 3, -1, -9 },
  { 192, 5, 9, 6, 1, -9 },
  { 198, 4, 9, 5, 1, -9 },
  { 203, 7, 9, 9, 1, -9 },
  { 211, 6, 9, 8, 1, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 5, 9, 6, 1, -9 },
  { 231, 6, 11, 8, 1, -9 },
  { 240, 5, 9, 6, 1, -9 },
  { 246, 4, 9, 6, 1, -9 },
  { 251, 5, 9, 5, 0, -9 },
  { 257, 6, 9, 8, 1, -9 },
  { 264, 6, 9, 6, 0, -9 },
  { 271, 9, 9, 10, 0, -9 },
  { 282, 5, 9, 6, 0, -9 },
  { 288, 5, 9, 5, 0, -9 },
  { 294, 5, 9, 6, 0, -9 },
  { 300, 2, 11, 4, 1, -9 },
  { 303, 4, 9, 4, 0, -9 },
  { 308, 3, 11, 4, 0, -9 },
  { 313, 6, 5, 6, 0, -9 },
  { 317, 5, 1, 5, 0, 1 },
  { 318, 2, 2, 3, 0, -9 },
  { 319, 4, 6, 6, 1, -6 },
  { 322, 5, 9, 6, 1, -9 },
  { 328, 4, 6, 5, 1, -6 },
  { 331, 4, 9, 6, 1, -9 },
  { 336, 4, 6, 6, 1, -6 },
  { 339, 4, 9, 3, 0, -9 },
  { 344, 4, 9, 6, 1, -6 },
  { 349, 4, 9, 6, 1, -9 },
  { 354, 1, 9, 2, 1, -9 },
  { 356, 2, 12, 2, 0, -9 },
  { 359, 4, 9, 5, 1, -9 },
  { 364, 1, 9, 2, 1, -9 },
  { 366, 7, 6, 9, 1, -6 },
  { 372, 4, 6, 6, 1, -6 },
  { 375, 5, 6, 6, 1, -6 },
  { 379, 5, 9, 6, 1, -6 },
  { 385, 4, 9, 6, 1, -6 },
  { 390, 3, 6, 4, 1, -6 },
  { 393, 4, 6, 5, 0, -6 },
  { 396, 3, 8, 3, 0, -8 },
  { 399, 4, 6, 6, 1, -6 },
  { 402, 5, 6, 5, 0, -6 },
  { 406, 8, 6, 8, 0, -6 },
  { 412, 5, 6, 5, 0, -6 },
  { 416, 5, 9, 5, 0, -6 },
  { 422, 4, 6, 5, 0, -6 },
  { 425, 4, 11, 4, 0, -9 },
  { 431, 1, 12, 6, 2, -9 },
  { 433, 4, 11, 4, 0, -9 },
  { 439, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT12PT7B_H_
