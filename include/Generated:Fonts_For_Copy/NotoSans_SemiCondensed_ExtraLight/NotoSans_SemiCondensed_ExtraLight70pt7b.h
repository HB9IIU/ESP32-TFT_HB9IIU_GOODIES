#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight70pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x39, 0xFF, 0xFB, 0xC8, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0xF8, 0x60, 0x78, 0x3C, 0x0C, 0x01, 0x0F, 0x01, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x03, 0x80, 0x30, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0,
  0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x0F, 0x8C, 0x00,
  0x00, 0xFD, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x3F, 0x00, 0x00, 0x61, 0xF0,
  0x00, 0x0C, 0x0F, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x30, 0x0F, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x38,
  0x00, 0x60, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00,
  0x03, 0x01, 0xC7, 0x00, 0x60, 0xF8, 0xFE, 0x0C, 0x7C, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xC0, 0x03, 0x80,
  0xE0, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x60, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x18, 0x00, 0x30, 0x1C,
  0x00, 0x03, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0xE0, 0x00,
  0x0C, 0x00, 0x38, 0x18, 0x07, 0x01, 0x80, 0x07, 0x07, 0x07, 0xF8, 0x38,
  0x00, 0xE0, 0xC1, 0xFF, 0xC7, 0x00, 0x18, 0x38, 0x70, 0x38, 0x60, 0x03,
  0x06, 0x0C, 0x03, 0x8E, 0x00, 0xE1, 0xC3, 0x80, 0x31, 0xC0, 0x1C, 0x30,
  0x60, 0x07, 0x1C, 0x07, 0x0E, 0x1C, 0x00, 0x63, 0xC1, 0xC1, 0x83, 0x80,
  0x0C, 0x3F, 0xF8, 0x70, 0x60, 0x01, 0xC3, 0xFC, 0x0C, 0x0C, 0x00, 0x38,
  0x0E, 0x03, 0x81, 0x80, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x00,
  0x0C, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x00, 0x60,
  0x38, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x00, 0x18, 0x01, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x30, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x38,
  0x03, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x00,
  0x18, 0x38, 0x00, 0x1C, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x03, 0x87, 0x00,
  0x00, 0xF0, 0x0C, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x60, 0x00, 0x03, 0x81,
  0x81, 0x80, 0x00, 0x07, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x38, 0x18, 0x00,
  0x00, 0x1D, 0xC0, 0x60, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x00,
  0x00, 0x77, 0x00, 0xE0, 0x00, 0x03, 0x8E, 0x01, 0xC0, 0x00, 0x1E, 0x3C,
  0x07, 0xC0, 0x01, 0xE0, 0x78, 0x0F, 0xC0, 0x1F, 0x00, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xD8, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00,
  0xBC, 0x03, 0x01, 0xEF, 0xE0, 0xC3, 0xFC, 0x7F, 0x37, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0x04, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C,
  0x38, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x77, 0xFF, 0xF7, 0x90, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0xF0, 0x1E, 0xE0, 0x79, 0xC3, 0xC3, 0x8F, 0x07, 0x3C, 0x0F,
  0xF0, 0x1D, 0x80, 0x3A, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x10, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x01,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x88, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x0F,
  0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xC0, 0x08, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x0F, 0xC0, 0x06, 0x07, 0xFF, 0x80, 0xE1, 0xFF, 0xFE, 0x0E, 0x3C,
  0x00, 0xF0, 0xE7, 0x00, 0x07, 0x8E, 0xE0, 0x00, 0x3C, 0xFC, 0x00, 0x01,
  0xCF, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x78, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x78, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xF1, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x70, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x0F, 0x80, 0x1E, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xB3,
  0x80, 0x00, 0x1B, 0x1C, 0x00, 0x03, 0x30, 0xE0, 0x00, 0x67, 0x0F, 0x80,
  0x1E, 0x70, 0x3F, 0xBF, 0x87, 0x01, 0xFF, 0xF0, 0x70, 0x03, 0xF8, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x10, 0x03, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x90, 0x1E, 0x7C,
  0xF8, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x87,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF0,
  0x07, 0x84, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x06,
  0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x0E, 0x38, 0x00, 0x3F, 0xBF, 0x80, 0x0C,
  0xE0, 0x00, 0xF0, 0x03, 0x00, 0x19, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x3B,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x76, 0x00, 0x18, 0x00, 0x38, 0x00, 0xFC,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xF0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x0C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0xF0, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x03,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0C,
  0x00, 0x0E, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x37, 0x00, 0x38,
  0x00, 0x6C, 0x00, 0xEE, 0x00, 0x70, 0x00, 0xD8, 0x01, 0x9C, 0x00, 0x70,
  0x03, 0xB0, 0x07, 0x18, 0x00, 0xF0, 0x0E, 0x70, 0x1C, 0x30, 0x00, 0xF0,
  0x38, 0x70, 0x70, 0x70, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xC0,
  0x0F, 0xFE, 0x0C, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x07, 0x8C, 0x00, 0x00,
  0x3C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x07, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x07, 0xE0, 0xC0,
  0x00, 0x0F, 0x8C, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x1E, 0xC0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x1F,
  0x0C, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x00,
  0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x1F, 0xFC, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0xC0,
  0x00, 0x03, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x00, 0xF0, 0xC0,
  0x00, 0x00, 0x78, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x03, 0xC0, 0xC0, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x7E, 0x00, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x00, 0x10, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0xA0, 0x7C, 0xFF, 0xE3, 0xFE,
  0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x03, 0xCC,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x1C, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00,
  0x78, 0x00, 0xC0, 0x0F, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0xC0, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0xC1,
  0xE0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x0C, 0x7E, 0x00,
  0x00, 0xCE, 0x70, 0x00, 0x0D, 0xC7, 0x80, 0x00, 0xF8, 0x38, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xF0, 0x0C, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xDE, 0xE0, 0x00,
  0x00, 0x00, 0xEF, 0x70, 0x00, 0x00, 0x00, 0x77, 0x98, 0x00, 0x00, 0x00,
  0x33, 0xCE, 0x00, 0x00, 0x00, 0x39, 0xE7, 0x00, 0x00, 0x00, 0x18, 0xF1,
  0x80, 0x00, 0x00, 0x1C, 0x78, 0xE0, 0x00, 0x00, 0x0E, 0x3C, 0x70, 0x00,
  0x00, 0x06, 0x1E, 0x18, 0x00, 0x00, 0x07, 0x0F, 0x0E, 0x00, 0x00, 0x03,
  0x87, 0x87, 0x00, 0x00, 0x01, 0x83, 0xC1, 0xC0, 0x00, 0x01, 0xC1, 0xE0,
  0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x60, 0x78, 0x1C, 0x00,
  0x00, 0x70, 0x3C, 0x0E, 0x00, 0x00, 0x30, 0x1E, 0x03, 0x00, 0x00, 0x38,
  0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0xC0,
  0x38, 0x00, 0x0E, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0x03, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x01, 0x80,
  0x1E, 0x00, 0x60, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x18, 0x00, 0x78, 0x00, 0x70, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x06, 0x00, 0x0F, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x80, 0x03, 0x83, 0x00, 0x03, 0xC0, 0x00, 0xC3,
  0x80, 0x01, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0xC0, 0x00,
  0x78, 0x00, 0x0C, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0C,
  0x03, 0xFF, 0x83, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x1E, 0x30, 0x00, 0x03,
  0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0xB0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x3C, 0x30, 0x00, 0x3E, 0x0C, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x07, 0xC0, 0xC0, 0x00,
  0x1E, 0x0C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x01, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x3C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x8C,
  0x00, 0x00, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x06, 0x00,
  0x07, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00,
  0xE0, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x06, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x60,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x37, 0x80, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x10, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0x3C, 0x0C, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0x0F, 0x80, 0x03,
  0x1E, 0x00, 0x03, 0x38, 0x00, 0x03, 0x70, 0x00, 0x03, 0x70, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x1B,
  0x70, 0x00, 0x3B, 0x38, 0x00, 0x73, 0x3C, 0x01, 0xE3, 0x1F, 0xFF, 0xC3,
  0x07, 0xFF, 0x03, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01,
  0xF8, 0x00, 0xC0, 0xFF, 0xF0, 0x0C, 0x1F, 0xFF, 0xC0, 0xC7, 0x80, 0x3E,
  0x0C, 0xF0, 0x00, 0xF0, 0xCC, 0x00, 0x07, 0x0D, 0x80, 0x00, 0x38, 0xD8,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xD8,
  0x00, 0x03, 0x8D, 0x80, 0x00, 0x78, 0xCC, 0x00, 0x0F, 0x0C, 0xE0, 0x01,
  0xE0, 0xC7, 0x80, 0x7C, 0x0C, 0x3F, 0xFF, 0x80, 0xC0, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0x00, 0x30, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xF8, 0x07, 0x00, 0xFF, 0xE0, 0x70, 0x3F, 0xFF, 0x87, 0x07,
  0xC0, 0x3C, 0x70, 0xF0, 0x00, 0xE7, 0x1E, 0x00, 0x07, 0x71, 0xC0, 0x00,
  0x37, 0x38, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F, 0x70, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1F, 0x38, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x37, 0x1C, 0x00, 0x07, 0x70,
  0xE0, 0x00, 0xE7, 0x07, 0x80, 0x3C, 0x70, 0x3F, 0xFF, 0x87, 0x01, 0xFF,
  0xE0, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x18, 0x1F,
  0x00, 0x1E, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xE0, 0x20, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFE, 0x0C, 0x0F, 0xFF, 0xE1, 0x83, 0xE0, 0x0E, 0x30,
  0xF0, 0x00, 0xE6, 0x3C, 0x00, 0x0E, 0xC7, 0x00, 0x00, 0xD9, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1B, 0x3C, 0x00,
  0x03, 0x63, 0x80, 0x00, 0xCC, 0x38, 0x00, 0x39, 0x83, 0xC0, 0x1E, 0x30,
  0x3F, 0xFF, 0x86, 0x03, 0xFF, 0xC0, 0xC0, 0x07, 0xC0, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x3E, 0x00, 0xC0, 0xFF, 0xF0, 0x61, 0xFF, 0xFC,
  0x31, 0xE0, 0x0F, 0x19, 0xC0, 0x03, 0xCC, 0xC0, 0x00, 0xF6, 0xC0, 0x00,
  0x3B, 0x60, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x38, 0x6F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x9F, 0xF3, 0xFC,
  0x7E, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x0C,
  0x00, 0x0E, 0x18, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x60, 0x03, 0x80, 0xC0,
  0x0E, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0C, 0x07,
  0x00, 0x18, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x60, 0xE0, 0x00, 0xC3, 0xE0,
  0x01, 0x8F, 0xC0, 0x03, 0x39, 0xC0, 0x06, 0x61, 0xC0, 0x0D, 0x83, 0x80,
  0x1F, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xC0, 0x07, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0x73, 0x00, 0x00, 0x76, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x18, 0x3F, 0xF8, 0x03, 0xFF, 0x83,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x63, 0x80, 0x78, 0x3C, 0x07, 0xCC, 0xE0,
  0x07, 0x8E, 0x00, 0x39, 0xB8, 0x00, 0x73, 0x80, 0x03, 0xB6, 0x00, 0x07,
  0x60, 0x00, 0x77, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0x80, 0x60, 0x7F, 0xF8, 0x30, 0x7F, 0xFE, 0x18,
  0xF0, 0x07, 0x8C, 0xE0, 0x01, 0xE6, 0x60, 0x00, 0x7B, 0x60, 0x00, 0x1D,
  0xB0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x0C, 0x0F, 0xFF, 0x00, 0xC1, 0xFF, 0xFC, 0x0C, 0x38, 0x03,
  0xE0, 0xC7, 0x00, 0x0F, 0x0C, 0xE0, 0x00, 0x70, 0xDC, 0x00, 0x03, 0x8D,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCD,
  0x80, 0x00, 0x38, 0xDC, 0x00, 0x07, 0x8C, 0xC0, 0x00, 0x70, 0xCF, 0x00,
  0x1E, 0x0C, 0x78, 0x03, 0xC0, 0xC1, 0xFF, 0xF8, 0x0C, 0x0F, 0xFE, 0x00,
  0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFC, 0x0C, 0x0F, 0xFF, 0xE1, 0x83, 0xE0, 0x1E, 0x30, 0xF0, 0x00,
  0xE6, 0x3C, 0x00, 0x0E, 0xC7, 0x00, 0x00, 0xD9, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1B, 0x38, 0x00, 0x03, 0x63,
  0x80, 0x00, 0xCC, 0x38, 0x00, 0x31, 0x87, 0xC0, 0x1E, 0x30, 0x3F, 0xFF,
  0x06, 0x03, 0xFF, 0xC0, 0xC0, 0x0F, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x1E, 0x60, 0x7F, 0xF0, 0xFF, 0xF8, 0xF0, 0x1C, 0xE0, 0x06, 0x60, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xF0, 0x01, 0xE3, 0x80, 0x00, 0x8E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7B, 0x00, 0x01,
  0xE7, 0xC0, 0x07, 0x8F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xEF,
  0xFF, 0xF8, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x01, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xE0, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x60, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xF7, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x37, 0x38, 0x00, 0x1D, 0xCF, 0x00,
  0x0E, 0x71, 0xF0, 0x0F, 0x1C, 0x3F, 0xFF, 0x83, 0x03, 0xFF, 0x80, 0xC0,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x18, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x37, 0x00, 0x03, 0x8C, 0x00, 0x06,
  0xE0, 0x00, 0x61, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0x38, 0x00, 0x39, 0xC0,
  0x03, 0x87, 0x00, 0x06, 0x38, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x00, 0x0C,
  0x0E, 0x00, 0x38, 0x60, 0x03, 0x81, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x38,
  0x00, 0xC1, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0x70, 0x07,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x70, 0x0E, 0x00, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x1C, 0x0E,
  0x00, 0x70, 0x18, 0x03, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x38, 0x00,
  0xE0, 0xE0, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x07, 0x18, 0x00,
  0x38, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x67,
  0x00, 0x01, 0x9C, 0x00, 0x0C, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00,
  0x07, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0x30, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0x5F, 0x0F, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0x40, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x18, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 51, 15, 5, -50 },
  { 33, 13, 18, 23, 5, -50 },
  { 63, 36, 50, 40, 2, -50 },
  { 288, 27, 57, 36, 4, -53 },
  { 481, 43, 52, 51, 4, -51 },
  { 761, 38, 52, 42, 3, -51 },
  { 1008, 3, 18, 12, 5, -50 },
  { 1015, 13, 61, 19, 3, -50 },
  { 1115, 12, 61, 19, 3, -50 },
  { 1207, 26, 25, 33, 4, -53 },
  { 1289, 29, 33, 36, 3, -41 },
  { 1409, 7, 17, 14, 3, -8 },
  { 1424, 17, 2, 21, 2, -20 },
  { 1429, 5, 6, 15, 5, -5 },
  { 1433, 21, 50, 23, 1, -50 },
  { 1565, 28, 52, 36, 4, -51 },
  { 1747, 15, 50, 36, 6, -50 },
  { 1841, 28, 51, 36, 3, -51 },
  { 2020, 28, 52, 36, 3, -51 },
  { 2202, 34, 50, 36, 1, -50 },
  { 2415, 28, 51, 36, 4, -50 },
  { 2594, 28, 52, 36, 4, -51 },
  { 2776, 29, 50, 36, 3, -50 },
  { 2958, 28, 52, 36, 4, -51 },
  { 3140, 28, 52, 36, 3, -51 },
  { 3322, 5, 38, 15, 5, -37 },
  { 3346, 7, 46, 15, 3, -37 },
  { 3387, 29, 31, 36, 3, -41 },
  { 3500, 29, 17, 36, 3, -33 },
  { 3562, 29, 31, 36, 3, -41 },
  { 3675, 21, 52, 26, 2, -51 },
  { 3812, 47, 57, 55, 4, -50 },
  { 4147, 36, 50, 36, 0, -50 },
  { 4372, 28, 50, 39, 7, -50 },
  { 4547, 32, 52, 38, 4, -51 },
  { 4755, 32, 50, 43, 7, -50 },
  { 4955, 23, 50, 34, 7, -50 },
  { 5099, 23, 50, 31, 7, -50 },
  { 5243, 37, 52, 46, 4, -51 },
  { 5484, 31, 50, 44, 7, -50 },
  { 5678, 13, 50, 19, 3, -50 },
  { 5760, 14, 62, 16, -5, -50 },
  { 5869, 28, 50, 35, 7, -50 },
  { 6044, 23, 50, 32, 7, -50 },
  { 6188, 41, 50, 55, 7, -50 },
  { 6445, 31, 50, 45, 7, -50 },
  { 6639, 39, 52, 47, 4, -51 },
  { 6893, 26, 50, 36, 7, -50 },
  { 7056, 39, 63, 47, 4, -51 },
  { 7364, 28, 50, 37, 7, -50 },
  { 7539, 28, 52, 34, 3, -51 },
  { 7721, 31, 50, 32, 0, -50 },
  { 7915, 32, 51, 44, 6, -50 },
  { 8119, 35, 50, 35, 0, -50 },
  { 8338, 54, 50, 56, 1, -50 },
  { 8676, 32, 50, 32, 0, -50 },
  { 8876, 31, 50, 31, 0, -50 },
  { 9070, 30, 50, 34, 2, -50 },
  { 9258, 14, 61, 22, 6, -50 },
  { 9365, 21, 50, 23, 1, -50 },
  { 9497, 14, 61, 22, 2, -50 },
  { 9604, 31, 28, 36, 2, -50 },
  { 9713, 28, 3, 28, 0, 6 },
  { 9724, 11, 12, 17, 3, -54 },
  { 9741, 24, 39, 33, 3, -38 },
  { 9858, 28, 54, 37, 6, -53 },
  { 10047, 23, 39, 29, 4, -38 },
  { 10160, 28, 54, 37, 4, -53 },
  { 10349, 26, 39, 34, 4, -38 },
  { 10476, 21, 54, 18, 1, -54 },
  { 10618, 27, 55, 37, 4, -38 },
  { 10804, 25, 53, 37, 6, -53 },
  { 10970, 4, 51, 14, 5, -51 },
  { 10996, 11, 68, 14, -2, -51 },
  { 11090, 23, 53, 30, 6, -53 },
  { 11243, 2, 53, 14, 6, -53 },
  { 11257, 43, 38, 55, 6, -38 },
  { 11462, 25, 38, 37, 6, -38 },
  { 11581, 29, 39, 36, 4, -38 },
  { 11723, 28, 54, 37, 6, -38 },
  { 11912, 27, 54, 37, 4, -38 },
  { 12095, 17, 38, 24, 6, -38 },
  { 12176, 23, 39, 29, 3, -38 },
  { 12289, 18, 47, 20, 1, -46 },
  { 12395, 26, 38, 37, 5, -37 },
  { 12519, 28, 37, 28, 0, -37 },
  { 12649, 43, 37, 45, 1, -37 },
  { 12848, 27, 37, 30, 1, -37 },
  { 12973, 28, 54, 28, 0, -37 },
  { 13162, 22, 37, 27, 3, -37 },
  { 13264, 19, 61, 24, 2, -50 },
  { 13409, 2, 70, 34, 16, -53 },
  { 13427, 19, 61, 24, 3, -50 },
  { 13572, 29, 7, 36, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT70PT7B_H_
