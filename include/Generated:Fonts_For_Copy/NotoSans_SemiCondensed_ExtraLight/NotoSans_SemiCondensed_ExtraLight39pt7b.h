#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight39pt7bBitmaps[] PROGMEM = {
  0x00, 0xD9, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x00, 0x0B, 0xE0,
  0x87, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x81, 0x80,
  0x08, 0x18, 0x01, 0x81, 0x00, 0x18, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10,
  0x01, 0x03, 0x00, 0x10, 0x30, 0x03, 0x02, 0x07, 0xFF, 0xFF, 0x02, 0x02,
  0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x04, 0x00, 0x60,
  0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0xFF, 0xFF, 0xE0, 0x40, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00,
  0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x7F, 0x83, 0x91, 0xCC, 0x20, 0x10, 0x40, 0x60, 0x80, 0xC1, 0x01,
  0x82, 0x03, 0x04, 0x06, 0x08, 0x06, 0x10, 0x06, 0x20, 0x07, 0x40, 0x03,
  0x80, 0x01, 0xE0, 0x02, 0xE0, 0x04, 0x70, 0x08, 0x20, 0x10, 0x60, 0x20,
  0x40, 0x40, 0x80, 0x81, 0x01, 0x06, 0x02, 0x0A, 0x04, 0x37, 0x8B, 0xC3,
  0xFE, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x1E, 0x00, 0x20, 0x21, 0x00,
  0x60, 0x61, 0x80, 0x40, 0x40, 0x80, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0xC1,
  0x80, 0xC0, 0xC1, 0x00, 0x80, 0xC1, 0x00, 0x80, 0xC2, 0x00, 0x80, 0xC2,
  0x00, 0xC0, 0xC6, 0x00, 0xC0, 0xC4, 0x78, 0xC0, 0x8C, 0xC6, 0x40, 0x89,
  0x82, 0x61, 0x99, 0x03, 0x23, 0x11, 0x03, 0x1E, 0x31, 0x01, 0x00, 0x23,
  0x01, 0x00, 0x63, 0x01, 0x00, 0x43, 0x01, 0x00, 0xC3, 0x01, 0x00, 0x83,
  0x01, 0x01, 0x81, 0x01, 0x01, 0x01, 0x03, 0x03, 0x01, 0x03, 0x02, 0x01,
  0x82, 0x02, 0x00, 0xC6, 0x04, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x61, 0x80,
  0x06, 0x06, 0x00, 0x20, 0x10, 0x01, 0x00, 0x80, 0x08, 0x04, 0x00, 0x40,
  0x20, 0x02, 0x01, 0x00, 0x18, 0x18, 0x00, 0x41, 0x80, 0x03, 0x18, 0x00,
  0x0D, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x76, 0x00, 0x06, 0x18,
  0x06, 0x60, 0x60, 0x22, 0x01, 0x81, 0x30, 0x06, 0x19, 0x80, 0x10, 0xC8,
  0x00, 0xC4, 0x40, 0x03, 0x63, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x40, 0x06,
  0xC3, 0x00, 0x63, 0x0E, 0x0E, 0x18, 0x3F, 0xE0, 0x70, 0xFF, 0xC0, 0x06,
  0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x81, 0x03,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C,
  0x0C, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03,
  0x04, 0x1F, 0x93, 0xC3, 0xF0, 0x03, 0x00, 0x1A, 0x00, 0x4C, 0x02, 0x18,
  0x18, 0x20, 0xC0, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x33, 0x33, 0x26, 0x64, 0xC0, 0xFF, 0x80, 0x5F,
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x1C, 0x38, 0x10, 0x18, 0x30, 0x0C,
  0x20, 0x04, 0x60, 0x06, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06,
  0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x1C, 0x38, 0x07, 0xE0,
  0x03, 0x07, 0x1F, 0x33, 0x63, 0xC3, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x0F, 0xE0, 0x70, 0x61, 0x80, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xE0, 0xF0,
  0x73, 0x00, 0x64, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x03, 0xF0, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x05, 0x00, 0x1B, 0x80, 0xE3,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0xD0, 0x00,
  0x6C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0xC3,
  0x00, 0x20, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x30, 0x20, 0x0C, 0x18, 0x03, 0x04, 0x00, 0xC2, 0x00, 0x30, 0xFF,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x3F, 0xFC, 0x3F, 0xFC, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x67, 0x80, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x1C, 0xE0, 0x38, 0x3F,
  0xE0, 0x01, 0xFC, 0x07, 0x04, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x47,
  0xF0, 0xCC, 0x38, 0xD0, 0x0C, 0xE0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x02, 0x60,
  0x02, 0x30, 0x06, 0x10, 0x0C, 0x1C, 0x18, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x1C, 0x38, 0x30, 0x0C, 0x60,
  0x04, 0x60, 0x06, 0x40, 0x06, 0x40, 0x06, 0x40, 0x06, 0x60, 0x06, 0x20,
  0x0C, 0x30, 0x18, 0x0C, 0x30, 0x07, 0xE0, 0x03, 0xC0, 0x0E, 0x70, 0x18,
  0x18, 0x20, 0x0C, 0x60, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x0C, 0x38, 0x18, 0x0F,
  0xF0, 0x0F, 0xE0, 0x30, 0x60, 0xC0, 0x63, 0x00, 0x64, 0x00, 0x58, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x68, 0x00, 0xD8, 0x02, 0x9C, 0x19, 0x1F, 0xE2, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x83, 0xFC, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x7C, 0x31, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x8C, 0x62, 0x11, 0x8C, 0x46, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x7F, 0x8E, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x20, 0x0F,
  0xC0, 0xCC, 0x07, 0x1C, 0x09, 0x01, 0x81, 0x81, 0x20, 0x60, 0x30, 0x2C,
  0x08, 0x06, 0x05, 0x81, 0x00, 0x80, 0xF0, 0x60, 0x10, 0x1C, 0x0C, 0x02,
  0x03, 0x81, 0x80, 0x40, 0x50, 0x30, 0x08, 0x0B, 0x06, 0x01, 0x01, 0x60,
  0xC0, 0x60, 0x6C, 0x08, 0x0E, 0x09, 0x81, 0x82, 0x43, 0x10, 0x1F, 0xCF,
  0xC3, 0x00, 0xE0, 0xF0, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x40,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x0D, 0x00, 0x00, 0x90, 0x00, 0x09, 0x80, 0x01, 0x88,
  0x00, 0x10, 0x80, 0x01, 0x0C, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20,
  0x60, 0x06, 0x02, 0x00, 0x40, 0x20, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x18, 0x01, 0x81, 0x00, 0x08, 0x10, 0x00, 0xC3,
  0x00, 0x0C, 0x20, 0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x02,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x80, 0x1C, 0x80,
  0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0xF0, 0xFF, 0xE0, 0x80, 0x38, 0x80,
  0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0xF8, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0xE0, 0x70, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x0C, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xFC, 0x08, 0x01, 0xC2, 0x00,
  0x38, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x00,
  0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x32, 0x00, 0x08, 0x80, 0x0E,
  0x20, 0x07, 0x08, 0x1F, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x7F, 0xFA, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x03, 0xFF, 0xD0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1E, 0x07, 0x81, 0x80, 0x04, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1A,
  0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x90, 0x00,
  0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0x70, 0x00, 0xC0,
  0xE0, 0x1E, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x03, 0x06, 0xFE, 0xF8, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0, 0x81, 0x80, 0x83, 0x00, 0x83,
  0x00, 0x86, 0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB4, 0x00, 0xA6, 0x00, 0xC3,
  0x00, 0x83, 0x00, 0x81, 0x80, 0x80, 0xC0, 0x80, 0xC0, 0x80, 0x60, 0x80,
  0x30, 0x80, 0x30, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x06, 0x80,
  0x03, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3D, 0x00, 0x00, 0xFA, 0x00,
  0x01, 0xF6, 0x00, 0x02, 0xE4, 0x00, 0x0D, 0xCC, 0x00, 0x13, 0x98, 0x00,
  0x27, 0x10, 0x00, 0xCE, 0x30, 0x01, 0x1C, 0x60, 0x02, 0x38, 0x40, 0x0C,
  0x70, 0xC0, 0x10, 0xE0, 0x80, 0x61, 0xC1, 0x00, 0xC3, 0x83, 0x01, 0x07,
  0x02, 0x06, 0x0E, 0x06, 0x08, 0x1C, 0x0C, 0x10, 0x38, 0x08, 0x60, 0x70,
  0x18, 0x80, 0xE0, 0x13, 0x01, 0xC0, 0x26, 0x03, 0x80, 0x68, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0C, 0x80, 0x06, 0x60, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0xC3, 0x00, 0x60, 0x80, 0x30, 0x60, 0x18, 0x10, 0x0C,
  0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x10, 0x60, 0x0C,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x13, 0x00, 0x0D, 0x80,
  0x02, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x01, 0xFE, 0x00, 0x1C,
  0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x46, 0x00, 0x01, 0x98, 0x00, 0x06, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00,
  0xD0, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x70, 0x38, 0x00, 0x7F,
  0x80, 0xFF, 0x03, 0xFF, 0x88, 0x03, 0xA0, 0x06, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1A,
  0x00, 0xE8, 0x0F, 0x3F, 0xF0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x70, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x80, 0x38, 0x80, 0x18, 0x80,
  0x0C, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x0C, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0xFF, 0xE0, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x03, 0x0F,
  0xF8, 0x38, 0x3C, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x1B,
  0x80, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x80, 0x03, 0x20, 0x01,
  0x8C, 0x00, 0xC1, 0xC0, 0xE0, 0x1F, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x02,
  0x40, 0x00, 0x66, 0x00, 0x04, 0x60, 0x00, 0x42, 0x00, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x08, 0x10, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x04, 0x06, 0x00, 0x40, 0x60, 0x06,
  0x04, 0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x30, 0x80, 0x01, 0x18, 0x00,
  0x11, 0x80, 0x01, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xB0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x2C, 0x00, 0x70, 0x01, 0x90, 0x01, 0x40, 0x06, 0x40, 0x05, 0x00, 0x11,
  0x80, 0x36, 0x00, 0x46, 0x00, 0xD8, 0x03, 0x08, 0x02, 0x20, 0x0C, 0x20,
  0x08, 0x80, 0x20, 0xC0, 0x63, 0x00, 0x83, 0x01, 0x8C, 0x06, 0x04, 0x04,
  0x10, 0x18, 0x10, 0x10, 0x40, 0x40, 0x60, 0xC1, 0x81, 0x01, 0x83, 0x06,
  0x0C, 0x02, 0x08, 0x08, 0x30, 0x08, 0x20, 0x20, 0x80, 0x31, 0x80, 0xC2,
  0x00, 0xC6, 0x03, 0x18, 0x01, 0x10, 0x04, 0x60, 0x04, 0x40, 0x11, 0x00,
  0x19, 0x00, 0x64, 0x00, 0x6C, 0x01, 0xB0, 0x00, 0xA0, 0x02, 0xC0, 0x02,
  0x80, 0x0A, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x88, 0x00, 0x63, 0x00, 0x30, 0x40, 0x0C, 0x18,
  0x06, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x00, 0xC4,
  0x00, 0x13, 0x00, 0x06, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0x30, 0x00, 0xC4, 0x00, 0x61, 0x80, 0x10, 0x20, 0x0C,
  0x0C, 0x02, 0x01, 0x01, 0x80, 0x60, 0x40, 0x08, 0x30, 0x03, 0x18, 0x00,
  0x46, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x66, 0x00, 0x10,
  0x80, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60, 0x30, 0x0C,
  0x0C, 0x03, 0x02, 0x00, 0x41, 0x80, 0x18, 0x40, 0x02, 0x30, 0x00, 0xC8,
  0x00, 0x16, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x3F, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x04, 0x80, 0x03, 0x30, 0x00, 0x84, 0x00, 0x61, 0x80, 0x10,
  0x20, 0x0C, 0x0C, 0x02, 0x01, 0x01, 0x80, 0x60, 0x40, 0x08, 0x30, 0x03,
  0x08, 0x00, 0x46, 0x00, 0x1B, 0x00, 0x03, 0xFF, 0xFF, 0xC3, 0x06, 0x0C,
  0x18, 0x30, 0x0F, 0xC3, 0xE7, 0x88, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x0F, 0xC7, 0xE2, 0x60, 0x16, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0A, 0xC1, 0x93, 0xF8,
  0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xE0, 0xCE, 0x38, 0xD0,
  0x0C, 0xE0, 0x04, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x02, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x04, 0xF0, 0x0C, 0x98, 0x38, 0x8F,
  0xF0, 0x03, 0xF0, 0x79, 0xC6, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x38, 0x10, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE3, 0x1C, 0x33, 0x30, 0x0B,
  0x20, 0x07, 0x60, 0x07, 0x40, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x40, 0x07, 0x60, 0x07, 0x30, 0x0B, 0x18, 0x1B, 0x0F, 0xE3,
  0x07, 0xE0, 0x3C, 0xE0, 0xC0, 0x61, 0x80, 0x66, 0x00, 0x48, 0x00, 0x90,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xE0, 0x60, 0xFF, 0x80, 0x01, 0xE0, 0x7F, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x03, 0xFC, 0xFF, 0xC0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x07, 0xE3, 0x1E, 0x73, 0x30, 0x0B, 0x20, 0x07, 0x60, 0x07, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x60,
  0x07, 0x30, 0x0B, 0x18, 0x33, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x70, 0x18, 0x3F,
  0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x1F, 0x8C, 0xC7, 0x34, 0x06, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x10, 0xF4, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0C, 0x30, 0x40, 0x00, 0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x86, 0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xF0, 0x0D, 0x80,
  0xCC, 0x04, 0x60, 0x43, 0x06, 0x18, 0x60, 0xC6, 0x06, 0x20, 0x33, 0x01,
  0xAC, 0x0F, 0x30, 0x71, 0x83, 0x06, 0x18, 0x10, 0xC0, 0xC6, 0x03, 0x30,
  0x09, 0x80, 0x6C, 0x01, 0xE0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x87, 0xC0, 0xF8, 0x9C, 0x63, 0xCE, 0xB0, 0x32, 0x02, 0xE0,
  0x14, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0xC0, 0x08, 0x01, 0x87, 0xE2, 0x39, 0xE9, 0x01, 0xB8, 0x03,
  0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x04, 0x07, 0xE0, 0x1E, 0x38, 0x30, 0x0C,
  0x20, 0x06, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x60, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x18, 0x18, 0x0F, 0xF0,
  0x87, 0xE0, 0x8E, 0x38, 0x90, 0x0C, 0xE0, 0x04, 0xE0, 0x06, 0xC0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x04,
  0xF0, 0x0C, 0xD8, 0x38, 0xCF, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x07, 0xE2, 0x3C, 0xE4, 0xC0, 0x29, 0x00, 0x76, 0x00, 0x68, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xA0, 0x03, 0x40, 0x06, 0xC0, 0x0C, 0xC0, 0x28,
  0xC1, 0x90, 0xFE, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x87, 0xE3, 0xBD,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x1F, 0xC3, 0x8F, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x3C, 0x06, 0xFF, 0xC0, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x03, 0xFF, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x07, 0xC0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x56, 0x01, 0x5C,
  0x19, 0x1F, 0xC4, 0xC0, 0x03, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x26, 0x00,
  0xC4, 0x01, 0x8C, 0x02, 0x18, 0x0C, 0x10, 0x18, 0x30, 0x20, 0x60, 0xC0,
  0x41, 0x80, 0xC2, 0x01, 0x8C, 0x01, 0x18, 0x03, 0x20, 0x06, 0x40, 0x05,
  0x80, 0x0A, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0x40, 0x0C,
  0x01, 0x60, 0x1C, 0x01, 0x60, 0x14, 0x03, 0x20, 0x16, 0x02, 0x20, 0x36,
  0x02, 0x30, 0x32, 0x02, 0x30, 0x22, 0x06, 0x10, 0x23, 0x04, 0x10, 0x61,
  0x04, 0x18, 0x61, 0x04, 0x18, 0x41, 0x8C, 0x08, 0xC1, 0x88, 0x08, 0xC0,
  0x88, 0x0C, 0x80, 0x88, 0x0C, 0x80, 0xD8, 0x05, 0x80, 0x50, 0x05, 0x80,
  0x50, 0x07, 0x00, 0x50, 0x03, 0x00, 0x70, 0x03, 0x00, 0x20, 0xC0, 0x04,
  0xC0, 0x18, 0x80, 0x61, 0x80, 0xC1, 0x03, 0x03, 0x04, 0x03, 0x18, 0x02,
  0x60, 0x06, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x6C, 0x01, 0x88,
  0x03, 0x18, 0x0C, 0x10, 0x10, 0x30, 0x60, 0x31, 0x80, 0x22, 0x00, 0x6C,
  0x00, 0x60, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04,
  0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x18, 0x18, 0x08, 0x10,
  0x0C, 0x30, 0x0C, 0x20, 0x04, 0x20, 0x06, 0x60, 0x06, 0x40, 0x02, 0x40,
  0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0F, 0xFF,
  0x80, 0x00, 0xE0, 0x7C, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0xF0,
  0x1E, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x03, 0x80, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x03, 0xC0, 0x70, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x38, 0x38, 0x00,
  0x1C, 0x00, 0x7F, 0x01, 0x81, 0xE7, 0x80, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 28, 9, 3, -28 },
  { 12, 7, 10, 13, 3, -28 },
  { 21, 20, 28, 22, 1, -28 },
  { 91, 15, 32, 20, 2, -30 },
  { 151, 24, 28, 28, 2, -28 },
  { 235, 21, 28, 23, 2, -28 },
  { 309, 1, 10, 7, 3, -28 },
  { 311, 7, 34, 10, 2, -28 },
  { 341, 8, 34, 10, 1, -28 },
  { 375, 14, 14, 19, 2, -30 },
  { 400, 16, 18, 20, 2, -23 },
  { 436, 4, 9, 8, 1, -4 },
  { 441, 9, 1, 12, 1, -11 },
  { 443, 3, 3, 8, 3, -3 },
  { 445, 11, 28, 13, 1, -28 },
  { 484, 16, 28, 20, 2, -28 },
  { 540, 8, 28, 20, 4, -28 },
  { 568, 15, 28, 20, 2, -28 },
  { 621, 15, 28, 20, 2, -28 },
  { 674, 18, 28, 20, 1, -28 },
  { 737, 16, 28, 20, 2, -28 },
  { 793, 16, 28, 20, 2, -28 },
  { 849, 16, 28, 20, 2, -28 },
  { 905, 16, 28, 20, 2, -28 },
  { 961, 15, 28, 20, 2, -28 },
  { 1014, 3, 21, 8, 3, -21 },
  { 1022, 5, 26, 8, 1, -21 },
  { 1039, 16, 18, 20, 2, -23 },
  { 1075, 16, 9, 20, 2, -18 },
  { 1093, 16, 18, 20, 2, -23 },
  { 1129, 12, 28, 14, 1, -28 },
  { 1171, 27, 32, 31, 2, -28 },
  { 1279, 20, 28, 20, 0, -28 },
  { 1349, 16, 28, 22, 4, -28 },
  { 1405, 18, 28, 21, 2, -28 },
  { 1468, 18, 28, 24, 4, -28 },
  { 1531, 13, 28, 19, 4, -28 },
  { 1577, 13, 28, 17, 4, -28 },
  { 1623, 21, 28, 25, 2, -28 },
  { 1697, 17, 28, 25, 4, -28 },
  { 1757, 7, 28, 11, 2, -28 },
  { 1782, 8, 35, 9, -3, -28 },
  { 1817, 16, 28, 20, 4, -28 },
  { 1873, 13, 28, 18, 4, -28 },
  { 1919, 23, 28, 31, 4, -28 },
  { 2000, 17, 28, 25, 4, -28 },
  { 2060, 22, 28, 26, 2, -28 },
  { 2137, 14, 28, 20, 4, -28 },
  { 2186, 22, 35, 26, 2, -28 },
  { 2283, 16, 28, 20, 4, -28 },
  { 2339, 15, 28, 19, 2, -28 },
  { 2392, 17, 28, 18, 0, -28 },
  { 2452, 18, 28, 25, 3, -28 },
  { 2515, 20, 28, 20, 0, -28 },
  { 2585, 30, 28, 31, 1, -28 },
  { 2690, 18, 28, 18, 0, -28 },
  { 2753, 18, 28, 18, 0, -28 },
  { 2816, 17, 28, 19, 1, -28 },
  { 2876, 8, 34, 12, 3, -28 },
  { 2910, 11, 28, 13, 1, -28 },
  { 2949, 8, 34, 12, 1, -28 },
  { 2983, 18, 16, 20, 1, -28 },
  { 3019, 16, 1, 16, 0, 4 },
  { 3021, 6, 6, 10, 2, -30 },
  { 3026, 13, 21, 18, 2, -21 },
  { 3061, 16, 30, 21, 3, -30 },
  { 3121, 13, 21, 16, 2, -21 },
  { 3156, 16, 30, 21, 2, -30 },
  { 3216, 15, 21, 19, 2, -21 },
  { 3256, 12, 30, 10, 0, -30 },
  { 3301, 16, 30, 21, 2, -21 },
  { 3361, 14, 30, 20, 3, -30 },
  { 3414, 2, 28, 8, 3, -28 },
  { 3421, 6, 37, 8, -1, -28 },
  { 3449, 13, 30, 16, 3, -30 },
  { 3498, 2, 30, 8, 3, -30 },
  { 3506, 24, 21, 30, 3, -21 },
  { 3569, 14, 21, 20, 3, -21 },
  { 3606, 16, 21, 20, 2, -21 },
  { 3648, 16, 30, 21, 3, -21 },
  { 3708, 15, 30, 21, 2, -21 },
  { 3765, 10, 21, 13, 3, -21 },
  { 3792, 12, 21, 16, 2, -21 },
  { 3824, 9, 26, 11, 1, -26 },
  { 3854, 14, 21, 20, 3, -21 },
  { 3891, 15, 21, 15, 0, -21 },
  { 3931, 24, 21, 25, 0, -21 },
  { 3994, 15, 21, 17, 1, -21 },
  { 4034, 16, 30, 16, 0, -21 },
  { 4094, 13, 21, 15, 1, -21 },
  { 4129, 11, 34, 14, 1, -28 },
  { 4176, 1, 40, 19, 9, -30 },
  { 4181, 10, 34, 14, 2, -28 },
  { 4224, 16, 4, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT39PT7B_H_
