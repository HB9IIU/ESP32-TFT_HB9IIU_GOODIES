#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight69pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC6, 0x31, 0x8C, 0x63,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x3F, 0xFF, 0x79, 0x00, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xD8, 0x06, 0xC0,
  0x36, 0x01, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0xC7,
  0xF0, 0x78, 0x30, 0x1C, 0x38, 0x0C, 0x01, 0x1C, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x0E, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x1E, 0x03,
  0x00, 0x03, 0xC0, 0xC0, 0x00, 0x7C, 0x30, 0x00, 0x07, 0xCC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0x7E, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x30, 0x78, 0x00, 0x0C,
  0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00,
  0x0C, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x30,
  0x0E, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x01, 0xCC, 0x00, 0xC1, 0xE3, 0xF0,
  0x31, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x70, 0x01, 0xE3, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x30, 0x00, 0x0E,
  0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x06,
  0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00,
  0x30, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x00, 0xE0,
  0x70, 0x00, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xC0, 0x03, 0x83, 0x81, 0xF8, 0x38, 0x00, 0xC0, 0xC1, 0xFF, 0x0E,
  0x00, 0x30, 0x70, 0xF0, 0xE3, 0x80, 0x0C, 0x18, 0x70, 0x1C, 0x60, 0x07,
  0x0E, 0x1C, 0x03, 0x9C, 0x01, 0x83, 0x0E, 0x00, 0xE3, 0x00, 0xE1, 0xC3,
  0x80, 0x18, 0xE0, 0x70, 0x60, 0xC0, 0x07, 0x1E, 0x3C, 0x38, 0x30, 0x01,
  0xC3, 0xFE, 0x0C, 0x1C, 0x00, 0x30, 0x3E, 0x07, 0x07, 0x00, 0x0C, 0x00,
  0x01, 0x81, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x30,
  0x00, 0x30, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x38, 0x01,
  0x80, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x01,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x00, 0x07, 0xFE, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x0E, 0x00, 0x06, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xE0, 0x03, 0x87, 0x00, 0x07, 0x00, 0x18,
  0x70, 0x00, 0x1C, 0x00, 0xC3, 0x80, 0x00, 0x70, 0x0E, 0x18, 0x00, 0x01,
  0xC0, 0x60, 0xC0, 0x00, 0x07, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x70,
  0x00, 0x00, 0xF3, 0x83, 0x80, 0x00, 0x03, 0x9C, 0x0C, 0x00, 0x00, 0x0F,
  0xC0, 0x60, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x0E, 0x70,
  0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x01, 0xF0, 0x03,
  0xE0, 0x1C, 0x03, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00,
  0x78, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x03, 0xFC, 0x0C, 0x07, 0xFF, 0xC2,
  0x1F, 0xC1, 0xFD, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x61,
  0x8E, 0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7,
  0x10, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x03, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0x70, 0x3C,
  0xE0, 0xF1, 0xC3, 0xC3, 0x8F, 0x07, 0x78, 0x0F, 0xE0, 0x1D, 0x80, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFB, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x3C, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFB, 0xFC, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x06,
  0x00, 0x00, 0x78, 0x40, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x0F, 0x0F, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x01, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x88, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x3F, 0x00, 0x3F, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x3F, 0xF0, 0x0E, 0x0F,
  0xFF, 0xC0, 0xE3, 0xE0, 0x3E, 0x0E, 0x70, 0x00, 0xF0, 0xEE, 0x00, 0x03,
  0x8E, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0C, 0xF0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0x78, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x01, 0xE0,
  0x00, 0xE0, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x30, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF3, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x37,
  0x1E, 0x00, 0x06, 0x70, 0xF0, 0x01, 0xE7, 0x07, 0xE0, 0xF8, 0x70, 0x3F,
  0xFF, 0x06, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x01, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x77, 0xFF, 0xF7, 0x10, 0x1C, 0x7C, 0xF9, 0xF1, 0xC1, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3,
  0x87, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0xEF, 0xE1, 0xE0, 0x07, 0x84,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x0E, 0x1C, 0x00, 0x1F, 0xFF, 0xC0,
  0x0C, 0x30, 0x00, 0x7C, 0x07, 0x80, 0x1C, 0xE0, 0x01, 0xE0, 0x07, 0x00,
  0x39, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x73, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x6E, 0x00, 0x38, 0x00, 0x30, 0x00, 0xDC, 0x00, 0x60, 0x00, 0x60, 0x01,
  0xB8, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x70, 0x03, 0x80, 0x01, 0x80, 0x06,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x1F,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x70, 0x00, 0x18, 0x00, 0x6C,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0xD8, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xB0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x60, 0x07, 0x00, 0x03, 0x80, 0x0E, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x1D, 0x80, 0x0C, 0x00, 0x1E, 0x00, 0x33, 0x00,
  0x18, 0x00, 0x3C, 0x00, 0x67, 0x00, 0x38, 0x00, 0x78, 0x01, 0xCE, 0x00,
  0x30, 0x01, 0xB8, 0x03, 0x1C, 0x00, 0x70, 0x07, 0x30, 0x0E, 0x18, 0x00,
  0x78, 0x1C, 0x70, 0x78, 0x30, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x70, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x3F, 0xC1,
  0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xE0, 0x01, 0xFE, 0x07, 0x00, 0x00, 0x7C, 0x38,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x07, 0xC3,
  0x80, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x02, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x1C,
  0x00, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x01, 0xF8, 0x03, 0x80, 0x7F, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x00, 0x70,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xCC,
  0x1F, 0x3F, 0xF8, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x1E,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x03, 0x8F, 0xC0, 0x00, 0x1C, 0xEF, 0x00, 0x00, 0xEE, 0x38, 0x00, 0x07,
  0x60, 0xE0, 0x00, 0x3F, 0x07, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x00,
  0x03, 0x7E, 0xE0, 0x00, 0x00, 0x01, 0xDF, 0x98, 0x00, 0x00, 0x00, 0x67,
  0xE7, 0x00, 0x00, 0x00, 0x39, 0xF9, 0xC0, 0x00, 0x00, 0x0E, 0x7E, 0x30,
  0x00, 0x00, 0x03, 0x1F, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0xE3, 0x80, 0x00,
  0x00, 0x71, 0xF8, 0x60, 0x00, 0x00, 0x18, 0x7E, 0x1C, 0x00, 0x00, 0x0E,
  0x1F, 0x87, 0x00, 0x00, 0x03, 0x07, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xF8,
  0x38, 0x00, 0x00, 0x70, 0x7E, 0x06, 0x00, 0x00, 0x18, 0x1F, 0x81, 0xC0,
  0x00, 0x0E, 0x07, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xF8, 0x0C, 0x00, 0x00,
  0xC0, 0x7E, 0x03, 0x80, 0x00, 0x70, 0x1F, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0xE0, 0x18, 0x00, 0x06, 0x01, 0xF8, 0x07, 0x00, 0x03, 0x80, 0x7E, 0x01,
  0xC0, 0x00, 0xC0, 0x1F, 0x80, 0x38, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00,
  0x1C, 0x01, 0xF8, 0x01, 0x80, 0x06, 0x00, 0x7E, 0x00, 0x70, 0x03, 0x80,
  0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x00, 0x30, 0x01, 0xF8,
  0x00, 0xE0, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x07, 0x00, 0x1F, 0x80, 0x06,
  0x01, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x30,
  0x00, 0x7E, 0x00, 0x0E, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x87, 0x00, 0x07,
  0xE0, 0x00, 0x61, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0x38, 0x00, 0x1F, 0x80, 0x00, 0xCC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x07,
  0xEE, 0x00, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x07,
  0xE3, 0x80, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x07,
  0xE0, 0xE0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x07,
  0xE0, 0x70, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x07,
  0xE0, 0x1C, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x07,
  0xE0, 0x07, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07,
  0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x07,
  0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x70, 0x07, 0xE0, 0x00, 0x38, 0x07,
  0xE0, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x1C, 0x07,
  0xE0, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x07, 0x07,
  0xE0, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x01, 0xC7,
  0xE0, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00, 0x77,
  0xE0, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x0E, 0x00, 0x3F, 0xC3, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x78, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x38, 0x00, 0xFF, 0x01, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x04, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x30, 0x00, 0x03, 0xC7, 0xE0, 0x03, 0xF0, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x38, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x60, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0xF8, 0x0E, 0x00, 0x3C,
  0x08, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0x0F, 0x80, 0x07,
  0x1E, 0x00, 0x07, 0x38, 0x00, 0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x60, 0x00, 0x1B,
  0x70, 0x00, 0x33, 0x78, 0x00, 0x73, 0x3C, 0x01, 0xE3, 0x1F, 0xFF, 0xC3,
  0x07, 0xFF, 0x03, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x03, 0xFE, 0x00,
  0xC1, 0xFF, 0xF8, 0x18, 0x7C, 0x1F, 0x83, 0x1C, 0x00, 0x78, 0x67, 0x00,
  0x07, 0x8D, 0xC0, 0x00, 0x71, 0xB0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x07, 0x36, 0x00, 0x01, 0xC6, 0xE0, 0x00, 0x78,
  0xCE, 0x00, 0x1E, 0x18, 0xF0, 0x0F, 0x83, 0x0F, 0xFF, 0xE0, 0x60, 0x7F,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x0F,
  0xE0, 0xF8, 0x3E, 0x00, 0x10, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x38, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x01, 0xE8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0xFE,
  0x07, 0x01, 0xFF, 0xF0, 0xE0, 0xFC, 0x0F, 0x1C, 0x3E, 0x00, 0x71, 0x87,
  0x00, 0x07, 0x31, 0xC0, 0x00, 0x76, 0x70, 0x00, 0x06, 0xCE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x06, 0xCE, 0x00, 0x00, 0xD8, 0xE0, 0x00,
  0x33, 0x1E, 0x00, 0x0C, 0x61, 0xF0, 0x07, 0x8C, 0x0F, 0xFF, 0xC1, 0x80,
  0xFF, 0xF0, 0x30, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x3E, 0x0F, 0x80, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x7C, 0x00, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x60, 0x3F, 0xFE, 0x0C, 0x1F, 0x83, 0xE1, 0x87, 0x80, 0x0E,
  0x31, 0xE0, 0x00, 0x66, 0x38, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xF9, 0xC0,
  0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x1F, 0x1C,
  0x00, 0x06, 0xE1, 0xC0, 0x01, 0x9C, 0x3E, 0x00, 0xE3, 0x81, 0xFF, 0xF8,
  0x70, 0x1F, 0xFE, 0x0E, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0xFF, 0x80, 0xC1, 0xFF, 0xF0, 0x61, 0xF0, 0x7C, 0x31, 0xC0,
  0x0F, 0x19, 0x80, 0x01, 0xCD, 0xC0, 0x00, 0xE6, 0xC0, 0x00, 0x3B, 0xC0,
  0x00, 0x1D, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0x70,
  0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0xFF, 0x1F, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0x80, 0x00, 0xE3, 0x00,
  0x03, 0xC6, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x30, 0x01,
  0xC0, 0x60, 0x07, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x00, 0xE0,
  0x06, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x70, 0x00,
  0x61, 0xE0, 0x00, 0xC7, 0xE0, 0x01, 0x9C, 0xE0, 0x03, 0x31, 0xC0, 0x06,
  0xC1, 0xC0, 0x0F, 0x81, 0xC0, 0x1E, 0x03, 0x80, 0x38, 0x03, 0x80, 0x60,
  0x07, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x60, 0x00,
  0x38, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x30, 0xFF, 0xF0, 0x0F, 0xFF,
  0x0C, 0x7C, 0x3E, 0x07, 0xC3, 0xF3, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0xCC,
  0x00, 0x39, 0xC0, 0x03, 0xB6, 0x00, 0x0E, 0xE0, 0x00, 0xEF, 0x00, 0x01,
  0xB0, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x7F, 0xC0, 0x60, 0xFF, 0xF8, 0x30,
  0xF0, 0x3E, 0x18, 0xE0, 0x07, 0x8C, 0xE0, 0x00, 0xE6, 0xC0, 0x00, 0x73,
  0x60, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0xC0, 0x7F, 0xC0, 0x18, 0x3F, 0xFF, 0x03, 0x0F, 0x83, 0xF0,
  0x63, 0x80, 0x0F, 0x0C, 0xE0, 0x00, 0xF1, 0x98, 0x00, 0x0E, 0x36, 0x00,
  0x00, 0xE6, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x36, 0x00, 0x00, 0xE6, 0xC0,
  0x00, 0x38, 0xCC, 0x00, 0x0F, 0x19, 0xC0, 0x03, 0xC3, 0x1E, 0x01, 0xF0,
  0x61, 0xFF, 0xFC, 0x0C, 0x0F, 0xFE, 0x01, 0x80, 0x3E, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x60, 0x3F, 0xFE, 0x0C, 0x1F, 0x83, 0xE1, 0x87,
  0x80, 0x0E, 0x31, 0xE0, 0x00, 0xE6, 0x38, 0x00, 0x0F, 0xCE, 0x00, 0x00,
  0xF9, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xF9, 0xC0, 0x00,
  0x37, 0x1C, 0x00, 0x0E, 0xE3, 0xC0, 0x03, 0x9C, 0x3E, 0x00, 0xE3, 0x83,
  0xFF, 0xF8, 0x70, 0x1F, 0xFE, 0x0E, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0xC0, 0x7F, 0xE0, 0xFF, 0xB0, 0xFD, 0xD8, 0xE0, 0x0C, 0xE0, 0x06, 0xE0,
  0x03, 0x60, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE1, 0xF8, 0x1F, 0xCF, 0x00, 0x06, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3B, 0x00, 0x01, 0xEF, 0x00, 0x1F, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x16, 0xE0, 0x00, 0x1B, 0x38, 0x00,
  0x19, 0x9E, 0x00, 0x1C, 0xC7, 0xC0, 0x3C, 0x61, 0xFF, 0xFC, 0x30, 0x3F,
  0xF8, 0x18, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x1C,
  0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x06,
  0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x00, 0x01,
  0x9C, 0x00, 0x06, 0xC0, 0x00, 0x67, 0x00, 0x03, 0xB8, 0x00, 0x38, 0xC0,
  0x00, 0xEE, 0x00, 0x0E, 0x38, 0x00, 0x31, 0x80, 0x03, 0x0E, 0x00, 0x0C,
  0x60, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x38, 0x01, 0x80,
  0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0xC0, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x30, 0x18,
  0x01, 0xC0, 0xE0, 0x0E, 0x06, 0x00, 0x30, 0x30, 0x03, 0x83, 0x80, 0x0E,
  0x0C, 0x00, 0x60, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0xC0,
  0x07, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x31,
  0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70,
  0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xBF, 0x40, 0x00, 0x7F, 0xF2,
  0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 50, 15, 5, -49 },
  { 33, 13, 18, 23, 5, -49 },
  { 63, 35, 49, 39, 2, -49 },
  { 278, 26, 56, 35, 4, -52 },
  { 460, 42, 51, 50, 4, -50 },
  { 728, 37, 51, 41, 3, -50 },
  { 964, 3, 18, 12, 5, -49 },
  { 971, 13, 60, 18, 3, -49 },
  { 1069, 13, 60, 18, 2, -49 },
  { 1167, 25, 24, 33, 4, -52 },
  { 1242, 29, 32, 35, 3, -40 },
  { 1358, 6, 17, 13, 3, -8 },
  { 1371, 16, 3, 21, 2, -20 },
  { 1377, 5, 6, 15, 5, -5 },
  { 1381, 21, 49, 23, 1, -49 },
  { 1510, 27, 51, 35, 4, -50 },
  { 1683, 15, 49, 35, 6, -49 },
  { 1775, 28, 50, 35, 3, -50 },
  { 1950, 28, 51, 35, 3, -50 },
  { 2129, 33, 50, 35, 1, -50 },
  { 2336, 27, 50, 35, 4, -49 },
  { 2505, 28, 51, 35, 4, -50 },
  { 2684, 28, 49, 35, 3, -49 },
  { 2856, 27, 51, 35, 4, -50 },
  { 3029, 28, 51, 35, 3, -50 },
  { 3208, 5, 38, 15, 5, -37 },
  { 3232, 7, 46, 15, 3, -37 },
  { 3273, 29, 30, 35, 3, -40 },
  { 3382, 29, 17, 35, 3, -33 },
  { 3444, 29, 30, 35, 3, -40 },
  { 3553, 21, 51, 25, 2, -50 },
  { 3687, 47, 56, 54, 4, -49 },
  { 4016, 36, 49, 36, 0, -49 },
  { 4237, 29, 49, 38, 6, -49 },
  { 4415, 32, 51, 38, 4, -50 },
  { 4619, 33, 49, 43, 6, -49 },
  { 4822, 24, 49, 34, 6, -49 },
  { 4969, 24, 49, 31, 6, -49 },
  { 5116, 36, 51, 45, 4, -50 },
  { 5346, 31, 49, 44, 6, -49 },
  { 5536, 12, 49, 19, 3, -49 },
  { 5610, 14, 61, 15, -5, -49 },
  { 5717, 29, 49, 35, 6, -49 },
  { 5895, 24, 49, 31, 6, -49 },
  { 6042, 42, 49, 54, 6, -49 },
  { 6300, 32, 49, 44, 6, -49 },
  { 6496, 38, 51, 46, 4, -50 },
  { 6739, 26, 49, 36, 6, -49 },
  { 6899, 38, 62, 46, 4, -50 },
  { 7194, 29, 49, 36, 6, -49 },
  { 7372, 27, 51, 34, 3, -50 },
  { 7545, 31, 49, 31, 0, -49 },
  { 7735, 32, 50, 44, 6, -49 },
  { 7935, 35, 49, 35, 0, -49 },
  { 8150, 53, 49, 55, 1, -49 },
  { 8475, 31, 49, 32, 0, -49 },
  { 8665, 31, 49, 31, 0, -49 },
  { 8855, 29, 49, 34, 2, -49 },
  { 9033, 14, 60, 22, 6, -49 },
  { 9138, 21, 49, 23, 1, -49 },
  { 9267, 14, 60, 22, 2, -49 },
  { 9372, 31, 28, 35, 2, -49 },
  { 9481, 28, 2, 28, 0, 6 },
  { 9488, 11, 11, 17, 3, -53 },
  { 9504, 24, 38, 32, 3, -37 },
  { 9618, 27, 53, 37, 6, -52 },
  { 9797, 23, 38, 29, 4, -37 },
  { 9907, 27, 53, 37, 4, -52 },
  { 10086, 26, 38, 34, 4, -37 },
  { 10210, 20, 53, 18, 1, -53 },
  { 10343, 27, 54, 37, 4, -37 },
  { 10526, 25, 52, 36, 6, -52 },
  { 10689, 4, 50, 14, 5, -50 },
  { 10714, 11, 67, 14, -2, -50 },
  { 10807, 23, 52, 29, 6, -52 },
  { 10957, 2, 52, 14, 6, -52 },
  { 10970, 42, 37, 54, 6, -37 },
  { 11165, 25, 37, 36, 6, -37 },
  { 11281, 28, 38, 36, 4, -37 },
  { 11414, 27, 53, 37, 6, -37 },
  { 11593, 27, 53, 37, 4, -37 },
  { 11772, 17, 37, 24, 6, -37 },
  { 11851, 22, 38, 28, 3, -37 },
  { 11956, 17, 46, 20, 1, -45 },
  { 12054, 25, 38, 36, 5, -37 },
  { 12173, 27, 37, 27, 0, -37 },
  { 12298, 42, 37, 44, 1, -37 },
  { 12493, 27, 37, 30, 1, -37 },
  { 12618, 28, 54, 28, 0, -37 },
  { 12807, 22, 37, 27, 2, -37 },
  { 12909, 19, 60, 24, 2, -49 },
  { 13052, 3, 70, 33, 15, -53 },
  { 13079, 18, 60, 24, 3, -49 },
  { 13214, 29, 7, 35, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT69PT7B_H_
