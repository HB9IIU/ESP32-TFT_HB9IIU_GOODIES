#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight43pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD0, 0x00, 0x07,
  0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1,
  0x00, 0x40, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00,
  0x80, 0xC0, 0x02, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x20, 0x01, 0x80,
  0x80, 0x06, 0x02, 0x07, 0xFF, 0xFF, 0xC0, 0x40, 0x60, 0x01, 0x01, 0x80,
  0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x01, 0x00, 0x08,
  0x0C, 0x00, 0x20, 0x30, 0x00, 0x80, 0x80, 0xFF, 0xFF, 0xF8, 0x18, 0x08,
  0x00, 0x60, 0x20, 0x01, 0x01, 0x80, 0x04, 0x06, 0x00, 0x10, 0x18, 0x00,
  0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0xFF, 0x01, 0xFF,
  0xF1, 0x84, 0x11, 0x82, 0x00, 0x81, 0x00, 0xC0, 0x80, 0x60, 0x40, 0x30,
  0x20, 0x18, 0x10, 0x04, 0x08, 0x03, 0x04, 0x00, 0xC2, 0x00, 0x39, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x13, 0x80, 0x08, 0x60, 0x04,
  0x18, 0x02, 0x06, 0x01, 0x03, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x20, 0x60,
  0x10, 0x20, 0x08, 0x36, 0x04, 0x33, 0xFB, 0xF0, 0x3F, 0xE0, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x0C, 0x06, 0x30,
  0x03, 0x00, 0x83, 0x00, 0x60, 0x30, 0x20, 0x08, 0x04, 0x04, 0x03, 0x00,
  0x80, 0xC0, 0x40, 0x30, 0x18, 0x18, 0x06, 0x03, 0x02, 0x00, 0xC0, 0x60,
  0xC0, 0x18, 0x0C, 0x10, 0x03, 0x01, 0x86, 0x00, 0x60, 0x30, 0x80, 0x0C,
  0x06, 0x30, 0xE0, 0x80, 0xC4, 0x7F, 0x10, 0x11, 0x88, 0x23, 0x02, 0x23,
  0x06, 0x20, 0xCC, 0x40, 0x47, 0x31, 0x18, 0x0C, 0x7C, 0x63, 0x01, 0x80,
  0x0C, 0x60, 0x30, 0x03, 0x0C, 0x06, 0x00, 0x61, 0x80, 0xC0, 0x08, 0x30,
  0x18, 0x03, 0x06, 0x03, 0x00, 0x40, 0xC0, 0x60, 0x18, 0x18, 0x0C, 0x02,
  0x01, 0x01, 0x00, 0xC0, 0x20, 0x20, 0x10, 0x06, 0x0C, 0x06, 0x00, 0x63,
  0x00, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x10, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x27, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x1C, 0x60, 0x00, 0x60, 0x60, 0x19, 0x80, 0xC0, 0x33, 0x00,
  0xC0, 0x44, 0x00, 0xC1, 0x98, 0x00, 0xC3, 0x30, 0x00, 0xC4, 0x60, 0x00,
  0xD8, 0xC0, 0x01, 0xE1, 0x80, 0x01, 0xC1, 0x00, 0x03, 0x83, 0x00, 0x0D,
  0x83, 0x00, 0x71, 0x83, 0x83, 0xC1, 0x83, 0xFE, 0x03, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C,
  0x0C, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x40, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x80, 0x81, 0xF0, 0x87, 0x3E, 0xBC, 0x03, 0xE0, 0x01,
  0xC0, 0x03, 0x40, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x18, 0x18, 0x0C, 0x10,
  0x08, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x33, 0x26,
  0x66, 0x4C, 0xC8, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0x9E, 0x07, 0x03, 0x83, 0x00, 0xC3, 0x00, 0x31, 0x00, 0x19,
  0x80, 0x04, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0x10, 0x00, 0x8C, 0x00, 0xC2, 0x00, 0x41, 0x80,
  0x60, 0x70, 0xE0, 0x1F, 0xC0, 0x01, 0x81, 0xC1, 0xE3, 0xB3, 0x9B, 0x0F,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0xF0, 0x1F, 0x3C, 0x1C, 0x03, 0x08, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0,
  0x1F, 0x3E, 0x38, 0x03, 0x88, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x67,
  0x81, 0xE1, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xB0, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x06, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x60, 0x30, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x00,
  0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xFF,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x3F, 0xFE,
  0x7F, 0xFE, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xFF, 0xF0, 0x60, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x80, 0x0C, 0xE0, 0x78, 0x7F, 0xE0,
  0x01, 0xFE, 0x03, 0xE3, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x3F, 0x04, 0x7F, 0xC2, 0x60, 0x39, 0x40, 0x0C, 0xE0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0x20, 0x01, 0x98, 0x00, 0xC4, 0x00, 0xC3,
  0x00, 0x60, 0xE0, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xCF, 0x01, 0x80, 0x60, 0xC0,
  0x0C, 0x60, 0x01, 0x18, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x08, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x18, 0x0C, 0x1C, 0x01, 0xCE, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x0E, 0x1C, 0x06, 0x01, 0x83, 0x00, 0x31, 0x80,
  0x06, 0x40, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xB0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x06, 0x30, 0x03, 0x07, 0x03, 0x80,
  0xFF, 0x80, 0x07, 0xF0, 0x0F, 0x3C, 0x0E, 0x03, 0x06, 0x00, 0xC6, 0x00,
  0x32, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x0D, 0x80, 0x0E, 0xC0, 0x05,
  0x30, 0x04, 0x8E, 0x1C, 0xC3, 0xFC, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x82, 0x03, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x37, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x33, 0x66, 0x66, 0x4C, 0xC8, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xC7, 0xCF,
  0x10, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x11, 0x80, 0x3F, 0x80,
  0x88, 0x07, 0x9E, 0x06, 0xC0, 0x70, 0x30, 0x36, 0x02, 0x01, 0x80, 0xA0,
  0x30, 0x0C, 0x05, 0x01, 0x00, 0x60, 0x38, 0x18, 0x03, 0x01, 0xC0, 0xC0,
  0x18, 0x0E, 0x06, 0x00, 0x80, 0x70, 0x30, 0x04, 0x03, 0x81, 0x80, 0x20,
  0x1C, 0x0C, 0x03, 0x01, 0xE0, 0x60, 0x18, 0x0D, 0x01, 0x00, 0xE0, 0x48,
  0x0C, 0x0D, 0x06, 0x40, 0x30, 0xCC, 0x63, 0x00, 0xFC, 0x3E, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x08, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x30, 0x00,
  0x0C, 0x40, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x06, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x40, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x10, 0x03, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x08, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x02, 0x04, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x60, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0x3F,
  0xFF, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x0C,
  0xC0, 0x06, 0x30, 0x03, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xC0, 0x06, 0x30,
  0x00, 0xCC, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C,
  0xC0, 0x06, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7E, 0xFC,
  0x1C, 0x00, 0x86, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x7F, 0xF0, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0xC0, 0x1E, 0x0C, 0x00, 0x70, 0xC0, 0x01, 0x8C, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x0E, 0x0F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFD, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x07, 0xE7, 0xF0, 0x70, 0x01, 0x83, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0C, 0x0F, 0x01, 0xF0,
  0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x08, 0xFF, 0x7E, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x67, 0xF1, 0xC0, 0xC0, 0x01, 0xB0, 0x00,
  0xCC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC6,
  0x00, 0x33, 0x80, 0x0D, 0xE0, 0x03, 0x6C, 0x00, 0xF3, 0x00, 0x38, 0x60,
  0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x03, 0x03,
  0x00, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0x6C, 0x00, 0x1C, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x02, 0xF4, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x6F,
  0x60, 0x00, 0x13, 0xC8, 0x00, 0x0C, 0xF3, 0x00, 0x02, 0x3C, 0x40, 0x01,
  0x8F, 0x18, 0x00, 0x63, 0xC6, 0x00, 0x10, 0xF0, 0x80, 0x0C, 0x3C, 0x30,
  0x03, 0x0F, 0x0C, 0x00, 0x83, 0xC1, 0x00, 0x60, 0xF0, 0x60, 0x18, 0x3C,
  0x18, 0x04, 0x0F, 0x03, 0x03, 0x03, 0xC0, 0xC0, 0x80, 0xF0, 0x10, 0x60,
  0x3C, 0x06, 0x18, 0x0F, 0x01, 0x84, 0x03, 0xC0, 0x23, 0x00, 0xF0, 0x0C,
  0xC0, 0x3C, 0x03, 0x20, 0x0F, 0x00, 0x58, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x3C, 0x00, 0xC0, 0x0C, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3D, 0x80, 0x03, 0xD8, 0x00, 0x3C,
  0xC0, 0x03, 0xC6, 0x00, 0x3C, 0x60, 0x03, 0xC3, 0x00, 0x3C, 0x30, 0x03,
  0xC1, 0x80, 0x3C, 0x08, 0x03, 0xC0, 0xC0, 0x3C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x03, 0x03, 0xC0, 0x30, 0x3C, 0x01, 0x83, 0xC0, 0x0C, 0x3C, 0x00,
  0xC3, 0xC0, 0x06, 0x3C, 0x00, 0x63, 0xC0, 0x03, 0x3C, 0x00, 0x1B, 0xC0,
  0x01, 0xBC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0x01, 0xFF, 0x00, 0x0F, 0xCF, 0x80, 0x38, 0x03, 0x80, 0xC0, 0x01, 0x83,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0,
  0x00, 0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x40, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x06, 0x00,
  0xF0, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x1C, 0xC1, 0xF8, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xCF, 0x80, 0x38, 0x03, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x06, 0x00, 0xF0, 0x78, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x80,
  0x3F, 0xFE, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0xE0, 0xFF, 0xE0,
  0x30, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x0C,
  0x01, 0x83, 0x00, 0x20, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1C, 0x07, 0xFC, 0x0F, 0x9F,
  0x8E, 0x00, 0x46, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x67, 0x81, 0xE1,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x46,
  0x00, 0x0C, 0x38, 0x01, 0x81, 0xE0, 0x70, 0x07, 0xFC, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x64, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x30,
  0x80, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x04, 0x02, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x02,
  0x00, 0x40, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x00, 0x08, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x80, 0x01, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x40, 0x00, 0x63, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x20, 0x00, 0x0D, 0x80,
  0x00, 0x16, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xB0, 0x00, 0x70, 0x00,
  0xC8, 0x00, 0x38, 0x00, 0x66, 0x00, 0x3C, 0x00, 0x33, 0x00, 0x1A, 0x00,
  0x11, 0x80, 0x09, 0x80, 0x18, 0x40, 0x04, 0xC0, 0x0C, 0x30, 0x06, 0x60,
  0x06, 0x18, 0x03, 0x10, 0x02, 0x0C, 0x01, 0x0C, 0x03, 0x02, 0x00, 0x86,
  0x01, 0x81, 0x80, 0xC3, 0x00, 0xC0, 0xC0, 0x60, 0x80, 0x40, 0x60, 0x20,
  0x60, 0x60, 0x10, 0x10, 0x30, 0x30, 0x0C, 0x18, 0x18, 0x18, 0x06, 0x0C,
  0x04, 0x08, 0x03, 0x04, 0x03, 0x0C, 0x00, 0x82, 0x01, 0x86, 0x00, 0x63,
  0x00, 0xC3, 0x00, 0x31, 0x80, 0x21, 0x00, 0x18, 0x80, 0x19, 0x80, 0x04,
  0x40, 0x0C, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x01, 0xB0, 0x01, 0x20, 0x00,
  0xD0, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x63, 0x00,
  0x04, 0x30, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00,
  0x19, 0x80, 0x00, 0x90, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x09, 0x00, 0x01, 0x98, 0x00, 0x10, 0x80, 0x03, 0x0C,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x18, 0x10, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x06, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x68, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x63,
  0x00, 0x08, 0x60, 0x03, 0x06, 0x00, 0x40, 0xC0, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0x20, 0xC0, 0x06, 0x30, 0x00,
  0x46, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0xFF,
  0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0xC0, 0x00, 0x48, 0x00, 0x19, 0x80, 0x02, 0x10, 0x00, 0xC3, 0x00, 0x10,
  0x20, 0x06, 0x06, 0x00, 0x80, 0x40, 0x30, 0x0C, 0x04, 0x00, 0x81, 0x80,
  0x18, 0x20, 0x01, 0x0C, 0x00, 0x31, 0x00, 0x02, 0x60, 0x00, 0x78, 0x00,
  0x04, 0xFF, 0xFF, 0x80, 0xC0, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x80, 0x0F,
  0xF0, 0x7C, 0xF0, 0x80, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x07, 0xF8, 0xFC, 0x33, 0x80, 0x6C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x76, 0x01, 0x6E, 0x0C, 0xCF, 0xF1, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x3F, 0x83, 0x3C, 0x70, 0xD8, 0x06,
  0x34, 0x00, 0xCE, 0x00, 0x13, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x2C,
  0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xB0, 0x00, 0x2E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01,
  0x3C, 0x00, 0xCD, 0x80, 0x63, 0x30, 0x70, 0xC7, 0xF8, 0x00, 0x03, 0xFC,
  0x0F, 0x1C, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0xFC, 0x21, 0xC3, 0x91, 0x80, 0x69, 0x80, 0x14,
  0xC0, 0x0E, 0xC0, 0x03, 0x60, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xA0,
  0x00, 0xD0, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x19, 0x80, 0x14, 0xE0, 0x1A,
  0x38, 0x19, 0x07, 0xF8, 0x80, 0x03, 0xF0, 0x07, 0x1E, 0x06, 0x03, 0x86,
  0x00, 0xC2, 0x00, 0x33, 0x00, 0x19, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x10, 0x70, 0x38, 0x1F, 0xF8, 0x00, 0xF8, 0x1F, 0xC1, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x1F, 0xF1,
  0xFF, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x03, 0xF0, 0x87, 0x8E, 0x46, 0x01, 0xA6, 0x00, 0x52, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x53, 0x80, 0x68, 0xE0, 0xE4, 0x1F,
  0xC2, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x19, 0x00, 0x1C, 0xF0, 0x3C, 0x1F, 0xF8, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x1F, 0xC4, 0xE3, 0xCB, 0x00, 0xD4,
  0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0xFF, 0x00, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x90, 0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x4C,
  0xF0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x01, 0xA0, 0x0C, 0x80, 0x32,
  0x01, 0x88, 0x0C, 0x20, 0x60, 0x83, 0x02, 0x0C, 0x08, 0x60, 0x23, 0x00,
  0x9C, 0x02, 0xD8, 0x0A, 0x30, 0x30, 0xC0, 0xC1, 0x82, 0x03, 0x08, 0x0C,
  0x20, 0x18, 0x80, 0x62, 0x00, 0xC8, 0x01, 0xA0, 0x06, 0x80, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x8F, 0xE0, 0x7E, 0x27, 0x1C, 0x79, 0xCB, 0x03,
  0xB0, 0x1B, 0x80, 0x68, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x87, 0xF1, 0x38, 0xF2, 0xC0,
  0x35, 0x00, 0x2C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0xF8, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C,
  0x20, 0x01, 0x98, 0x00, 0x66, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0D, 0x00, 0x03, 0x60, 0x00, 0x98, 0x00, 0x62, 0x00, 0x18, 0xC0, 0x0C,
  0x18, 0x07, 0x03, 0x83, 0x80, 0x7F, 0x80, 0x87, 0xF0, 0x4F, 0x1C, 0x24,
  0x03, 0x14, 0x00, 0xCE, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02,
  0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x05, 0x00, 0x02, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x94,
  0x00, 0xCB, 0x00, 0xC4, 0xE1, 0xC2, 0x3F, 0xC1, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x87, 0x0E, 0x46, 0x01,
  0xA6, 0x00, 0x52, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x40, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xE6, 0x00,
  0x53, 0x80, 0x68, 0xE0, 0xE4, 0x3F, 0xC2, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x87, 0xE7, 0xBB, 0x02, 0x80, 0xE0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F, 0xF0,
  0xE1, 0xE6, 0x00, 0xB0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x80, 0x1B, 0x81,
  0xC7, 0xFE, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xFF, 0xFC,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01,
  0xC4, 0x3F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x07, 0x60, 0x07, 0x70, 0x0B, 0x38, 0x33, 0x1F, 0xE1,
  0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x31, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x0C, 0x18, 0x04, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x01, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x10, 0x40, 0x0C, 0x60, 0x06, 0x30,
  0x01, 0x10, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x80, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0B, 0x00,
  0x78, 0x02, 0x40, 0x16, 0x01, 0x98, 0x04, 0x80, 0x66, 0x03, 0x30, 0x11,
  0x80, 0xCC, 0x04, 0x20, 0x21, 0x03, 0x0C, 0x08, 0x40, 0xC3, 0x06, 0x18,
  0x20, 0x41, 0x86, 0x08, 0x10, 0x40, 0x86, 0x06, 0x30, 0x31, 0x81, 0x8C,
  0x0C, 0x40, 0x22, 0x01, 0x10, 0x09, 0x80, 0x4C, 0x03, 0x60, 0x1B, 0x00,
  0xD8, 0x06, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0C,
  0x18, 0x08, 0x08, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x03, 0x40,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x04, 0x30,
  0x0C, 0x10, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x62, 0x00,
  0x31, 0x80, 0x10, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x04, 0x0C, 0x06, 0x02,
  0x03, 0x01, 0x81, 0x00, 0xC1, 0x80, 0x20, 0xC0, 0x18, 0x40, 0x0C, 0x60,
  0x02, 0x30, 0x01, 0x90, 0x00, 0xD8, 0x00, 0x2C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x01, 0x18, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0xFF, 0xE0, 0x00, 0x30, 0x1F, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0xF8, 0x0F, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x1F, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x07, 0x80, 0xF0, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x0F, 0x81, 0x80, 0x00, 0x3F,
  0x00, 0x78, 0xF0, 0x38, 0x07, 0xFA, 0x00, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 31, 10, 3, -31 },
  { 13, 8, 11, 14, 3, -31 },
  { 24, 22, 31, 24, 1, -31 },
  { 110, 17, 36, 22, 2, -33 },
  { 187, 27, 31, 31, 2, -31 },
  { 292, 23, 31, 26, 2, -31 },
  { 382, 2, 11, 8, 3, -31 },
  { 385, 8, 38, 11, 2, -31 },
  { 423, 8, 38, 11, 2, -31 },
  { 461, 16, 16, 21, 2, -33 },
  { 493, 18, 20, 22, 2, -25 },
  { 538, 4, 11, 8, 2, -5 },
  { 544, 10, 1, 13, 1, -12 },
  { 546, 3, 3, 9, 3, -3 },
  { 548, 13, 31, 14, 1, -31 },
  { 599, 17, 31, 22, 2, -31 },
  { 665, 9, 31, 22, 4, -31 },
  { 700, 17, 31, 22, 2, -31 },
  { 766, 17, 31, 22, 2, -31 },
  { 832, 20, 31, 22, 1, -31 },
  { 910, 16, 31, 22, 3, -31 },
  { 972, 17, 31, 22, 3, -31 },
  { 1038, 18, 31, 22, 2, -31 },
  { 1108, 18, 31, 22, 2, -31 },
  { 1178, 17, 31, 22, 2, -31 },
  { 1244, 3, 23, 9, 3, -23 },
  { 1253, 4, 29, 9, 2, -23 },
  { 1268, 18, 19, 22, 2, -25 },
  { 1311, 18, 10, 22, 2, -20 },
  { 1334, 18, 19, 22, 2, -25 },
  { 1377, 13, 31, 16, 1, -31 },
  { 1428, 29, 35, 34, 2, -31 },
  { 1555, 22, 31, 22, 0, -31 },
  { 1641, 18, 31, 24, 4, -31 },
  { 1711, 19, 31, 23, 3, -31 },
  { 1785, 20, 31, 27, 4, -31 },
  { 1863, 15, 31, 21, 4, -31 },
  { 1922, 15, 31, 19, 4, -31 },
  { 1981, 22, 31, 28, 3, -31 },
  { 2067, 19, 31, 27, 4, -31 },
  { 2141, 8, 31, 12, 2, -31 },
  { 2172, 9, 39, 10, -3, -31 },
  { 2216, 18, 31, 22, 4, -31 },
  { 2286, 14, 31, 19, 4, -31 },
  { 2341, 26, 31, 34, 4, -31 },
  { 2442, 20, 31, 28, 4, -31 },
  { 2520, 23, 31, 29, 3, -31 },
  { 2610, 16, 31, 22, 4, -31 },
  { 2672, 23, 38, 29, 3, -31 },
  { 2782, 18, 31, 23, 4, -31 },
  { 2852, 17, 31, 21, 2, -31 },
  { 2918, 19, 31, 19, 0, -31 },
  { 2992, 20, 31, 27, 4, -31 },
  { 3070, 22, 31, 22, 0, -31 },
  { 3156, 33, 31, 34, 1, -31 },
  { 3284, 20, 31, 20, 0, -31 },
  { 3362, 19, 31, 19, 0, -31 },
  { 3436, 19, 31, 21, 1, -31 },
  { 3510, 8, 38, 13, 4, -31 },
  { 3548, 13, 31, 14, 1, -31 },
  { 3599, 9, 38, 13, 1, -31 },
  { 3642, 19, 18, 22, 1, -31 },
  { 3685, 17, 1, 17, 0, 4 },
  { 3688, 7, 7, 11, 2, -33 },
  { 3695, 15, 23, 20, 2, -23 },
  { 3739, 18, 33, 23, 3, -33 },
  { 3814, 15, 23, 18, 2, -23 },
  { 3858, 17, 33, 23, 2, -33 },
  { 3929, 17, 23, 21, 2, -23 },
  { 3978, 13, 33, 11, 0, -33 },
  { 4032, 17, 33, 23, 2, -23 },
  { 4103, 15, 33, 22, 4, -33 },
  { 4165, 3, 31, 9, 3, -31 },
  { 4177, 7, 41, 9, -1, -31 },
  { 4213, 14, 33, 18, 4, -33 },
  { 4271, 1, 33, 9, 4, -33 },
  { 4276, 26, 23, 34, 4, -23 },
  { 4351, 15, 23, 22, 4, -23 },
  { 4395, 18, 23, 22, 2, -23 },
  { 4447, 17, 33, 23, 4, -23 },
  { 4518, 17, 33, 23, 2, -23 },
  { 4589, 10, 23, 15, 4, -23 },
  { 4618, 14, 23, 18, 2, -23 },
  { 4659, 10, 28, 12, 1, -28 },
  { 4694, 16, 23, 22, 3, -23 },
  { 4740, 17, 23, 17, 0, -23 },
  { 4789, 26, 23, 28, 1, -23 },
  { 4864, 16, 23, 18, 1, -23 },
  { 4910, 17, 33, 17, 0, -23 },
  { 4981, 13, 23, 17, 2, -23 },
  { 5019, 12, 38, 15, 1, -31 },
  { 5076, 1, 44, 21, 10, -33 },
  { 5082, 11, 38, 15, 2, -31 },
  { 5135, 18, 4, 22, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT43PT7B_H_
