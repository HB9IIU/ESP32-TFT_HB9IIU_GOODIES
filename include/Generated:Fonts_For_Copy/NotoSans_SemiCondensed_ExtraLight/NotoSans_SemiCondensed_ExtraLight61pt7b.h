#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight61pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x34, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x1E, 0x18, 0x3C, 0x38, 0x18, 0x04, 0x70, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18,
  0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x70, 0x18,
  0x00, 0x70, 0x18, 0x00, 0x38, 0x18, 0x00, 0x1E, 0x18, 0x00, 0x0F, 0x98,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x19, 0xF0, 0x00, 0x18, 0x78, 0x00, 0x18, 0x1C, 0x00, 0x18,
  0x0E, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0C, 0x80, 0x18, 0x1C, 0xF0, 0x18,
  0x78, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x01, 0x83,
  0x80, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x38,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x03, 0x80, 0x18,
  0x30, 0x1C, 0x06, 0x00, 0x60, 0xC1, 0xFC, 0x18, 0x01, 0x86, 0x0E, 0x38,
  0x60, 0x0E, 0x18, 0x60, 0x71, 0x80, 0x30, 0xE3, 0x80, 0xC3, 0x00, 0xC3,
  0x0C, 0x01, 0x8C, 0x07, 0x1C, 0x30, 0x06, 0x1C, 0x38, 0x61, 0x80, 0x18,
  0x3F, 0xC3, 0x86, 0x00, 0x70, 0x7E, 0x0C, 0x18, 0x00, 0xC0, 0x00, 0x70,
  0x60, 0x03, 0x00, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x30,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x07, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x0E, 0x00, 0x03,
  0x9E, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x06, 0x38, 0x03, 0x80, 0x0E, 0x38, 0x01, 0xC0, 0x0C, 0x70,
  0x00, 0xE0, 0x0C, 0x60, 0x00, 0xE0, 0x0C, 0xE0, 0x00, 0x70, 0x1C, 0xE0,
  0x00, 0x38, 0x18, 0xE0, 0x00, 0x1C, 0x38, 0xC0, 0x00, 0x0E, 0x30, 0xC0,
  0x00, 0x07, 0x70, 0xC0, 0x00, 0x03, 0x60, 0xE0, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0x70, 0x38,
  0x00, 0x0E, 0x38, 0x3C, 0x00, 0x1C, 0x18, 0x1E, 0x00, 0x78, 0x1C, 0x0F,
  0xFF, 0xF0, 0x0E, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xA4, 0x92, 0x00, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x30, 0x08, 0x06, 0xF8, 0x10,
  0x3E, 0x7E, 0x23, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x80, 0x01, 0x83, 0x00,
  0x06, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x06, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x71,
  0xC7, 0x1C, 0x63, 0x8E, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xEF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x60, 0x00,
  0x30, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0x60, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x03,
  0xC0, 0x78, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x1E, 0x03, 0xF0, 0x3D, 0x83, 0x8C, 0x38, 0x67,
  0x83, 0xF8, 0x1B, 0x00, 0xD0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0x01, 0xE0, 0x78, 0x00, 0x70,
  0x30, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x78, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x80, 0x00, 0x38, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x60, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x67, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x80, 0x00, 0x70, 0xF0, 0x01,
  0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x08, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x7E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0xC1, 0xF0, 0xCE, 0x00,
  0x78, 0xDC, 0x00, 0x1C, 0xD8, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0x70, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x38,
  0x00, 0x03, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x0F, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x01,
  0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x18, 0x70, 0x00,
  0x1C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00,
  0x1B, 0x1C, 0x00, 0x73, 0x0E, 0x00, 0xE3, 0x07, 0xFF, 0xC3, 0x03, 0xFF,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x4E, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0,
  0x0C, 0x38, 0x78, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x0F, 0x01, 0xF3, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x1F, 0xF0, 0x03,
  0x0E, 0x00, 0x1F, 0xFE, 0x00, 0xE3, 0x00, 0x1E, 0x01, 0x80, 0x18, 0xC0,
  0x0E, 0x00, 0x60, 0x06, 0x70, 0x03, 0x00, 0x18, 0x01, 0x98, 0x01, 0xC0,
  0x06, 0x00, 0x66, 0x00, 0x60, 0x01, 0x80, 0x19, 0x80, 0x38, 0x00, 0x60,
  0x07, 0xE0, 0x0C, 0x00, 0x18, 0x01, 0xF8, 0x03, 0x00, 0x06, 0x00, 0x7E,
  0x00, 0xC0, 0x01, 0x80, 0x1F, 0x00, 0x70, 0x00, 0x60, 0x07, 0xC0, 0x1C,
  0x00, 0x18, 0x01, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x6C, 0x01, 0xC0, 0x03,
  0x80, 0x1B, 0x00, 0x70, 0x00, 0xE0, 0x06, 0xE0, 0x0C, 0x00, 0x38, 0x01,
  0xB8, 0x03, 0x00, 0x0E, 0x00, 0xE6, 0x00, 0xC0, 0x07, 0x80, 0x31, 0x80,
  0x38, 0x01, 0xE0, 0x0C, 0x60, 0x06, 0x00, 0xCC, 0x06, 0x18, 0x01, 0xE0,
  0x63, 0x03, 0x87, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x18, 0x00, 0x0F, 0x0C, 0x00, 0x03, 0xC6, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x60, 0x00,
  0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x0E, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x3E, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0x00, 0x0F, 0xC1, 0x80, 0x00, 0x78, 0xC0, 0x00, 0x1E,
  0x60, 0x00, 0x07, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x39, 0x80, 0x00, 0x38, 0xC0,
  0x00, 0x3C, 0x60, 0x00, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x1E,
  0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x0C, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0xF8, 0x0C, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x80,
  0x00, 0x60, 0x3C, 0x00, 0x00, 0x40, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0xC3, 0xC0, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x03, 0x03, 0xE0, 0x00,
  0x06, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xEF,
  0x7E, 0x7F, 0xE1, 0xFC, 0x00, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0,
  0x00, 0x03, 0x98, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83,
  0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x06, 0x01, 0xC0,
  0x03, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x0C, 0x7C, 0x00, 0x06, 0x76,
  0x00, 0x03, 0x73, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70,
  0x1C, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x07,
  0x06, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xBD,
  0x80, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x03, 0xBD, 0xC0, 0x00, 0x00,
  0x33, 0xCC, 0x00, 0x00, 0x03, 0x3C, 0xE0, 0x00, 0x00, 0x73, 0xCE, 0x00,
  0x00, 0x06, 0x3C, 0x60, 0x00, 0x00, 0x63, 0xC7, 0x00, 0x00, 0x0C, 0x3C,
  0x30, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x1C, 0x3C, 0x38, 0x00, 0x01,
  0x83, 0xC1, 0x80, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x03, 0x83, 0xC1, 0xC0,
  0x00, 0x30, 0x3C, 0x0C, 0x00, 0x03, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x3C,
  0x0E, 0x00, 0x06, 0x03, 0xC0, 0x60, 0x00, 0x60, 0x3C, 0x07, 0x00, 0x0C,
  0x03, 0xC0, 0x30, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0x1C, 0x03, 0xC0, 0x38,
  0x01, 0x80, 0x3C, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x18, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x30, 0x03, 0xC0, 0x0C, 0x03, 0x00, 0x3C, 0x00, 0xE0, 0x70,
  0x03, 0xC0, 0x0E, 0x06, 0x00, 0x3C, 0x00, 0x60, 0xE0, 0x03, 0xC0, 0x07,
  0x0C, 0x00, 0x3C, 0x00, 0x30, 0xC0, 0x03, 0xC0, 0x03, 0x1C, 0x00, 0x3C,
  0x00, 0x39, 0x80, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x3C, 0x00, 0x1B, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x78, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x30, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0,
  0x0C, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x18, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x00,
  0x06, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0,
  0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x38, 0x78, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x67,
  0x80, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x06, 0x00, 0x0F, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00,
  0x76, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x1E, 0x30, 0x00, 0x78,
  0x60, 0x3F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x18, 0x00, 0x3E, 0x0C, 0x00, 0x07, 0x06,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x0F, 0x03, 0x00, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0E,
  0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x38, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0x80, 0x3E, 0x1E,
  0x00, 0x04, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x80, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x01, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x06, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x18, 0x00, 0x07, 0x60,
  0x00, 0x1C, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x19, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE3, 0x00,
  0x03, 0x81, 0xC0, 0x01, 0x87, 0x00, 0x07, 0x03, 0x80, 0x03, 0x0E, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x18, 0x00,
  0x70, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x70, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0xC0, 0x0E,
  0x00, 0x70, 0x06, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x30,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x01, 0x80, 0x70, 0x06, 0x01, 0xC0,
  0x03, 0x80, 0xC0, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80, 0x1C, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x00,
  0x1C, 0x18, 0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x00,
  0xE3, 0x80, 0x03, 0x8E, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x1C,
  0x01, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x0C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x38, 0x03, 0x80, 0x06,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x30, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x03, 0x80, 0x07,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xE0, 0xF0,
  0x30, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x07, 0xFE,
  0x18, 0xF8, 0x00, 0xCF, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xBE, 0x00, 0x0D, 0xB8, 0x00, 0xCD, 0xE0,
  0x0C, 0x67, 0xE7, 0xC3, 0x0F, 0xFC, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x7F, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0xC1, 0xF0, 0xCE, 0x00,
  0x78, 0xCC, 0x00, 0x38, 0xD8, 0x00, 0x1C, 0xD0, 0x00, 0x0C, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x1C, 0xD8, 0x00, 0x18, 0xCC, 0x00, 0x38, 0xCE, 0x00, 0xF0, 0xC7, 0xFF,
  0xE0, 0xC1, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xC0, 0xFC, 0x1E, 0x0F, 0x00, 0x10, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x60, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x68,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0xF8, 0x1C, 0x07, 0xFF, 0x0E,
  0x0F, 0x83, 0xC7, 0x0F, 0x00, 0x33, 0x8F, 0x00, 0x0D, 0xC7, 0x00, 0x03,
  0xE7, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x1E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x1E, 0x60, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x8C, 0x00, 0x0D,
  0xC7, 0x00, 0x06, 0xE1, 0xE0, 0x0E, 0x70, 0x7F, 0x7E, 0x18, 0x0F, 0xFC,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x07,
  0x80, 0x78, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x07,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x41, 0xE0, 0x03, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x1F,
  0xBC, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC3, 0x07, 0xE1,
  0xE3, 0x0F, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x1C, 0x00, 0x0F, 0x38, 0x00,
  0x0F, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x1B, 0x1C, 0x00, 0x3B, 0x0F, 0x00,
  0x73, 0x07, 0xF7, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x20, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x3F, 0xE7, 0xF0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x01, 0xFC, 0x0C, 0x1F, 0xFC, 0x31, 0xF0, 0x78,
  0xCE, 0x00, 0x73, 0x30, 0x00, 0xED, 0x80, 0x01, 0xBC, 0x00, 0x06, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x7F,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x01, 0xC0, 0xF0,
  0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0xDF, 0x3F, 0x87, 0x80, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0B,
  0x00, 0x03, 0x98, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x01,
  0xC1, 0x80, 0x1C, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18,
  0x0E, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x87, 0x00,
  0x0C, 0x7C, 0x00, 0x67, 0x70, 0x03, 0x31, 0x80, 0x1B, 0x0E, 0x00, 0xF0,
  0x30, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0,
  0x60, 0x03, 0x03, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xC0, 0x01, 0x86, 0x00,
  0x0E, 0x30, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x03, 0x0F, 0xFC, 0x03, 0xFF, 0x0C, 0x78, 0x78,
  0x3C, 0x1E, 0x33, 0x80, 0x71, 0xC0, 0x1C, 0xD8, 0x00, 0xE6, 0x00, 0x3B,
  0x40, 0x01, 0xB0, 0x00, 0xEF, 0x00, 0x07, 0x80, 0x01, 0xB8, 0x00, 0x1E,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x01, 0xF0,
  0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0xC0,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x00,
  0x01, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x00, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00,
  0x07, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x7F, 0x03, 0x07, 0xFF, 0x0C, 0x7C, 0x1E, 0x33, 0x80, 0x1C,
  0xCC, 0x00, 0x3B, 0x60, 0x00, 0x6F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xC1, 0xFF,
  0xC0, 0xC3, 0xC1, 0xF0, 0xC6, 0x00, 0x78, 0xCC, 0x00, 0x38, 0xD8, 0x00,
  0x1C, 0xD8, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xD8, 0x00, 0x1C, 0xD8, 0x00, 0x1C, 0xCC, 0x00,
  0x38, 0xC7, 0x00, 0xF0, 0xC3, 0xFF, 0xE0, 0xC1, 0xFF, 0x80, 0xC0, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC3, 0x07, 0xC1,
  0xE3, 0x0F, 0x00, 0x73, 0x1C, 0x00, 0x1B, 0x1C, 0x00, 0x0F, 0x38, 0x00,
  0x0F, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0x18, 0x00, 0x1B, 0x1C, 0x00, 0x33, 0x0F, 0x00,
  0x73, 0x07, 0xFF, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x7D, 0x87, 0xFF, 0x1F, 0x3E, 0x70, 0x0C, 0xC0, 0x1B, 0x00,
  0x34, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0x03, 0xF3, 0xC0,
  0x02, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x78, 0x00, 0x0E, 0xF0, 0x01, 0xCF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x30, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x06, 0xD8,
  0x00, 0x1B, 0x70, 0x00, 0xCC, 0xF0, 0x0E, 0x31, 0xFF, 0xF0, 0xC3, 0xFF,
  0x83, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xD8, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x00, 0xF0, 0x00, 0x66, 0x00,
  0x0D, 0x80, 0x03, 0x38, 0x00, 0x6E, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x01,
  0xC6, 0x00, 0x39, 0x80, 0x0C, 0x38, 0x01, 0x8E, 0x00, 0x61, 0xC0, 0x0C,
  0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x38, 0x30, 0x07, 0x0C, 0x01, 0x81,
  0xC0, 0x30, 0x70, 0x0C, 0x0E, 0x01, 0x81, 0x80, 0x60, 0x30, 0x1C, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x70, 0x30, 0x0E, 0x06, 0x03, 0x81, 0x80, 0x70,
  0x30, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x60, 0xE0, 0x0C, 0x18, 0x03, 0x86,
  0x00, 0x70, 0xC0, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x61, 0x80, 0x0C, 0x60,
  0x03, 0x1C, 0x00, 0x63, 0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0x66, 0x00,
  0x0D, 0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1B, 0x80, 0x03, 0x60, 0x00,
  0x78, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x01,
  0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0x70, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x0C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xCF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1E, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xF0,
  0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xBF, 0xFC,
  0x00, 0x78, 0x0F, 0x80, 0xF0, 0x01, 0xFF, 0xE8, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 44, 13, 5, -44 },
  { 23, 12, 16, 20, 4, -44 },
  { 47, 32, 44, 35, 1, -44 },
  { 223, 24, 50, 31, 3, -46 },
  { 373, 38, 45, 44, 3, -44 },
  { 587, 32, 45, 36, 3, -44 },
  { 767, 3, 16, 11, 4, -44 },
  { 773, 11, 54, 16, 3, -44 },
  { 848, 11, 54, 16, 2, -44 },
  { 923, 23, 22, 29, 3, -46 },
  { 987, 25, 29, 31, 3, -36 },
  { 1078, 6, 15, 12, 2, -7 },
  { 1090, 14, 3, 18, 2, -18 },
  { 1096, 4, 4, 13, 5, -4 },
  { 1098, 19, 44, 20, 1, -44 },
  { 1203, 25, 45, 31, 3, -44 },
  { 1344, 13, 44, 31, 5, -44 },
  { 1416, 24, 44, 31, 3, -44 },
  { 1548, 24, 45, 31, 3, -44 },
  { 1683, 29, 44, 31, 1, -44 },
  { 1843, 24, 45, 31, 4, -44 },
  { 1978, 24, 45, 31, 4, -44 },
  { 2113, 25, 44, 31, 3, -44 },
  { 2251, 25, 45, 31, 3, -44 },
  { 2392, 24, 45, 31, 3, -44 },
  { 2527, 4, 33, 13, 5, -33 },
  { 2544, 7, 41, 13, 2, -33 },
  { 2580, 25, 27, 31, 3, -35 },
  { 2665, 25, 15, 31, 3, -29 },
  { 2712, 25, 27, 31, 3, -35 },
  { 2797, 18, 44, 22, 2, -44 },
  { 2896, 42, 49, 48, 3, -43 },
  { 3154, 32, 44, 32, 0, -44 },
  { 3330, 25, 44, 34, 6, -44 },
  { 3468, 28, 45, 33, 4, -44 },
  { 3626, 28, 44, 38, 6, -44 },
  { 3780, 20, 44, 30, 6, -44 },
  { 3890, 21, 44, 27, 6, -44 },
  { 4006, 31, 45, 40, 4, -44 },
  { 4181, 27, 44, 39, 6, -44 },
  { 4330, 11, 44, 17, 3, -44 },
  { 4391, 13, 55, 14, -5, -44 },
  { 4481, 25, 44, 31, 6, -44 },
  { 4619, 20, 44, 27, 6, -44 },
  { 4729, 36, 44, 48, 6, -44 },
  { 4927, 27, 44, 39, 6, -44 },
  { 5076, 33, 45, 41, 4, -44 },
  { 5262, 23, 44, 31, 6, -44 },
  { 5389, 33, 54, 41, 4, -44 },
  { 5612, 25, 44, 32, 6, -44 },
  { 5750, 24, 45, 30, 3, -44 },
  { 5885, 27, 44, 28, 0, -44 },
  { 6034, 28, 45, 39, 5, -44 },
  { 6192, 31, 44, 31, 0, -44 },
  { 6363, 47, 44, 49, 1, -44 },
  { 6622, 28, 44, 28, 0, -44 },
  { 6776, 27, 44, 27, 0, -44 },
  { 6925, 26, 44, 30, 2, -44 },
  { 7068, 12, 54, 19, 5, -44 },
  { 7149, 19, 44, 20, 1, -44 },
  { 7254, 12, 54, 19, 2, -44 },
  { 7335, 27, 25, 31, 2, -44 },
  { 7420, 25, 3, 25, 0, 5 },
  { 7430, 11, 10, 15, 2, -47 },
  { 7444, 21, 34, 29, 3, -33 },
  { 7534, 24, 47, 32, 5, -46 },
  { 7675, 21, 34, 25, 3, -33 },
  { 7765, 25, 47, 32, 3, -46 },
  { 7912, 23, 34, 30, 3, -33 },
  { 8010, 18, 47, 16, 1, -47 },
  { 8116, 24, 48, 32, 3, -33 },
  { 8260, 22, 46, 32, 5, -46 },
  { 8387, 4, 44, 13, 4, -44 },
  { 8409, 10, 59, 13, -2, -44 },
  { 8483, 21, 46, 26, 5, -46 },
  { 8604, 2, 46, 12, 5, -46 },
  { 8616, 38, 33, 48, 5, -33 },
  { 8773, 22, 33, 32, 5, -33 },
  { 8864, 25, 34, 32, 3, -33 },
  { 8971, 24, 47, 32, 5, -33 },
  { 9112, 24, 47, 32, 3, -33 },
  { 9253, 15, 33, 21, 5, -33 },
  { 9315, 20, 34, 25, 2, -33 },
  { 9400, 15, 41, 18, 1, -40 },
  { 9477, 22, 33, 32, 5, -32 },
  { 9568, 24, 32, 24, 0, -32 },
  { 9664, 37, 32, 39, 1, -32 },
  { 9812, 24, 32, 26, 1, -32 },
  { 9908, 24, 47, 25, 0, -32 },
  { 10049, 20, 32, 24, 2, -32 },
  { 10129, 17, 54, 21, 2, -44 },
  { 10244, 2, 61, 29, 14, -46 },
  { 10260, 17, 54, 21, 2, -44 },
  { 10375, 25, 5, 31, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT61PT7B_H_
