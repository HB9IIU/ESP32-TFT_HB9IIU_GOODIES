#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x99, 0x99, 0x99, 0x08, 0x81, 0x10, 0x22, 0x08, 0x4F,
  0xFE, 0x21, 0x04, 0x40, 0x88, 0x11, 0x04, 0x23, 0xFF, 0x90, 0x82, 0x20,
  0x44, 0x08, 0x82, 0x10, 0x08, 0x1F, 0x92, 0x31, 0x08, 0x84, 0x41, 0x20,
  0xD0, 0x18, 0x07, 0x02, 0x41, 0x10, 0x88, 0x44, 0x23, 0xD6, 0x1C, 0x04,
  0x00, 0x30, 0x11, 0x20, 0x84, 0x42, 0x21, 0x10, 0x84, 0x42, 0x12, 0x08,
  0x48, 0x21, 0x4E, 0x45, 0x45, 0x29, 0x13, 0x24, 0x40, 0x91, 0x04, 0x44,
  0x11, 0x10, 0x84, 0x42, 0x11, 0x10, 0x38, 0x0C, 0x03, 0x20, 0x21, 0x02,
  0x10, 0x21, 0x02, 0x10, 0x12, 0x01, 0xC0, 0x18, 0x02, 0x41, 0x42, 0x18,
  0x12, 0x81, 0xA8, 0x0C, 0x80, 0x44, 0x1A, 0x3E, 0x10, 0xFC, 0x12, 0x44,
  0x48, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42, 0x21, 0x84, 0x22, 0x21, 0x11,
  0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x08, 0x04, 0x22, 0x2F, 0xE0, 0x80,
  0xA0, 0x88, 0xC4, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x56, 0xA0, 0xF8, 0xC0, 0x02, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x60, 0x0C, 0x19,
  0x90, 0x48, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0A, 0x05, 0x02, 0x42, 0x1E, 0x00, 0x19, 0x72, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x1C, 0x31, 0x80, 0x40, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x1C, 0x31, 0xA0, 0x40, 0x10, 0x08, 0x04, 0x04, 0x04, 0x3C, 0x01, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x03, 0x02, 0xFE, 0x00, 0x00, 0x80, 0x30, 0x06,
  0x01, 0x40, 0x48, 0x09, 0x02, 0x20, 0x84, 0x10, 0x84, 0x11, 0x02, 0x20,
  0x4F, 0xFE, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x7F, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xF8, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x04, 0xFC, 0x07, 0x06, 0x22, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x7C,
  0xA0, 0xB0, 0x28, 0x0A, 0x01, 0x80, 0x50, 0x24, 0x08, 0x82, 0x1F, 0x00,
  0xFF, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x60, 0x1C, 0x11, 0x90, 0x28, 0x14, 0x0A,
  0x05, 0x84, 0x24, 0x1C, 0x11, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x81,
  0x3F, 0x00, 0x1C, 0x11, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x40,
  0xB1, 0xC7, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x7C, 0x00, 0xC0, 0x30,
  0x50, 0x00, 0x15, 0xA8, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x00, 0x71, 0x18, 0x10, 0x10, 0x20, 0x41, 0x04, 0x10, 0x40, 0x81,
  0x02, 0x00, 0x00, 0x10, 0x60, 0x07, 0xF0, 0x18, 0x0C, 0x20, 0x04, 0x20,
  0x02, 0x41, 0xE2, 0x42, 0x21, 0x84, 0x21, 0x84, 0x21, 0x88, 0x21, 0x88,
  0x21, 0x88, 0x21, 0x84, 0x22, 0x86, 0xD6, 0x41, 0x08, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x10, 0x0F, 0xE0, 0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x09,
  0x01, 0x10, 0x10, 0x81, 0x08, 0x20, 0x83, 0xFC, 0x20, 0x44, 0x04, 0x40,
  0x24, 0x02, 0x80, 0x28, 0x01, 0xFF, 0x20, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x13, 0xF8, 0x81, 0xA0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x28, 0x1B,
  0xF8, 0x07, 0x83, 0x0C, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xE0, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x05, 0x01, 0x20, 0x47, 0xF0, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x03, 0xC0, 0xC3, 0x10, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x1F, 0x80, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x20, 0x11, 0x01, 0x0F, 0xF0, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x2F, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x43, 0xE0, 0x80, 0xA0, 0x48, 0x22, 0x10, 0x88, 0x26, 0x09, 0x02, 0xC0,
  0xC8, 0x22, 0x08, 0x42, 0x08, 0x82, 0x20, 0x48, 0x0A, 0x03, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xC0, 0x0F, 0x00, 0x3A, 0x01, 0x68, 0x05, 0xA0, 0x16, 0x40,
  0x99, 0x02, 0x64, 0x09, 0x88, 0x46, 0x21, 0x18, 0x88, 0x61, 0x21, 0x84,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC0, 0x38, 0x06, 0x80, 0xD0, 0x19,
  0x03, 0x10, 0x62, 0x0C, 0x21, 0x84, 0x30, 0x46, 0x08, 0xC0, 0x98, 0x0B,
  0x01, 0x60, 0x1C, 0x03, 0x07, 0x80, 0xC2, 0x08, 0x08, 0x80, 0x24, 0x01,
  0x20, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x14,
  0x00, 0xA0, 0x08, 0x80, 0x46, 0x04, 0x0F, 0xC0, 0xFE, 0x40, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x05, 0x06, 0xFC, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x07, 0x80, 0xC2, 0x08, 0x08, 0x80, 0x24, 0x01, 0x20, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x14, 0x00, 0xA0,
  0x08, 0x80, 0x46, 0x04, 0x0F, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x08, 0xFC,
  0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x03, 0x1E, 0x10, 0xD0,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x04, 0x02, 0x02, 0xFE, 0x00, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x04, 0x80, 0x90, 0x21, 0xF8, 0x80,
  0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04, 0x20, 0x82, 0x08, 0x10,
  0x81, 0x10, 0x11, 0x00, 0x90, 0x0A, 0x00, 0xA0, 0x06, 0x00, 0x40, 0xC0,
  0x40, 0x50, 0x30, 0x14, 0x0C, 0x09, 0x02, 0x82, 0x21, 0x20, 0x88, 0x48,
  0x22, 0x12, 0x10, 0x84, 0x44, 0x12, 0x11, 0x04, 0x84, 0x41, 0x21, 0x20,
  0x48, 0x28, 0x0C, 0x0A, 0x03, 0x02, 0x80, 0xC0, 0xC0, 0x30, 0x10, 0x40,
  0x48, 0x22, 0x08, 0x44, 0x11, 0x02, 0x80, 0xC0, 0x10, 0x0C, 0x02, 0x81,
  0x10, 0x44, 0x20, 0x90, 0x24, 0x06, 0x01, 0x80, 0x50, 0x24, 0x08, 0x82,
  0x21, 0x04, 0x41, 0x20, 0x28, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0xFF, 0xFC, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0xC0, 0x81,
  0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x0C, 0x03,
  0x01, 0x20, 0x48, 0x21, 0x10, 0x44, 0x0A, 0x02, 0x80, 0x40, 0xFF, 0x80,
  0x84, 0x23, 0x7E, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x61, 0x81, 0x81, 0x81,
  0x83, 0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x85, 0xB3, 0x05, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x82, 0xBE, 0x00, 0x3F, 0x60,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x60, 0x3F, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x09, 0xF5, 0x06, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x05, 0x02, 0x83, 0x3E, 0x80, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0F,
  0xFE, 0x01, 0x00, 0x80, 0x20, 0x18, 0x07, 0xF0, 0x0E, 0x20, 0x81, 0x02,
  0x04, 0x3F, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x3E, 0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50,
  0x67, 0xD0, 0x08, 0x04, 0x02, 0x01, 0x63, 0x0E, 0x00, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xBE, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC7, 0xFF, 0x80, 0x11, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x12, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84,
  0x88, 0x90, 0x90, 0xB0, 0xD0, 0x88, 0x84, 0x84, 0x82, 0x83, 0xFF, 0xFF,
  0x80, 0xBC, 0xFB, 0x0C, 0x18, 0x30, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18,
  0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0xBE, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3F, 0x10,
  0x24, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x90, 0x26, 0x18,
  0xFC, 0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xB0, 0x57, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x3E, 0xA0, 0xD0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x67, 0xD0, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xBF, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x7F, 0x02, 0x04, 0x04, 0x06, 0x03, 0x01, 0x02, 0x04, 0x0F,
  0xE0, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81,
  0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x7D, 0x80, 0xA0, 0x50, 0x48, 0x22, 0x11, 0x10, 0x88, 0x24, 0x14, 0x0A,
  0x05, 0x01, 0x00, 0x81, 0x05, 0x0C, 0x14, 0x28, 0x50, 0xA1, 0x42, 0x88,
  0x91, 0x22, 0x44, 0x89, 0x12, 0x18, 0x50, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x40, 0x90, 0x88, 0x82, 0x40, 0xC0, 0x60, 0x30, 0x24, 0x12, 0x10, 0x90,
  0x58, 0x10, 0x80, 0xA0, 0x50, 0x48, 0x22, 0x11, 0x10, 0x88, 0x24, 0x14,
  0x0A, 0x03, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x60, 0x00, 0xFE,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x07, 0xF0, 0x1C, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x23, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x31,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x30, 0xF8, 0x61, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 4, 6, 8, 2, -16 },
  { 6, 11, 16, 13, 1, -16 },
  { 28, 9, 18, 12, 1, -17 },
  { 49, 14, 17, 17, 1, -17 },
  { 79, 12, 17, 14, 1, -17 },
  { 105, 1, 6, 4, 2, -16 },
  { 106, 4, 20, 6, 1, -16 },
  { 116, 4, 20, 6, 1, -16 },
  { 126, 9, 8, 11, 1, -17 },
  { 135, 10, 10, 12, 1, -13 },
  { 148, 2, 6, 4, 1, -3 },
  { 150, 5, 1, 7, 1, -7 },
  { 151, 1, 2, 5, 2, -2 },
  { 152, 7, 16, 8, 0, -16 },
  { 166, 9, 17, 12, 1, -17 },
  { 186, 5, 16, 12, 2, -16 },
  { 196, 9, 17, 12, 1, -17 },
  { 216, 9, 17, 12, 1, -17 },
  { 236, 11, 17, 12, 0, -17 },
  { 260, 9, 16, 12, 1, -16 },
  { 278, 10, 17, 12, 1, -17 },
  { 300, 9, 16, 12, 1, -16 },
  { 318, 9, 17, 12, 1, -17 },
  { 338, 9, 17, 12, 1, -17 },
  { 358, 1, 12, 5, 2, -12 },
  { 360, 2, 15, 5, 1, -12 },
  { 364, 10, 10, 12, 1, -13 },
  { 377, 10, 6, 12, 1, -11 },
  { 385, 10, 10, 12, 1, -13 },
  { 398, 7, 17, 8, 1, -17 },
  { 413, 16, 18, 18, 1, -16 },
  { 449, 12, 16, 12, 0, -16 },
  { 473, 10, 16, 13, 2, -16 },
  { 493, 11, 17, 13, 1, -17 },
  { 517, 11, 16, 14, 2, -16 },
  { 539, 8, 16, 11, 2, -16 },
  { 555, 8, 16, 10, 2, -16 },
  { 571, 12, 17, 15, 1, -17 },
  { 597, 10, 16, 15, 2, -16 },
  { 617, 4, 16, 6, 1, -16 },
  { 625, 5, 20, 5, -2, -16 },
  { 638, 10, 16, 12, 2, -16 },
  { 658, 8, 16, 10, 2, -16 },
  { 674, 14, 16, 18, 2, -16 },
  { 702, 11, 16, 15, 2, -16 },
  { 724, 13, 17, 15, 1, -17 },
  { 752, 9, 16, 12, 2, -16 },
  { 770, 13, 21, 15, 1, -17 },
  { 805, 10, 16, 12, 2, -16 },
  { 825, 9, 17, 11, 1, -17 },
  { 845, 10, 16, 10, 0, -16 },
  { 865, 11, 16, 15, 2, -16 },
  { 887, 12, 16, 12, 0, -16 },
  { 911, 18, 16, 18, 0, -16 },
  { 947, 10, 16, 11, 0, -16 },
  { 967, 10, 16, 10, 0, -16 },
  { 987, 9, 16, 11, 1, -16 },
  { 1005, 5, 20, 7, 2, -16 },
  { 1018, 7, 16, 8, 0, -16 },
  { 1032, 4, 20, 7, 1, -16 },
  { 1042, 10, 9, 12, 1, -16 },
  { 1054, 9, 1, 9, 0, 2 },
  { 1056, 4, 4, 6, 1, -18 },
  { 1058, 8, 12, 11, 1, -12 },
  { 1070, 9, 17, 12, 2, -17 },
  { 1090, 8, 12, 10, 1, -12 },
  { 1102, 9, 17, 12, 1, -17 },
  { 1122, 9, 12, 11, 1, -12 },
  { 1136, 7, 18, 6, 0, -18 },
  { 1152, 9, 18, 12, 1, -12 },
  { 1173, 8, 17, 12, 2, -17 },
  { 1190, 1, 17, 5, 2, -17 },
  { 1193, 4, 23, 5, -1, -17 },
  { 1205, 8, 17, 10, 2, -17 },
  { 1222, 1, 17, 5, 2, -17 },
  { 1225, 14, 12, 18, 2, -12 },
  { 1246, 8, 12, 12, 2, -12 },
  { 1258, 10, 12, 12, 1, -12 },
  { 1273, 9, 17, 12, 2, -12 },
  { 1293, 9, 17, 12, 1, -12 },
  { 1313, 6, 12, 8, 2, -12 },
  { 1322, 7, 12, 9, 1, -12 },
  { 1333, 6, 15, 7, 0, -15 },
  { 1345, 8, 12, 12, 2, -12 },
  { 1357, 9, 12, 9, 0, -12 },
  { 1371, 14, 12, 15, 0, -12 },
  { 1392, 9, 12, 10, 0, -12 },
  { 1406, 9, 18, 9, 0, -12 },
  { 1427, 7, 12, 9, 1, -12 },
  { 1438, 6, 20, 8, 1, -16 },
  { 1453, 1, 24, 11, 5, -18 },
  { 1456, 6, 20, 8, 1, -16 },
  { 1471, 10, 2, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT23PT7B_H_
