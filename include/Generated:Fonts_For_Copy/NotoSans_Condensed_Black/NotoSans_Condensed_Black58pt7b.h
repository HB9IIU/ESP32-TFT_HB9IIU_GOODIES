#ifndef _NOTOSANS_CONDENSED_BLACK58PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x3F, 0xC7, 0xFE, 0x7F, 0xE7, 0xFE, 0xFF, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x3F, 0xC0, 0x60, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xF3,
  0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF,
  0x9F, 0x0E, 0x3F, 0xE7, 0xC0, 0x8F, 0xF1, 0xF0, 0x03, 0xFE, 0x7C, 0x00,
  0xFF, 0x9F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xDF, 0xF0, 0x01, 0xF3,
  0xFE, 0x00, 0x7C, 0xFF, 0x60, 0x1F, 0x3F, 0xDE, 0x07, 0xDF, 0xF7, 0xF9,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0x9F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x02, 0x00, 0x7F,
  0x0F, 0xE3, 0xFC, 0x3F, 0xE0, 0x7F, 0x9F, 0xE3, 0xF8, 0x7F, 0xF0, 0x7F,
  0xFF, 0xE7, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xCF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x8F, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0x0F, 0xE3, 0xFC, 0xFE, 0x07, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x01,
  0xF8, 0x1F, 0xC7, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0xFF, 0x00,
  0x00, 0x3F, 0x87, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0xFF, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0xBF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x0F, 0xE0, 0x63,
  0xE1, 0xFC, 0x7C, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F,
  0xE3, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFE,
  0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x0F, 0xF3, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xCF, 0xF0, 0x30, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xE7,
  0xFE, 0x1F, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x87, 0xFE, 0x7F,
  0xE1, 0xFF, 0x8F, 0xFC, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xBF, 0xF3, 0xFC, 0xFF, 0xC7, 0xE3, 0xFF, 0x0F, 0x0F, 0xFC, 0x18, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F,
  0xF1, 0xF0, 0x1F, 0xFC, 0x38, 0x03, 0xFF, 0x04, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x87, 0x80, 0xFF, 0xE1, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0x7F, 0xE0, 0x07, 0xFB, 0xFF, 0x00, 0x7F, 0x9F, 0xF8, 0x03, 0xFC,
  0xFF, 0xC0, 0x3F, 0xC7, 0xFE, 0x01, 0xFE, 0x3F, 0xF0, 0x1F, 0xE1, 0xFF,
  0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x70, 0x7F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFD, 0x80,
  0x0F, 0xFE, 0xF8, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x18, 0x01, 0xFF,
  0x3F, 0xE0, 0xFF, 0x9F, 0xFE, 0x3F, 0xEF, 0xFF, 0x8F, 0xFB, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xFC, 0x7F,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xE1,
  0xFF, 0x9F, 0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F,
  0xE0, 0xFF, 0x9F, 0xF8, 0x7F, 0xE3, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0xE7, 0xFE, 0x1F, 0xFB,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F,
  0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0x7F, 0xC7, 0xFF, 0xDF, 0xF0, 0xFF, 0xE7, 0xFC, 0x0F, 0xE1, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x04, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x9F, 0xFB,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0x81, 0xC0, 0x02,
  0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xE3, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC, 0x7F,
  0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3E, 0x03, 0xFF, 0x18, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x04, 0x01, 0xFC, 0x0F, 0xF0,
  0x1F, 0xFE, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF3, 0xF8, 0x7F, 0x03, 0xFF,
  0xFE, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0xC7, 0xF3, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFE, 0x7F, 0x0F, 0xF8, 0xFF, 0x1F, 0xCF, 0xE1, 0xFE, 0x1F, 0xE1, 0xF9,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xFF, 0xE1,
  0xFC, 0x0F, 0xE0, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0x87, 0xF0,
  0x3F, 0x83, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x7E, 0xFE, 0x1F, 0xC0, 0xFE,
  0x0F, 0xDF, 0xC3, 0xF8, 0x1F, 0xC3, 0xFB, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xEF, 0xE1, 0xFE, 0x1F, 0xE3, 0xF9, 0xFE,
  0x1F, 0xEF, 0xFE, 0xFF, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xDF, 0xFE, 0x0F, 0xF0, 0x7F, 0xF1,
  0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F,
  0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0xEF, 0xFC, 0x0F, 0xFE, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F,
  0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xFE,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x3C, 0x3F,
  0xFC, 0x00, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x02, 0x3F, 0xFC, 0x00, 0xE1, 0xFF, 0xF0, 0x7E, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xCF, 0xFC, 0x07, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0xEF,
  0xFC, 0x0F, 0xFF, 0x3F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x78, 0x3F, 0xFE, 0x00,
  0x10, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF,
  0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF,
  0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03,
  0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xFC, 0x03,
  0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xBB, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xCF, 0xFC, 0x07,
  0xFF, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE,
  0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x9F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x03,
  0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x0F,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xBF,
  0xFF, 0xFB, 0xFE, 0x1F, 0xEF, 0xFF, 0xFE, 0x7F, 0x87, 0xF3, 0xFF, 0xFF,
  0x9F, 0xE3, 0xFC, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xCF, 0xE3, 0xFF, 0xFF, 0x8F, 0xF7, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF,
  0xFF, 0xDF, 0xF8, 0x7F, 0xFF, 0xE7, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xE7, 0xFF, 0xFE, 0x1F, 0xFB,
  0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07,
  0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F,
  0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF,
  0xC3, 0xFF, 0x07, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x80,
  0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x01,
  0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xF8, 0x3F, 0x3F, 0xF8, 0x03, 0x1F,
  0xF8, 0x00, 0x8F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF,
  0xF8, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x87, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xC1, 0xFD, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xBF, 0x87,
  0xFE, 0x01, 0xFF, 0x8F, 0xF7, 0xF0, 0xFF, 0xC0, 0x3F, 0xF1, 0xFE, 0xFF,
  0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xDF, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFB,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFE, 0x3F, 0x8F, 0xF8, 0x01, 0xFF, 0x3F,
  0xC7, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0xFF, 0x1F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xE3, 0xFD, 0xFF, 0x00, 0x0F,
  0xFB, 0xFC, 0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0x07, 0xF7, 0xFC, 0x00,
  0x3F, 0xEF, 0xE0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF8,
  0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE,
  0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0x81, 0xFF,
  0x81, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xDF, 0xF3, 0xFF, 0xE3, 0xFC,
  0x7F, 0xF0, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x70, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x9F, 0xFC, 0x3F, 0xF7, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xF3, 0xFF, 0xE3, 0xFE, 0x3F, 0xF8, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xF0, 0x18,
  0x7F, 0xE0, 0x08, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x02, 0x7F, 0xE0, 0x06, 0x7F, 0xF0, 0x1E, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x78, 0x3F, 0xF0, 0x3F, 0xC7, 0xFE, 0x0F, 0xFE, 0x7F, 0xC3,
  0xFF, 0xCF, 0xF8, 0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0x0F, 0xFE, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF8,
  0x7F, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7, 0xFC, 0x1F, 0xFC,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0,
  0xFF, 0xDF, 0xF8, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x02, 0x7F, 0xE0, 0x01, 0x9F, 0xFE, 0x03, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xC3, 0xFC, 0x1F, 0xFC, 0xFF, 0x87, 0xFF, 0xDF, 0xF1, 0xFF, 0xFB, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFE, 0x1F, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xF0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x7F,
  0xC3, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFF, 0x03, 0xFC, 0x7F, 0xE0, 0x0C,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF4, 0x00, 0x07, 0xFE,
  0xE0, 0x01, 0xFF, 0x9F, 0xC1, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x70, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x9F, 0xFE, 0x3F, 0xF7, 0xFF,
  0xE7, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF0, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF,
  0xC1, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x3F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x3F,
  0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xDF, 0xFF, 0xCF, 0xFF, 0xCF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0xFF, 0x83,
  0xFC, 0x7F, 0xFC, 0x7F, 0xDF, 0xFF, 0xCF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF9, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7,
  0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x9F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x1F,
  0xE0, 0xFF, 0x83, 0xFE, 0x3F, 0xF8, 0x7F, 0xCF, 0xFF, 0x8F, 0xFB, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF7, 0xFF, 0xC7, 0xFE, 0x7F, 0xF0, 0xFF, 0xC7, 0xF8, 0x1F,
  0xF8, 0x18, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x1F, 0xFC, 0xFF, 0x87, 0xFF, 0xDF,
  0xF1, 0xFF, 0xFB, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F, 0xFD, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xF0, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0x7F, 0xC3, 0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xFF, 0x03,
  0xFC, 0x7F, 0xE0, 0x0C, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xEF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xC1,
  0xE7, 0xFC, 0x03, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x11, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFB,
  0xFE, 0x3F, 0xFF, 0x3F, 0xC3, 0xFF, 0xC7, 0xF8, 0x3F, 0xE0, 0xFF, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF,
  0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x87, 0xFE,
  0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC3,
  0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFF,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFB, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFE, 0x07, 0xFE,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xE7, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xC7, 0xFE,
  0x1F, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0x7F, 0x0F, 0xF8, 0x3F, 0xE3, 0xFB,
  0xFC, 0xFF, 0xC1, 0xFF, 0x1F, 0xDF, 0xE7, 0xFC, 0x0F, 0xFC, 0xFE, 0xFF,
  0x3F, 0xE0, 0x3F, 0xEF, 0xF3, 0xF9, 0xFF, 0x01, 0xFF, 0x7F, 0x9F, 0xCF,
  0xF8, 0x0F, 0xFB, 0xFC, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xC7, 0xFB, 0xFC,
  0x01, 0xFE, 0xFE, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF1, 0xFF, 0xFF, 0x00,
  0x7F, 0xBF, 0x87, 0xFF, 0xF8, 0x03, 0xFD, 0xFC, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFD, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xBF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x81, 0xFF, 0x87, 0xFE,
  0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFF, 0x00, 0x0D, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xD8, 0x00, 0xFF, 0xF2,
  0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph NotoSans_Condensed_Black58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 42, 16, 2, -41 },
  { 64, 23, 15, 29, 3, -41 },
  { 108, 32, 41, 34, 1, -41 },
  { 272, 26, 47, 30, 2, -44 },
  { 425, 48, 42, 51, 1, -42 },
  { 677, 38, 43, 40, 2, -42 },
  { 882, 10, 15, 15, 3, -41 },
  { 901, 17, 52, 19, 2, -43 },
  { 1012, 16, 52, 19, 1, -43 },
  { 1116, 27, 26, 29, 1, -44 },
  { 1204, 26, 29, 31, 2, -35 },
  { 1299, 12, 16, 16, 2, -8 },
  { 1323, 15, 9, 19, 2, -20 },
  { 1340, 11, 11, 16, 3, -10 },
  { 1356, 25, 43, 25, 0, -42 },
  { 1491, 26, 43, 30, 2, -42 },
  { 1631, 22, 41, 30, 2, -41 },
  { 1744, 26, 42, 30, 1, -42 },
  { 1881, 26, 43, 30, 2, -42 },
  { 2021, 29, 41, 30, 1, -41 },
  { 2170, 25, 42, 30, 3, -41 },
  { 2302, 26, 43, 30, 2, -42 },
  { 2442, 26, 41, 30, 2, -41 },
  { 2576, 26, 43, 30, 2, -42 },
  { 2716, 26, 43, 30, 2, -42 },
  { 2856, 11, 34, 16, 3, -33 },
  { 2903, 12, 41, 17, 2, -33 },
  { 2965, 26, 30, 31, 2, -36 },
  { 3063, 26, 21, 31, 2, -31 },
  { 3132, 26, 30, 31, 2, -36 },
  { 3230, 24, 43, 25, 0, -42 },
  { 3359, 43, 46, 47, 2, -42 },
  { 3607, 36, 41, 36, 0, -41 },
  { 3792, 28, 41, 34, 4, -41 },
  { 3936, 28, 43, 32, 2, -42 },
  { 4087, 30, 41, 37, 4, -41 },
  { 4241, 21, 41, 28, 4, -41 },
  { 4349, 21, 41, 27, 4, -41 },
  { 4457, 32, 43, 37, 2, -42 },
  { 4629, 30, 41, 38, 4, -41 },
  { 4783, 18, 41, 22, 2, -41 },
  { 4876, 18, 54, 18, -4, -41 },
  { 4998, 31, 41, 34, 4, -41 },
  { 5157, 22, 41, 27, 4, -41 },
  { 5270, 42, 41, 50, 4, -41 },
  { 5486, 33, 41, 41, 4, -41 },
  { 5656, 35, 43, 39, 2, -42 },
  { 5845, 26, 41, 32, 4, -41 },
  { 5979, 35, 52, 39, 2, -42 },
  { 6207, 30, 41, 34, 4, -41 },
  { 6361, 25, 43, 28, 2, -42 },
  { 6496, 27, 41, 29, 1, -41 },
  { 6635, 30, 42, 37, 4, -41 },
  { 6793, 35, 41, 35, 0, -41 },
  { 6973, 51, 41, 51, 0, -41 },
  { 7235, 34, 41, 34, 0, -41 },
  { 7410, 33, 41, 33, 0, -41 },
  { 7580, 27, 41, 30, 1, -41 },
  { 7719, 14, 53, 18, 3, -43 },
  { 7812, 25, 43, 25, 0, -42 },
  { 7947, 14, 53, 18, 1, -43 },
  { 8040, 31, 27, 31, 0, -41 },
  { 8145, 29, 7, 29, 0, 4 },
  { 8171, 17, 9, 21, 2, -44 },
  { 8191, 26, 34, 31, 2, -33 },
  { 8302, 27, 45, 32, 3, -44 },
  { 8454, 24, 34, 27, 2, -33 },
  { 8556, 27, 45, 32, 2, -44 },
  { 8708, 26, 34, 30, 2, -33 },
  { 8819, 21, 44, 20, 1, -44 },
  { 8935, 27, 47, 32, 2, -33 },
  { 9094, 27, 44, 33, 3, -44 },
  { 9243, 10, 45, 16, 3, -45 },
  { 9300, 15, 59, 16, -2, -45 },
  { 9411, 30, 44, 33, 3, -44 },
  { 9576, 10, 44, 16, 3, -44 },
  { 9631, 43, 33, 49, 3, -33 },
  { 9809, 27, 33, 33, 3, -33 },
  { 9921, 28, 34, 32, 2, -33 },
  { 10040, 27, 47, 32, 3, -33 },
  { 10199, 27, 47, 32, 2, -33 },
  { 10358, 20, 33, 23, 3, -33 },
  { 10441, 21, 34, 25, 2, -33 },
  { 10531, 20, 40, 22, 1, -39 },
  { 10631, 27, 33, 33, 3, -32 },
  { 10743, 31, 32, 31, 0, -32 },
  { 10867, 45, 32, 46, 0, -32 },
  { 11047, 30, 32, 30, 0, -32 },
  { 11167, 30, 46, 31, 0, -32 },
  { 11340, 23, 32, 25, 1, -32 },
  { 11432, 20, 52, 22, 1, -42 },
  { 11562, 8, 58, 26, 9, -45 },
  { 11620, 20, 52, 22, 1, -42 },
  { 11750, 27, 11, 31, 2, -26 },
};

const GFXfont NotoSans_Condensed_Black58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_BLACK58PT7B_H_
