#ifndef _NOTOSANS_CONDENSED_BLACK22PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x6F, 0xFF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFE, 0x7F, 0x3C, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF1, 0xDC, 0x1D, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0x83,
  0xB8, 0x3B, 0x83, 0xB8, 0x0C, 0x03, 0x03, 0xF9, 0xFE, 0xFF, 0xBB, 0x2E,
  0xC3, 0xF0, 0x7F, 0x0F, 0xE0, 0xF8, 0x3F, 0x8D, 0xFF, 0xEF, 0xFB, 0xFC,
  0x0C, 0x03, 0x00, 0x3C, 0x0E, 0x0F, 0xC3, 0x81, 0xF8, 0x70, 0x33, 0x9C,
  0x0E, 0x73, 0x81, 0xCE, 0xE0, 0x19, 0xDC, 0xC3, 0xF7, 0x7E, 0x7E, 0xEF,
  0xC7, 0x99, 0x98, 0x07, 0x73, 0x80, 0xCE, 0x70, 0x39, 0xCE, 0x07, 0x1F,
  0x81, 0xC3, 0xF0, 0x38, 0x3C, 0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x1C, 0xF0,
  0x7B, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xCF, 0x7F, 0x7B, 0xFF, 0xEF, 0x7F,
  0xB8, 0xFC, 0xF3, 0xF3, 0xFF, 0xCF, 0xFF, 0x9F, 0xDF, 0xFF, 0xFF, 0xEE,
  0x3C, 0xE7, 0x9C, 0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xC7, 0x1C,
  0x78, 0xE3, 0xC0, 0xF1, 0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x73, 0xCF, 0x39, 0xEF, 0x00, 0x0E, 0x01, 0xC1, 0x39, 0x3F, 0xE7,
  0xFD, 0xFF, 0xC7, 0xC1, 0xFC, 0x7B, 0xC2, 0x20, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xFF, 0xFE,
  0xEE, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0xF0,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x81, 0xC1, 0xE0,
  0x1E, 0x1F, 0xC7, 0xFB, 0xDE, 0xF3, 0xBC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCE, 0xF7, 0x9F, 0xE7, 0xF0, 0xF8, 0x07, 0x0F, 0x1F, 0x7F,
  0xFF, 0xFF, 0x6F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x0F, 0xEF, 0xFD, 0xCF, 0x23, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x1F, 0xF7, 0xFD, 0xFF, 0x3E, 0x3F, 0xCF, 0xF9,
  0x9E, 0x07, 0x81, 0xE3, 0xF0, 0xF8, 0x3F, 0x0F, 0xE0, 0x78, 0x1F, 0x87,
  0xBF, 0xEF, 0xFB, 0xF8, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x3F,
  0x8E, 0xF1, 0xDE, 0x73, 0xCE, 0x7B, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80,
  0xF0, 0x1E, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x70, 0x3C, 0x0F, 0xF3, 0xFE,
  0xFF, 0x81, 0xE0, 0x3C, 0x0E, 0x87, 0xBF, 0xEF, 0xF3, 0xF8, 0x0F, 0x8F,
  0xE7, 0xF9, 0xE0, 0xF0, 0x3C, 0x0E, 0xF3, 0xFE, 0xFF, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xDF, 0xE7, 0xF8, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03,
  0xC1, 0xE0, 0x3E, 0x1F, 0xEF, 0xFB, 0xCE, 0xF3, 0xBD, 0xE7, 0xF8, 0xF8,
  0x7F, 0x3F, 0xEF, 0x3F, 0x8F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFC, 0x3E, 0x1F,
  0xCF, 0xFB, 0xDE, 0xF3, 0xF8, 0xFF, 0x3F, 0xDF, 0xFF, 0xDF, 0xF3, 0xB8,
  0x0E, 0x07, 0x9F, 0xC7, 0xE1, 0xF0, 0xFF, 0xF6, 0x00, 0x00, 0x6F, 0xFF,
  0xFF, 0xF6, 0x00, 0x00, 0x0F, 0xFF, 0xEE, 0xE0, 0x00, 0x40, 0x70, 0x7C,
  0x7F, 0x7F, 0x3E, 0x0F, 0x81, 0xF8, 0x1F, 0xC1, 0xF0, 0x1C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x0F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0xFE, 0xFE, 0x3E, 0x0C, 0x02, 0x00,
  0x3E, 0x7F, 0xBF, 0xEC, 0xF0, 0x38, 0x3C, 0x3C, 0x3E, 0x1C, 0x0E, 0x00,
  0x00, 0x01, 0x81, 0xE0, 0xF0, 0x78, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C,
  0x78, 0x0E, 0x73, 0xE6, 0xE7, 0xF7, 0xEF, 0x77, 0xEE, 0x77, 0xCE, 0x77,
  0xCE, 0x77, 0xCE, 0x77, 0xEF, 0xFE, 0xE7, 0xBC, 0x70, 0x00, 0x78, 0x08,
  0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x77, 0x81, 0xDE, 0x0F, 0x38, 0x3C, 0xF0, 0xF3, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF9, 0xE1, 0xEF, 0x87, 0xBC, 0x1F, 0xFF, 0x1F,
  0xFB, 0xFF, 0x79, 0xFF, 0x1F, 0xE3, 0xFF, 0xF7, 0xFC, 0xFF, 0xDE, 0x7F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0x87, 0xFD, 0xFF,
  0x3E, 0x67, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0x84, 0xFF, 0x8F, 0xF0, 0xFE, 0xFE, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE,
  0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E,
  0xF3, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x83, 0xFD, 0xFE, 0xFF, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0xC1, 0xFF, 0x3F, 0xE7, 0xC6, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0xFF, 0x8F, 0x78, 0xF7,
  0xFF, 0x3F, 0xF1, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFB, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x9F, 0xBF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3E, 0xFF, 0xFE, 0xF0, 0xF0, 0xFF,
  0x1F, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x8F,
  0xF8, 0xFF, 0xCF, 0x3C, 0xF3, 0xEF, 0x1E, 0xF1, 0xEF, 0x0F, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x77, 0xFF, 0x77, 0xF7, 0x77, 0xF7, 0x77,
  0xF7, 0xE7, 0xF3, 0xE7, 0xF3, 0xE7, 0xF3, 0xE7, 0xF3, 0xC7, 0xF1, 0xC7,
  0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0xFE,
  0xE7, 0xF7, 0xBF, 0x9D, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3,
  0xFE, 0x1F, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0x78, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xE7, 0x8F, 0x3F,
  0xF8, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xF3, 0xFF, 0x7F, 0xEF, 0x3D, 0xE3,
  0xFC, 0xF7, 0xBE, 0xFF, 0xDF, 0xF3, 0xF8, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0x78, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xF7, 0x8F, 0x3F,
  0xF8, 0xFF, 0x83, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0xFE,
  0x0F, 0xF8, 0xFF, 0xCF, 0x7C, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0xFC, 0xFF,
  0x8F, 0xF8, 0xF7, 0x8F, 0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x1F, 0x3F,
  0x3F, 0xFF, 0xFF, 0x6F, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0,
  0xFC, 0x7F, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0xFE,
  0x3F, 0xC1, 0xF8, 0xF0, 0x7F, 0x83, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F, 0x3C,
  0x78, 0xF3, 0x87, 0xBC, 0x3D, 0xE0, 0xEF, 0x07, 0x70, 0x3F, 0x81, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0xF0, 0xE1, 0xFE, 0x1E, 0x3D, 0xC3, 0xC7,
  0xB8, 0xF8, 0xF7, 0x9F, 0x1C, 0xF3, 0xE7, 0x9E, 0x7E, 0xF1, 0xCD, 0xDE,
  0x3B, 0xBB, 0xC7, 0xF7, 0x70, 0xFE, 0xEE, 0x1F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0xF0, 0xF3, 0xC7, 0x9E, 0x78,
  0x7B, 0xC3, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xF0, 0x7F, 0x83, 0xDE, 0x3C, 0xF1, 0xE3, 0xDE, 0x1F, 0xF0, 0xF7, 0x8F,
  0x78, 0xE7, 0x9E, 0x3D, 0xE3, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xF0, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81,
  0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0x07,
  0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xF8,
  0x39, 0xC3, 0x9C, 0x70, 0xE7, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF1, 0xE3, 0xC7, 0x7F, 0x1F, 0xE7, 0xF8, 0x0F, 0x1F, 0xDF, 0xFF,
  0xFF, 0x8F, 0xE3, 0xFF, 0xFF, 0xFD, 0xE7, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xEF, 0x3F, 0xF7, 0xFE, 0xF3, 0xDE, 0x3B, 0xC7, 0xF8, 0xFF,
  0x1D, 0xE7, 0xBF, 0xF7, 0xFE, 0xE7, 0x80, 0x3F, 0xBF, 0xBF, 0xDE, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF1, 0x7F, 0x9F, 0xC7, 0xE0, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xDF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3D, 0xC0, 0x3F, 0x1F, 0xEF, 0x7B, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x7F, 0xE7, 0xF8, 0xFE, 0x0F, 0x3F,
  0x3F, 0x3C, 0x38, 0x7F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x7D, 0xDF, 0xFF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFF, 0xF7, 0xFC, 0xFF, 0x03, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF,
  0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xC0, 0x7F,
  0xF6, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xF3, 0xC6, 0x00,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFB,
  0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE3, 0xFC, 0xF7, 0xBC,
  0xF7, 0x9F, 0xE3, 0xFC, 0x7F, 0xCF, 0xF9, 0xE7, 0xBC, 0xF7, 0x8F, 0xF1,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0x9E,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDE, 0x7C, 0xFF, 0x3C, 0x7F, 0x9E, 0x3F, 0xCF,
  0x1F, 0xE7, 0x8F, 0xF3, 0xC7, 0xF9, 0xE3, 0xFC, 0xF1, 0xFE, 0x78, 0xF0,
  0xEF, 0xBF, 0xFF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0x3F, 0x1F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0x7F, 0x1F,
  0xCF, 0xF3, 0xDF, 0xF7, 0xF8, 0xFC, 0xE7, 0x9F, 0xFB, 0xFF, 0x79, 0xEF,
  0x1D, 0xE3, 0xFC, 0x7F, 0x8E, 0xF3, 0xDF, 0xFB, 0xFF, 0x7B, 0xCF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x7D, 0xDF, 0xFF, 0xFF, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0xF7, 0xFC, 0xFF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xE7, 0xFF, 0xFE, 0xFE, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x7F, 0xFE, 0xF6, 0xF0, 0xF8, 0xFE, 0x7F, 0x1F,
  0x8F, 0xFF, 0xFE, 0xFC, 0x18, 0x38, 0x38, 0x7F, 0xFF, 0xFF, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xF3, 0xFF, 0xF7, 0xFC, 0xF7, 0xF1, 0xF7,
  0x1E, 0x79, 0xE7, 0x9C, 0x79, 0xC3, 0xBC, 0x3B, 0x83, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x00, 0xF0, 0xF3, 0xE7, 0xB9, 0xF3, 0xDC, 0xF9, 0xEF, 0x7C,
  0xE7, 0xB7, 0x73, 0xFB, 0xF8, 0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x3E, 0x1F,
  0x9F, 0x07, 0x8F, 0x83, 0xC7, 0xC0, 0xF9, 0xEF, 0x78, 0xEF, 0x1F, 0xC1,
  0xF8, 0x3E, 0x07, 0xE1, 0xFC, 0x3F, 0xCF, 0x79, 0xE7, 0xF8, 0xF0, 0xF0,
  0xF7, 0x1E, 0x79, 0xE7, 0x9C, 0x39, 0xC3, 0xBC, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x7E, 0x07, 0xC0, 0x78,
  0x00, 0x7F, 0xBF, 0xDF, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFC,
  0xF8, 0xF8, 0x7C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x1F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xE3, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x3E, 0x3C, 0xF9, 0xE7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3,
  0xC6, 0x00, 0x70, 0x7F, 0xFF, 0xFE, 0x3E,
};

const GFXglyph NotoSans_Condensed_Black22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 12, 16, 13, 0, -16 },
  { 40, 10, 18, 11, 1, -17 },
  { 63, 19, 16, 19, 0, -16 },
  { 101, 14, 16, 15, 1, -16 },
  { 129, 4, 6, 6, 1, -16 },
  { 132, 6, 19, 7, 1, -16 },
  { 147, 6, 19, 7, 0, -16 },
  { 162, 11, 10, 11, 0, -17 },
  { 176, 10, 11, 12, 1, -13 },
  { 190, 4, 6, 6, 1, -3 },
  { 193, 6, 4, 7, 1, -8 },
  { 196, 4, 4, 6, 1, -4 },
  { 198, 9, 16, 9, 0, -16 },
  { 216, 10, 16, 11, 1, -16 },
  { 236, 8, 16, 11, 1, -16 },
  { 252, 10, 16, 11, 0, -16 },
  { 272, 10, 16, 11, 1, -16 },
  { 292, 11, 16, 11, 0, -16 },
  { 314, 10, 16, 11, 1, -16 },
  { 334, 10, 16, 11, 1, -16 },
  { 354, 10, 16, 11, 1, -16 },
  { 374, 10, 16, 11, 1, -16 },
  { 394, 10, 16, 11, 1, -16 },
  { 414, 4, 12, 6, 1, -12 },
  { 420, 4, 15, 6, 1, -12 },
  { 428, 10, 12, 12, 1, -14 },
  { 443, 10, 8, 12, 1, -12 },
  { 453, 10, 12, 12, 1, -14 },
  { 468, 9, 16, 10, 0, -16 },
  { 486, 16, 18, 18, 1, -16 },
  { 522, 14, 16, 14, 0, -16 },
  { 550, 11, 16, 13, 1, -16 },
  { 572, 11, 16, 12, 1, -16 },
  { 594, 12, 16, 14, 1, -16 },
  { 618, 9, 16, 10, 1, -16 },
  { 636, 8, 16, 10, 1, -16 },
  { 652, 12, 16, 14, 1, -16 },
  { 676, 12, 16, 14, 1, -16 },
  { 700, 7, 16, 8, 1, -16 },
  { 714, 6, 21, 7, -1, -16 },
  { 730, 12, 16, 13, 1, -16 },
  { 754, 9, 16, 10, 1, -16 },
  { 772, 16, 16, 19, 1, -16 },
  { 804, 13, 16, 16, 1, -16 },
  { 830, 13, 16, 15, 1, -16 },
  { 856, 11, 16, 12, 1, -16 },
  { 878, 13, 20, 15, 1, -16 },
  { 911, 12, 16, 13, 1, -16 },
  { 935, 9, 16, 11, 1, -16 },
  { 953, 11, 16, 11, 0, -16 },
  { 975, 12, 16, 14, 1, -16 },
  { 999, 13, 16, 13, 0, -16 },
  { 1025, 19, 16, 19, 0, -16 },
  { 1063, 13, 16, 13, 0, -16 },
  { 1089, 12, 16, 12, 0, -16 },
  { 1113, 10, 16, 11, 1, -16 },
  { 1133, 5, 20, 7, 1, -16 },
  { 1146, 9, 16, 9, 0, -16 },
  { 1164, 6, 20, 7, 0, -16 },
  { 1179, 12, 11, 12, 0, -16 },
  { 1196, 11, 3, 11, 0, 1 },
  { 1201, 6, 4, 8, 1, -17 },
  { 1204, 10, 12, 12, 1, -12 },
  { 1219, 11, 17, 12, 1, -17 },
  { 1243, 9, 12, 10, 1, -12 },
  { 1257, 10, 17, 12, 1, -17 },
  { 1279, 10, 12, 12, 1, -12 },
  { 1294, 8, 17, 8, 0, -17 },
  { 1311, 10, 17, 12, 1, -12 },
  { 1333, 10, 17, 13, 1, -17 },
  { 1355, 4, 17, 6, 1, -17 },
  { 1364, 6, 22, 6, -1, -17 },
  { 1381, 11, 17, 12, 1, -17 },
  { 1405, 4, 17, 6, 1, -17 },
  { 1414, 17, 12, 19, 1, -12 },
  { 1440, 10, 12, 13, 1, -12 },
  { 1455, 10, 12, 12, 1, -12 },
  { 1470, 11, 17, 12, 1, -12 },
  { 1494, 10, 17, 12, 1, -12 },
  { 1516, 8, 12, 9, 1, -12 },
  { 1528, 8, 12, 10, 1, -12 },
  { 1540, 8, 15, 8, 0, -15 },
  { 1555, 10, 12, 13, 1, -12 },
  { 1570, 12, 12, 12, 0, -12 },
  { 1588, 17, 12, 17, 0, -12 },
  { 1614, 11, 12, 11, 0, -12 },
  { 1631, 12, 17, 12, 0, -12 },
  { 1657, 9, 12, 9, 0, -12 },
  { 1671, 8, 20, 9, 0, -16 },
  { 1691, 3, 22, 10, 3, -17 },
  { 1700, 7, 20, 9, 1, -16 },
  { 1718, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_Black22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_BLACK22PT7B_H_
