#ifndef _NOTOSANS_CONDENSED_BLACK26PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF0, 0x00, 0x9F, 0xFF,
  0xDE, 0xFB, 0xFF, 0x7F, 0xEF, 0xF9, 0xFF, 0x1C, 0xE3, 0x9C, 0x70, 0x0E,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x1E, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x77, 0x83, 0xDC, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3,
  0x9C, 0x0E, 0x70, 0x3B, 0xC1, 0xEE, 0x07, 0x38, 0x00, 0x06, 0x00, 0x60,
  0x1F, 0x87, 0xFE, 0x7F, 0xEF, 0xFC, 0xF6, 0x0F, 0x60, 0xFE, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x6F, 0x86, 0xFE, 0x7E, 0xFF, 0xEF, 0xFC,
  0x7F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x07, 0x03, 0xF0, 0x78, 0x3F,
  0x83, 0x81, 0xDE, 0x3C, 0x0E, 0x71, 0xC0, 0x73, 0x8E, 0x03, 0x9C, 0xE0,
  0x1C, 0xE7, 0x00, 0xEF, 0x7B, 0xE7, 0xFB, 0xBF, 0x9F, 0xBD, 0xFE, 0x71,
  0xCE, 0xF0, 0x1E, 0xF3, 0x80, 0xE7, 0x9C, 0x0F, 0x1C, 0xE0, 0x70, 0xEF,
  0x03, 0x87, 0xF8, 0x38, 0x1F, 0x83, 0xC0, 0xF8, 0x0F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xBE, 0x07, 0x8F, 0x03, 0xEF, 0x80, 0xF7, 0x80, 0x7F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xCF, 0x9F, 0xF7, 0xDF, 0xFF, 0xCF, 0x3F, 0xE7,
  0x8F, 0xF3, 0xC3, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xE7,
  0xE0, 0xFF, 0xFF, 0xEF, 0x39, 0xC0, 0x1E, 0x38, 0xF1, 0xE7, 0x8F, 0x1E,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C, 0x78, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0x80, 0xF8, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x78, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x06, 0x73, 0x7F, 0xF7, 0xFF, 0xFF,
  0xF0, 0xF8, 0x1F, 0xC3, 0xDE, 0x79, 0xE0, 0x88, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x7B, 0xDF, 0xFF, 0x7B, 0xDC, 0xFF, 0xFF, 0xFF,
  0xF0, 0x27, 0xFF, 0xF7, 0x80, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xF8, 0x7F,
  0xC7, 0xFE, 0xFB, 0xEF, 0x9E, 0xF9, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF9, 0xFF, 0x9E, 0xF9, 0xE7, 0xFE, 0x7F, 0xC3, 0xFC, 0x1F,
  0x80, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xFD, 0xDF, 0x27,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0xF3, 0xFF, 0x7F, 0xF7, 0x3E, 0x87, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x0F, 0xFC, 0xFF, 0xC7, 0xFE, 0x63, 0xE0,
  0x1E, 0x03, 0xE0, 0x7C, 0x3F, 0x83, 0xF0, 0x3F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x83, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x3D, 0xE1,
  0xCF, 0x1E, 0x78, 0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0x80, 0xF0,
  0x1E, 0x03, 0xFC, 0x7F, 0xCF, 0xFD, 0xFF, 0x81, 0xF0, 0x1E, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x00, 0x03, 0xE1, 0xFE, 0x3F, 0xE7,
  0xFE, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFE, 0xFD, 0xFF,
  0x9F, 0xF1, 0xFF, 0x1F, 0xF9, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xF9,
  0xEF, 0x9E, 0x7B, 0xE7, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0xCF, 0xFE, 0xF9,
  0xEF, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x0E, 0x03,
  0xF8, 0x7F, 0xCF, 0xFE, 0xF9, 0xEF, 0x1E, 0xF1, 0xFF, 0x1F, 0xF9, 0xFF,
  0xFF, 0x7F, 0xF7, 0xFF, 0x1D, 0xE0, 0x1E, 0x03, 0xE5, 0xFC, 0x7F, 0xC7,
  0xF8, 0x7E, 0x00, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x08, 0xFF, 0xFD,
  0xE0, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0xF7, 0xBF, 0xFE, 0xF7,
  0xB8, 0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFF, 0x3F, 0xCF, 0xF0, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x7F, 0x3F,
  0xCF, 0xF0, 0xFC, 0x0F, 0x00, 0xC0, 0x00, 0x1F, 0x0F, 0xFB, 0xFF, 0x3F,
  0xF6, 0x3E, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x03, 0xC3, 0x80, 0x3C, 0xF3, 0xFB,
  0x9C, 0xFF, 0x7F, 0xBE, 0xE7, 0xE7, 0x1C, 0xFC, 0xE3, 0x9F, 0x9C, 0x73,
  0xF3, 0x8E, 0x7E, 0x73, 0xCF, 0xCF, 0xFF, 0xBC, 0xFF, 0xF3, 0x8F, 0x38,
  0x78, 0x00, 0x07, 0x80, 0x40, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3E, 0x7C, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x3E, 0xFF, 0xEF, 0xFC, 0xFF, 0xEF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF1,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xCF, 0xFC,
  0x7F, 0xE7, 0xE3, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x4F, 0xFE, 0x3F, 0xF0, 0xFF,
  0x83, 0xF8, 0xFC, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x3F, 0x78, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC7, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE,
  0x7E, 0x19, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0x7F, 0xF8, 0x3D, 0xE0, 0xF7, 0xC3, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F,
  0xF0, 0xFF, 0x80, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0, 0x7F, 0xC3, 0xEF, 0x1F, 0x3C,
  0x7C, 0xF3, 0xE3, 0xCF, 0x8F, 0x7C, 0x3D, 0xF0, 0xFF, 0x83, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFB, 0xE3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF1, 0xF3,
  0xC3, 0xEF, 0x0F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFE, 0xE7, 0x7F, 0xDE, 0xEF, 0xFB, 0xFD, 0xFF, 0x7F, 0xBF, 0xE7,
  0xE7, 0xFC, 0xFC, 0xFF, 0x9F, 0x9F, 0xF3, 0xF3, 0xFE, 0x3C, 0x7F, 0xC7,
  0x8F, 0x80, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x9F, 0xEF, 0x3F, 0xDF, 0x7F, 0x9E,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC1, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xEF,
  0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x83, 0xEF, 0x07, 0xDF, 0x0F, 0xBF, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0x80, 0xFE, 0x0F, 0xF8, 0xFF, 0xEF, 0xFE, 0xF3, 0xEF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF3, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7C, 0x7E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x7C,
  0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF,
  0x3F, 0x78, 0xFB, 0xC7, 0xDE, 0x3E, 0xF7, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF,
  0x0F, 0x7C, 0x79, 0xE3, 0xCF, 0x9E, 0x3E, 0xF1, 0xF7, 0x87, 0xFC, 0x3E,
  0x0F, 0x87, 0xFD, 0xFF, 0xFF, 0xEF, 0x8D, 0xF0, 0x3E, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0x07, 0xF0, 0xF8, 0x1F, 0xF8, 0x3E, 0x78, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3C, 0x7C, 0x3C, 0x3C, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x78, 0x3F, 0xF0, 0xF8, 0x7D, 0xE1,
  0xF0, 0xF3, 0xC3, 0xE1, 0xE7, 0x87, 0xC7, 0xCF, 0x9F, 0x8F, 0x9F, 0x3F,
  0x9E, 0x1E, 0x7F, 0x3C, 0x3C, 0xEE, 0x78, 0x79, 0xDD, 0xF0, 0xF7, 0xBB,
  0xE1, 0xFF, 0x77, 0x81, 0xFE, 0xFF, 0x03, 0xF9, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80,
  0xF8, 0x3E, 0xF8, 0xF9, 0xF1, 0xF1, 0xE7, 0xC3, 0xEF, 0x83, 0xDE, 0x07,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFF,
  0x03, 0xFE, 0x0F, 0xBE, 0x1F, 0x7C, 0x7C, 0x7C, 0xF8, 0xFB, 0xE0, 0xF8,
  0xF8, 0x3F, 0xF0, 0x79, 0xF1, 0xF3, 0xE3, 0xC3, 0xCF, 0x87, 0xDE, 0x07,
  0xBC, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF,
  0xFF, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFE, 0x0F, 0x38, 0x3C, 0xF0, 0xE1, 0xC7, 0x87, 0x9C, 0x0E, 0xF0,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0xF0, 0xF0, 0x06, 0x0F,
  0xF9, 0xFF, 0x9F, 0xF2, 0x1E, 0x03, 0xCF, 0xFB, 0xFF, 0xFF, 0xFE, 0x3F,
  0xC7, 0xFD, 0xFF, 0xFF, 0xFD, 0xDF, 0x38, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0xC3, 0xEF, 0x9F, 0xFE, 0xFF, 0xF7, 0xEF, 0xBE,
  0x3D, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1E, 0xFD, 0xF7, 0xFF,
  0xBF, 0xF9, 0xE7, 0x80, 0x06, 0x0F, 0xF7, 0xFD, 0xFF, 0xF8, 0xBE, 0x0F,
  0x83, 0xC0, 0xF0, 0x3E, 0x0F, 0x87, 0xF7, 0x7F, 0xDF, 0xF1, 0xF8, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0x8F, 0x3E, 0xF7, 0xFF, 0x7F,
  0xFF, 0x9F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x9F, 0xFD,
  0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x06, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xF9,
  0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0x86, 0x7F,
  0xE3, 0xFE, 0x1F, 0xC0, 0x0F, 0x87, 0xF3, 0xF8, 0xFE, 0x3C, 0x0F, 0x07,
  0xFB, 0xFE, 0xFF, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x18, 0x03, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9,
  0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x7F,
  0xF7, 0xEF, 0x3E, 0xF0, 0x0F, 0x81, 0xF7, 0x3F, 0x7F, 0xE7, 0xFC, 0x7F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x98, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x7F, 0xFE, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x7C, 0xF8, 0xF0,
  0x00, 0x0F, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xFD, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x8F, 0xBE, 0x7C, 0xF9, 0xF3, 0xEF,
  0x8F, 0xBC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3E, 0x78, 0xF9,
  0xF3, 0xE3, 0xCF, 0x8F, 0xBE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC3, 0x0F, 0x7E, 0x7E,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xF0, 0x01, 0x8F, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF0, 0x06, 0x03, 0xFC, 0x7F,
  0xE7, 0xFE, 0xF9, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8,
  0xF7, 0xDF, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0x01, 0x87, 0xBF, 0x3F, 0xFD,
  0xFF, 0xEF, 0x9F, 0x7C, 0x7B, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3D, 0xFB, 0xEF, 0xFF, 0x7F, 0xF3, 0xEF, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x18, 0x03, 0xEF, 0x7F, 0xF7, 0xFF,
  0xF9, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF,
  0x7F, 0xF7, 0xEF, 0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x01, 0xF9, 0xFD, 0xFF, 0xFF, 0xFF, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF,
  0x17, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1C, 0x0E, 0x0F, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xF4, 0xFE, 0x7F, 0x1F, 0x80, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x7F,
  0xF7, 0xFF, 0x7F, 0x73, 0xE7, 0xF8, 0x7D, 0xE1, 0xE7, 0x8F, 0x9F, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xDF, 0x07, 0x78, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0xF8, 0xF7, 0x9F, 0x8F, 0x79,
  0xF9, 0xF7, 0x9F, 0xDE, 0x79, 0xFD, 0xE3, 0xDF, 0xDE, 0x3F, 0xDD, 0xE3,
  0xFD, 0xDE, 0x3F, 0x9D, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0xFC, 0xFB, 0xE7, 0x8F, 0x7C, 0x7F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0x7C, 0xFB,
  0xE7, 0xCF, 0xFC, 0x7C, 0xF8, 0x7D, 0xE1, 0xE7, 0x8F, 0x9F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xDF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x03, 0xE0, 0x78, 0x1F, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0x87, 0xC7, 0xE3, 0xF1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x3F, 0x9F,
  0x8F, 0xC7, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF8, 0x7C,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7C, 0x3E, 0x1F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0x0F, 0xE3, 0xF1, 0xF9, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0x8F, 0xC7, 0xC3, 0xC0, 0x30, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xE0,
};

const GFXglyph NotoSans_Condensed_Black26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 11, 7, 13, 1, -19 },
  { 23, 14, 19, 15, 1, -19 },
  { 57, 12, 22, 14, 1, -20 },
  { 90, 21, 19, 23, 1, -19 },
  { 140, 17, 19, 18, 1, -19 },
  { 181, 5, 7, 7, 1, -19 },
  { 186, 7, 23, 9, 1, -19 },
  { 207, 8, 23, 9, 0, -19 },
  { 230, 12, 12, 13, 0, -20 },
  { 248, 12, 13, 14, 1, -16 },
  { 268, 5, 8, 7, 1, -4 },
  { 273, 7, 4, 8, 1, -9 },
  { 277, 5, 5, 7, 1, -5 },
  { 281, 11, 19, 11, 0, -19 },
  { 308, 12, 19, 14, 1, -19 },
  { 337, 10, 19, 14, 1, -19 },
  { 361, 11, 19, 14, 1, -19 },
  { 388, 12, 19, 14, 1, -19 },
  { 417, 13, 19, 14, 0, -19 },
  { 448, 11, 19, 14, 1, -19 },
  { 475, 12, 19, 14, 1, -19 },
  { 504, 12, 19, 14, 1, -19 },
  { 533, 12, 19, 14, 1, -19 },
  { 562, 12, 19, 14, 1, -19 },
  { 591, 5, 15, 7, 1, -15 },
  { 601, 5, 19, 7, 1, -15 },
  { 613, 12, 13, 14, 1, -16 },
  { 633, 12, 9, 14, 1, -14 },
  { 647, 12, 13, 14, 1, -16 },
  { 667, 11, 19, 11, 0, -19 },
  { 694, 19, 21, 21, 1, -19 },
  { 744, 16, 19, 16, 0, -19 },
  { 782, 12, 19, 15, 2, -19 },
  { 811, 13, 19, 14, 1, -19 },
  { 842, 13, 19, 16, 2, -19 },
  { 873, 9, 19, 12, 2, -19 },
  { 895, 9, 19, 12, 2, -19 },
  { 917, 14, 19, 17, 1, -19 },
  { 951, 13, 19, 17, 2, -19 },
  { 982, 8, 19, 10, 1, -19 },
  { 1001, 8, 25, 8, -2, -19 },
  { 1026, 14, 19, 15, 2, -19 },
  { 1060, 10, 19, 12, 2, -19 },
  { 1084, 19, 19, 22, 2, -19 },
  { 1130, 15, 19, 18, 2, -19 },
  { 1166, 15, 19, 18, 1, -19 },
  { 1202, 12, 19, 14, 2, -19 },
  { 1231, 16, 23, 18, 1, -19 },
  { 1277, 13, 19, 15, 2, -19 },
  { 1308, 11, 19, 13, 1, -19 },
  { 1335, 12, 19, 13, 0, -19 },
  { 1364, 13, 19, 17, 2, -19 },
  { 1395, 16, 19, 16, 0, -19 },
  { 1433, 23, 19, 23, 0, -19 },
  { 1488, 15, 19, 15, 0, -19 },
  { 1524, 15, 19, 15, 0, -19 },
  { 1560, 12, 19, 13, 1, -19 },
  { 1589, 7, 23, 8, 1, -19 },
  { 1610, 11, 19, 11, 0, -19 },
  { 1637, 7, 23, 8, 0, -19 },
  { 1658, 14, 13, 14, 0, -19 },
  { 1681, 13, 3, 13, 0, 2 },
  { 1686, 7, 4, 9, 1, -20 },
  { 1690, 11, 15, 14, 1, -15 },
  { 1711, 13, 20, 15, 1, -20 },
  { 1744, 10, 15, 12, 1, -15 },
  { 1763, 12, 20, 15, 1, -20 },
  { 1793, 12, 15, 14, 1, -15 },
  { 1816, 10, 20, 9, 0, -20 },
  { 1841, 12, 21, 15, 1, -15 },
  { 1873, 12, 20, 15, 1, -20 },
  { 1903, 5, 20, 7, 1, -20 },
  { 1916, 7, 26, 7, -1, -20 },
  { 1939, 14, 20, 15, 1, -20 },
  { 1974, 5, 20, 7, 1, -20 },
  { 1987, 20, 15, 22, 1, -15 },
  { 2025, 12, 15, 15, 1, -15 },
  { 2048, 12, 15, 14, 1, -15 },
  { 2071, 13, 21, 15, 1, -15 },
  { 2106, 12, 21, 15, 1, -15 },
  { 2138, 9, 15, 10, 1, -15 },
  { 2155, 9, 15, 11, 1, -15 },
  { 2172, 9, 17, 10, 0, -17 },
  { 2192, 12, 14, 15, 1, -14 },
  { 2213, 14, 14, 14, 0, -14 },
  { 2238, 20, 14, 20, 0, -14 },
  { 2273, 13, 14, 14, 0, -14 },
  { 2296, 14, 20, 14, 0, -14 },
  { 2331, 11, 14, 11, 0, -14 },
  { 2351, 9, 23, 10, 0, -19 },
  { 2377, 4, 26, 12, 4, -20 },
  { 2390, 9, 23, 10, 1, -19 },
  { 2416, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Black26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_BLACK26PT7B_H_
