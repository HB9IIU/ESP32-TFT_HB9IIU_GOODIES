#ifndef _NOTOSANS_CONDENSED_BLACK7PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black7pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0xF4, 0x5F, 0x6F, 0x60, 0x79, 0xDE, 0xDA, 0xCD, 0xCB,
  0x6C, 0x63, 0x1F, 0x6F, 0x80, 0xE0, 0x7A, 0xD0, 0xD5, 0x60, 0xEB, 0x80,
  0x5D, 0x00, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x7E, 0xF6, 0x7C, 0x92, 0xF4,
  0xAE, 0xE5, 0x9E, 0x26, 0xAF, 0x20, 0x7B, 0x9E, 0x7B, 0xD6, 0xE4, 0xA4,
  0x7D, 0xDE, 0x77, 0x9E, 0xC3, 0xC3, 0x80, 0x38, 0x80, 0xE3, 0x80, 0xC7,
  0x00, 0xE5, 0x04, 0x7D, 0xF7, 0x74, 0x98, 0x66, 0x7F, 0x90, 0xFF, 0xED,
  0xE0, 0x7C, 0xCC, 0x60, 0xED, 0xDD, 0xE0, 0xFB, 0xEE, 0xFB, 0xEC, 0x7C,
  0xFD, 0x70, 0xDD, 0xFD, 0xD0, 0xD5, 0xC0, 0xFF, 0xF8, 0xDE, 0xEE, 0xD0,
  0xDB, 0x6E, 0xCF, 0xFF, 0xFF, 0xFC, 0xDF, 0xFF, 0xFD, 0x80, 0x7D, 0xDD,
  0x70, 0xEF, 0xEC, 0xC0, 0x7D, 0xDD, 0x71, 0xEF, 0xEE, 0xD0, 0x79, 0x9E,
  0xE9, 0x24, 0xDD, 0xDD, 0x70, 0x9D, 0x76, 0x60, 0xB7, 0xD7, 0xDE, 0x68,
  0xF6, 0x66, 0xF0, 0xB6, 0x66, 0x60, 0xE5, 0x2E, 0xEA, 0xB0, 0x89, 0x22,
  0xD5, 0x70, 0x46, 0xB0, 0xF0, 0xC0, 0x67, 0xF0, 0xCE, 0xFF, 0xE0, 0x7A,
  0x30, 0x37, 0xFB, 0x70, 0x77, 0x30, 0x79, 0x24, 0x7F, 0xB7, 0xA6, 0xCE,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xF8, 0xCF, 0xEE, 0xF0, 0xFF, 0xC0, 0xAB,
  0xFF, 0xFF, 0xAF, 0xFF, 0x6F, 0xB6, 0xAF, 0xFE, 0xCC, 0x7F, 0xB7, 0x33,
  0xBB, 0x60, 0xF9, 0xF0, 0x5F, 0x66, 0xFF, 0xF7, 0xBE, 0x66, 0xBD, 0xDE,
  0xB0, 0xF6, 0x6F, 0xBE, 0x66, 0x4C, 0xE9, 0x70, 0x69, 0x64, 0xC0, 0xFE,
  0xC9, 0x35, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_Black7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 4, 0, -5 },
  { 9, 6, 5, 6, 0, -5 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 2, 2, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 2, 6, 2, 0, -5 },
  { 22, 3, 3, 3, 0, -5 },
  { 24, 3, 3, 4, 0, -4 },
  { 26, 2, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 2, 1, 2, 0, -1 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 4, 0, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 0, -5 },
  { 44, 3, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 0, -5 },
  { 48, 3, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 0, -5 },
  { 52, 2, 4, 2, 0, -4 },
  { 53, 2, 5, 2, 0, -4 },
  { 55, 3, 3, 4, 0, -4 },
  { 57, 3, 3, 4, 0, -4 },
  { 59, 3, 3, 4, 0, -4 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 5, 6, 6, 0, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 3, 0, -5 },
  { 81, 3, 5, 3, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 5, 0, -5 },
  { 89, 2, 5, 3, 0, -5 },
  { 91, 2, 7, 2, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 6, 5, 6, 0, -5 },
  { 102, 5, 5, 5, 0, -5 },
  { 106, 4, 5, 5, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 6, 5, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 3, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 6, 5, 6, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 3, 5, 4, 0, -5 },
  { 140, 2, 6, 2, 0, -5 },
  { 142, 3, 5, 3, 0, -5 },
  { 144, 2, 6, 2, 0, -5 },
  { 146, 4, 3, 4, 0, -5 },
  { 148, 4, 1, 4, 0, 0 },
  { 149, 2, 1, 3, 0, -5 },
  { 150, 3, 4, 4, 0, -4 },
  { 152, 4, 5, 4, 0, -5 },
  { 155, 3, 4, 3, 0, -4 },
  { 157, 4, 5, 4, 0, -5 },
  { 160, 3, 4, 4, 0, -4 },
  { 162, 3, 5, 2, 0, -5 },
  { 164, 4, 6, 4, 0, -4 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 2, 5, 2, 0, -5 },
  { 172, 2, 7, 2, 0, -5 },
  { 174, 4, 5, 4, 0, -5 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 6, 4, 6, 0, -4 },
  { 182, 4, 4, 4, 0, -4 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 4, 6, 4, 0, -4 },
  { 189, 4, 6, 4, 0, -4 },
  { 192, 3, 4, 3, 0, -4 },
  { 194, 3, 4, 3, 0, -4 },
  { 196, 3, 5, 3, 0, -5 },
  { 198, 4, 4, 4, 0, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 5, 4, 6, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 6, 4, 0, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 3, 6, 3, 0, -5 },
  { 215, 1, 7, 3, 1, -5 },
  { 216, 3, 6, 3, 0, -5 },
  { 219, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_Black7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_BLACK7PT7B_H_
