#ifndef _NOTOSANS_CONDENSED_BLACK6PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black6pt7bBitmaps[] PROGMEM = {
  0x00, 0xD0, 0xA0, 0x7F, 0xD0, 0x5F, 0x3E, 0xD7, 0x4E, 0xB0, 0x66, 0xBF,
  0x80, 0x6A, 0x40, 0x95, 0x80, 0x5F, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x69, 0x40, 0xF6, 0xB0, 0x7D, 0xB0, 0xE5, 0x70, 0xE8, 0xF0, 0x6F, 0x90,
  0xF8, 0xF0, 0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0,
  0x39, 0x80, 0xFC, 0x8F, 0x00, 0xE8, 0x20, 0x77, 0xF7, 0xE0, 0x66, 0xEB,
  0xFE, 0xF0, 0x72, 0x30, 0xEB, 0xAE, 0xFE, 0x70, 0xFE, 0x40, 0x76, 0xB0,
  0xBF, 0xBB, 0xD7, 0xF8, 0xBE, 0xEB, 0x92, 0x70, 0xDE, 0xEB, 0x50, 0xDD,
  0xBB, 0x79, 0x96, 0xF7, 0x40, 0x79, 0x96, 0x30, 0xEA, 0xEB, 0xF8, 0xF0,
  0xE9, 0x20, 0xB6, 0xB0, 0xBE, 0x66, 0xAD, 0x56, 0xA0, 0xE9, 0xD0, 0xAD,
  0x20, 0xE9, 0x70, 0xEA, 0xC0, 0x89, 0x30, 0xD5, 0xC0, 0x56, 0x80, 0xE0,
  0xC0, 0xFF, 0x80, 0x93, 0xDE, 0xF3, 0x80, 0x27, 0xDE, 0xFF, 0x80, 0x6E,
  0x80, 0xF7, 0xF0, 0x93, 0xDA, 0xB8, 0xBC, 0x92, 0xFA, 0xF8, 0xFD, 0x6A,
  0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0x79, 0xB7,
  0x80, 0xAD, 0x00, 0xAF, 0x94, 0xEA, 0x80, 0xAD, 0x60, 0xDC, 0x59, 0x40,
  0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_Black6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 3, 1, 3, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 2, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 1, 3, 2, 0, -3 },
  { 47, 1, 4, 2, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 5, 4, 5, 0, -4 },
  { 58, 4, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 2, 4, 2, 0, -4 },
  { 75, 1, 5, 2, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 5, 4, 5, 0, -4 },
  { 83, 4, 4, 4, 0, -4 },
  { 85, 4, 4, 4, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 4, 5, 4, 0, -4 },
  { 92, 4, 4, 4, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 3, 4, 3, 0, -4 },
  { 98, 3, 4, 4, 0, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 5, 4, 5, 0, -4 },
  { 105, 3, 4, 3, 0, -4 },
  { 107, 3, 4, 3, 0, -4 },
  { 109, 3, 4, 3, 0, -4 },
  { 111, 2, 5, 2, 0, -4 },
  { 113, 3, 4, 3, 0, -4 },
  { 115, 2, 5, 2, 0, -4 },
  { 117, 3, 3, 3, 0, -4 },
  { 119, 3, 1, 3, 0, 0 },
  { 120, 2, 1, 2, 0, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 3, 3, 3, 0, -3 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 2, 5, 2, 0, -5 },
  { 133, 3, 4, 3, 0, -3 },
  { 135, 3, 5, 3, 0, -5 },
  { 137, 1, 5, 2, 0, -5 },
  { 138, 1, 6, 2, 0, -5 },
  { 139, 3, 5, 3, 0, -5 },
  { 141, 1, 5, 2, 0, -5 },
  { 142, 5, 3, 5, 0, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 3, 4, 3, 0, -3 },
  { 150, 3, 4, 3, 0, -3 },
  { 152, 2, 3, 2, 0, -3 },
  { 153, 2, 3, 3, 0, -3 },
  { 154, 2, 4, 2, 0, -4 },
  { 155, 3, 3, 3, 0, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 5, 3, 5, 0, -3 },
  { 161, 3, 3, 3, 0, -3 },
  { 163, 3, 4, 3, 0, -3 },
  { 165, 2, 3, 3, 0, -3 },
  { 166, 2, 5, 2, 0, -4 },
  { 168, 1, 6, 3, 1, -5 },
  { 169, 2, 5, 2, 0, -4 },
  { 171, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Black6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_BLACK6PT7B_H_
