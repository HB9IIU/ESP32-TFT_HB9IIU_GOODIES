#ifndef _NOTOSANS_CONDENSED_BLACK10PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black10pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x1C, 0xDA, 0x80, 0x28, 0xAF, 0xDC, 0xF9, 0x45, 0x00, 0x23,
  0xFD, 0xC7, 0x1F, 0xEE, 0x20, 0x66, 0xF4, 0xF8, 0x6F, 0x15, 0x17, 0x33,
  0x78, 0xB1, 0xE3, 0xBD, 0xDB, 0x9F, 0x80, 0xD0, 0x69, 0x6C, 0x93, 0x20,
  0xCD, 0xB6, 0xDA, 0xC0, 0x25, 0x7E, 0xE5, 0x00, 0x21, 0x3E, 0x42, 0x00,
  0x70, 0xE0, 0x70, 0x13, 0x26, 0x64, 0xC0, 0x72, 0xF7, 0xBD, 0xAD, 0xC0,
  0x37, 0xF3, 0x33, 0x30, 0xF2, 0xC6, 0x66, 0x3F, 0xE0, 0xF2, 0xCC, 0xE1,
  0xCF, 0xC0, 0x31, 0x9C, 0xAF, 0xFC, 0x40, 0x72, 0x1C, 0xF1, 0xCF, 0xC0,
  0x7B, 0x3D, 0xFD, 0xAD, 0xC0, 0xF8, 0xC4, 0x63, 0x31, 0x80, 0x76, 0xDC,
  0xED, 0xED, 0xC0, 0x76, 0xF7, 0xF7, 0x99, 0xC0, 0x70, 0x70, 0x70, 0x1C,
  0x1B, 0xB0, 0x70, 0x80, 0xF8, 0x3E, 0xC3, 0x87, 0xC8, 0x00, 0xFB, 0x36,
  0x06, 0x60, 0x3C, 0x42, 0x5F, 0xE5, 0xFF, 0x5E, 0x64, 0x1C, 0x31, 0xE7,
  0x9A, 0x7F, 0xFC, 0xC0, 0xFB, 0xBF, 0x9B, 0xF0, 0x7B, 0x51, 0x84, 0x35,
  0xE0, 0xF5, 0xE7, 0x39, 0xFB, 0x80, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20,
  0x3D, 0x94, 0x37, 0x4D, 0xB3, 0xC0, 0x9C, 0xE7, 0xF9, 0xCE, 0x60, 0xF6,
  0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0xE0, 0x9D, 0xA9, 0xCF, 0x5A, 0x60,
  0x88, 0x88, 0x88, 0xF0, 0xCF, 0x9F, 0xBD, 0x7B, 0xF6, 0xED, 0x80, 0xCF,
  0x7B, 0x5B, 0xCE, 0x60, 0x79, 0xBC, 0xF3, 0x4D, 0xB3, 0x80, 0xFB, 0xBF,
  0xE8, 0x80, 0x79, 0xBC, 0xF3, 0x4D, 0xB3, 0x83, 0x0C, 0xF5, 0xAD, 0xEB,
  0x5A, 0x60, 0x7E, 0xB8, 0xE1, 0xFF, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80,
  0x9C, 0xE7, 0x39, 0xEF, 0xC0, 0xCF, 0x34, 0x9E, 0x78, 0xC3, 0x00, 0xC9,
  0xEC, 0x97, 0x4A, 0xE7, 0x73, 0xB9, 0xD8, 0xDD, 0xE7, 0x0C, 0x71, 0xEC,
  0xC0, 0xCD, 0x67, 0x0C, 0x30, 0xC3, 0x00, 0xF8, 0xCC, 0x46, 0x63, 0xE0,
  0xFB, 0x6D, 0xB7, 0xE0, 0xC4, 0x66, 0x23, 0x10, 0xED, 0xB6, 0xDF, 0xE0,
  0x23, 0x94, 0xB8, 0x80, 0xF8, 0xC4, 0x33, 0xC7, 0xFD, 0xBC, 0x88, 0xAF,
  0xB9, 0xBF, 0x37, 0xCC, 0xD7, 0x18, 0xDE, 0xFD, 0xEF, 0x6F, 0x33, 0xF7,
  0xF4, 0xBC, 0x36, 0x6E, 0x44, 0x44, 0x2B, 0xF7, 0xBD, 0xBC, 0x6F, 0x88,
  0xAF, 0xBB, 0xBB, 0xFF, 0x75, 0x55, 0x70, 0x84, 0x27, 0x6E, 0x72, 0xD3,
  0xFF, 0xA5, 0xFE, 0xDD, 0xBB, 0x76, 0xC0, 0xAF, 0xBB, 0xBB, 0x33, 0xF7,
  0xB5, 0xB8, 0xAF, 0xB9, 0xFF, 0x88, 0x2B, 0xF7, 0xBD, 0xBC, 0x63, 0xBE,
  0x49, 0x00, 0x6F, 0xE7, 0xBF, 0x47, 0xF4, 0x47, 0x70, 0xBB, 0xBB, 0xBD,
  0xDE, 0xD6, 0xA7, 0x18, 0xDB, 0xDB, 0x5A, 0x7A, 0x6E, 0x66, 0xDA, 0xDC,
  0xE7, 0x6C, 0xDE, 0xD6, 0xE7, 0x18, 0x8C, 0xFF, 0x26, 0xCF, 0x76, 0x66,
  0xC6, 0x67, 0x30, 0xFF, 0xC0, 0xC6, 0x66, 0x76, 0x6E, 0xC0, 0xF8,
};

const GFXglyph NotoSans_Condensed_Black10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 3, 0, -7 },
  { 3, 5, 2, 5, 0, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 8, 7, 9, 0, -7 },
  { 24, 7, 7, 7, 0, -7 },
  { 31, 2, 2, 3, 0, -7 },
  { 32, 3, 9, 3, 0, -7 },
  { 36, 3, 9, 3, 0, -7 },
  { 40, 5, 5, 5, 0, -8 },
  { 44, 5, 5, 5, 0, -6 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 4, 7, 5, 0, -7 },
  { 64, 5, 7, 5, 0, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 5, 7, 5, 0, -7 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 5, 7, 5, 0, -7 },
  { 99, 5, 7, 5, 0, -7 },
  { 104, 2, 6, 3, 0, -6 },
  { 106, 2, 7, 3, 0, -6 },
  { 108, 5, 5, 5, 0, -6 },
  { 112, 5, 3, 5, 0, -5 },
  { 114, 5, 5, 5, 0, -6 },
  { 118, 4, 7, 4, 0, -7 },
  { 122, 8, 8, 8, 0, -7 },
  { 130, 6, 7, 6, 0, -7 },
  { 136, 4, 7, 6, 1, -7 },
  { 140, 5, 7, 6, 0, -7 },
  { 145, 5, 7, 6, 1, -7 },
  { 150, 3, 7, 5, 1, -7 },
  { 153, 3, 7, 5, 1, -7 },
  { 156, 6, 7, 6, 0, -7 },
  { 162, 5, 7, 7, 1, -7 },
  { 167, 4, 7, 4, 0, -7 },
  { 171, 3, 9, 3, -1, -7 },
  { 175, 5, 7, 6, 1, -7 },
  { 180, 4, 7, 5, 1, -7 },
  { 184, 7, 7, 9, 1, -7 },
  { 191, 5, 7, 7, 1, -7 },
  { 196, 6, 7, 7, 0, -7 },
  { 202, 4, 7, 6, 1, -7 },
  { 206, 6, 9, 7, 0, -7 },
  { 213, 5, 7, 6, 1, -7 },
  { 218, 5, 7, 5, 0, -7 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 5, 7, 6, 1, -7 },
  { 233, 6, 7, 6, 0, -7 },
  { 239, 9, 7, 9, 0, -7 },
  { 247, 6, 7, 6, 0, -7 },
  { 253, 6, 7, 6, 0, -7 },
  { 259, 5, 7, 5, 0, -7 },
  { 264, 3, 9, 3, 0, -7 },
  { 268, 4, 7, 4, 0, -7 },
  { 272, 3, 9, 3, 0, -7 },
  { 276, 5, 5, 5, 0, -7 },
  { 280, 5, 1, 5, 0, 1 },
  { 281, 3, 2, 4, 0, -8 },
  { 282, 5, 6, 5, 0, -6 },
  { 286, 4, 8, 6, 1, -8 },
  { 290, 4, 6, 5, 0, -6 },
  { 293, 5, 8, 6, 0, -8 },
  { 298, 5, 6, 5, 0, -6 },
  { 302, 4, 8, 4, 0, -8 },
  { 306, 5, 8, 6, 0, -6 },
  { 311, 4, 8, 6, 1, -8 },
  { 315, 1, 8, 3, 1, -8 },
  { 316, 2, 10, 3, 0, -8 },
  { 319, 5, 8, 6, 1, -8 },
  { 324, 1, 8, 3, 1, -8 },
  { 325, 7, 6, 9, 1, -6 },
  { 331, 4, 6, 6, 1, -6 },
  { 334, 5, 6, 6, 0, -6 },
  { 338, 4, 8, 6, 1, -6 },
  { 342, 5, 8, 6, 0, -6 },
  { 347, 3, 6, 4, 1, -6 },
  { 350, 4, 6, 4, 0, -6 },
  { 353, 4, 7, 4, 0, -7 },
  { 357, 4, 6, 6, 1, -6 },
  { 360, 5, 6, 5, 0, -6 },
  { 364, 8, 6, 8, 0, -6 },
  { 370, 5, 6, 5, 0, -6 },
  { 374, 5, 8, 5, 0, -6 },
  { 379, 4, 6, 4, 0, -6 },
  { 382, 4, 9, 4, 0, -7 },
  { 387, 1, 10, 4, 2, -8 },
  { 389, 4, 9, 4, 0, -7 },
  { 394, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Black10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_BLACK10PT7B_H_
