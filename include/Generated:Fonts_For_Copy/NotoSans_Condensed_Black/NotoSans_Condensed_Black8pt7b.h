#ifndef _NOTOSANS_CONDENSED_BLACK8PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x30, 0xFF, 0x72, 0xBE, 0xAE, 0x30, 0x2F, 0xC3, 0xB6, 0x49,
  0x52, 0xD2, 0xD2, 0xA5, 0xC0, 0x61, 0x47, 0x3A, 0xD9, 0xF0, 0xF0, 0x6B,
  0x6C, 0x98, 0xD5, 0x5C, 0x6F, 0xF6, 0x22, 0xF2, 0xF0, 0xC0, 0xC0, 0x25,
  0xA5, 0x00, 0x6F, 0xFF, 0xF6, 0x2F, 0x92, 0x40, 0x6B, 0x36, 0x4F, 0x6B,
  0x27, 0x3E, 0x26, 0x6A, 0xF2, 0x77, 0x6B, 0x3E, 0x34, 0xEF, 0xD6, 0xFF,
  0x22, 0x64, 0x6F, 0x67, 0xD7, 0x6F, 0xF7, 0x36, 0xC3, 0xC3, 0xC0, 0x16,
  0xE3, 0xF0, 0xF0, 0x86, 0x3C, 0xF4, 0xA0, 0x80, 0x39, 0x1B, 0xEB, 0xBD,
  0x23, 0x00, 0x62, 0x94, 0xAF, 0xEC, 0xF7, 0xFB, 0xC0, 0x35, 0xCC, 0x47,
  0xCE, 0xBB, 0xAE, 0xEF, 0xB0, 0xEB, 0xA0, 0x3B, 0xB1, 0xB5, 0xBC, 0xBB,
  0xFF, 0xBB, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x5E, 0xBA, 0xEE, 0xAB, 0x92,
  0x49, 0xC0, 0x9E, 0xF7, 0xBE, 0xD4, 0x9D, 0xDF, 0xBB, 0x72, 0xF3, 0x95,
  0xB8, 0xDE, 0xF9, 0x00, 0x72, 0xF3, 0x95, 0xB8, 0x60, 0xCE, 0xAC, 0xEB,
  0x6D, 0xC7, 0xBE, 0xF6, 0x66, 0x66, 0xDE, 0xF7, 0xB5, 0xB8, 0xDE, 0x94,
  0xA7, 0x30, 0x93, 0xAF, 0xBB, 0x66, 0xCD, 0x80, 0xD3, 0x98, 0xC7, 0x6C,
  0xDA, 0x9C, 0xC2, 0x10, 0xF3, 0x26, 0x4F, 0xFF, 0xFC, 0x89, 0x22, 0x40,
  0xD5, 0x5C, 0x26, 0x79, 0xF0, 0xE0, 0x27, 0x7F, 0xF0, 0xCE, 0xFD, 0xDF,
  0x36, 0xCC, 0x60, 0x15, 0xFD, 0xD7, 0x27, 0xFC, 0x70, 0x6B, 0xA4, 0x80,
  0x4F, 0xDD, 0x79, 0xE0, 0xCE, 0xFD, 0xDD, 0xCF, 0xF0, 0xCF, 0xFE, 0xC6,
  0x3D, 0xCF, 0x6C, 0xFF, 0xF0, 0x27, 0xFD, 0x75, 0xD4, 0x2F, 0xDD, 0xD0,
  0x27, 0xDD, 0x70, 0x2F, 0xDD, 0xFC, 0xC0, 0x4F, 0xDD, 0x71, 0x10, 0x3F,
  0x6C, 0x5F, 0x9E, 0x5D, 0x26, 0xDD, 0xD7, 0xD7, 0x66, 0xF7, 0xD7, 0xDA,
  0xF6, 0x6F, 0xD7, 0x66, 0x6C, 0xED, 0x70, 0x69, 0x64, 0x98, 0xFF, 0xC9,
  0x34, 0xB0, 0x5F,
};

const GFXglyph NotoSans_Condensed_Black8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 7, 6, 7, 0, -6 },
  { 17, 6, 6, 6, 0, -6 },
  { 22, 2, 2, 2, 0, -6 },
  { 23, 3, 7, 3, 0, -6 },
  { 26, 2, 7, 3, 0, -6 },
  { 28, 4, 4, 4, 0, -6 },
  { 30, 4, 4, 4, 0, -5 },
  { 32, 2, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 2, 1, 2, 0, -1 },
  { 35, 3, 6, 3, 0, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 3, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 4, 6, 4, 0, -6 },
  { 68, 2, 4, 2, 0, -4 },
  { 69, 2, 5, 2, 0, -4 },
  { 71, 4, 4, 4, 0, -5 },
  { 73, 4, 3, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -5 },
  { 77, 3, 6, 3, 0, -6 },
  { 80, 6, 7, 6, 0, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 2, 6, 4, 1, -6 },
  { 101, 2, 6, 4, 1, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 3, 6, 3, 0, -6 },
  { 113, 3, 8, 2, -1, -6 },
  { 116, 4, 6, 5, 1, -6 },
  { 119, 3, 6, 4, 1, -6 },
  { 122, 5, 6, 7, 1, -6 },
  { 126, 4, 6, 6, 1, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 3, 6, 4, 1, -6 },
  { 136, 5, 7, 5, 0, -6 },
  { 141, 4, 6, 5, 1, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 7, 6, 7, 0, -6 },
  { 164, 5, 6, 5, 0, -6 },
  { 168, 5, 6, 5, 0, -6 },
  { 172, 4, 6, 4, 0, -6 },
  { 175, 2, 7, 2, 0, -6 },
  { 177, 3, 6, 3, 0, -6 },
  { 180, 2, 7, 2, 0, -6 },
  { 182, 4, 4, 4, 0, -6 },
  { 184, 4, 1, 4, 0, 0 },
  { 185, 3, 1, 3, 0, -6 },
  { 186, 4, 5, 4, 0, -5 },
  { 189, 4, 6, 4, 0, -6 },
  { 192, 4, 5, 4, 0, -5 },
  { 195, 4, 6, 4, 0, -6 },
  { 198, 4, 5, 4, 0, -5 },
  { 201, 3, 6, 3, 0, -6 },
  { 204, 4, 7, 4, 0, -5 },
  { 208, 4, 6, 5, 0, -6 },
  { 211, 2, 6, 2, 0, -6 },
  { 213, 2, 8, 2, 0, -6 },
  { 215, 5, 6, 5, 0, -6 },
  { 219, 2, 6, 2, 0, -6 },
  { 221, 6, 5, 7, 0, -5 },
  { 225, 4, 5, 5, 0, -5 },
  { 228, 4, 5, 4, 0, -5 },
  { 231, 4, 7, 4, 0, -5 },
  { 235, 4, 7, 4, 0, -5 },
  { 239, 3, 5, 3, 0, -5 },
  { 241, 3, 5, 3, 0, -5 },
  { 243, 3, 5, 3, 0, -5 },
  { 245, 4, 4, 5, 0, -4 },
  { 247, 4, 4, 4, 0, -4 },
  { 249, 6, 4, 6, 0, -4 },
  { 252, 4, 4, 4, 0, -4 },
  { 254, 4, 6, 4, 0, -4 },
  { 257, 3, 4, 3, 0, -4 },
  { 259, 3, 7, 3, 0, -6 },
  { 262, 1, 8, 4, 1, -6 },
  { 263, 3, 7, 3, 0, -6 },
  { 266, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_Black8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_BLACK8PT7B_H_
