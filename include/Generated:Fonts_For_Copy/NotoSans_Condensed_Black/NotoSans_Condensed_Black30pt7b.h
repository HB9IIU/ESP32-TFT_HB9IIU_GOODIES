#ifndef _NOTOSANS_CONDENSED_BLACK30PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x78, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xFD, 0xFF, 0xCF, 0x9E, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0x79, 0xE3, 0xC0, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x38, 0x0F, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x78, 0x1E, 0x70, 0x1E, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3C,
  0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x39, 0xE0, 0x39, 0xE0, 0x79, 0xE0, 0x03,
  0x00, 0x18, 0x03, 0xF0, 0x7F, 0xF7, 0xFF, 0xBF, 0xFB, 0xEC, 0xDE, 0x60,
  0xFB, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x6F, 0x83, 0x7F, 0x1B, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xE0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x7F, 0x01, 0xC0, 0x7F, 0x83,
  0xC0, 0xFF, 0x83, 0x80, 0xF7, 0x87, 0x80, 0xF3, 0xC7, 0x80, 0xF3, 0xCF,
  0x00, 0xF3, 0xCF, 0x00, 0xF3, 0xDE, 0x00, 0xF7, 0x9E, 0x7C, 0xFF, 0xBC,
  0xFE, 0x7F, 0xBD, 0xFF, 0x7F, 0x39, 0xEF, 0x0C, 0x79, 0xEF, 0x00, 0x71,
  0xCF, 0x00, 0xF1, 0xC7, 0x00, 0xF1, 0xCF, 0x01, 0xE1, 0xEF, 0x01, 0xE1,
  0xEF, 0x03, 0xC1, 0xFF, 0x03, 0xC0, 0xFE, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xC7,
  0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE7, 0xE3, 0xFE, 0x7E, 0x7F, 0xF7, 0xCF, 0xFF, 0xFC, 0xF9, 0xFF, 0xCF,
  0x8F, 0xF8, 0xF8, 0x7F, 0x8F, 0xC7, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x0F,
  0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x3E,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x10, 0xE1, 0x7B, 0xBD, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0x83, 0xEF, 0x0F, 0xBE, 0x1C, 0x70,
  0x11, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x7D, 0xF7, 0xDE, 0x7B, 0xEF, 0xBC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0x07, 0x00, 0x7F, 0x83, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF9, 0xF3, 0xEF, 0xCF, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xBE, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x7F, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xF7, 0xBF, 0x33, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x07, 0x01, 0xFF, 0x1F, 0xFD, 0xFF,
  0xEF, 0xFF, 0xB8, 0xFC, 0x83, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF7, 0xFF, 0x90, 0xFC, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0xFF, 0x07, 0xE0,
  0x3F, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1E, 0xF8, 0x7D,
  0xF0, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xF8, 0x7F,
  0xE3, 0xFF, 0x9F, 0xFE, 0x47, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xE1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF9, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFB,
  0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFC, 0xFF, 0xE3, 0xFF, 0x87, 0xFE,
  0x1F, 0xFC, 0xFD, 0xF3, 0xE7, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x7D, 0xFB, 0xE3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7F, 0xF0, 0xFF, 0xC1, 0xFC, 0x0F, 0xF8, 0x7F, 0xF1,
  0xF7, 0xEF, 0x8F, 0xBE, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF0, 0x7F, 0x80, 0x07, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFC, 0xFF,
  0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFC, 0xFD, 0xE1, 0xE7, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0xC7,
  0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x39, 0xFF, 0xFF, 0x7C, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xDF, 0x78, 0x39, 0xFF, 0xFF, 0x7C,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDF, 0x7B, 0xEF, 0xBE, 0xF0,
  0x00, 0x04, 0x00, 0x30, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xC7, 0xFC,
  0x3F, 0x80, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFC, 0x01,
  0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x01, 0xFC, 0x1F, 0xF1, 0xFF, 0x3F, 0xF0, 0xFE, 0x03, 0xE0,
  0x0E, 0x00, 0x20, 0x00, 0x0F, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xE7, 0xFF,
  0x30, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xF1, 0xFC, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xE7, 0x87, 0xF3, 0x9E,
  0x7F, 0xCF, 0x71, 0xFF, 0x3F, 0xCF, 0x1C, 0xFF, 0x3C, 0x71, 0xFC, 0xE1,
  0xC7, 0xF3, 0x8F, 0x3F, 0xCE, 0x3C, 0xFF, 0x3C, 0xF3, 0xFC, 0xF7, 0xFE,
  0xF3, 0xFF, 0xF9, 0xE7, 0xEF, 0xC7, 0x82, 0x0C, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1F, 0x78,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0xC1, 0xF9, 0xF0, 0x3F, 0x7E, 0x03, 0xEF, 0xC0, 0x7E,
  0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0x87,
  0xFE, 0x3F, 0xFF, 0xFB, 0xFF, 0x8F, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xC0, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xC1,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x04, 0xFE, 0x38, 0xFF,
  0xF1, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x7E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00,
  0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x02, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x7F, 0x1F, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0xCF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0x7F, 0xBF, 0x9F, 0x00,
  0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF9, 0xF8, 0xF9, 0xF8,
  0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFD, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C,
  0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xDF,
  0xFF, 0xCF, 0x7F, 0xFF, 0x3D, 0xFF, 0xBC, 0xF7, 0xFE, 0xF7, 0x9F, 0xFB,
  0xFE, 0x7F, 0xE7, 0xF9, 0xFF, 0x9F, 0xE7, 0xFE, 0x7F, 0x1F, 0xF9, 0xFC,
  0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7C,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFD, 0xF7, 0xFE, 0xF9, 0xFF,
  0x3E, 0xFF, 0x9F, 0x7F, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xF8, 0x01, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0x87, 0xE7, 0xE0,
  0xF9, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F,
  0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFB, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F,
  0x87, 0xE7, 0xE0, 0xF9, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F,
  0x7E, 0x1F, 0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFC, 0xF8,
  0xFC, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFB, 0xF0, 0xF9, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8,
  0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3F, 0x07, 0x80, 0xFF, 0x9F, 0xFE,
  0xFF, 0xEF, 0xFF, 0x7E, 0x1B, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0xDF,
  0xFF, 0xFD, 0xFF, 0xEF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFE, 0xFE, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x0F,
  0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x1F,
  0x07, 0xDF, 0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0xFD, 0xF0, 0xFC, 0x3E, 0x7C,
  0x3F, 0x0F, 0x9F, 0x0F, 0xE3, 0xE3, 0xE7, 0xF8, 0xF8, 0xF9, 0xFE, 0x7E,
  0x3E, 0x7F, 0x9F, 0x0F, 0x9F, 0xE7, 0xC3, 0xE7, 0xBD, 0xF0, 0x7B, 0xEF,
  0x7C, 0x1F, 0xF3, 0xDF, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0xBF, 0x1F, 0x8F,
  0x8F, 0x87, 0xEF, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xF0, 0x3E, 0xF8, 0x3F, 0x3E, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF,
  0x83, 0xFF, 0xC1, 0xF8, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x8F, 0xC7, 0xC7,
  0xC3, 0xE3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xE0, 0x78, 0x0F,
  0xC3, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0x0F, 0x80, 0x7C, 0x0F, 0xE7, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xEF, 0x3E, 0x38, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x9C, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xEF, 0xDF, 0xBE, 0x3E,
  0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F,
  0xBF, 0xFE, 0xFF, 0xFB, 0xDF, 0xCF, 0x3E, 0x00, 0x07, 0xC1, 0xFF, 0x3F,
  0xF7, 0xFE, 0x7E, 0xEF, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0xFC, 0x37, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xE7, 0xCF, 0xDF,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF,
  0xF1, 0xF3, 0xC0, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7C, 0xFB,
  0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00,
  0x7C, 0x09, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x07, 0xC3, 0xFC,
  0x7F, 0x8F, 0xE3, 0xF0, 0x7C, 0x0F, 0xF3, 0xFE, 0xFF, 0xDF, 0xF8, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x0E, 0x3C, 0xFD, 0xF7, 0xFF, 0xDF, 0xFF,
  0x7F, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFF, 0x1F, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0x01,
  0xF0, 0x07, 0xD8, 0x3F, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x0F, 0xF0, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x9E, 0x3F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x8F, 0xC0, 0xF7, 0xFF, 0xF7, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x1F, 0x3F, 0x1F, 0x0E,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFF, 0xFE, 0xFE,
  0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x1F, 0xFC, 0x7E, 0xF8, 0xF9, 0xF3, 0xF3, 0xE7, 0xC7, 0xDF, 0x0F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFB, 0xE3, 0xE7,
  0xE7, 0xC7, 0xCF, 0x8F, 0xDF, 0x0F, 0xBE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF1, 0xE1, 0xE3, 0xDF, 0xCF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8,
  0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F,
  0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7C, 0xF1,
  0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFC, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFF, 0x1F, 0x7C, 0x7D, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xF1,
  0xC3, 0xDF, 0xCF, 0xFF, 0x3F, 0xFE, 0xFD, 0xFB, 0xE3, 0xEF, 0x8F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFC, 0xFB, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x0E, 0x3C, 0xFD, 0xF7, 0xFF, 0xDF, 0xFF,
  0x7E, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFF, 0x1F, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF1,
  0xFC, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xEF, 0x8D, 0xF0, 0x3F, 0x87, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF9, 0x3F, 0xE3, 0xFC, 0x7F, 0x87,
  0xF0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xEF, 0x3E, 0x78, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0xF8, 0x7E, 0x3F, 0xF8, 0xFC, 0x7D, 0xF1, 0xF8, 0xFB,
  0xE7, 0xF1, 0xF7, 0xCF, 0xF3, 0xEF, 0x9F, 0xEF, 0x8F, 0x3F, 0xDF, 0x1F,
  0x77, 0xBE, 0x3F, 0xEF, 0x7C, 0x7F, 0xDE, 0xF0, 0xFF, 0x9D, 0xE0, 0xFF,
  0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0xF8, 0xFD, 0xF9, 0xF1, 0xF7, 0xE3,
  0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0x9F, 0x9F, 0x3E, 0x3F, 0xFC, 0x3E,
  0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xE1, 0xF8, 0xFE, 0x3E, 0x0F, 0xC3, 0xF8, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFE, 0x1F, 0xC1, 0xF1, 0xFC, 0x7F, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0x00, 0x7E,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF8,
};

const GFXglyph NotoSans_Condensed_Black30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 13, 7, 15, 1, -21 },
  { 29, 16, 21, 17, 1, -21 },
  { 71, 13, 25, 16, 1, -23 },
  { 112, 24, 22, 26, 1, -22 },
  { 178, 20, 22, 21, 1, -22 },
  { 233, 6, 7, 8, 1, -21 },
  { 239, 9, 27, 10, 1, -22 },
  { 270, 9, 27, 10, 0, -22 },
  { 301, 14, 14, 15, 0, -23 },
  { 326, 14, 15, 16, 1, -18 },
  { 353, 6, 8, 9, 1, -4 },
  { 359, 8, 4, 10, 1, -10 },
  { 363, 6, 5, 8, 1, -5 },
  { 367, 13, 22, 13, 0, -22 },
  { 403, 14, 22, 16, 1, -22 },
  { 442, 12, 21, 16, 1, -21 },
  { 474, 13, 22, 16, 1, -22 },
  { 510, 13, 22, 16, 1, -22 },
  { 546, 15, 21, 16, 0, -21 },
  { 586, 13, 21, 16, 1, -21 },
  { 621, 14, 22, 16, 1, -22 },
  { 660, 14, 21, 16, 1, -21 },
  { 697, 14, 22, 16, 1, -22 },
  { 736, 14, 22, 16, 1, -22 },
  { 775, 6, 17, 8, 1, -17 },
  { 788, 6, 21, 9, 1, -17 },
  { 804, 14, 16, 16, 1, -19 },
  { 832, 14, 11, 16, 1, -16 },
  { 852, 14, 16, 16, 1, -19 },
  { 880, 13, 22, 13, 0, -22 },
  { 916, 22, 24, 24, 1, -22 },
  { 982, 19, 21, 19, 0, -21 },
  { 1032, 14, 21, 18, 2, -21 },
  { 1069, 15, 22, 17, 1, -22 },
  { 1111, 16, 21, 19, 2, -21 },
  { 1153, 11, 21, 14, 2, -21 },
  { 1182, 11, 21, 14, 2, -21 },
  { 1211, 16, 22, 19, 1, -22 },
  { 1255, 16, 21, 20, 2, -21 },
  { 1297, 10, 21, 11, 1, -21 },
  { 1324, 9, 28, 9, -2, -21 },
  { 1356, 16, 21, 18, 2, -21 },
  { 1398, 12, 21, 14, 2, -21 },
  { 1430, 22, 21, 26, 2, -21 },
  { 1488, 17, 21, 21, 2, -21 },
  { 1533, 18, 22, 20, 1, -22 },
  { 1583, 14, 21, 17, 2, -21 },
  { 1620, 18, 27, 20, 1, -22 },
  { 1681, 16, 21, 18, 2, -21 },
  { 1723, 13, 22, 15, 1, -22 },
  { 1759, 13, 21, 15, 1, -21 },
  { 1794, 15, 21, 19, 2, -21 },
  { 1834, 18, 21, 18, 0, -21 },
  { 1882, 26, 21, 26, 0, -21 },
  { 1951, 17, 21, 17, 0, -21 },
  { 1996, 17, 21, 17, 0, -21 },
  { 2041, 14, 21, 15, 1, -21 },
  { 2078, 8, 27, 9, 1, -22 },
  { 2105, 13, 22, 13, 0, -22 },
  { 2141, 7, 27, 9, 1, -22 },
  { 2165, 16, 14, 16, 0, -21 },
  { 2193, 15, 4, 15, 0, 2 },
  { 2201, 9, 5, 11, 1, -23 },
  { 2207, 13, 17, 16, 1, -17 },
  { 2235, 14, 23, 17, 2, -23 },
  { 2276, 12, 17, 14, 1, -17 },
  { 2302, 14, 23, 17, 1, -23 },
  { 2343, 14, 17, 16, 1, -17 },
  { 2373, 11, 23, 11, 0, -23 },
  { 2405, 14, 24, 17, 1, -17 },
  { 2447, 14, 23, 17, 2, -23 },
  { 2488, 5, 23, 8, 2, -23 },
  { 2503, 8, 30, 8, -1, -23 },
  { 2533, 15, 23, 17, 2, -23 },
  { 2577, 5, 23, 8, 2, -23 },
  { 2592, 22, 17, 26, 2, -17 },
  { 2639, 14, 17, 17, 2, -17 },
  { 2669, 14, 17, 17, 1, -17 },
  { 2699, 14, 24, 17, 2, -17 },
  { 2741, 14, 24, 17, 1, -17 },
  { 2783, 10, 17, 12, 2, -17 },
  { 2805, 11, 17, 13, 1, -17 },
  { 2829, 11, 20, 12, 0, -20 },
  { 2857, 13, 17, 17, 2, -17 },
  { 2885, 16, 17, 16, 0, -17 },
  { 2919, 23, 17, 24, 0, -17 },
  { 2968, 15, 17, 16, 0, -17 },
  { 3000, 16, 24, 16, 0, -17 },
  { 3048, 11, 17, 13, 1, -17 },
  { 3072, 10, 27, 12, 1, -22 },
  { 3106, 4, 30, 13, 5, -23 },
  { 3121, 10, 27, 12, 1, -22 },
  { 3155, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_Condensed_Black30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_BLACK30PT7B_H_
