#ifndef _NOTOSANS_CONDENSED_BLACK41PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFC, 0xFD, 0xC7, 0x3E, 0x70, 0x4F, 0x9C, 0x03, 0xF7,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xDF, 0xC0, 0x73, 0xF8,
  0x1C, 0xFF, 0x87, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xFE, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x7F, 0xF8, 0x1F, 0x00, 0x3F, 0x7E,
  0x07, 0xC0, 0x0F, 0xCF, 0x83, 0xE0, 0x03, 0xE3, 0xE0, 0xF8, 0x00, 0xF8,
  0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x8F, 0xC0, 0x03,
  0xE3, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0xF8, 0xFC, 0x3F, 0x3E, 0x7C, 0x7F,
  0x87, 0xFF, 0x9F, 0x3F, 0xF1, 0xFF, 0xCF, 0x9F, 0xFE, 0x3F, 0xF3, 0xE7,
  0xFF, 0x87, 0xF9, 0xF1, 0xF3, 0xE0, 0x70, 0x7C, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xCF, 0xC0, 0x07, 0xE3, 0xF3, 0xF0, 0x01,
  0xF0, 0xFC, 0xFC, 0x00, 0x7C, 0x3F, 0x3F, 0x00, 0x3E, 0x07, 0xCF, 0x80,
  0x0F, 0x81, 0xF3, 0xE0, 0x07, 0xC0, 0x7F, 0xF8, 0x01, 0xF0, 0x0F, 0xFC,
  0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x1F, 0xC1, 0xFF, 0xE3, 0xFC, 0x3F, 0xFF, 0x3F, 0x87, 0xFF, 0xFB, 0xF8,
  0x7F, 0x7F, 0xFF, 0x8F, 0xF3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x0F, 0xE0,
  0xFF, 0xF0, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x7C, 0xF8, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x04, 0x1F, 0x0C, 0xF3,
  0xCF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xCF, 0xC3, 0xF9,
  0xFC, 0x1E, 0x1E, 0x00, 0xC3, 0x80, 0x08, 0x20, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xEF, 0xF3, 0xF8,
  0xFE, 0x7F, 0x1F, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F, 0xBF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC7,
  0xF3, 0xF8, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFD, 0xF3, 0xF9, 0xC7, 0xF1, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xF0, 0xFF, 0x10, 0x1F, 0xC4, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03,
  0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0x9F, 0xF0, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xBF,
  0x81, 0xFB, 0xF8, 0x1F, 0x3F, 0x83, 0xF3, 0xF8, 0x3E, 0x3F, 0x87, 0xE3,
  0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x81, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xEC,
  0x07, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFC, 0x11, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x20, 0x3F, 0x3F, 0x87, 0xEF, 0xF8, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8,
  0xFF, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xC7, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE3, 0xF8, 0xFE, 0xFF,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFE, 0xFF, 0x3F, 0x8F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF,
  0x9F, 0xEF, 0xF3, 0xF8, 0xFE, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xBF, 0x87, 0xE7, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x33, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3C, 0xFE,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x1E, 0x1F, 0x9F,
  0xEF, 0xF7, 0xFB, 0xF8, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF1, 0xFE, 0x60, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x07, 0xFC, 0xF8, 0x7C, 0x3F, 0xFC,
  0xF8, 0xF8, 0xFF, 0xF9, 0xF3, 0xE3, 0xFF, 0xF3, 0xE7, 0xC7, 0xE3, 0xE3,
  0xCF, 0x8F, 0x87, 0xC7, 0x9F, 0x3E, 0x0F, 0x8F, 0xBC, 0x7C, 0x3F, 0x1F,
  0xF8, 0xF8, 0x7E, 0x3D, 0xF1, 0xF0, 0xFC, 0x7B, 0xE3, 0xE1, 0xF1, 0xF3,
  0xC7, 0xC3, 0xE3, 0xE7, 0xCF, 0xC7, 0xE7, 0xCF, 0x8F, 0xFF, 0xFF, 0x1F,
  0x1F, 0xFF, 0xFE, 0x3E, 0x1F, 0xE7, 0xF8, 0x3E, 0x1F, 0x87, 0xE0, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x04, 0x00, 0xFF,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xF9,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xF8, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xE7, 0xFE, 0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE1, 0xFE, 0xFE, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE1, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFE, 0x06, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0B, 0xFE, 0x06, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x7F, 0xDF, 0xC1, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x7F, 0x0F, 0xFB,
  0xF8, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xBF, 0x1F, 0xF0, 0x08, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xF8, 0x1F,
  0xDF, 0xF0, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF,
  0xFC, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F,
  0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x9F,
  0xE0, 0xFE, 0x7F, 0x83, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x3F,
  0xC3, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F, 0x81, 0xFE, 0xFE, 0x07, 0xFC, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x7C, 0x1F,
  0x7F, 0xFB, 0xF1, 0xFB, 0xFF, 0xDF, 0x8F, 0xDF, 0xFE, 0xFC, 0x7C, 0xFF,
  0xF3, 0xE3, 0xE7, 0xFF, 0x9F, 0xBF, 0x3F, 0xFC, 0xFD, 0xF9, 0xFF, 0xE7,
  0xEF, 0x8F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFE, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0x87, 0xFC, 0x3F,
  0xFC, 0x3F, 0xE1, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0x7F, 0xF8,
  0x3F, 0x83, 0xFF, 0xC1, 0xF8, 0x1F, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xEF, 0xE3, 0xFF, 0xDF, 0xC7, 0xFF, 0x9F, 0xCF, 0xFF,
  0x3F, 0x9F, 0xFE, 0x3F, 0xBF, 0xFC, 0x7F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xEF, 0xFC, 0x7F, 0x83, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00,
  0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x01,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xEF, 0xFC, 0x7F, 0x83, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00,
  0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x01,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF,
  0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x8F, 0xEF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0xC1,
  0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFD, 0xFC, 0x1F, 0xEF,
  0xE0, 0x7F, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFC, 0x0C, 0x7F, 0x01, 0x1F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x9F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFE,
  0x01, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0x0F,
  0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x03, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0xC0, 0xFE, 0x3F, 0x03, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F,
  0x87, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F, 0x87, 0xFE, 0x1F,
  0xC1, 0xF8, 0xFF, 0xE3, 0xF8, 0x1F, 0xCF, 0xFF, 0x3F, 0x81, 0xFC, 0xFF,
  0xF3, 0xF8, 0x1F, 0xCF, 0x9F, 0x3F, 0x81, 0xFC, 0xF9, 0xF3, 0xF8, 0x0F,
  0xCF, 0x9F, 0x3F, 0x00, 0xFD, 0xF9, 0xF7, 0xF0, 0x0F, 0xFF, 0x9F, 0xFF,
  0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x01,
  0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC7,
  0xF8, 0x1F, 0xE7, 0xF0, 0x0F, 0xEF, 0xF0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF8, 0x3F, 0xC3,
  0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xF1, 0xFC, 0x1F,
  0xE3, 0xF8, 0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xF3, 0xF8,
  0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x03, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x7F, 0x82, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0x7E, 0x7F, 0xCF,
  0xC7, 0xF1, 0xF8, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x3E,
  0x1F, 0xCF, 0xE3, 0xFB, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFD, 0xFF, 0x3F, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF9, 0xFE, 0x08, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x81, 0x3F, 0xE7, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xC7, 0xF0, 0xFE, 0x7F, 0x1F, 0xF7, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xF0, 0xFF, 0x7F, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFD, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE3, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFF, 0x3F, 0x9F, 0xC3, 0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x4F, 0xF0, 0x38, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xC3, 0xFC, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xFC,
  0x7F, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x87, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0xFF, 0x7F, 0x1F,
  0xF7, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7,
  0xF0, 0xFF, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xF7, 0xF1, 0xFF,
  0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE4, 0x00, 0xFE, 0x70,
  0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x3E, 0x1F, 0xDF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE,
  0xFE, 0x7C, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xCF, 0xFC, 0xFF, 0x87, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0x83, 0xF9, 0xFC,
  0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0,
  0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xF7, 0xF0, 0xFE, 0x3F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x87, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x7F, 0x03,
  0xFB, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0x07, 0xE1,
  0xF9, 0xFF, 0x1F, 0xF3, 0xF7, 0xFF, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0xFF,
  0x87, 0xF8, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8,
  0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F,
  0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8,
  0x3F, 0x80, 0xFC, 0x3E, 0x1F, 0x9F, 0xF3, 0xF7, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0x8F, 0xE7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0x0F, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x3E, 0x1F, 0x9F, 0xE3,
  0xFB, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFD, 0xFF, 0x3F,
  0x9F, 0xC7, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0xFF, 0x7F, 0x1F, 0xF7, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xF0, 0xFF, 0x7F, 0x07,
  0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFD, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xF7, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFC, 0xFE, 0x3C, 0xFE, 0x04, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0xC0, 0x7F, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0x7E, 0x7F, 0xEF, 0xC7, 0xF0, 0xF8, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0x07,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F,
  0x7E, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x7E, 0x0F, 0xF0, 0x7F, 0x7F,
  0x0F, 0xF8, 0x7F, 0x7F, 0x0F, 0xF8, 0x7E, 0x7F, 0x1F, 0xF8, 0xFE, 0x7F,
  0x1F, 0xF8, 0xFE, 0x3F, 0x1F, 0xF8, 0xFE, 0x3F, 0x9F, 0xF8, 0xFC, 0x3F,
  0x9F, 0xFC, 0xFC, 0x3F, 0xBF, 0x7D, 0xFC, 0x1F, 0xBF, 0x7D, 0xFC, 0x1F,
  0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x0F,
  0xBE, 0x7F, 0xF8, 0x0F, 0xBE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x07, 0xFB, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC1, 0xFD, 0xFE,
  0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x0F, 0xF7,
  0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0xFF, 0x3F, 0x83, 0xFB, 0xFC, 0x1F, 0xE0,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F,
  0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0xF0, 0x7F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0x2F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0,
  0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_Black41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 29, 11, 2, -29 },
  { 30, 16, 10, 20, 2, -29 },
  { 50, 22, 29, 24, 1, -29 },
  { 130, 18, 33, 21, 2, -31 },
  { 205, 34, 30, 36, 1, -30 },
  { 333, 28, 30, 28, 1, -30 },
  { 438, 7, 10, 11, 2, -29 },
  { 447, 11, 36, 14, 2, -30 },
  { 497, 12, 36, 14, 0, -30 },
  { 551, 19, 19, 20, 1, -31 },
  { 597, 18, 19, 22, 2, -24 },
  { 640, 9, 12, 12, 1, -6 },
  { 654, 11, 6, 13, 1, -14 },
  { 663, 8, 7, 11, 2, -7 },
  { 670, 18, 30, 18, 0, -30 },
  { 738, 19, 30, 21, 1, -30 },
  { 810, 15, 29, 21, 2, -29 },
  { 865, 18, 30, 21, 1, -30 },
  { 933, 19, 30, 21, 1, -30 },
  { 1005, 20, 29, 21, 1, -29 },
  { 1078, 18, 29, 21, 2, -29 },
  { 1144, 19, 30, 21, 1, -30 },
  { 1216, 18, 29, 21, 2, -29 },
  { 1282, 19, 30, 21, 1, -30 },
  { 1354, 19, 30, 21, 1, -30 },
  { 1426, 8, 23, 12, 2, -23 },
  { 1449, 9, 29, 12, 1, -23 },
  { 1482, 19, 21, 22, 1, -25 },
  { 1532, 18, 15, 22, 2, -22 },
  { 1566, 18, 21, 22, 2, -25 },
  { 1614, 17, 30, 18, 0, -30 },
  { 1678, 31, 33, 33, 1, -30 },
  { 1806, 25, 29, 25, 0, -29 },
  { 1897, 20, 29, 24, 3, -29 },
  { 1970, 19, 30, 23, 2, -30 },
  { 2042, 21, 29, 26, 3, -29 },
  { 2119, 15, 29, 19, 3, -29 },
  { 2174, 15, 29, 19, 3, -29 },
  { 2229, 22, 30, 26, 2, -30 },
  { 2312, 21, 29, 27, 3, -29 },
  { 2389, 13, 29, 16, 1, -29 },
  { 2437, 13, 38, 13, -3, -29 },
  { 2499, 22, 29, 24, 3, -29 },
  { 2579, 16, 29, 19, 3, -29 },
  { 2637, 29, 29, 35, 3, -29 },
  { 2743, 23, 29, 29, 3, -29 },
  { 2827, 24, 30, 28, 2, -30 },
  { 2917, 18, 29, 23, 3, -29 },
  { 2983, 24, 37, 28, 2, -30 },
  { 3094, 21, 29, 24, 3, -29 },
  { 3171, 18, 30, 20, 1, -30 },
  { 3239, 19, 29, 20, 1, -29 },
  { 3308, 22, 29, 26, 2, -29 },
  { 3388, 25, 29, 25, 0, -29 },
  { 3479, 36, 29, 36, 0, -29 },
  { 3610, 24, 29, 24, 0, -29 },
  { 3697, 23, 29, 23, 0, -29 },
  { 3781, 19, 29, 21, 1, -29 },
  { 3850, 10, 37, 13, 2, -30 },
  { 3897, 18, 30, 18, 0, -30 },
  { 3965, 10, 37, 13, 1, -30 },
  { 4012, 22, 19, 22, 0, -29 },
  { 4065, 21, 5, 21, 0, 3 },
  { 4079, 11, 6, 15, 2, -31 },
  { 4088, 19, 23, 22, 1, -23 },
  { 4143, 19, 31, 23, 2, -31 },
  { 4217, 17, 23, 19, 1, -23 },
  { 4266, 20, 31, 23, 1, -31 },
  { 4344, 19, 23, 21, 1, -23 },
  { 4399, 15, 31, 14, 0, -31 },
  { 4458, 20, 33, 23, 1, -23 },
  { 4541, 19, 31, 23, 2, -31 },
  { 4615, 8, 32, 12, 2, -32 },
  { 4647, 12, 42, 12, -2, -32 },
  { 4710, 21, 31, 23, 2, -31 },
  { 4792, 7, 31, 12, 2, -31 },
  { 4820, 31, 23, 35, 2, -23 },
  { 4910, 19, 23, 23, 2, -23 },
  { 4965, 20, 23, 23, 1, -23 },
  { 5023, 19, 33, 23, 2, -23 },
  { 5102, 20, 33, 23, 1, -23 },
  { 5185, 14, 23, 17, 2, -23 },
  { 5226, 16, 23, 18, 1, -23 },
  { 5272, 14, 27, 16, 1, -27 },
  { 5320, 19, 23, 23, 2, -23 },
  { 5375, 22, 23, 22, 0, -23 },
  { 5439, 32, 23, 32, 0, -23 },
  { 5531, 21, 23, 21, 0, -23 },
  { 5592, 22, 33, 22, 0, -23 },
  { 5683, 16, 23, 18, 1, -23 },
  { 5729, 14, 37, 16, 1, -30 },
  { 5794, 6, 40, 18, 6, -31 },
  { 5824, 14, 37, 16, 1, -30 },
  { 5889, 19, 7, 22, 1, -18 },
};

const GFXfont NotoSans_Condensed_Black41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_BLACK41PT7B_H_
