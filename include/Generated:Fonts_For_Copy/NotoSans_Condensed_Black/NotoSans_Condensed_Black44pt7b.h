#ifndef _NOTOSANS_CONDENSED_BLACK44PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xBF, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xF1, 0xF0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x07, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7,
  0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xEF, 0x9F, 0x9C, 0x13, 0xF3, 0x80, 0x7E, 0x70, 0x0F,
  0xEE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xDF, 0xC0,
  0x39, 0xFC, 0x07, 0x3F, 0xC0, 0xE7, 0xFF, 0x1D, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFF,
  0x80, 0x7E, 0x00, 0x7F, 0xFC, 0x07, 0xC0, 0x0F, 0xEF, 0xC0, 0xFC, 0x00,
  0xFC, 0x7C, 0x0F, 0x80, 0x0F, 0xC7, 0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x1F,
  0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE7, 0xE0, 0x00, 0xFC, 0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xC7, 0xC3, 0xF0,
  0x7E, 0xFC, 0xFC, 0xFF, 0xC7, 0xFF, 0xCF, 0x9F, 0xFE, 0x7F, 0xF9, 0xF9,
  0xFF, 0xE3, 0xFF, 0x9F, 0x3F, 0xFF, 0x1F, 0xE3, 0xF3, 0xF3, 0xF0, 0x78,
  0x3E, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF1, 0xF0, 0x00, 0x7E, 0x3F, 0x1F,
  0x00, 0x07, 0xC3, 0xF1, 0xF0, 0x00, 0xFC, 0x3F, 0x1F, 0x00, 0x0F, 0x83,
  0xF1, 0xF0, 0x01, 0xF8, 0x3F, 0x3F, 0x00, 0x1F, 0x03, 0xF3, 0xF0, 0x03,
  0xF0, 0x1F, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0xFF, 0x03, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFE, 0x7F, 0x87, 0xFF, 0xFD, 0xFE, 0x1F, 0xEF, 0xFF, 0xF8,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x04,
  0x1F, 0x86, 0x79, 0xF1, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFB, 0xF8, 0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0x0F, 0x0F, 0x00, 0x60,
  0xE0, 0x02, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xFB,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x9F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF3, 0xF8, 0xFE, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xEF, 0xF7, 0xF9, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3E, 0x7F,
  0x1C, 0x7F, 0x08, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xE1, 0xFE, 0x18, 0x0F,
  0xE1, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0x81, 0xFE, 0x10, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xF7, 0xF0, 0x1F,
  0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8,
  0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFD, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF3,
  0x87, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x3E, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0xE1, 0xFB, 0xFF, 0x8F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xBF, 0xE1, 0xFD, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFE, 0x7F, 0x87, 0xF3,
  0xFE, 0x7F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xCF, 0xF1, 0xFE, 0x7F, 0x07, 0xF3, 0xFC, 0x7F, 0x8F, 0xE3,
  0xF8, 0x7F, 0xBF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xBF,
  0xC7, 0xF8, 0xFF, 0x3F, 0x83, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0x9F, 0xF7, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0x7F, 0x0F, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1,
  0xFD, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x87, 0xFD, 0xFE, 0x3F, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xEF,
  0xE0, 0xFE, 0x7F, 0x00, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x1C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x0E, 0x1F,
  0x9F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xF9, 0xFC, 0xFE,
  0xFF, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xE0, 0x7F, 0x20, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x03,
  0xF8, 0x7C, 0x7E, 0x0F, 0xFF, 0x7E, 0x7E, 0x3F, 0xFF, 0x3E, 0x7C, 0x3F,
  0xFF, 0x3E, 0xFC, 0x7F, 0x3E, 0x3F, 0xFC, 0xFE, 0x3E, 0x1F, 0xF8, 0xFC,
  0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8,
  0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x3E, 0xF8, 0xF8,
  0x7E, 0x3E, 0xF8, 0xFC, 0x7E, 0x3E, 0xF8, 0xFE, 0xFF, 0x7E, 0xF8, 0x7F,
  0xFF, 0xFC, 0xFC, 0x7F, 0xEF, 0xF8, 0x7C, 0x3F, 0xC7, 0xF0, 0x7E, 0x0F,
  0x83, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xC0, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xCF, 0xF8,
  0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xBF, 0xC3, 0xFD,
  0xFE, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFC, 0x0C, 0x7F, 0xC0, 0x23, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x13, 0xFF,
  0x87, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC7,
  0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC1, 0xFF, 0x7F,
  0x87, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xE0, 0x18, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0xFF, 0x3F, 0xF0, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF0, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F,
  0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x9F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFD,
  0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F,
  0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0x7F,
  0xFF, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3E, 0xFF,
  0xFE, 0xFC, 0x7E, 0xFF, 0xFE, 0xFE, 0x7E, 0xFF, 0xFE, 0x7E, 0x7E, 0xFF,
  0xFE, 0x7E, 0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFC, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF,
  0xFE, 0x1F, 0xF8, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF,
  0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0xE3,
  0xFF, 0xF7, 0xF9, 0xFF, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0x7F, 0xFE, 0x7F,
  0xBF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0x7F,
  0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9,
  0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0x07,
  0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0,
  0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xE7,
  0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFC, 0x1E, 0x7F, 0x80, 0x8F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xCF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x1F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x80, 0xFF,
  0x7F, 0x81, 0xFF, 0x03, 0xF9, 0xFE, 0x07, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0xC1, 0xFE, 0x3F, 0x83, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xF8, 0x7F, 0x07, 0xF0, 0xFF,
  0xE1, 0xFC, 0x1F, 0xC7, 0xEF, 0x8F, 0xF0, 0x7F, 0x1F, 0xBE, 0x3F, 0xC1,
  0xFC, 0x7E, 0xFC, 0xFE, 0x07, 0xF9, 0xFB, 0xF3, 0xF8, 0x0F, 0xE7, 0xEF,
  0xCF, 0xE0, 0x3F, 0xBF, 0x3F, 0x3F, 0x80, 0xFE, 0xFC, 0x7D, 0xFE, 0x03,
  0xFB, 0xF1, 0xF7, 0xF0, 0x07, 0xEF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x9F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xEF, 0xF8,
  0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFD, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07,
  0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F,
  0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7E,
  0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x0F, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x0F, 0xF0,
  0x80, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFB, 0xF3, 0xFF, 0x3F, 0x1F, 0xE1, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x0E, 0x07, 0xF9, 0xFC, 0x3F,
  0xDF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xCF, 0xF8, 0xFE, 0x3F, 0x80,
  0x00, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0x7D, 0xFF, 0x02, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0xEF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0x87, 0xF1, 0xFE, 0x7F, 0x3F, 0xF7, 0xF3, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0x3F, 0x0F, 0xE3, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0,
  0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x47, 0xFC, 0x7C, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF2, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0x80, 0x01, 0xFE, 0x3F, 0x3F, 0xF7, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xF7, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x60, 0x1F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0x07, 0xFB, 0xFE,
  0x3F, 0xFF, 0xF9, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xF8, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x18, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFB,
  0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F,
  0xC7, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0x7F, 0x81, 0xFE, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF,
  0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0xF0, 0x7E, 0x3F, 0xE1, 0xFE, 0x3F,
  0xBF, 0xF9, 0xFF, 0x9F, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF,
  0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0xC1, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0x07, 0xE3, 0xFE, 0x3F, 0xBF, 0xF9, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE, 0x7F, 0xDF,
  0xE1, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x1E, 0x07, 0xF1, 0xFC, 0x3F, 0x9F, 0xF1, 0xFD, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0x7F, 0xDF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xEF, 0xF8, 0xFF, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xFE, 0x3F, 0x3F, 0xF7, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF7, 0xF1, 0xFF, 0x7F, 0x0F, 0xC7,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF7, 0xFF, 0xF3, 0xFC, 0x39, 0xFE, 0x04, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x7F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F,
  0xFD, 0xFC, 0x7F, 0xEF, 0xE1, 0xFC, 0x3F, 0xFF, 0x01, 0xFE, 0xFE, 0x03,
  0xFD, 0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01,
  0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0x07,
  0xF7, 0xF0, 0x7F, 0xC3, 0xFD, 0xFC, 0x3F, 0xF0, 0xFE, 0x7F, 0x8F, 0xFE,
  0x3F, 0x8F, 0xE3, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xE3, 0xF8, 0xFE, 0x3E,
  0xF8, 0xFE, 0x3F, 0x9F, 0xBE, 0x7F, 0x07, 0xF7, 0xEF, 0x9F, 0xC1, 0xFD,
  0xFB, 0xF7, 0xF0, 0x7F, 0x7E, 0xFD, 0xFC, 0x1F, 0xDF, 0x3F, 0x7E, 0x07,
  0xF7, 0xCF, 0xDF, 0x80, 0xFF, 0xF1, 0xF7, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83,
  0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0xFF,
  0x03, 0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xDF, 0xC0, 0x7F, 0xBF, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x8F, 0xF0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x01, 0xFE, 0xFE, 0x03,
  0xFD, 0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x09, 0xFF, 0x00, 0xDF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xD8, 0x07,
  0xFC, 0x80, 0x03, 0x80,
};

const GFXglyph NotoSans_Condensed_Black44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 18, 11, 22, 2, -31 },
  { 58, 24, 31, 26, 1, -31 },
  { 151, 19, 36, 23, 2, -33 },
  { 237, 36, 32, 38, 1, -32 },
  { 381, 30, 32, 30, 1, -32 },
  { 501, 8, 11, 12, 2, -31 },
  { 512, 12, 39, 15, 2, -32 },
  { 571, 13, 39, 15, 0, -32 },
  { 635, 20, 21, 22, 1, -34 },
  { 688, 19, 21, 23, 2, -26 },
  { 738, 9, 12, 13, 1, -6 },
  { 752, 12, 7, 14, 1, -15 },
  { 763, 8, 9, 12, 2, -8 },
  { 772, 19, 32, 19, 0, -32 },
  { 848, 19, 32, 23, 2, -32 },
  { 924, 16, 31, 23, 2, -31 },
  { 986, 20, 32, 23, 1, -32 },
  { 1066, 20, 32, 23, 1, -32 },
  { 1146, 21, 31, 23, 1, -31 },
  { 1228, 19, 31, 23, 2, -31 },
  { 1302, 21, 32, 23, 1, -32 },
  { 1386, 19, 31, 23, 2, -31 },
  { 1460, 21, 32, 23, 1, -32 },
  { 1544, 21, 32, 23, 1, -32 },
  { 1628, 8, 26, 12, 2, -25 },
  { 1654, 9, 31, 13, 1, -25 },
  { 1689, 20, 22, 23, 1, -27 },
  { 1744, 19, 15, 23, 2, -23 },
  { 1780, 20, 22, 23, 2, -27 },
  { 1835, 18, 33, 19, 0, -32 },
  { 1910, 32, 35, 35, 2, -32 },
  { 2050, 27, 31, 27, 0, -31 },
  { 2155, 21, 31, 26, 3, -31 },
  { 2237, 21, 32, 24, 2, -32 },
  { 2321, 23, 31, 28, 3, -31 },
  { 2411, 16, 31, 21, 3, -31 },
  { 2473, 16, 31, 21, 3, -31 },
  { 2535, 24, 32, 28, 2, -32 },
  { 2631, 23, 31, 29, 3, -31 },
  { 2721, 14, 31, 17, 1, -31 },
  { 2776, 14, 41, 14, -3, -31 },
  { 2848, 23, 31, 26, 3, -31 },
  { 2938, 17, 31, 21, 3, -31 },
  { 3004, 32, 31, 38, 3, -31 },
  { 3128, 25, 31, 31, 3, -31 },
  { 3225, 26, 32, 30, 2, -32 },
  { 3329, 20, 31, 24, 3, -31 },
  { 3407, 26, 39, 30, 2, -32 },
  { 3534, 23, 31, 26, 3, -31 },
  { 3624, 19, 32, 22, 1, -32 },
  { 3700, 20, 31, 22, 1, -31 },
  { 3778, 22, 31, 28, 3, -31 },
  { 3864, 26, 31, 26, 0, -31 },
  { 3965, 38, 31, 39, 0, -31 },
  { 4113, 26, 31, 26, 0, -31 },
  { 4214, 25, 31, 25, 0, -31 },
  { 4311, 21, 31, 23, 1, -31 },
  { 4393, 11, 39, 14, 2, -32 },
  { 4447, 19, 32, 19, 0, -32 },
  { 4523, 11, 39, 14, 1, -32 },
  { 4577, 24, 20, 24, 0, -31 },
  { 4637, 22, 5, 22, 0, 3 },
  { 4651, 12, 7, 16, 2, -34 },
  { 4662, 20, 25, 23, 1, -25 },
  { 4725, 21, 33, 25, 2, -33 },
  { 4812, 17, 25, 20, 2, -25 },
  { 4866, 20, 33, 25, 2, -33 },
  { 4949, 20, 25, 23, 2, -25 },
  { 5012, 16, 34, 16, 0, -34 },
  { 5080, 20, 36, 25, 2, -25 },
  { 5170, 21, 33, 25, 2, -33 },
  { 5257, 8, 34, 12, 2, -34 },
  { 5291, 12, 45, 12, -2, -34 },
  { 5359, 23, 33, 25, 2, -33 },
  { 5454, 8, 33, 12, 2, -33 },
  { 5487, 33, 25, 37, 2, -25 },
  { 5591, 21, 25, 25, 2, -25 },
  { 5657, 21, 25, 24, 2, -25 },
  { 5723, 21, 36, 25, 2, -25 },
  { 5818, 20, 36, 25, 2, -25 },
  { 5908, 15, 25, 18, 2, -25 },
  { 5955, 17, 25, 19, 1, -25 },
  { 6009, 15, 29, 17, 1, -29 },
  { 6064, 21, 24, 25, 2, -24 },
  { 6127, 23, 24, 23, 0, -24 },
  { 6196, 34, 24, 35, 0, -24 },
  { 6298, 23, 24, 23, 0, -24 },
  { 6367, 23, 35, 23, 0, -24 },
  { 6468, 17, 24, 19, 1, -24 },
  { 6519, 15, 39, 17, 1, -32 },
  { 6593, 6, 44, 20, 7, -34 },
  { 6626, 15, 39, 17, 1, -32 },
  { 6700, 21, 9, 23, 1, -20 },
};

const GFXfont NotoSans_Condensed_Black44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_BLACK44PT7B_H_
