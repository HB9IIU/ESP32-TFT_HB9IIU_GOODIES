#ifndef _NOTOSANS_CONDENSED_BLACK18PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0xEF, 0xDF, 0xBF, 0x7E, 0xE0, 0x1D,
  0x86, 0x61, 0x98, 0x6E, 0x7F, 0xDF, 0xF3, 0xB3, 0xFF, 0xFF, 0xFF, 0xF3,
  0x60, 0xD8, 0x76, 0x00, 0x10, 0x10, 0x7E, 0xFE, 0xD2, 0xF0, 0xF8, 0x7E,
  0x1E, 0x17, 0x97, 0xFE, 0xFE, 0x10, 0x10, 0x38, 0x70, 0xF8, 0xC1, 0xB1,
  0x87, 0x66, 0x0E, 0xCC, 0x0D, 0xB3, 0x9F, 0x6F, 0x9D, 0xFB, 0x03, 0x76,
  0x0E, 0xEC, 0x19, 0xD8, 0x71, 0xF0, 0xC1, 0xC0, 0x1E, 0x01, 0xF8, 0x0E,
  0xE0, 0x77, 0x03, 0xF0, 0x1F, 0x80, 0xF9, 0xCF, 0xFC, 0x77, 0xE7, 0x9F,
  0x1F, 0xF0, 0xFF, 0xC3, 0xEF, 0x80, 0xFF, 0xFE, 0x3B, 0x99, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xC7, 0xE3, 0x8C, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0xB9, 0xDC, 0x1C, 0x0E, 0x17, 0x4F, 0xEF, 0xF9, 0xF1, 0xD8,
  0x6E, 0x14, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0xFF, 0xFD, 0x80, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0x3C, 0x7E, 0xFE, 0xEE,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFE, 0x7E, 0x3C, 0x1E, 0x7D, 0xFF,
  0xFF, 0xEB, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE0, 0x3E, 0x3F, 0xBF,
  0xC4, 0xE0, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7C, 0xFE, 0xFE, 0x0E, 0x0E, 0x7C, 0x7C, 0x7E, 0x0F, 0x0F, 0xDE, 0xFE,
  0xFC, 0x07, 0x07, 0x83, 0xC3, 0xE3, 0xF1, 0xB9, 0xDC, 0xCE, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0x70, 0xFE, 0xFE, 0xFE, 0xE0, 0xE0, 0xFC, 0xFE, 0x0E,
  0x0F, 0x0F, 0xDE, 0xFE, 0xFC, 0x1E, 0x7E, 0x7E, 0xE0, 0xE8, 0xFE, 0xFF,
  0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0xFF, 0xFF, 0xFF, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x7C, 0xFE, 0xEE, 0xE7, 0xEE,
  0x7E, 0x7C, 0xFE, 0xEF, 0xE7, 0xE7, 0xFE, 0x7C, 0x7C, 0xFE, 0xFE, 0xEF,
  0xE7, 0xEF, 0xFF, 0xFF, 0x77, 0x0E, 0x9E, 0xFC, 0xF8, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xEC, 0x01, 0x0F, 0x3F, 0xF8, 0xE0, 0xF8,
  0x3F, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0xF8, 0x3E, 0x0F, 0x3E, 0xF8, 0xE0, 0x80, 0x7C, 0xFE, 0x7E, 0x47, 0x0E,
  0x1E, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x0F, 0x81, 0xFF, 0x1C,
  0x1C, 0xCF, 0x6C, 0xFB, 0xEE, 0xCF, 0x66, 0x7B, 0x33, 0xD9, 0xBE, 0xFF,
  0xB3, 0xB8, 0xC0, 0x07, 0xDC, 0x0F, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x0D,
  0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0xCE, 0x7F, 0xCF, 0xF9, 0xFF, 0x78, 0xFF,
  0x0E, 0xFE, 0x7F, 0xBF, 0xFC, 0xFE, 0x77, 0xFB, 0xF9, 0xFE, 0xE3, 0xF1,
  0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0x7F, 0x7F, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0xFF, 0x7F, 0x3F, 0xFC, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xB8, 0xEF, 0xFB, 0xFC, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x0E, 0x1F, 0xFF, 0xFF, 0xE1, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x0E, 0x1F, 0xBF, 0x7E, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x1F, 0x9F,
  0xDF, 0xFE, 0x0E, 0x07, 0x3F, 0x9F, 0xCF, 0xE3, 0xF9, 0xDF, 0xEF, 0xF3,
  0xF8, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xC0, 0xFF, 0xF3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0xBF, 0xFC, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9F, 0xFF, 0xF0, 0xE3, 0xF8, 0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFF, 0x39, 0xCE, 0x7B, 0x8E, 0xE3, 0xC0, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0xC3, 0xFE,
  0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0xFF, 0xB7, 0xFD, 0xB7, 0xEF, 0xBF, 0x7D,
  0xF9, 0xEF, 0xCE, 0x7E, 0x73, 0x80, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFB, 0xBF, 0x77, 0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1E,
  0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC,
  0x77, 0xFD, 0xFE, 0x3F, 0x00, 0xFC, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF,
  0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x77, 0xFD, 0xFE, 0x3F, 0x01, 0xE0,
  0x38, 0x0F, 0xFC, 0x3F, 0xCF, 0xF3, 0x9E, 0xE7, 0x39, 0xCF, 0xF3, 0xF8,
  0xEE, 0x3B, 0xCE, 0x73, 0x9E, 0xE3, 0xC0, 0x7F, 0xFF, 0xFF, 0x1E, 0x1F,
  0x1F, 0x1F, 0x0F, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE3, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xEF, 0xF3,
  0xF0, 0xF1, 0xFE, 0x39, 0xC7, 0x38, 0xE7, 0x3C, 0xF7, 0x0E, 0xE1, 0xDC,
  0x3B, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0xE3, 0x87, 0xE3, 0xCE, 0x73,
  0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x77, 0xCE, 0x77, 0xFC, 0x37, 0xFC, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0xF3, 0xDC, 0xE7,
  0xB8, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x7C, 0x3F, 0x0F, 0xE7, 0xB9, 0xCF,
  0xF1, 0xC0, 0xE1, 0xDC, 0xF7, 0x39, 0xEE, 0x3F, 0x0F, 0xC1, 0xE0, 0x78,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x78, 0x38, 0x3C, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38,
  0x38, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x0C, 0x07, 0x01, 0xE0, 0xF8, 0x3F, 0x1C,
  0xC7, 0x39, 0x8E, 0xE1, 0xC0, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x7E, 0x1F,
  0x89, 0xE0, 0x73, 0xFB, 0xFF, 0xCE, 0xEF, 0x7F, 0xBD, 0xC0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xEE, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xF7, 0xFF, 0xFE,
  0x3E, 0xFF, 0xD7, 0x0E, 0x1C, 0x38, 0x7B, 0xFE, 0xF8, 0x07, 0x07, 0x07,
  0x07, 0x77, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x7F, 0x7C,
  0xFE, 0xE7, 0xE7, 0xFF, 0xFF, 0xE0, 0xE2, 0xFE, 0x7E, 0x1C, 0x7C, 0xF3,
  0x87, 0xDF, 0xBF, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x7F, 0xFF,
  0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0x07, 0x8F, 0xFE, 0xFC,
  0xE0, 0xE0, 0xE0, 0xE0, 0xEE, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xCE, 0x03, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0x80, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x7F, 0x3B, 0xB9, 0xFC, 0xFC, 0x7F, 0x3F, 0x9C, 0xEE, 0x77, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x77, 0xFF, 0xFF, 0xFF, 0xCE,
  0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xC0, 0xDE,
  0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x7E, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0xEE, 0xFF, 0xF7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xF7, 0xFF, 0xEE, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0x07, 0x07, 0x07, 0x07, 0xCF,
  0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x7F, 0xFE, 0x78, 0xF9, 0xF1,
  0xE7, 0xFF, 0xE0, 0x30, 0x61, 0xF7, 0xEF, 0xCE, 0x1C, 0x38, 0x70, 0xF4,
  0xF9, 0xF0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x7B,
  0xE3, 0xF9, 0xDC, 0xEE, 0xE7, 0x71, 0xB8, 0xF8, 0x7C, 0x1E, 0x0F, 0x00,
  0xE7, 0x9F, 0x9E, 0x77, 0x79, 0x9D, 0xEE, 0x77, 0xF9, 0xFF, 0xE3, 0xCF,
  0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0, 0xF3, 0xBB, 0x9F, 0xC7, 0xC3, 0xE1,
  0xF0, 0xFC, 0xEE, 0x77, 0xF9, 0xC0, 0xE3, 0xB9, 0xDC, 0xEE, 0xE3, 0x71,
  0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x87, 0x83, 0xC0, 0x7E, 0xFD,
  0xF8, 0xE1, 0xC7, 0x1E, 0x38, 0xFF, 0xFC, 0x1E, 0x7C, 0xE1, 0xC3, 0x87,
  0x0E, 0x78, 0xF0, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF1, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x0F, 0x1E, 0x70, 0xE1,
  0xC3, 0x8F, 0x3C, 0x78, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_Condensed_Black18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 7, 5, 9, 1, -13 },
  { 11, 10, 13, 10, 0, -13 },
  { 28, 8, 15, 9, 1, -14 },
  { 43, 15, 13, 16, 0, -13 },
  { 68, 13, 13, 12, 0, -13 },
  { 90, 3, 5, 5, 1, -13 },
  { 92, 5, 16, 6, 1, -13 },
  { 102, 5, 16, 6, 0, -13 },
  { 112, 9, 9, 9, 0, -14 },
  { 123, 8, 9, 9, 1, -11 },
  { 132, 3, 6, 5, 1, -3 },
  { 135, 5, 3, 6, 0, -6 },
  { 137, 3, 3, 5, 1, -3 },
  { 139, 8, 13, 8, 0, -13 },
  { 152, 8, 13, 9, 1, -13 },
  { 165, 7, 13, 9, 1, -13 },
  { 177, 9, 13, 9, 0, -13 },
  { 192, 8, 13, 9, 1, -13 },
  { 205, 9, 13, 9, 0, -13 },
  { 220, 8, 13, 9, 1, -13 },
  { 233, 8, 13, 9, 1, -13 },
  { 246, 8, 13, 9, 1, -13 },
  { 259, 8, 13, 9, 1, -13 },
  { 272, 8, 13, 9, 1, -13 },
  { 285, 3, 10, 5, 1, -10 },
  { 289, 3, 13, 5, 1, -10 },
  { 294, 8, 9, 9, 1, -11 },
  { 303, 8, 7, 9, 1, -10 },
  { 310, 8, 9, 9, 1, -11 },
  { 319, 8, 13, 8, 0, -13 },
  { 332, 13, 14, 15, 1, -13 },
  { 355, 11, 13, 11, 0, -13 },
  { 373, 9, 13, 11, 1, -13 },
  { 388, 8, 13, 10, 1, -13 },
  { 401, 10, 13, 11, 1, -13 },
  { 418, 7, 13, 9, 1, -13 },
  { 430, 7, 13, 8, 1, -13 },
  { 442, 9, 13, 11, 1, -13 },
  { 457, 10, 13, 12, 1, -13 },
  { 474, 6, 13, 7, 0, -13 },
  { 484, 5, 17, 6, -1, -13 },
  { 495, 10, 13, 11, 1, -13 },
  { 512, 7, 13, 9, 1, -13 },
  { 524, 13, 13, 15, 1, -13 },
  { 546, 11, 13, 13, 1, -13 },
  { 564, 10, 13, 12, 1, -13 },
  { 581, 8, 13, 10, 1, -13 },
  { 594, 10, 16, 12, 1, -13 },
  { 614, 10, 13, 11, 1, -13 },
  { 631, 7, 13, 9, 1, -13 },
  { 643, 9, 13, 9, 0, -13 },
  { 658, 9, 13, 12, 1, -13 },
  { 673, 11, 13, 11, 0, -13 },
  { 691, 16, 13, 16, 0, -13 },
  { 717, 10, 13, 10, 0, -13 },
  { 734, 10, 13, 10, 0, -13 },
  { 751, 9, 13, 9, 0, -13 },
  { 766, 4, 16, 6, 1, -13 },
  { 774, 8, 13, 8, 0, -13 },
  { 787, 5, 16, 6, 0, -13 },
  { 797, 10, 9, 10, 0, -13 },
  { 809, 9, 2, 9, 0, 1 },
  { 812, 5, 3, 7, 1, -14 },
  { 814, 9, 10, 10, 0, -10 },
  { 826, 8, 14, 10, 1, -14 },
  { 840, 7, 10, 8, 1, -10 },
  { 849, 8, 14, 10, 1, -14 },
  { 863, 8, 10, 9, 1, -10 },
  { 873, 7, 14, 6, 0, -14 },
  { 886, 8, 14, 10, 1, -10 },
  { 900, 8, 14, 10, 1, -14 },
  { 914, 3, 14, 5, 1, -14 },
  { 920, 5, 18, 5, -1, -14 },
  { 932, 9, 14, 10, 1, -14 },
  { 948, 3, 14, 5, 1, -14 },
  { 954, 13, 10, 15, 1, -10 },
  { 971, 8, 10, 10, 1, -10 },
  { 981, 8, 10, 10, 1, -10 },
  { 991, 8, 14, 10, 1, -10 },
  { 1005, 8, 14, 10, 1, -10 },
  { 1019, 6, 10, 7, 1, -10 },
  { 1027, 6, 10, 8, 1, -10 },
  { 1035, 7, 12, 7, 0, -12 },
  { 1046, 8, 10, 10, 1, -10 },
  { 1056, 9, 10, 9, 0, -10 },
  { 1068, 14, 10, 14, 0, -10 },
  { 1086, 9, 10, 9, 0, -10 },
  { 1098, 9, 14, 9, 0, -10 },
  { 1114, 7, 10, 8, 0, -10 },
  { 1123, 7, 16, 7, 0, -13 },
  { 1137, 2, 18, 8, 3, -14 },
  { 1142, 7, 16, 7, 0, -13 },
  { 1156, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Black18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_BLACK18PT7B_H_
