#ifndef _NOTOSANS_CONDENSED_BLACK53PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xE3, 0xFE, 0xFF, 0xDF, 0xFB,
  0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0x03, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFF, 0x7F, 0x87, 0xFD, 0xFE, 0x1F, 0xF7,
  0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8,
  0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xBD,
  0xF8, 0xFF, 0x3C, 0x18, 0xFF, 0x3C, 0x00, 0xFF, 0x3C, 0x00, 0xFF, 0x3C,
  0x00, 0xFF, 0xBC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3C,
  0xFE, 0x00, 0x3C, 0xFF, 0x80, 0x3C, 0xFF, 0x60, 0x3C, 0xFE, 0x78, 0x3D,
  0xFE, 0x7F, 0xBF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC1, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC3, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC7, 0xE0, 0x00, 0x07,
  0xE1, 0xF8, 0xFE, 0x1F, 0xE0, 0x7F, 0x3F, 0x8F, 0xE3, 0xFF, 0x07, 0xFF,
  0xF9, 0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xCF, 0xFF, 0xC3, 0xFF, 0xF3,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0x9F, 0xFF, 0xE0, 0xFF, 0xC3, 0xF1,
  0xFC, 0xFE, 0x07, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xE1, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xE0,
  0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFC,
  0x1F, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xFD,
  0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0x07, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF1, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xF9, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x60, 0x7E, 0x02, 0x78, 0x7E, 0x1E, 0x7F, 0x7E, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F,
  0xC3, 0xF8, 0x07, 0xC1, 0xE0, 0x03, 0x81, 0xC0, 0x00, 0x80, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xE7, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC,
  0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFD, 0xFF, 0x3F, 0x81, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xC7, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F,
  0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xEF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xDF, 0xF3, 0xF9, 0xFF, 0x1F, 0x1F, 0xF0, 0xE1, 0xFF,
  0x04, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0x07, 0xFE, 0x1E, 0x03,
  0xFF, 0x0C, 0x03, 0xFF, 0x08, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xBF,
  0xFC, 0x18, 0x07, 0xFE, 0x10, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0xC0, 0x07, 0xFE, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0x40, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x3F,
  0xDF, 0xF0, 0x0F, 0xE7, 0xFC, 0x07, 0xF9, 0xFF, 0x01, 0xFC, 0x7F, 0xC0,
  0xFF, 0x1F, 0xF0, 0x3F, 0x87, 0xFC, 0x1F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x40, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFC, 0x04, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xE0, 0xFF, 0x3F, 0xF0, 0xFF,
  0x7F, 0xF8, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFE, 0x7F,
  0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xEF, 0xFE, 0xFF, 0xC7, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFD, 0xFF, 0x1F,
  0xF9, 0xFE, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x40, 0x3F, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x0E,
  0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x7F, 0xC7, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFF, 0x7F, 0xCF,
  0xE0, 0x40, 0x0E, 0x07, 0xF1, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0xDF, 0xF3,
  0xFE, 0x3F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0x3C, 0x07, 0xFC, 0x40, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xFF,
  0xC7, 0xE1, 0xFC, 0x1F, 0xFF, 0xCF, 0xE3, 0xF0, 0x7F, 0xFF, 0x8F, 0xCF,
  0xE1, 0xFF, 0xFF, 0x1F, 0x9F, 0x87, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xE1,
  0xFC, 0x7F, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0xFC, 0x7F, 0x07, 0xF0, 0xFF,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFF, 0xE1, 0xF8, 0x1F, 0x83, 0xFF, 0xC3, 0xF0,
  0x3F, 0x0F, 0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0xFF, 0x0F, 0xC0, 0xFC, 0x3F,
  0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0xFC, 0x3F, 0x87, 0xF0, 0xFD, 0xF8, 0x7F,
  0x0F, 0xE3, 0xFB, 0xF8, 0xFF, 0x3F, 0xE7, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC7, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xE1, 0xFF, 0xCF, 0xFC, 0x1F, 0xC1,
  0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x7F,
  0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x03,
  0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0x03,
  0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFC, 0x3F, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFC, 0x1F,
  0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0x0F, 0xFC, 0x00, 0x83, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x8F, 0xFE, 0x00, 0xC3, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC3, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF,
  0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFE, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0x01, 0xC1, 0xFF, 0xC0, 0x02, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0xE0,
  0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xFC, 0x07, 0xFC, 0xFF, 0xFD, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF1, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xFD, 0xFF, 0x80, 0xFF, 0xCF, 0xFC,
  0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81,
  0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xE7, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0,
  0x1F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xDF, 0xC1, 0xFD, 0xFF,
  0xFF, 0xBF, 0xC3, 0xFB, 0xFF, 0xFF, 0x7F, 0x87, 0xF7, 0xFF, 0xFE, 0xFF,
  0x1F, 0xCF, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0xFF, 0xF9, 0xFE, 0x7F, 0x3F,
  0xFF, 0xF3, 0xFD, 0xFE, 0x7F, 0xFF, 0xE3, 0xFB, 0xF8, 0xFF, 0xFF, 0xC7,
  0xF7, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF,
  0xF0, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xFE, 0x7F,
  0xC7, 0xFF, 0xFC, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF,
  0xBF, 0xFF, 0xE1, 0xFF, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03,
  0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xE7, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF,
  0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF,
  0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F,
  0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x07,
  0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xC0, 0xF9, 0xFF, 0x80,
  0x63, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xDF, 0x01, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF9, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x07,
  0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFF, 0xC3, 0xFE, 0x07, 0xFC,
  0x3F, 0xBF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFE, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3,
  0xFB, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xEF, 0xE3, 0xFE, 0x03, 0xFE, 0x7F,
  0x3F, 0x9F, 0xF0, 0x0F, 0xF9, 0xFC, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xF3,
  0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xC7, 0xF7, 0xFC, 0x01, 0xFE, 0x7F, 0x1F,
  0xDF, 0xF0, 0x07, 0xFF, 0xFC, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0xE1, 0xFD,
  0xFE, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE,
  0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF9,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xE7, 0xFE,
  0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0x81, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xC3, 0xFF, 0x06, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF,
  0x7F, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F,
  0x3F, 0xFE, 0x7F, 0x1F, 0xFC, 0x7F, 0x0F, 0xF8, 0x3F, 0x00, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xF0, 0x1F, 0xF3,
  0xFE, 0x0F, 0xFB, 0xFF, 0x87, 0xFD, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xDF,
  0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFD, 0xFF, 0x83, 0xFE, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFB, 0xFF, 0xE3, 0xFC,
  0xFF, 0xE1, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xE0, 0x63, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0D, 0xFF, 0x81, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x78, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0xCF, 0xF8,
  0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x7F,
  0xE3, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF7, 0xFC, 0x3F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x7F, 0xE3, 0xFE, 0x7F, 0xC1, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x02, 0x7F, 0xE0,
  0x0C, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x14,
  0x00, 0x00, 0x10, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xC3, 0xFF, 0x9F,
  0xE3, 0xFF, 0xDF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFD,
  0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xF0, 0xFF, 0xCF, 0xF8, 0x3F, 0xC7,
  0xFC, 0x02, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x20, 0x00,
  0xFF, 0x9E, 0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x87, 0xC0, 0xFF, 0x9F, 0xF8, 0xFF, 0xBF, 0xFC, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xF9,
  0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x87,
  0xFE, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F,
  0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE,
  0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x1F, 0xF9, 0xFF, 0x01, 0xFF,
  0xBF, 0xE0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE3, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xC0, 0xFE, 0x1F,
  0xF8, 0xFE, 0x3F, 0xFC, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xEF, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFE, 0x0F, 0xFD, 0xFF, 0x87,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x0F, 0xF8, 0x3F, 0xCF, 0xFE, 0x1F,
  0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xE0, 0x7F,
  0xDF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF7, 0xFE, 0x0F, 0xFB, 0xFF,
  0x8F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0x8F, 0xFB, 0xFF, 0x87, 0xFC, 0x7F, 0x03,
  0xFE, 0x06, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xC3,
  0xFF, 0x9F, 0xE3, 0xFF, 0xDF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFD, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xF0, 0xFF, 0xCF, 0xF8,
  0x3F, 0xC7, 0xFC, 0x02, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFC, 0x3C, 0xFF,
  0x01, 0x9F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE1, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x60, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F,
  0x1F, 0xFC, 0x7F, 0x0F, 0xF8, 0x7F, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x07, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xF9,
  0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xDF, 0xF0, 0x7F, 0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xFC, 0x1F, 0xF7,
  0xFC, 0x1F, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F,
  0xFF, 0x87, 0xFC, 0x7F, 0xC7, 0xFF, 0xC3, 0xFE, 0x3F, 0xE3, 0xFF, 0xF1,
  0xFE, 0x0F, 0xF1, 0xFB, 0xF8, 0xFF, 0x07, 0xF8, 0xFD, 0xFC, 0xFF, 0x83,
  0xFC, 0xFE, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0x3F, 0x3F, 0xC0, 0x7F, 0xBF,
  0x9F, 0xDF, 0xE0, 0x3F, 0xDF, 0xCF, 0xEF, 0xF0, 0x1F, 0xEF, 0xE7, 0xF7,
  0xF8, 0x0F, 0xF7, 0xE3, 0xFB, 0xFC, 0x07, 0xFB, 0xF1, 0xFD, 0xFC, 0x01,
  0xFD, 0xF8, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xEF,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x9F,
  0xF8, 0x3F, 0xF3, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x3F, 0xF0,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x07,
  0xFC,
};

const GFXglyph NotoSans_Condensed_Black53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 39, 15, 2, -38 },
  { 55, 22, 14, 26, 2, -38 },
  { 94, 29, 38, 31, 1, -38 },
  { 232, 24, 43, 28, 2, -40 },
  { 361, 44, 38, 46, 1, -38 },
  { 570, 36, 39, 37, 1, -38 },
  { 746, 10, 14, 14, 2, -38 },
  { 764, 15, 47, 18, 2, -39 },
  { 853, 16, 47, 18, 0, -39 },
  { 947, 24, 24, 26, 1, -40 },
  { 1019, 24, 26, 28, 2, -32 },
  { 1097, 11, 15, 15, 2, -8 },
  { 1118, 15, 8, 17, 1, -18 },
  { 1133, 10, 10, 15, 2, -9 },
  { 1146, 23, 39, 23, 0, -38 },
  { 1259, 24, 39, 28, 2, -38 },
  { 1376, 20, 38, 28, 2, -38 },
  { 1471, 24, 38, 28, 1, -38 },
  { 1585, 24, 39, 28, 2, -38 },
  { 1702, 26, 38, 28, 1, -38 },
  { 1826, 22, 39, 28, 3, -38 },
  { 1934, 24, 39, 28, 2, -38 },
  { 2051, 24, 38, 28, 2, -38 },
  { 2165, 24, 39, 28, 2, -38 },
  { 2282, 24, 39, 28, 2, -38 },
  { 2399, 10, 31, 15, 2, -30 },
  { 2438, 11, 37, 15, 2, -30 },
  { 2489, 24, 27, 28, 2, -33 },
  { 2570, 24, 19, 28, 2, -28 },
  { 2627, 24, 27, 28, 2, -33 },
  { 2708, 22, 39, 23, 0, -38 },
  { 2816, 39, 42, 43, 2, -38 },
  { 3021, 33, 38, 33, 0, -38 },
  { 3178, 26, 38, 31, 3, -38 },
  { 3302, 26, 39, 29, 2, -38 },
  { 3429, 28, 38, 33, 3, -38 },
  { 3562, 20, 38, 25, 3, -38 },
  { 3657, 20, 38, 25, 3, -38 },
  { 3752, 29, 39, 34, 2, -38 },
  { 3894, 28, 38, 35, 3, -38 },
  { 4027, 18, 38, 20, 1, -38 },
  { 4113, 17, 50, 16, -4, -38 },
  { 4220, 29, 38, 31, 3, -38 },
  { 4358, 21, 38, 25, 3, -38 },
  { 4458, 39, 38, 45, 3, -38 },
  { 4644, 31, 38, 38, 3, -38 },
  { 4792, 31, 39, 36, 2, -38 },
  { 4944, 25, 38, 29, 3, -38 },
  { 5063, 32, 47, 36, 2, -38 },
  { 5251, 28, 38, 31, 3, -38 },
  { 5384, 23, 39, 26, 2, -38 },
  { 5497, 24, 38, 26, 1, -38 },
  { 5611, 28, 39, 34, 3, -38 },
  { 5748, 32, 38, 32, 0, -38 },
  { 5900, 46, 38, 47, 0, -38 },
  { 6119, 31, 38, 31, 0, -38 },
  { 6267, 30, 38, 30, 0, -38 },
  { 6410, 25, 38, 27, 1, -38 },
  { 6529, 13, 48, 16, 2, -39 },
  { 6607, 23, 39, 23, 0, -38 },
  { 6720, 13, 48, 16, 1, -39 },
  { 6798, 28, 25, 28, 0, -38 },
  { 6886, 27, 7, 27, 0, 3 },
  { 6910, 15, 9, 19, 2, -41 },
  { 6927, 24, 31, 28, 1, -30 },
  { 7020, 25, 41, 30, 3, -40 },
  { 7149, 21, 31, 25, 2, -30 },
  { 7231, 25, 41, 30, 2, -40 },
  { 7360, 24, 31, 28, 2, -30 },
  { 7453, 19, 41, 19, 1, -41 },
  { 7551, 25, 43, 30, 2, -30 },
  { 7686, 24, 40, 30, 3, -40 },
  { 7806, 9, 41, 15, 3, -41 },
  { 7853, 14, 54, 15, -2, -41 },
  { 7948, 27, 40, 30, 3, -40 },
  { 8083, 9, 40, 15, 3, -40 },
  { 8128, 39, 30, 45, 3, -30 },
  { 8275, 24, 30, 30, 3, -30 },
  { 8365, 25, 31, 29, 2, -30 },
  { 8462, 25, 43, 30, 3, -30 },
  { 8597, 25, 43, 30, 2, -30 },
  { 8732, 18, 30, 21, 3, -30 },
  { 8800, 19, 31, 23, 2, -30 },
  { 8874, 18, 36, 20, 1, -35 },
  { 8955, 24, 30, 30, 3, -29 },
  { 9045, 28, 29, 28, 0, -29 },
  { 9147, 41, 29, 42, 0, -29 },
  { 9296, 27, 29, 28, 0, -29 },
  { 9394, 28, 42, 28, 0, -29 },
  { 9541, 21, 29, 23, 1, -29 },
  { 9618, 18, 47, 21, 1, -38 },
  { 9724, 7, 53, 24, 8, -41 },
  { 9771, 19, 47, 21, 1, -38 },
  { 9883, 24, 10, 28, 2, -24 },
};

const GFXfont NotoSans_Condensed_Black53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_BLACK53PT7B_H_
