#ifndef _NOTOSANS_CONDENSED_BLACK52PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x83,
  0x80, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7,
  0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87,
  0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF0, 0x7F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E,
  0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF,
  0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFC, 0xF1, 0xE7, 0xF1, 0xE0, 0xCF, 0xE3, 0xC0, 0x1F,
  0xC7, 0x80, 0x3F, 0xCF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7B,
  0xFC, 0x00, 0xF3, 0xF8, 0x01, 0xE7, 0xFC, 0x03, 0xCF, 0xFE, 0x07, 0xBF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x3F, 0x80,
  0x03, 0xF1, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xC3, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xE1, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x7F, 0x07,
  0xC0, 0x7E, 0x3F, 0x8F, 0xC3, 0xFE, 0x0F, 0xE7, 0xF3, 0xF8, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7E, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F, 0xCF, 0xFF, 0xE3, 0xFF,
  0xE3, 0xF1, 0xFF, 0xFC, 0x3F, 0xF8, 0xFE, 0x3F, 0xBF, 0x81, 0xFE, 0x1F,
  0xCF, 0xE3, 0xF8, 0x0E, 0x07, 0xF1, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0x8F, 0xE0, 0x00, 0x1F, 0x87, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x3F,
  0x80, 0x00, 0xFC, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0xFE, 0x00,
  0x07, 0xE0, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0xF3, 0xFE,
  0x0F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF,
  0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x70, 0x7E, 0x0E, 0x7C, 0x7E, 0x7E,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF8, 0x3F, 0xE7, 0xFC,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xCF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x83, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xE7, 0xFC,
  0xFF, 0x8F, 0xF9, 0xFF, 0x0F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF7, 0xFC, 0x3F, 0xEF, 0xF8, 0xFF,
  0x9F, 0xFB, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x9F, 0xF3,
  0xF9, 0xFF, 0x1F, 0x1F, 0xF0, 0xE1, 0xFF, 0x04, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x3F, 0x8F, 0xFE, 0x1E, 0x07, 0xFE, 0x1C, 0x03, 0xFE, 0x08, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3E, 0x0F, 0xFC, 0x20, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xBF, 0xE0, 0x1F, 0xDF, 0xF0, 0x1F, 0xCF,
  0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xF0,
  0xFF, 0x87, 0xF0, 0x7F, 0xC3, 0xF8, 0x3F, 0xE3, 0xF8, 0x1F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x38, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFB, 0xE0, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0x00, 0xFF, 0x1F,
  0xE0, 0xFF, 0x3F, 0xF0, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x83,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xEF, 0xFC,
  0x7F, 0xC3, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0xEF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xEF, 0xFC,
  0xFF, 0xC7, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0xFF, 0xC7, 0xFD, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xCF, 0xFF, 0x7F, 0x8F, 0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x01, 0x83, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0x1F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF,
  0x3F, 0x83, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x1F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD,
  0xFF, 0x3F, 0x81, 0x00, 0x1F, 0x1F, 0xE7, 0xFD, 0xFF, 0xFF, 0xDF, 0xF7,
  0xFD, 0xFF, 0x3F, 0x83, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3,
  0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3E, 0x0F, 0xFC,
  0xE0, 0x1F, 0xF1, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xF8,
  0x0F, 0xFC, 0x3F, 0x0F, 0xE0, 0xFF, 0xFC, 0xFE, 0x3F, 0x07, 0xFF, 0xF1,
  0xF9, 0xFC, 0x3F, 0xFF, 0xC7, 0xE7, 0xE1, 0xFF, 0xFF, 0x1F, 0xDF, 0x87,
  0xF0, 0xFC, 0x3F, 0xFE, 0x3F, 0x83, 0xF0, 0xFF, 0xF8, 0xFE, 0x0F, 0xC3,
  0xFF, 0xC3, 0xF0, 0x3F, 0x0F, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0xFC, 0x7F,
  0x07, 0xF0, 0xFF, 0xF1, 0xFC, 0x1F, 0xC3, 0xFF, 0xC7, 0xF0, 0x7F, 0x0F,
  0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0xFC, 0x3F, 0x07, 0xF1, 0xFB, 0xF0, 0xFC,
  0x3F, 0xC7, 0xEF, 0xC3, 0xF8, 0xFF, 0x3F, 0xBF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x7E, 0x1F, 0xFF, 0xFF, 0xE1, 0xF8, 0x3F, 0xFB, 0xFF, 0x87, 0xF0, 0x7F,
  0xC7, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x20, 0x03, 0xFE, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x0F,
  0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF,
  0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0x3F, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xEF, 0xFC,
  0x1F, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xF1, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFC, 0x3E, 0x1F, 0xFC, 0x03, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x11, 0xFF, 0xC0, 0x38, 0xFF, 0xF8,
  0x7C, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF,
  0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC,
  0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0xFF,
  0xCF, 0xFC, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFE, 0x07, 0xC3, 0xFF, 0x80, 0x08, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x3F, 0xF0,
  0x1F, 0xF3, 0xFF, 0x81, 0xFF, 0x3F, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC,
  0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x0F,
  0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x7F, 0x03, 0xFB, 0xFF, 0xFD, 0xFE,
  0x0F, 0xEF, 0xFF, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0xEF, 0xE1, 0xFE, 0xFF,
  0xFF, 0xBF, 0x87, 0xF7, 0xFF, 0xFE, 0xFF, 0x1F, 0xDF, 0xFF, 0xFB, 0xFC,
  0x7F, 0x7F, 0xFF, 0xE7, 0xF3, 0xF9, 0xFF, 0xFF, 0x9F, 0xCF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xBF, 0x9F, 0xFF, 0xF9, 0xFE, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xFF,
  0x81, 0xFE, 0x07, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xDF,
  0xF0, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0x3F,
  0xE7, 0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xFC, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF,
  0xBF, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0,
  0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x0F, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3,
  0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x0F,
  0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x07, 0xFE,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xE3, 0xF3, 0xFF, 0x01, 0xCF, 0xF8, 0x01, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xF7, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xC7,
  0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFB, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xF8,
  0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFE, 0x03,
  0xFE, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0x0F, 0xF8, 0x1F, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0xC1,
  0xFE, 0x0F, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1,
  0xFD, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xEF, 0xE3, 0xFE, 0x03, 0xFE, 0x7F,
  0x3F, 0x1F, 0xF0, 0x1F, 0xF3, 0xF9, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xCF,
  0xE7, 0xF8, 0x03, 0xFC, 0xFE, 0x7F, 0x7F, 0xC0, 0x1F, 0xEF, 0xE3, 0xFB,
  0xFE, 0x00, 0xFF, 0x7F, 0x1F, 0xDF, 0xF0, 0x07, 0xFB, 0xF8, 0x7E, 0xFF,
  0x00, 0x1F, 0xFF, 0xC3, 0xF7, 0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x1F,
  0xF9, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03,
  0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF,
  0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFB, 0xFE, 0x00,
  0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x9F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x3F,
  0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0x03, 0xFF, 0x04, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xE7, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F,
  0x1F, 0xFC, 0x7F, 0x0F, 0xF8, 0x7F, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xE0, 0xFF, 0x9F, 0xF0,
  0xFF, 0xBF, 0xF8, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0x7F, 0xF8, 0xFF, 0x3F, 0xF0, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFC, 0x1C, 0x7F, 0xC0, 0x27,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0x3F, 0xF0, 0x39, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF1, 0xFF, 0x0F, 0xFD, 0xFF, 0x1F, 0xFE,
  0xFF, 0x3F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xE7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE,
  0xFF, 0x0F, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x81,
  0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x04, 0x7F, 0xC0, 0x0C, 0x7F, 0xF8, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xE6, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF0,
  0x7F, 0x0F, 0xFC, 0xFF, 0x1F, 0xFE, 0xFF, 0x3F, 0xFE, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1,
  0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0x07, 0xF9,
  0xFF, 0x00, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x40, 0x03,
  0xFF, 0x78, 0x07, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x8F,
  0xE0, 0xFF, 0x3F, 0xF8, 0xFF, 0x7F, 0xFC, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0x7F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xBF,
  0xE0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0x87, 0xFC,
  0x3F, 0xE3, 0xFF, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0xFF, 0xBF,
  0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0x83, 0xFE, 0x3F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF3, 0xFE,
  0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xF9, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF3,
  0xFF, 0xE7, 0xFE, 0xFF, 0xC3, 0xFF, 0x87, 0xFD, 0xFF, 0x07, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x3F, 0xF8, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC7, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F, 0xDF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0xFE, 0x3F, 0xF0, 0xFF, 0x3F, 0xF8, 0xFF, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF,
  0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xF8, 0xFF, 0xBF, 0xF0, 0xFF,
  0x9F, 0xE0, 0xFF, 0x83, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xFC, 0xFF, 0x1F, 0xFE, 0xFF, 0x3F,
  0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0x1F, 0xFE, 0xFF, 0x0F,
  0xFD, 0xFF, 0x07, 0xF9, 0xFF, 0x00, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xE7,
  0xF8, 0x1C, 0xFF, 0x00, 0x9F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0x87, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC1, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0x40, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFE,
  0xFF, 0x1F, 0xFC, 0x7F, 0x0F, 0xF8, 0x7F, 0x01, 0x80, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xE1, 0xFF, 0x07,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07,
  0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xBF, 0xC0, 0xFF, 0xE0, 0x7F, 0x9F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xCF, 0xF8, 0x3F, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF1, 0xFE, 0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0x87, 0xF8,
  0x7F, 0xC7, 0xFF, 0xC3, 0xFC, 0x3F, 0xE3, 0xF7, 0xE3, 0xFE, 0x1F, 0xF1,
  0xFB, 0xF1, 0xFE, 0x07, 0xF9, 0xFD, 0xF8, 0xFF, 0x03, 0xFC, 0xFE, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0xBF, 0x9F, 0xE0,
  0x3F, 0xDF, 0x9F, 0xDF, 0xE0, 0x1F, 0xEF, 0xC7, 0xEF, 0xF0, 0x0F, 0xF7,
  0xE3, 0xF7, 0xF8, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xEF, 0xFC, 0x1F, 0xF8,
  0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xF3,
  0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFF,
  0x3F, 0xF0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC,
  0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x80,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF,
  0xF0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x01,
  0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC,
  0x80, 0x00, 0x40,
};

const GFXglyph NotoSans_Condensed_Black52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 38, 14, 2, -37 },
  { 49, 21, 13, 26, 2, -37 },
  { 84, 28, 37, 30, 1, -37 },
  { 214, 23, 42, 27, 2, -39 },
  { 335, 43, 38, 45, 1, -38 },
  { 540, 35, 39, 36, 1, -38 },
  { 711, 9, 13, 14, 2, -37 },
  { 726, 15, 46, 17, 2, -38 },
  { 813, 15, 46, 17, 0, -38 },
  { 900, 24, 24, 26, 1, -40 },
  { 972, 23, 25, 27, 2, -31 },
  { 1044, 10, 15, 15, 2, -8 },
  { 1063, 14, 8, 17, 1, -18 },
  { 1077, 10, 10, 14, 2, -9 },
  { 1090, 22, 39, 22, 0, -38 },
  { 1198, 23, 39, 27, 2, -38 },
  { 1311, 20, 37, 27, 2, -37 },
  { 1404, 24, 38, 27, 1, -38 },
  { 1518, 23, 39, 27, 2, -38 },
  { 1631, 25, 37, 27, 1, -37 },
  { 1747, 22, 38, 27, 3, -37 },
  { 1852, 24, 39, 27, 2, -38 },
  { 1969, 23, 37, 27, 2, -37 },
  { 2076, 24, 39, 27, 2, -38 },
  { 2193, 23, 39, 27, 2, -38 },
  { 2306, 10, 30, 15, 2, -29 },
  { 2344, 10, 36, 15, 2, -29 },
  { 2389, 23, 27, 27, 2, -32 },
  { 2467, 23, 19, 27, 2, -28 },
  { 2522, 24, 27, 27, 2, -32 },
  { 2603, 22, 39, 23, 0, -38 },
  { 2711, 38, 42, 42, 2, -38 },
  { 2911, 32, 37, 32, 0, -37 },
  { 3059, 26, 37, 31, 3, -37 },
  { 3180, 25, 39, 29, 2, -38 },
  { 3302, 28, 37, 33, 3, -37 },
  { 3432, 19, 37, 25, 3, -37 },
  { 3520, 19, 37, 24, 3, -37 },
  { 3608, 28, 39, 33, 2, -38 },
  { 3745, 28, 37, 34, 3, -37 },
  { 3875, 17, 37, 20, 1, -37 },
  { 3954, 16, 49, 16, -3, -37 },
  { 4052, 28, 37, 31, 3, -37 },
  { 4182, 21, 37, 25, 3, -37 },
  { 4280, 38, 37, 44, 3, -37 },
  { 4456, 31, 37, 37, 3, -37 },
  { 4600, 31, 39, 35, 2, -38 },
  { 4752, 24, 37, 29, 3, -37 },
  { 4863, 31, 47, 35, 2, -38 },
  { 5046, 28, 37, 30, 3, -37 },
  { 5176, 22, 39, 26, 2, -38 },
  { 5284, 24, 37, 26, 1, -37 },
  { 5395, 27, 38, 33, 3, -37 },
  { 5524, 31, 37, 31, 0, -37 },
  { 5668, 45, 37, 46, 0, -37 },
  { 5877, 30, 37, 30, 0, -37 },
  { 6016, 29, 37, 29, 0, -37 },
  { 6151, 25, 37, 27, 1, -37 },
  { 6267, 13, 47, 16, 2, -38 },
  { 6344, 22, 39, 22, 0, -38 },
  { 6452, 13, 47, 16, 1, -38 },
  { 6529, 28, 24, 28, 0, -37 },
  { 6613, 26, 7, 26, 0, 3 },
  { 6636, 15, 8, 19, 2, -40 },
  { 6651, 24, 30, 28, 1, -29 },
  { 6741, 24, 41, 29, 3, -40 },
  { 6864, 21, 30, 24, 2, -29 },
  { 6943, 24, 41, 29, 2, -40 },
  { 7066, 24, 30, 27, 2, -29 },
  { 7156, 18, 40, 18, 1, -40 },
  { 7246, 24, 41, 29, 2, -29 },
  { 7369, 24, 40, 30, 3, -40 },
  { 7489, 9, 40, 15, 3, -40 },
  { 7534, 14, 52, 15, -2, -40 },
  { 7625, 26, 40, 29, 3, -40 },
  { 7755, 9, 40, 15, 3, -40 },
  { 7800, 39, 29, 44, 3, -29 },
  { 7942, 24, 29, 30, 3, -29 },
  { 8029, 25, 30, 29, 2, -29 },
  { 8123, 24, 41, 29, 3, -29 },
  { 8246, 24, 41, 29, 2, -29 },
  { 8369, 17, 29, 21, 3, -29 },
  { 8431, 19, 30, 22, 2, -29 },
  { 8503, 18, 36, 20, 1, -35 },
  { 8584, 24, 30, 30, 3, -29 },
  { 8674, 27, 29, 27, 0, -29 },
  { 8772, 41, 29, 41, 0, -29 },
  { 8921, 27, 29, 27, 0, -29 },
  { 9019, 27, 41, 27, 0, -29 },
  { 9158, 20, 29, 22, 1, -29 },
  { 9231, 18, 47, 20, 1, -38 },
  { 9337, 7, 52, 23, 8, -40 },
  { 9383, 18, 47, 20, 1, -38 },
  { 9489, 24, 10, 27, 2, -23 },
};

const GFXfont NotoSans_Condensed_Black52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_BLACK52PT7B_H_
