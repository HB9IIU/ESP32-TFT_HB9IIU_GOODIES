#ifndef _NOTOSANS_CONDENSED_BLACK13PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xDE, 0xF6, 0x36, 0x69, 0xFB, 0xF2, 0xDF, 0xFF,
  0xB4, 0x68, 0x11, 0xF7, 0xF4, 0x70, 0xF1, 0xE7, 0x7C, 0xC1, 0x00, 0x71,
  0x9B, 0x63, 0x68, 0x6F, 0x67, 0x5E, 0x1A, 0xC3, 0x58, 0xCF, 0x19, 0xC0,
  0x3C, 0x36, 0x1B, 0x07, 0x87, 0xBF, 0xFB, 0xBC, 0xFE, 0x7F, 0x80, 0xFC,
  0x6F, 0x6D, 0xB6, 0xDB, 0x30, 0xC6, 0x67, 0x33, 0x33, 0x36, 0x6C, 0x32,
  0xDF, 0xCC, 0x7D, 0xA0, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x6D, 0xE0,
  0xFF, 0xF0, 0x1C, 0x61, 0x0C, 0x31, 0x86, 0x18, 0xC0, 0x79, 0xF6, 0xFB,
  0xED, 0xB6, 0xDF, 0x38, 0x19, 0xFE, 0xB1, 0x8C, 0x63, 0x18, 0x7B, 0xF4,
  0xC7, 0x18, 0xC7, 0x3F, 0xFC, 0xFD, 0xF0, 0xCE, 0x38, 0x30, 0xFF, 0xF8,
  0x1C, 0x78, 0xF3, 0xE7, 0xDF, 0xFF, 0x8E, 0x1C, 0xFF, 0xF1, 0xEF, 0x8C,
  0x7F, 0xF0, 0x3D, 0xD6, 0x1F, 0xFF, 0xB6, 0xDF, 0x38, 0xFF, 0xF0, 0xC7,
  0x18, 0x63, 0x0C, 0x70, 0x7D, 0xB6, 0xDF, 0x79, 0xBE, 0xDF, 0x7C, 0x79,
  0xFE, 0xFB, 0x7D, 0xF0, 0xDE, 0x78, 0xF0, 0x3C, 0x6C, 0x00, 0xDB, 0xC0,
  0x04, 0x77, 0xB8, 0x3C, 0x30, 0x40, 0xFF, 0xF0, 0x3F, 0xFC, 0xC3, 0xC3,
  0xC7, 0x7B, 0x88, 0x00, 0xFE, 0xC6, 0x73, 0x10, 0x0E, 0x70, 0x1F, 0x08,
  0x66, 0xFD, 0x6F, 0xD2, 0xF6, 0xB5, 0xF9, 0xA4, 0x31, 0x07, 0xC0, 0x3C,
  0x3C, 0x3C, 0x7E, 0x66, 0x7E, 0x7E, 0xE7, 0xE7, 0xFB, 0xFC, 0xFF, 0xFB,
  0x3C, 0xFF, 0xF8, 0x7F, 0xEC, 0x30, 0xC3, 0x0C, 0x3E, 0x78, 0xF9, 0xFB,
  0x36, 0x7C, 0xF9, 0xF3, 0x7E, 0xF8, 0xFF, 0xF1, 0xEF, 0x63, 0x1F, 0xF8,
  0xFF, 0xF1, 0x8F, 0x63, 0x18, 0xC0, 0x7D, 0xFB, 0x06, 0x0D, 0xF9, 0xF3,
  0xFF, 0x7E, 0xCF, 0x9F, 0x3F, 0xFF, 0xF9, 0xF3, 0xE7, 0xCE, 0xFB, 0x9C,
  0xE7, 0x39, 0xCE, 0xF8, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xCF, 0xBB,
  0x67, 0xCF, 0x9F, 0x37, 0x66, 0xCE, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8,
  0xE3, 0xF1, 0xFD, 0xFE, 0xFF, 0x7E, 0xEF, 0x77, 0xBB, 0xDD, 0x80, 0xE7,
  0xCF, 0xDF, 0xBD, 0xFB, 0xF7, 0xE7, 0xCE, 0x7D, 0xFF, 0x1E, 0x3C, 0x78,
  0xF3, 0xFF, 0x7C, 0xFB, 0xFD, 0xF7, 0xFB, 0xCC, 0x30, 0xC0, 0x7D, 0xFF,
  0x1E, 0x3C, 0x78, 0xF3, 0xFF, 0x7C, 0x18, 0x38, 0xF9, 0xFB, 0x36, 0xEF,
  0x9F, 0x36, 0x6E, 0xCE, 0x7D, 0xFE, 0x1C, 0x78, 0x78, 0xFF, 0xF8, 0xFF,
  0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0x7E, 0x78, 0xE7, 0xE6, 0x66, 0x6E, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0xC6,
  0x7D, 0xCD, 0xB9, 0xB7, 0x76, 0xFC, 0xD7, 0x9E, 0xF1, 0xDE, 0x39, 0xC0,
  0xEE, 0x6C, 0x7C, 0x38, 0x38, 0x3C, 0x7C, 0x6E, 0xE7, 0xE6, 0xDD, 0xB1,
  0xE3, 0x83, 0x06, 0x0C, 0x18, 0xFF, 0xF1, 0xC6, 0x31, 0xC6, 0x3F, 0xFC,
  0xFF, 0x6D, 0xB6, 0xDB, 0x70, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x86, 0x1C,
  0xFD, 0xB6, 0xDB, 0x6D, 0xF0, 0x10, 0x70, 0xE3, 0x66, 0xD8, 0xC0, 0xFE,
  0xCC, 0x7D, 0xB1, 0xDF, 0xEF, 0xF7, 0xC0, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C,
  0xF7, 0xFF, 0xE0, 0x7D, 0xE6, 0x38, 0x61, 0xF3, 0xC0, 0x0E, 0x1C, 0x3B,
  0xF7, 0xFD, 0xFB, 0xB7, 0x7E, 0xEC, 0x7D, 0xB6, 0xFF, 0x61, 0xF3, 0xC0,
  0x3B, 0xD9, 0xEF, 0x31, 0x8C, 0x63, 0x00, 0x76, 0xFD, 0xBF, 0x76, 0xEF,
  0xDF, 0x86, 0x7C, 0xF0, 0xC3, 0x0C, 0x3E, 0xFF, 0x7C, 0xF3, 0xCF, 0x30,
  0xF3, 0xFF, 0xF0, 0x33, 0x03, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC3, 0x0C,
  0x37, 0xDB, 0xCF, 0x36, 0xDF, 0x30, 0xFF, 0xFF, 0xF0, 0xFB, 0xFF, 0xF7,
  0x7B, 0xBD, 0xDE, 0xEF, 0x76, 0xFB, 0xFD, 0xF3, 0xCF, 0x3C, 0xC0, 0x7C,
  0xD9, 0xBF, 0x76, 0xEF, 0x8F, 0x00, 0xFB, 0xFC, 0xF3, 0xDF, 0xFF, 0xB0,
  0xC3, 0x00, 0x76, 0xFD, 0xBF, 0x76, 0xEF, 0xDF, 0x87, 0x0E, 0x1C, 0xFF,
  0xCC, 0xCC, 0xC0, 0x7F, 0x7C, 0xF1, 0xFF, 0xE0, 0x23, 0x3F, 0xF6, 0x31,
  0x8F, 0x78, 0xDF, 0x7D, 0xF7, 0xDF, 0xFE, 0xC0, 0xCE, 0xD9, 0xB3, 0x67,
  0x87, 0x0E, 0x00, 0xCE, 0xFB, 0xB7, 0xFD, 0xFE, 0x7B, 0x9C, 0xE3, 0x38,
  0xEE, 0xF9, 0xE1, 0xC7, 0x8D, 0xBB, 0x80, 0xEE, 0xD9, 0xB3, 0x63, 0x87,
  0x0E, 0x18, 0x70, 0xC0, 0xFF, 0xCC, 0x66, 0x7F, 0xE0, 0x39, 0x8C, 0x6F,
  0x71, 0xC6, 0x31, 0xCE, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0x18, 0xC3, 0x9D,
  0xCC, 0x67, 0x38, 0x67, 0xF8, 0xC0,
};

const GFXglyph NotoSans_Condensed_Black13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 5, 3, 6, 1, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 11, 7, 0, -10 },
  { 23, 11, 9, 11, 0, -9 },
  { 36, 9, 9, 9, 0, -9 },
  { 47, 2, 3, 3, 1, -9 },
  { 48, 3, 12, 4, 1, -10 },
  { 53, 4, 12, 4, 0, -10 },
  { 59, 6, 6, 6, 0, -10 },
  { 64, 6, 7, 7, 0, -8 },
  { 70, 3, 4, 4, 0, -2 },
  { 72, 4, 2, 4, 0, -4 },
  { 73, 2, 2, 4, 1, -2 },
  { 74, 6, 9, 6, 0, -9 },
  { 81, 6, 9, 7, 0, -9 },
  { 88, 5, 9, 7, 0, -9 },
  { 94, 6, 9, 7, 0, -9 },
  { 101, 6, 9, 7, 0, -9 },
  { 108, 7, 9, 7, 0, -9 },
  { 116, 5, 9, 7, 1, -9 },
  { 122, 6, 9, 7, 0, -9 },
  { 129, 6, 9, 7, 0, -9 },
  { 136, 6, 9, 7, 0, -9 },
  { 143, 6, 9, 7, 0, -9 },
  { 150, 2, 7, 4, 1, -7 },
  { 152, 3, 9, 4, 0, -7 },
  { 156, 6, 7, 7, 0, -8 },
  { 162, 6, 5, 7, 0, -7 },
  { 166, 6, 7, 7, 0, -8 },
  { 172, 5, 9, 6, 0, -9 },
  { 178, 10, 10, 10, 0, -9 },
  { 191, 8, 9, 8, 0, -9 },
  { 200, 6, 9, 8, 1, -9 },
  { 207, 6, 9, 7, 1, -9 },
  { 214, 7, 9, 8, 1, -9 },
  { 222, 5, 9, 6, 1, -9 },
  { 228, 5, 9, 6, 1, -9 },
  { 234, 7, 9, 8, 1, -9 },
  { 242, 7, 9, 9, 1, -9 },
  { 250, 5, 9, 5, 0, -9 },
  { 256, 4, 12, 4, -1, -9 },
  { 262, 7, 9, 8, 1, -9 },
  { 270, 5, 9, 6, 1, -9 },
  { 276, 9, 9, 11, 1, -9 },
  { 287, 7, 9, 9, 1, -9 },
  { 295, 7, 9, 9, 1, -9 },
  { 303, 6, 9, 7, 1, -9 },
  { 310, 7, 11, 9, 1, -9 },
  { 320, 7, 9, 8, 1, -9 },
  { 328, 6, 9, 6, 0, -9 },
  { 335, 6, 9, 6, 0, -9 },
  { 342, 7, 9, 8, 1, -9 },
  { 350, 8, 9, 8, 0, -9 },
  { 359, 11, 9, 11, 0, -9 },
  { 372, 8, 9, 8, 0, -9 },
  { 381, 7, 9, 7, 0, -9 },
  { 389, 6, 9, 7, 0, -9 },
  { 396, 3, 12, 4, 1, -10 },
  { 401, 6, 9, 6, 0, -9 },
  { 408, 3, 12, 4, 0, -10 },
  { 413, 7, 6, 7, 0, -9 },
  { 419, 7, 1, 7, 0, 1 },
  { 420, 3, 2, 5, 1, -10 },
  { 421, 6, 7, 7, 0, -7 },
  { 427, 6, 10, 7, 1, -10 },
  { 435, 6, 7, 6, 0, -7 },
  { 441, 7, 10, 7, 0, -10 },
  { 450, 6, 7, 7, 0, -7 },
  { 456, 5, 10, 5, 0, -10 },
  { 463, 7, 10, 7, 0, -7 },
  { 472, 6, 10, 7, 1, -10 },
  { 480, 2, 10, 4, 1, -10 },
  { 483, 4, 13, 4, -1, -10 },
  { 490, 6, 10, 7, 1, -10 },
  { 498, 2, 10, 4, 1, -10 },
  { 501, 9, 7, 11, 1, -7 },
  { 509, 6, 7, 7, 1, -7 },
  { 515, 7, 7, 7, 0, -7 },
  { 522, 6, 10, 7, 1, -7 },
  { 530, 7, 10, 7, 0, -7 },
  { 539, 4, 7, 5, 1, -7 },
  { 543, 5, 7, 6, 0, -7 },
  { 548, 5, 9, 5, 0, -9 },
  { 554, 6, 7, 7, 1, -7 },
  { 560, 7, 7, 7, 0, -7 },
  { 567, 10, 7, 10, 0, -7 },
  { 576, 7, 7, 7, 0, -7 },
  { 583, 7, 10, 7, 0, -7 },
  { 592, 5, 7, 6, 0, -7 },
  { 597, 5, 11, 5, 0, -9 },
  { 604, 2, 13, 6, 2, -10 },
  { 608, 5, 11, 5, 0, -9 },
  { 615, 6, 3, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_Black13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_BLACK13PT7B_H_
