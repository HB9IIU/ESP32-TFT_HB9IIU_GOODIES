#ifndef _NOTOSANS_CONDENSED_BLACK25PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x9C, 0xE0, 0x03, 0xDF, 0xFB,
  0x80, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xDC, 0xF7, 0x3C, 0x07, 0x78,
  0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x71, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x0E, 0xE0, 0x73, 0x8F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x77, 0x81, 0xDC,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x00, 0x06, 0x00, 0xC0, 0xFF, 0x3F, 0xFF,
  0xFD, 0xEC, 0xB9, 0x87, 0xB0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x7E,
  0x0D, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x18, 0x03, 0x00, 0x3C, 0x0F,
  0x07, 0xE0, 0xE0, 0xFE, 0x1C, 0x0E, 0xF1, 0xC0, 0xE7, 0x3C, 0x0E, 0x73,
  0x80, 0xE7, 0x78, 0x0E, 0xF7, 0x3C, 0xFE, 0x77, 0xE7, 0xEE, 0xFF, 0x3C,
  0xEE, 0x70, 0x1C, 0xE7, 0x01, 0xCE, 0x70, 0x38, 0xE7, 0x03, 0x8E, 0x70,
  0x78, 0xFF, 0x07, 0x07, 0xE0, 0xF0, 0x3C, 0x0F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x7D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x9F, 0x7F, 0x9E, 0xFF, 0xFE, 0xF3, 0xFE, 0xF3, 0xFC, 0xF1, 0xFC, 0xFB,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xBF, 0xFF, 0xFF, 0xF7, 0x70, 0x1E,
  0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x38, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0xF8, 0xF0, 0xF1, 0xE3, 0xC3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1,
  0xE7, 0x9E, 0x00, 0x0F, 0x00, 0x70, 0x07, 0x07, 0x7E, 0x7F, 0xFF, 0xFF,
  0x0F, 0x01, 0xF8, 0x3F, 0xC7, 0x9E, 0x19, 0x80, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x7B, 0xFF, 0xEF, 0x7B, 0xC0, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xE0,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0xBF, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF7, 0xDE, 0xFB, 0xFE, 0x3F,
  0x83, 0xE0, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xFD, 0xDE, 0x4F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x3F,
  0x0F, 0xF3, 0xFF, 0x7F, 0xE6, 0x3E, 0x87, 0xC0, 0xF0, 0x1E, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x1F, 0xFB, 0xFF, 0x3F, 0xF4, 0x3E, 0x07, 0x80, 0xF1, 0xFC, 0x3E,
  0x07, 0xF0, 0xFF, 0x01, 0xF0, 0x3F, 0x07, 0xFB, 0xFF, 0xFE, 0xFF, 0xDF,
  0xE0, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x77,
  0x83, 0xBC, 0x39, 0xE3, 0xCF, 0x1C, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0x80, 0xF0, 0x1F, 0xC3, 0xFC, 0x7F, 0xDF, 0xFC, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xFD, 0xFF, 0xFE, 0xFF, 0xCF, 0xE0, 0x0F, 0xC3, 0xF8, 0xFF,
  0x3F, 0xA7, 0x81, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFE, 0xFB, 0xFF, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x80, 0x1F, 0x8F,
  0xF9, 0xFF, 0x7D, 0xFF, 0x1F, 0xF7, 0xDE, 0xF3, 0xFE, 0x3F, 0x07, 0xF1,
  0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xFF, 0x7F, 0xC7, 0xF0, 0x1F,
  0x0F, 0xF1, 0xFF, 0x7F, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xFF,
  0xFD, 0xFF, 0x9E, 0xF0, 0x1E, 0x07, 0xA3, 0xF3, 0xFC, 0x7F, 0x0F, 0xC0,
  0x77, 0xFF, 0xF3, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x77, 0xFF, 0xF3,
  0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFB, 0xDE, 0xF0, 0x00, 0x60, 0x3C, 0x1F,
  0x8F, 0xF7, 0xF1, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0xFC, 0x07, 0x80,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC1, 0xF8,
  0xFE, 0x7F, 0x1F, 0x83, 0xC0, 0x60, 0x00, 0x3F, 0x3F, 0xEF, 0xFD, 0xFF,
  0x43, 0xC0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0xF8, 0x3E, 0x07, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFB,
  0xF0, 0xF0, 0x1E, 0x78, 0x63, 0x9C, 0xFF, 0x7F, 0x7F, 0xDF, 0x9C, 0xE7,
  0xE7, 0x39, 0xFB, 0xCE, 0x7E, 0xF3, 0x9F, 0x9C, 0xE7, 0xE7, 0x7F, 0xF9,
  0xFF, 0xE7, 0x3C, 0xF1, 0xC0, 0x00, 0x3C, 0x02, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C,
  0x78, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x78, 0x3E, 0xF8,
  0x3E, 0xF8, 0x1F, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF1, 0xEF, 0x1E,
  0xF1, 0xEF, 0xFC, 0xFF, 0x8F, 0xFE, 0xF7, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0x0F, 0xE1, 0xFF, 0x3F, 0xF7, 0xFE,
  0x7C, 0x27, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC1, 0x7F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFE, 0xFF, 0x07, 0xFE,
  0x3F, 0xF9, 0xFF, 0xCF, 0x1F, 0x78, 0x7B, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0x1F, 0x78, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF,
  0xC7, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDE, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0x7F, 0xBF,
  0xDE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x07, 0xF0, 0x7F,
  0xE3, 0xFF, 0x9F, 0xFC, 0x7C, 0x13, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x1F, 0xF8, 0x7D, 0xF1, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xC0, 0xFF,
  0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0xFF, 0xFE, 0xFC, 0x60, 0xF0, 0xFF, 0x8F, 0xBC, 0x7D, 0xE7, 0xCF,
  0x3E, 0x7B, 0xE3, 0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x8F, 0x3C, 0x79, 0xF3, 0xC7, 0x9E, 0x3E, 0xF1, 0xF7, 0x87, 0xC0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xBF,
  0xFC, 0xEF, 0xFF, 0x3B, 0xFD, 0xDE, 0xFF, 0x77, 0x3F, 0xDF, 0xCF, 0xF7,
  0xF3, 0xFC, 0xFC, 0xFF, 0x3E, 0x3F, 0xCF, 0x8F, 0xF3, 0xE3, 0xFC, 0x78,
  0xF0, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFE,
  0xF3, 0xFF, 0xCF, 0xFF, 0xBF, 0xDE, 0xFF, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xF0, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xCF, 0x8F, 0x9F,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F,
  0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x8F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xCF, 0x8F, 0x9F, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0xFE, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x3E, 0x78, 0xF3,
  0xC7, 0x9E, 0x7C, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xEF, 0x0F, 0x7C, 0x79,
  0xE3, 0xCF, 0x9E, 0x3C, 0xF1, 0xF7, 0x87, 0xC0, 0x1F, 0x8F, 0xFD, 0xFF,
  0x7F, 0xEF, 0x05, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x03,
  0xE0, 0x3F, 0x07, 0xFF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xE3, 0xF8, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7,
  0xCF, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x3E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0,
  0xF7, 0x81, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0x80, 0xF0, 0x78, 0x7F, 0xE1, 0xE1, 0xF7, 0x87, 0x87, 0x9E, 0x3F, 0x1E,
  0x78, 0xFC, 0x79, 0xE3, 0xF3, 0xE7, 0xCF, 0xCF, 0x8F, 0x3F, 0x3C, 0x3D,
  0xFC, 0xF0, 0xF7, 0xFB, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xFC, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0xF8, 0xF1, 0xF3, 0xE1, 0xE7, 0x83, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0xFF, 0x01, 0xFF, 0x07, 0xDE, 0x0F, 0x3E, 0x3E, 0x7C, 0x78, 0x7D, 0xF0,
  0xFC, 0xF8, 0x7D, 0xE1, 0xF7, 0xC7, 0x9F, 0x3E, 0x3C, 0xF0, 0xFB, 0xC1,
  0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xF0, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0F, 0xE0, 0x77, 0x87,
  0x9C, 0x38, 0xF3, 0xC3, 0x9C, 0x1F, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0xF8, 0xF0, 0x70, 0x3F, 0x8F, 0xF9, 0xFF, 0x99, 0xF0, 0x1E,
  0x3F, 0xDF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xFF, 0xFF, 0xFE, 0xF9,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xBC, 0xFF, 0xEF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFE, 0xF7, 0xC0, 0x1F, 0x8F, 0xF7, 0xFF, 0xFE, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1F, 0xDD, 0xFF, 0x7F, 0xC7, 0xE0,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF3, 0xDF, 0x7F, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x9F,
  0x7F, 0xF7, 0xFF, 0x3C, 0xF0, 0x1F, 0x07, 0xF9, 0xFF, 0x7C, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xE1, 0xBF, 0xF7, 0xFE, 0x3F,
  0x80, 0x0F, 0x8F, 0xCF, 0xE7, 0xD3, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x3C,
  0xF7, 0xEF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF3, 0xDF, 0x01, 0xF8, 0x1E, 0xFF,
  0xEF, 0xFE, 0xFF, 0xC3, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xBC, 0xF7, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF0, 0x7F, 0xFE,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x7C,
  0xF8, 0xE0, 0x07, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0xFF, 0x7E, 0xF8, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x7F, 0xE7, 0xDF, 0x3C, 0xFB, 0xE7, 0xFE,
  0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xEF, 0x9F, 0x3C, 0xF9, 0xF7,
  0xC7, 0xBE, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF3, 0xC7, 0x9E, 0xFD, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0x3F, 0xF3, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1,
  0xFF, 0x1E, 0x3F, 0xE3, 0xC7, 0xFC, 0x78, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3,
  0xC0, 0xF3, 0xCF, 0x7E, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x1F, 0x83,
  0xFC, 0x7F, 0xEF, 0xBE, 0xF9, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF9, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xF3, 0xCF, 0x7E, 0xFF, 0xEF,
  0xDF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFD, 0xFF,
  0xFE, 0xFF, 0xEF, 0xBC, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x3C, 0xF7, 0xEF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xFB, 0xF7, 0xFF, 0x7F, 0xF3, 0xDF, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x3F,
  0x3F, 0xFF, 0xDE, 0x6F, 0x07, 0xE3, 0xFC, 0xFF, 0x1F, 0x83, 0xF1, 0xFF,
  0xFF, 0xF7, 0xF0, 0x1C, 0x0E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF4, 0xFE, 0x7F, 0x1F, 0x80, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0xF8, 0x7F, 0xC7, 0xDE,
  0x3C, 0xF1, 0xE7, 0x8F, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x1D, 0xE0, 0xEE,
  0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0xF1, 0xF1, 0xFF, 0x9F, 0x9E,
  0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0xBF, 0xBC, 0x3F, 0xBB,
  0xC3, 0xFB, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9,
  0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0xF8, 0xFB, 0xE7, 0x9F, 0x7C, 0x7B,
  0xC3, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFF, 0x0F, 0x78,
  0xFB, 0xE7, 0x8F, 0x7C, 0x7C, 0xF8, 0x7F, 0xC7, 0xDE, 0x3C, 0xF1, 0xE7,
  0xCF, 0x1E, 0xF8, 0xF7, 0x87, 0xBC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xF0, 0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x07, 0x83, 0xE1, 0xF0, 0x78,
  0x3E, 0x0F, 0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x87, 0xC7, 0xE3,
  0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x7F, 0x3F, 0x1F, 0x8F, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xF0, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F, 0x1F, 0x3F, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0xF8, 0xF8, 0xF0, 0x7C, 0x3F, 0xFF, 0xFF, 0xC7, 0xF8, 0x18,
};

const GFXglyph NotoSans_Condensed_Black25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 10, 7, 12, 1, -18 },
  { 22, 14, 18, 15, 0, -18 },
  { 54, 11, 20, 13, 1, -19 },
  { 82, 20, 18, 22, 1, -18 },
  { 127, 16, 18, 17, 1, -18 },
  { 163, 4, 7, 7, 1, -18 },
  { 167, 7, 22, 8, 1, -18 },
  { 187, 7, 22, 8, 0, -18 },
  { 207, 12, 11, 12, 0, -19 },
  { 224, 11, 12, 13, 1, -15 },
  { 241, 5, 7, 7, 1, -4 },
  { 246, 6, 4, 8, 1, -9 },
  { 249, 5, 4, 7, 1, -4 },
  { 252, 11, 18, 11, 0, -18 },
  { 277, 11, 18, 13, 1, -18 },
  { 302, 9, 18, 13, 1, -18 },
  { 323, 11, 18, 13, 1, -18 },
  { 348, 11, 18, 13, 1, -18 },
  { 373, 13, 18, 13, 0, -18 },
  { 403, 11, 18, 13, 1, -18 },
  { 428, 11, 18, 13, 1, -18 },
  { 453, 11, 18, 13, 1, -18 },
  { 478, 11, 18, 13, 1, -18 },
  { 503, 11, 18, 13, 1, -18 },
  { 528, 5, 14, 7, 1, -14 },
  { 537, 5, 17, 7, 1, -14 },
  { 548, 11, 12, 13, 1, -15 },
  { 565, 11, 9, 13, 1, -13 },
  { 578, 11, 12, 13, 1, -15 },
  { 595, 10, 18, 11, 0, -18 },
  { 618, 18, 20, 20, 1, -18 },
  { 663, 16, 18, 16, 0, -18 },
  { 699, 12, 18, 15, 2, -18 },
  { 726, 12, 18, 14, 1, -18 },
  { 753, 13, 18, 16, 2, -18 },
  { 783, 9, 18, 12, 2, -18 },
  { 804, 9, 18, 12, 2, -18 },
  { 825, 14, 18, 16, 1, -18 },
  { 857, 13, 18, 16, 2, -18 },
  { 887, 8, 18, 10, 1, -18 },
  { 905, 8, 24, 8, -2, -18 },
  { 929, 13, 18, 15, 2, -18 },
  { 959, 9, 18, 12, 2, -18 },
  { 980, 18, 18, 21, 2, -18 },
  { 1021, 14, 18, 18, 2, -18 },
  { 1053, 15, 18, 17, 1, -18 },
  { 1087, 11, 18, 14, 2, -18 },
  { 1112, 15, 22, 17, 1, -18 },
  { 1154, 13, 18, 15, 2, -18 },
  { 1184, 11, 18, 12, 1, -18 },
  { 1209, 12, 18, 12, 0, -18 },
  { 1236, 12, 18, 16, 2, -18 },
  { 1263, 15, 18, 15, 0, -18 },
  { 1297, 22, 18, 22, 0, -18 },
  { 1347, 15, 18, 15, 0, -18 },
  { 1381, 14, 18, 14, 0, -18 },
  { 1413, 11, 18, 13, 1, -18 },
  { 1438, 6, 22, 8, 1, -18 },
  { 1455, 11, 18, 11, 0, -18 },
  { 1480, 7, 22, 8, 0, -18 },
  { 1500, 13, 12, 13, 0, -18 },
  { 1520, 13, 3, 13, 0, 2 },
  { 1525, 7, 4, 9, 1, -19 },
  { 1529, 11, 14, 13, 1, -14 },
  { 1549, 12, 19, 14, 1, -19 },
  { 1578, 10, 14, 12, 1, -14 },
  { 1596, 12, 19, 14, 1, -19 },
  { 1625, 11, 14, 13, 1, -14 },
  { 1645, 9, 19, 9, 0, -19 },
  { 1667, 12, 20, 14, 1, -14 },
  { 1697, 12, 19, 14, 1, -19 },
  { 1726, 5, 19, 7, 1, -19 },
  { 1738, 7, 25, 7, -1, -19 },
  { 1760, 13, 19, 14, 1, -19 },
  { 1791, 5, 19, 7, 1, -19 },
  { 1803, 19, 14, 21, 1, -14 },
  { 1837, 12, 14, 14, 1, -14 },
  { 1858, 12, 14, 14, 1, -14 },
  { 1879, 12, 20, 14, 1, -14 },
  { 1909, 12, 20, 14, 1, -14 },
  { 1939, 9, 14, 10, 1, -14 },
  { 1955, 9, 14, 11, 1, -14 },
  { 1971, 9, 17, 10, 0, -17 },
  { 1991, 12, 14, 14, 1, -14 },
  { 2012, 13, 14, 13, 0, -14 },
  { 2035, 20, 14, 20, 0, -14 },
  { 2070, 13, 14, 13, 0, -14 },
  { 2093, 13, 20, 13, 0, -14 },
  { 2126, 10, 14, 11, 0, -14 },
  { 2144, 9, 22, 10, 0, -18 },
  { 2169, 3, 25, 11, 4, -19 },
  { 2179, 8, 22, 10, 1, -18 },
  { 2201, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Black25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_BLACK25PT7B_H_
