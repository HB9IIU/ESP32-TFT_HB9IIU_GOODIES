#ifndef _NOTOSANS_CONDENSED_BLACK23PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9C, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0xC7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE3, 0x98, 0x1D, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE3,
  0x9C, 0x1C, 0xC0, 0xEE, 0x07, 0x70, 0x0C, 0x07, 0xC7, 0xFF, 0xFE, 0xEC,
  0xBB, 0x0F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFC, 0x37, 0x8D, 0xFF, 0xFF,
  0xFB, 0xFC, 0x0C, 0x03, 0x00, 0x18, 0x00, 0x03, 0xE0, 0xE0, 0x7F, 0x1C,
  0x07, 0x71, 0xC0, 0x77, 0x38, 0x0F, 0x73, 0x80, 0x77, 0x38, 0x07, 0x77,
  0x3C, 0x7F, 0x77, 0xE3, 0xEE, 0xFE, 0x18, 0xEE, 0xE0, 0x1C, 0xE7, 0x01,
  0xCE, 0x70, 0x38, 0xEE, 0x03, 0x8E, 0xE0, 0x70, 0x7E, 0x07, 0x03, 0xC0,
  0x0E, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xDE, 0x07, 0x9C, 0x0F, 0x78, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x3C, 0xFE, 0x7B, 0xDF, 0xF7, 0xBF, 0xCF, 0x3F,
  0x9E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x3E, 0xFF, 0xFF, 0xFF, 0x1E,
  0x78, 0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x38, 0x78, 0xF0, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xE1, 0xE3, 0xC3, 0x87,
  0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x71, 0xE3, 0x8F,
  0x00, 0x0E, 0x01, 0xC0, 0x38, 0x37, 0x27, 0xFF, 0xFF, 0xC3, 0xC0, 0xFC,
  0x3B, 0xCF, 0x38, 0x44, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF,
  0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x7F, 0xFF, 0xEE, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0,
  0x00, 0x0C, 0x0F, 0xC7, 0xF9, 0xFE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF7, 0xF9, 0xFE, 0x3F, 0x00, 0x0F,
  0x8F, 0xCF, 0xEF, 0xFF, 0xFB, 0xBC, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0E, 0x07, 0xF3, 0xFF, 0x3F, 0xE3, 0x3E,
  0x43, 0xC0, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8,
  0x1F, 0xFB, 0xFF, 0x7F, 0xE0, 0x1C, 0x3F, 0xCF, 0xF9, 0xFF, 0x43, 0xC0,
  0xF0, 0x78, 0xFC, 0x3E, 0x0F, 0xE0, 0x7C, 0x0F, 0x03, 0xE1, 0xFF, 0xFF,
  0xFE, 0xFF, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3B, 0xC3, 0xBC, 0x73, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x03, 0xC0, 0x3C, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1F, 0x8F, 0xFB,
  0xFE, 0x7F, 0xC0, 0xF0, 0x3C, 0x0F, 0xC7, 0xFF, 0xEF, 0xFB, 0xFC, 0x07,
  0x87, 0xE3, 0xF9, 0xFE, 0x78, 0x3C, 0x0F, 0x73, 0xBE, 0xFF, 0xFE, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xF7, 0xFD, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xF3, 0xFC,
  0xF7, 0xF9, 0xFE, 0x3F, 0x1F, 0xEF, 0xFF, 0xCF, 0xE1, 0xFC, 0xFF, 0xFD,
  0xFE, 0x3F, 0x00, 0x1C, 0x1F, 0xC7, 0xFB, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xFF, 0xFF, 0xF7, 0xDC, 0x4F, 0x03, 0xC1, 0xE7, 0xF9, 0xFC, 0x7C,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xEE, 0x00, 0x40, 0x70, 0x7C, 0x7E, 0xFE, 0x3E, 0x0F,
  0xC1, 0xFC, 0x0F, 0xC0, 0xF0, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x81, 0xFC, 0x1F, 0xC1,
  0xF0, 0xFC, 0xFE, 0xFE, 0x3C, 0x0C, 0x02, 0x00, 0x1C, 0x1F, 0xCF, 0xF9,
  0xFF, 0x43, 0xC0, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0xF8, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0x01, 0xC7, 0x08, 0x73, 0x9F, 0xBB, 0x9F, 0xCF, 0xDE, 0xE7, 0xEE,
  0x73, 0xF7, 0x39, 0xFB, 0x9C, 0xFD, 0xCE, 0x6E, 0x7F, 0xF7, 0x3E, 0xF1,
  0xC0, 0x00, 0xF0, 0x08, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1E, 0xE0, 0x7B, 0x81, 0xCF, 0x0F,
  0x3C, 0x3C, 0xF0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xE1, 0xFF,
  0x83, 0xFE, 0x0F, 0xFF, 0xCF, 0xFE, 0xFF, 0xEF, 0x9E, 0xF9, 0xEF, 0x9E,
  0xFF, 0xCF, 0xF8, 0xFF, 0xEF, 0x9E, 0xF9, 0xFF, 0x9F, 0xF9, 0xEF, 0xFE,
  0xFF, 0xCF, 0xF8, 0x07, 0x03, 0xFC, 0xFF, 0xBF, 0xE7, 0x85, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x9F, 0xF1,
  0xFE, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xF3, 0xEF, 0x8F, 0x7C,
  0x7B, 0xE3, 0xFF, 0x1F, 0xF8, 0xF7, 0xC7, 0xBE, 0x3D, 0xF3, 0xEF, 0xBE,
  0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x03, 0x81, 0xFF, 0x3F, 0xF7, 0xFE, 0x7C,
  0x2F, 0x80, 0xF0, 0x0F, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x8F, 0xF8,
  0xF7, 0xCF, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFD, 0xF3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0xFF, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0xFE, 0xFC, 0xF8, 0xF8, 0xFF, 0xCF, 0xBE,
  0x79, 0xF7, 0xCF, 0xBC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFE,
  0x3E, 0xF1, 0xF7, 0xCF, 0x9E, 0x7C, 0xFB, 0xE3, 0xDF, 0x1F, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xDC, 0xFF, 0xEE, 0x7F, 0xF7, 0x77, 0xFB,
  0xFB, 0xFC, 0xFD, 0xFE, 0x7E, 0xFF, 0x3E, 0x7F, 0x9F, 0x3F, 0xC7, 0x9F,
  0xE3, 0xCF, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC,
  0xFF, 0x7B, 0xFD, 0xEF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F,
  0xFC, 0x78, 0xFB, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xBC, 0x1E, 0xF8, 0x79, 0xF3, 0xE7, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0,
  0xFF, 0x9F, 0xFB, 0xFF, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xFF, 0xFF,
  0xDF, 0xF3, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x78, 0xFB, 0xE1, 0xEF, 0x07, 0xBC, 0x1E,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBC, 0x1E, 0xF8, 0x79, 0xF3, 0xE7, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xFF,
  0x87, 0xFE, 0x3F, 0xF9, 0xF3, 0xCF, 0x9E, 0x7C, 0xF3, 0xEF, 0x9F, 0xF8,
  0xFF, 0x87, 0xFC, 0x3E, 0xF1, 0xF7, 0x8F, 0xBE, 0x7C, 0xF3, 0xE7, 0xDF,
  0x1F, 0x0E, 0x1F, 0xF7, 0xFB, 0xFE, 0xF0, 0xBC, 0x0F, 0x83, 0xF8, 0x7F,
  0x0F, 0xE0, 0xF8, 0x1F, 0x83, 0xF9, 0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0x79, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC, 0xF8, 0x7D, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3D,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x78, 0xF0, 0xF7, 0x8F, 0x9E, 0x79,
  0xF9, 0xE7, 0x9F, 0x9E, 0x39, 0xF9, 0xE3, 0xDF, 0x9C, 0x3D, 0xDF, 0xC3,
  0xFD, 0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xF8, 0xF8,
  0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0xF8, 0xFB, 0xC7, 0x8F, 0x78, 0x7B, 0xC1,
  0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x7B,
  0xC3, 0xDE, 0x3E, 0x79, 0xE3, 0xFF, 0x0F, 0xF8, 0xFB, 0xC7, 0x9E, 0x3C,
  0x7B, 0xC3, 0xDE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFC, 0xF0, 0x3C, 0x07,
  0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0xFC, 0x06,
  0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xDC, 0x39, 0xC7, 0x8E, 0x70,
  0xEF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0xC7, 0x3F, 0x1F,
  0xE7, 0xFC, 0x8F, 0x03, 0xCF, 0xFF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF,
  0xF7, 0x79, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x79, 0xFF, 0xBF,
  0xF7, 0xDF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF3, 0xFF, 0xF7,
  0xFE, 0xF7, 0x80, 0x1F, 0x1F, 0xDF, 0xFF, 0x2F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7C, 0x7F, 0xEF, 0xF3, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF3,
  0x9E, 0xFB, 0xDF, 0xFF, 0xDF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE7, 0xFF, 0xFB, 0xFF, 0x3D, 0xE0, 0x1E, 0x1F, 0xE7, 0xFF, 0xCF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x17, 0xFD, 0xFF, 0x3F, 0x80, 0x06,
  0x0F, 0xCF, 0xC7, 0xE3, 0xC1, 0xFB, 0xFD, 0xFE, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x3D, 0xEF, 0xFD, 0xFF,
  0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0xFF, 0xBF,
  0xF3, 0xDE, 0x03, 0xE0, 0xF7, 0xFE, 0xFF, 0x9F, 0xE0, 0x20, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x79, 0xFF, 0xBF, 0xFF, 0xDF, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x7F,
  0xF7, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xF3, 0xC7, 0x00,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF,
  0xFF, 0x88, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xFF, 0x1E, 0xF3,
  0xCF, 0x7C, 0xF7, 0x8F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0xCF, 0x3C, 0xF3,
  0xEF, 0x1E, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE7, 0x8F, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFF, 0x1E, 0x7F,
  0x8F, 0x3F, 0xC7, 0x9F, 0xE3, 0xCF, 0xF1, 0xE7, 0xF8, 0xF3, 0xFC, 0x79,
  0xFE, 0x3C, 0xFF, 0x1E, 0x78, 0xE7, 0x9F, 0xFB, 0xFF, 0xFD, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1E, 0x1F,
  0x07, 0xF1, 0xFF, 0x7D, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x79, 0xFF, 0x3F, 0xC1, 0xF0, 0xE7, 0x9F, 0xFB, 0xFF, 0x7D, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x3F, 0xFF, 0x7F, 0xEF, 0x79, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3D, 0xEF, 0xFD, 0xFF,
  0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0xFF, 0xBF,
  0xF3, 0xDE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE3,
  0xF7, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x3E, 0xFF, 0xFF, 0xE2, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x8F, 0xFF, 0xFF,
  0xFE, 0x1C, 0x3C, 0x3F, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3D, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x7F, 0xFF, 0xBF, 0xF3, 0xCE, 0xF0, 0xFF,
  0x0F, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x9C, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF1, 0xE3, 0xFC, 0x7C, 0xF7, 0x3F,
  0x39, 0xEF, 0xCE, 0x7B, 0xF7, 0x9E, 0xFD, 0xE3, 0xBF, 0x78, 0xEC, 0xFC,
  0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0x7C, 0xF8, 0x1E, 0x1E, 0x00,
  0xF9, 0xF7, 0x9E, 0x7B, 0xE3, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0xC3, 0xFC, 0x7B, 0xE7, 0x9E, 0xF9, 0xF0, 0xF0, 0xFF, 0x0F, 0x79,
  0xE7, 0x9E, 0x79, 0xE3, 0xDC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x20,
  0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x0F, 0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0xFC, 0xF0, 0xFC, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC1, 0xE3,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x3C, 0x7C, 0x39, 0xF3, 0xCF, 0x1E, 0x3C,
  0x78, 0xF3, 0xE7, 0x8E, 0x00, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
};

const GFXglyph NotoSans_Condensed_Black23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 13, 16, 13, 0, -16 },
  { 42, 10, 18, 12, 1, -17 },
  { 65, 20, 17, 20, 0, -17 },
  { 108, 15, 17, 16, 1, -17 },
  { 140, 4, 6, 6, 1, -16 },
  { 143, 7, 21, 8, 1, -17 },
  { 162, 7, 21, 8, 0, -17 },
  { 181, 11, 11, 11, 0, -18 },
  { 197, 10, 11, 12, 1, -14 },
  { 211, 4, 6, 7, 1, -3 },
  { 214, 6, 4, 7, 1, -8 },
  { 217, 4, 4, 6, 1, -4 },
  { 219, 10, 17, 10, 0, -17 },
  { 241, 10, 17, 12, 1, -17 },
  { 263, 9, 16, 12, 1, -16 },
  { 281, 11, 17, 12, 0, -17 },
  { 305, 10, 17, 12, 1, -17 },
  { 327, 12, 16, 12, 0, -16 },
  { 351, 10, 16, 12, 1, -16 },
  { 371, 10, 17, 12, 1, -17 },
  { 393, 10, 16, 12, 1, -16 },
  { 413, 10, 17, 12, 1, -17 },
  { 435, 10, 17, 12, 1, -17 },
  { 457, 4, 13, 7, 1, -13 },
  { 464, 4, 16, 7, 1, -13 },
  { 472, 10, 12, 12, 1, -14 },
  { 487, 10, 8, 12, 1, -12 },
  { 497, 10, 12, 12, 1, -14 },
  { 512, 10, 17, 10, 0, -17 },
  { 534, 17, 19, 19, 1, -17 },
  { 575, 14, 16, 14, 0, -16 },
  { 603, 12, 16, 14, 1, -16 },
  { 627, 11, 17, 13, 1, -17 },
  { 651, 13, 16, 15, 1, -16 },
  { 677, 9, 16, 11, 1, -16 },
  { 695, 9, 16, 11, 1, -16 },
  { 713, 12, 17, 15, 1, -17 },
  { 739, 13, 16, 15, 1, -16 },
  { 765, 7, 16, 9, 1, -16 },
  { 779, 8, 21, 7, -2, -16 },
  { 800, 13, 16, 14, 1, -16 },
  { 826, 9, 16, 11, 1, -16 },
  { 844, 17, 16, 20, 1, -16 },
  { 878, 14, 16, 16, 1, -16 },
  { 906, 14, 17, 16, 1, -17 },
  { 936, 11, 16, 13, 1, -16 },
  { 958, 14, 21, 16, 1, -17 },
  { 995, 13, 16, 13, 1, -16 },
  { 1021, 10, 17, 11, 1, -17 },
  { 1043, 11, 16, 11, 0, -16 },
  { 1065, 12, 16, 15, 1, -16 },
  { 1089, 14, 16, 14, 0, -16 },
  { 1117, 20, 16, 20, 0, -16 },
  { 1157, 13, 16, 13, 0, -16 },
  { 1183, 13, 16, 13, 0, -16 },
  { 1209, 10, 16, 12, 1, -16 },
  { 1229, 6, 21, 7, 1, -17 },
  { 1245, 10, 17, 10, 0, -17 },
  { 1267, 6, 21, 7, 0, -17 },
  { 1283, 12, 10, 12, 0, -16 },
  { 1298, 12, 3, 12, 0, 1 },
  { 1303, 6, 4, 8, 1, -18 },
  { 1306, 10, 13, 12, 1, -13 },
  { 1323, 11, 17, 13, 1, -17 },
  { 1347, 9, 13, 11, 1, -13 },
  { 1362, 11, 17, 13, 1, -17 },
  { 1386, 10, 13, 12, 1, -13 },
  { 1403, 9, 18, 8, 0, -18 },
  { 1424, 11, 19, 13, 1, -13 },
  { 1451, 11, 17, 13, 1, -17 },
  { 1475, 4, 18, 7, 1, -18 },
  { 1484, 6, 24, 7, -1, -18 },
  { 1502, 12, 17, 13, 1, -17 },
  { 1528, 4, 17, 6, 1, -17 },
  { 1537, 17, 13, 20, 1, -13 },
  { 1565, 11, 13, 13, 1, -13 },
  { 1583, 11, 13, 13, 1, -13 },
  { 1601, 11, 19, 13, 1, -13 },
  { 1628, 11, 19, 13, 1, -13 },
  { 1655, 8, 13, 9, 1, -13 },
  { 1668, 8, 13, 10, 1, -13 },
  { 1681, 8, 15, 9, 0, -15 },
  { 1696, 11, 13, 13, 1, -13 },
  { 1714, 12, 13, 12, 0, -13 },
  { 1734, 18, 13, 18, 0, -13 },
  { 1764, 12, 13, 12, 0, -13 },
  { 1784, 12, 19, 12, 0, -13 },
  { 1813, 9, 13, 10, 0, -13 },
  { 1828, 8, 21, 9, 0, -17 },
  { 1849, 3, 23, 10, 4, -18 },
  { 1858, 7, 21, 9, 1, -17 },
  { 1877, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_Black23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_BLACK23PT7B_H_
