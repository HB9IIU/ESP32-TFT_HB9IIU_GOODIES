#ifndef _NOTOSANS_CONDENSED_BLACK47PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0x86, 0x00, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFE, 0xFE, 0x3F, 0xDF, 0xC7, 0xFB, 0xF8, 0x7F,
  0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x9C, 0x39, 0xF8, 0xE0, 0x4F, 0xC7,
  0x00, 0x7F, 0x38, 0x03, 0xFD, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0E, 0xFF, 0x00, 0x73, 0xF8, 0x03, 0x9F, 0xF0,
  0x1C, 0xFF, 0xE0, 0xEF, 0xEF, 0xF7, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xE0,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0xDF,
  0xC0, 0x7E, 0x00, 0x3F, 0x9F, 0x81, 0xF8, 0x00, 0x7E, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xF1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC7, 0xE0, 0xF0, 0x3F, 0x9F, 0x8F, 0xC7, 0xF8, 0x3F,
  0x7F, 0x3F, 0x1F, 0xF8, 0x7F, 0xFE, 0x7E, 0x7F, 0xF8, 0x7F, 0xF9, 0xF9,
  0xFF, 0xF8, 0xFF, 0xE3, 0xF3, 0xFF, 0xF0, 0xFF, 0x8F, 0xC7, 0xE7, 0xE0,
  0x7E, 0x1F, 0x8F, 0xCF, 0xE0, 0x00, 0x7E, 0x3F, 0x8F, 0xC0, 0x00, 0xFC,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0x3F, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x07, 0xE7, 0xF0, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x1F, 0xFF,
  0x80, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x00, 0x3E,
  0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC3, 0xFC,
  0x0F, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xC7, 0xF8,
  0x3F, 0xFF, 0xE7, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0x9F, 0xFF, 0xF0,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0x03, 0xE0, 0x47, 0x8F, 0x8F, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFF,
  0x3F, 0xC3, 0xF8, 0xFE, 0x03, 0xE1, 0xE0, 0x07, 0x07, 0x00, 0x04, 0x08,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF9, 0xFE,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xF3, 0xFE, 0xFF, 0x8F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3,
  0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0xFF,
  0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE3, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0x7F, 0xCF, 0x9F, 0xF1, 0xC7, 0xFC,
  0x21, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xE3, 0xFF, 0x3C, 0x0F, 0xF8, 0xC0, 0x7F, 0xC2, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0x03, 0xFE, 0x10,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xBF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0x9F, 0xE0,
  0x7E, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x7F, 0x3F, 0xE3, 0xFB, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3,
  0xFE, 0xFF, 0xBF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0x9F, 0xE1, 0xFE,
  0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFE, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9,
  0xFF, 0x1F, 0xE7, 0xF8, 0x7F, 0xDF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0x87,
  0xF9, 0xFE, 0x1F, 0xEF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFB, 0xFC, 0x3F, 0xCF,
  0xE0, 0x3C, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x08, 0x1F, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xBF, 0x82, 0x00, 0x1F, 0x8F, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF3, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F,
  0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xC1, 0xFF, 0x30, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x30, 0x3F, 0x0F, 0xC1, 0xFF, 0xC7,
  0xE7, 0xE0, 0xFF, 0xF9, 0xF9, 0xF8, 0x7F, 0xFE, 0x3F, 0x7E, 0x3F, 0xFF,
  0x8F, 0xFF, 0x0F, 0xE7, 0xE3, 0xFF, 0xC7, 0xE1, 0xF8, 0x7F, 0xF1, 0xF8,
  0x7E, 0x1F, 0xFC, 0x7E, 0x1F, 0x87, 0xFE, 0x3F, 0x07, 0xE1, 0xFF, 0x8F,
  0xC1, 0xF8, 0x7F, 0xE3, 0xF0, 0x7E, 0x3F, 0xF8, 0xFC, 0x1F, 0x8F, 0xFE,
  0x3F, 0x07, 0xE3, 0xFF, 0x87, 0xE3, 0xF8, 0xFB, 0xF1, 0xF8, 0xFE, 0x7E,
  0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0xC7, 0xE3, 0xFF, 0x3F,
  0xE1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x03, 0x80, 0x60, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x0F, 0xFC,
  0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0x87, 0xFE, 0xFF, 0x07, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7,
  0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xEF, 0xF0, 0x7F, 0xDF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x1F, 0xF8, 0x3C, 0x3F, 0xE0, 0x10, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x09, 0xFF, 0xC0, 0x61,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFE, 0x7F, 0xFC, 0xFF, 0x07, 0xFE,
  0x7F, 0x81, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F,
  0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFE, 0xFF,
  0x03, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xC3, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xF0, 0x3C, 0x3F, 0xE0,
  0x02, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0x7F, 0xC0, 0x7F, 0xBF, 0xF0, 0x3F, 0xCF, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0x30, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0,
  0x3F, 0xE7, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x0F, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F,
  0xF7, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0,
  0xFF, 0x8F, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xFD, 0xFE,
  0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFB, 0xF0, 0x3F, 0x7F, 0xFE, 0xFE, 0x0F, 0xDF, 0xFF, 0xBF, 0x87,
  0xFF, 0xFF, 0xEF, 0xE1, 0xFF, 0xFF, 0xFD, 0xF8, 0x7E, 0xFF, 0xFF, 0x7F,
  0x1F, 0xBF, 0xFF, 0xDF, 0xCF, 0xEF, 0xFF, 0xF7, 0xF3, 0xF3, 0xFF, 0xFC,
  0xFC, 0xFC, 0xFF, 0xFF, 0x3F, 0xBF, 0x3F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xF8, 0xFF, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0x83, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xF0, 0xFF, 0xFD,
  0xFE, 0x1F, 0xFF, 0xBF, 0xE3, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0x7F, 0x8F,
  0xFF, 0xE7, 0xF9, 0xFF, 0xFC, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7, 0xFF, 0xF1,
  0xFE, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xC7, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xEF,
  0xF0, 0xFF, 0xBF, 0xC7, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFE,
  0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC,
  0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xD0,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFE, 0x3F, 0xF8, 0xFF,
  0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F,
  0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xF9, 0xFE,
  0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xF8, 0x7C, 0xFF, 0x00, 0xCF, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xF7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F,
  0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x80,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xDF,
  0xE0, 0x1F, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0xC1, 0xFE, 0x1F,
  0xE0, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xFF, 0x1F,
  0xE0, 0x7F, 0x8F, 0xDF, 0x8F, 0xF0, 0x3F, 0xC7, 0xEF, 0xC7, 0xF8, 0x0F,
  0xE3, 0xF7, 0xE3, 0xFC, 0x07, 0xF1, 0xFB, 0xF9, 0xFE, 0x03, 0xFD, 0xFC,
  0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x7E, 0xFF, 0x00, 0xFF, 0x7E, 0x3F, 0x7F,
  0x80, 0x3F, 0xBF, 0x1F, 0xBF, 0xC0, 0x1F, 0xDF, 0x8F, 0xDF, 0xE0, 0x0F,
  0xEF, 0xC7, 0xEF, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xCF,
  0xF8, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xF0, 0x0F,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x1F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xF9, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xE0, 0x7F, 0x82, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0x7F, 0x3F, 0xF9, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF3, 0xF8, 0x3F, 0x9F, 0xF0, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xCF, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0,
  0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xBF,
  0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0x8F, 0xEF, 0xFC, 0x3F, 0x0F, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xF1, 0xE7, 0xFC, 0x04, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0x7F, 0xE1, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x3F,
  0xFB, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0x9F, 0xC3, 0xF8, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFE, 0x1F, 0xDF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x04, 0xFF, 0x00, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xD8, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x7F, 0xEF,
  0xF3, 0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF3, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFE,
  0xFF, 0x1F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF9, 0x80, 0x1F, 0xE7, 0xF3, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x8F, 0xE1, 0xFC, 0xFF, 0xCF, 0xEF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF0, 0x07, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x83, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07,
  0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFE, 0xFF, 0x80, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x1F,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07,
  0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xC1, 0xFE, 0x1F, 0x9F, 0xFC, 0x7F, 0xE3, 0xFB, 0xFF, 0xDF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF7, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xE1, 0xFE, 0xFF, 0x07, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x83,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0x83, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0x03, 0xFC, 0xFC, 0x3F, 0xC7, 0xE7, 0xFF, 0x3F, 0xBF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xBF, 0xE1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xE1, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFC, 0x3F, 0x83, 0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF,
  0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFB,
  0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xF3, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xBF, 0xF8, 0xFE, 0x7F, 0xC3, 0xF8, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x7F, 0xEF,
  0xF3, 0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF3, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFE,
  0xFF, 0x1F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0xFE, 0xFE, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xF0, 0x33, 0xFC, 0x04, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE3, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0x3F, 0xF1, 0xF8,
  0xFF, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0xF0, 0x3F, 0x9F, 0xE0,
  0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xF0, 0xFF,
  0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xFC, 0x3F, 0x87, 0xF8, 0xFB,
  0xE3, 0xFC, 0x3F, 0xCF, 0xDF, 0x9F, 0xE1, 0xFE, 0x7E, 0xFC, 0xFF, 0x07,
  0xF3, 0xF7, 0xE7, 0xF0, 0x3F, 0x9F, 0xBF, 0x3F, 0x81, 0xFC, 0xFD, 0xF9,
  0xFC, 0x0F, 0xFF, 0xCF, 0xDF, 0xE0, 0x3F, 0xFE, 0x3F, 0xFE, 0x01, 0xFF,
  0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xFC,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x7F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F,
  0xE3, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xF7, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xF7, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F,
  0xC3, 0xFE, 0x7F, 0xC1, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xBF,
  0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0B,
  0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0x07, 0xFE, 0x80, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_Black47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 35, 13, 2, -34 },
  { 41, 19, 13, 23, 2, -34 },
  { 72, 26, 34, 27, 1, -34 },
  { 183, 21, 39, 24, 2, -36 },
  { 286, 39, 34, 41, 1, -34 },
  { 452, 32, 34, 32, 1, -34 },
  { 588, 8, 13, 12, 2, -34 },
  { 601, 13, 42, 16, 2, -35 },
  { 670, 14, 42, 16, 0, -35 },
  { 744, 22, 22, 23, 1, -36 },
  { 805, 21, 23, 25, 2, -28 },
  { 866, 10, 14, 13, 1, -7 },
  { 884, 13, 7, 15, 1, -16 },
  { 896, 9, 9, 13, 2, -8 },
  { 907, 20, 34, 20, 0, -34 },
  { 992, 21, 34, 25, 2, -34 },
  { 1082, 18, 34, 25, 2, -34 },
  { 1159, 21, 34, 25, 1, -34 },
  { 1249, 22, 34, 25, 1, -34 },
  { 1343, 23, 34, 25, 1, -34 },
  { 1441, 20, 34, 25, 2, -34 },
  { 1526, 21, 34, 25, 2, -34 },
  { 1616, 21, 34, 25, 2, -34 },
  { 1706, 22, 34, 25, 1, -34 },
  { 1800, 22, 34, 25, 1, -34 },
  { 1894, 9, 27, 13, 2, -26 },
  { 1925, 10, 33, 13, 1, -26 },
  { 1967, 21, 24, 25, 2, -29 },
  { 2030, 21, 17, 25, 2, -25 },
  { 2075, 21, 24, 25, 2, -29 },
  { 2138, 20, 35, 20, 0, -34 },
  { 2226, 34, 38, 38, 2, -34 },
  { 2388, 29, 34, 29, 0, -34 },
  { 2512, 23, 34, 28, 3, -34 },
  { 2610, 23, 34, 26, 2, -34 },
  { 2708, 25, 34, 30, 3, -34 },
  { 2815, 17, 34, 22, 3, -34 },
  { 2888, 17, 34, 22, 3, -34 },
  { 2961, 25, 34, 30, 2, -34 },
  { 3068, 25, 34, 31, 3, -34 },
  { 3175, 16, 34, 18, 1, -34 },
  { 3243, 14, 45, 15, -3, -34 },
  { 3322, 25, 34, 28, 3, -34 },
  { 3429, 18, 34, 22, 3, -34 },
  { 3506, 34, 34, 40, 3, -34 },
  { 3651, 27, 34, 33, 3, -34 },
  { 3766, 28, 34, 32, 2, -34 },
  { 3885, 22, 34, 26, 3, -34 },
  { 3979, 28, 42, 32, 2, -34 },
  { 4126, 25, 34, 28, 3, -34 },
  { 4233, 20, 34, 23, 2, -34 },
  { 4318, 22, 34, 23, 1, -34 },
  { 4412, 24, 34, 30, 3, -34 },
  { 4514, 28, 34, 28, 0, -34 },
  { 4633, 41, 34, 41, 0, -34 },
  { 4808, 27, 34, 27, 0, -34 },
  { 4923, 27, 34, 27, 0, -34 },
  { 5038, 22, 34, 24, 1, -34 },
  { 5132, 12, 43, 15, 2, -35 },
  { 5197, 20, 34, 20, 0, -34 },
  { 5282, 11, 43, 15, 1, -35 },
  { 5342, 25, 23, 25, 0, -34 },
  { 5414, 24, 6, 24, 0, 3 },
  { 5432, 13, 8, 17, 2, -36 },
  { 5445, 22, 26, 25, 1, -26 },
  { 5517, 22, 36, 26, 3, -36 },
  { 5616, 19, 26, 22, 2, -26 },
  { 5678, 22, 36, 26, 2, -36 },
  { 5777, 21, 26, 25, 2, -26 },
  { 5846, 17, 36, 17, 1, -36 },
  { 5923, 22, 37, 26, 2, -26 },
  { 6025, 21, 36, 27, 3, -36 },
  { 6120, 9, 36, 13, 2, -36 },
  { 6161, 13, 47, 13, -2, -36 },
  { 6238, 24, 36, 26, 3, -36 },
  { 6346, 8, 36, 13, 3, -36 },
  { 6382, 35, 26, 40, 3, -26 },
  { 6496, 21, 26, 27, 3, -26 },
  { 6565, 22, 26, 26, 2, -26 },
  { 6637, 22, 37, 26, 3, -26 },
  { 6739, 22, 37, 26, 2, -26 },
  { 6841, 16, 26, 19, 3, -26 },
  { 6893, 18, 26, 20, 1, -26 },
  { 6952, 16, 31, 18, 1, -31 },
  { 7014, 21, 26, 27, 3, -26 },
  { 7083, 25, 26, 25, 0, -26 },
  { 7165, 37, 26, 37, 0, -26 },
  { 7286, 24, 26, 24, 0, -26 },
  { 7364, 25, 37, 25, 0, -26 },
  { 7480, 18, 26, 20, 1, -26 },
  { 7539, 16, 42, 18, 1, -34 },
  { 7623, 7, 47, 21, 7, -36 },
  { 7665, 16, 42, 18, 1, -34 },
  { 7749, 21, 9, 25, 2, -21 },
};

const GFXfont NotoSans_Condensed_Black47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_BLACK47PT7B_H_
