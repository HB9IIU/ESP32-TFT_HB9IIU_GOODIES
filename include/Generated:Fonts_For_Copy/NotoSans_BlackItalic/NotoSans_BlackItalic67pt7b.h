#ifndef _NOTOSANS_BLACKITALIC67PT7B_H_
#define _NOTOSANS_BLACKITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFC,
  0x7F, 0xF3, 0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC7, 0xFE,
  0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x9F, 0x0F, 0xC0, 0xFF, 0xF3, 0xF0, 0x18, 0x0F, 0xFF,
  0x3F, 0x00, 0x00, 0xFF, 0xF3, 0xE0, 0x00, 0x0F, 0xFF, 0x3E, 0x00, 0x00,
  0xFF, 0xF3, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x03, 0xF3, 0xFF, 0x80,
  0x00, 0x3F, 0x3F, 0xF8, 0xC0, 0x03, 0xE3, 0xFF, 0x8F, 0x00, 0x3E, 0x3F,
  0xF8, 0xFF, 0x03, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x83, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x07,
  0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0x7F, 0xF1, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xE3, 0xFF, 0x8F, 0xFC, 0x00, 0x80, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x60, 0x0F,
  0xF8, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x17, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xF0,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFD, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0xFE, 0x1F, 0xF8, 0x00, 0x3E, 0x0F, 0xFC, 0x00, 0x07, 0x03, 0xFF,
  0x00, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x03, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01,
  0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xF7, 0xFF,
  0xC0, 0x1F, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0xFE,
  0x7F, 0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xF8, 0x03,
  0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF,
  0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFC,
  0xFF, 0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F,
  0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF8, 0x3F, 0xF1, 0xFF,
  0xE0, 0x7F, 0x0F, 0xFF, 0x81, 0xF8, 0x3F, 0xFE, 0x03, 0x80, 0xFF, 0xF0,
  0x04, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xFF,
  0xE0, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x02,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x03, 0xFF, 0xF0, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC8, 0x00, 0x00, 0x7F, 0xFE, 0x70,
  0x00, 0x07, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFC, 0x7F,
  0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x20, 0x00,
  0x03, 0xFF, 0xE0, 0xC0, 0x00, 0x1F, 0xFF, 0x83, 0xE0, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC1,
  0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F,
  0xFB, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0x8F, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xEF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x8F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x07, 0xFF,
  0xDF, 0xFF, 0x81, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xF0, 0x0F,
  0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0x80,
  0x7F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF,
  0x03, 0xFF, 0xF7, 0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFD, 0xFF,
  0xE0, 0xFF, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x08, 0x00,
  0x7F, 0xFF, 0x83, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7,
  0xF0, 0x1F, 0xFF, 0x1E, 0x00, 0x7F, 0xFC, 0x20, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xF0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF9, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xF3, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xFC, 0x1F, 0xE0, 0x7F, 0xDF, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xEF, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xDF, 0xE0, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xBF, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x7F,
  0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF9, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF8, 0xFF,
  0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xBF, 0xFE,
  0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x80, 0x1F,
  0xFF, 0xC0, 0x01, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x0C, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xE3,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x4F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x80, 0x1F,
  0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7,
  0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xBF,
  0xE0, 0x3F, 0xE7, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0xF0,
  0x07, 0xFF, 0xBF, 0xE0, 0x7F, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFE, 0x0F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xE0, 0xFF, 0x8F, 0xFE, 0x00, 0x7F,
  0xF3, 0xFE, 0x1F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xE1, 0xFF, 0x1F,
  0xFE, 0x00, 0xFF, 0xF3, 0xFE, 0x3F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F,
  0xE3, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFE, 0x3F, 0xE3, 0xFF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xE7, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFE, 0x7F,
  0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xEF, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0xE3, 0xFE, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xDF, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF3,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF3, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF1,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF3, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x10, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x08, 0x00, 0x03,
  0xFF, 0xE0, 0xE0, 0x00, 0x3F, 0xFE, 0x0F, 0x80, 0x07, 0xFF, 0xE0, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x07,
  0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x03, 0xFF, 0xF3,
  0xFF, 0xE0, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xF0,
  0x07, 0xFF, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFD,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x7F, 0xE7, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xCF,
  0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0xC7, 0xFE, 0x3F, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xF8, 0xFF,
  0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x00, 0x0F,
  0xFE, 0x7F, 0xE3, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x87, 0xFE,
  0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F,
  0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xF8, 0x3F, 0xF7,
  0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF9, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x00,
  0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x7F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x7F,
  0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x78, 0x00, 0x07, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xFC, 0xFF,
  0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF,
  0xE0, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x87, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0,
  0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xF8, 0x07, 0xFE, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xF0, 0x3F, 0xFF, 0x80, 0x30,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xC0,
  0xFF, 0xFC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0x3F,
  0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFD,
  0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x83, 0xFF, 0xE0, 0x00, 0xE0, 0xFF, 0xFC, 0x00, 0xF8, 0x3F,
  0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC6, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0xE0, 0x07, 0xFF,
  0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFD,
  0xFF, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x03, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x1F, 0xFF, 0x3F,
  0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x41, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xBF,
  0xFE, 0x00, 0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFE,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x00, 0x7F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x7F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0xF0,
  0x07, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x9F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0xFC,
  0x07, 0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F,
  0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xF8,
  0x0F, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F,
  0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xDF, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x7F, 0xE0,
  0x1F, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF,
  0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xFC,
  0x00, 0x03, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xFF, 0x83, 0xFC, 0x07,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F,
  0xF7, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE3, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xF0, 0x3F, 0xFC,
  0x01, 0xC0, 0x7F, 0xF8, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE2,
  0x00, 0x07, 0xFF, 0xC6, 0x00, 0x0F, 0xFF, 0x8F, 0x80, 0x1F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x30, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xBF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xE3,
  0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFD, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x3F, 0xFE, 0x3F,
  0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x0F,
  0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xFC,
  0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xBF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x7F, 0xC7, 0xFF,
  0x80, 0x7F, 0xF1, 0xFF, 0x7F, 0xC7, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0x7F,
  0xCF, 0xFF, 0x00, 0x7F, 0xF1, 0xFE, 0x7F, 0xCF, 0xFF, 0x00, 0x7F, 0xF3,
  0xFE, 0x7F, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFE, 0x7F, 0xDF, 0xFE, 0x00,
  0x3F, 0xF7, 0xFC, 0x7F, 0x9F, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x7F, 0x9F,
  0xFC, 0x00, 0x3F, 0xF7, 0xF8, 0x7F, 0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xF8,
  0x7F, 0xBF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xBF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xBF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC7, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00,
  0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x83,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x8F, 0xFF,
  0x80, 0x00, 0xDF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xD8, 0x00, 0x07, 0xFF, 0x88, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_BlackItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 23, 49, 20, 0, -48 },
  { 142, 28, 17, 30, 6, -48 },
  { 202, 44, 48, 43, 0, -48 },
  { 466, 36, 55, 39, 2, -51 },
  { 714, 57, 50, 62, 4, -49 },
  { 1071, 49, 50, 49, 0, -49 },
  { 1378, 14, 17, 16, 6, -48 },
  { 1408, 28, 60, 25, 2, -49 },
  { 1618, 27, 60, 25, -4, -49 },
  { 1821, 33, 33, 36, 5, -51 },
  { 1958, 33, 33, 39, 3, -40 },
  { 2095, 17, 17, 21, -3, -8 },
  { 2132, 20, 10, 22, 1, -23 },
  { 2157, 14, 13, 21, 0, -12 },
  { 2180, 39, 50, 31, -3, -49 },
  { 2424, 36, 50, 39, 2, -49 },
  { 2649, 30, 48, 39, 5, -48 },
  { 2829, 39, 49, 39, -2, -49 },
  { 3068, 37, 50, 39, 0, -49 },
  { 3300, 38, 48, 39, 0, -48 },
  { 3528, 38, 49, 39, 1, -48 },
  { 3761, 36, 50, 39, 3, -49 },
  { 3986, 41, 48, 39, 1, -48 },
  { 4232, 36, 50, 39, 2, -49 },
  { 4457, 34, 50, 39, 3, -49 },
  { 4670, 20, 39, 21, 0, -38 },
  { 4768, 24, 47, 21, -4, -38 },
  { 4909, 33, 37, 39, 3, -43 },
  { 5062, 33, 23, 39, 3, -35 },
  { 5157, 33, 37, 39, 3, -43 },
  { 5310, 30, 50, 33, 5, -49 },
  { 5498, 55, 55, 60, 3, -49 },
  { 5877, 45, 48, 45, -4, -48 },
  { 6147, 41, 48, 42, 1, -48 },
  { 6393, 42, 50, 42, 3, -49 },
  { 6656, 43, 48, 46, 1, -48 },
  { 6914, 39, 48, 38, 1, -48 },
  { 7148, 38, 48, 38, 1, -48 },
  { 7376, 43, 50, 47, 3, -49 },
  { 7645, 47, 48, 48, 1, -48 },
  { 7927, 34, 48, 29, -2, -48 },
  { 8131, 36, 63, 25, -11, -48 },
  { 8415, 49, 48, 45, 1, -48 },
  { 8709, 31, 48, 35, 1, -48 },
  { 8895, 60, 48, 61, 1, -48 },
  { 9255, 52, 48, 53, 1, -48 },
  { 9567, 44, 50, 49, 3, -49 },
  { 9842, 40, 48, 42, 1, -48 },
  { 10082, 44, 60, 49, 3, -49 },
  { 10412, 40, 48, 44, 1, -48 },
  { 10652, 36, 50, 37, 1, -49 },
  { 10877, 36, 48, 37, 5, -48 },
  { 11093, 43, 49, 47, 4, -48 },
  { 11357, 41, 48, 41, 5, -48 },
  { 11603, 63, 48, 63, 5, -48 },
  { 11981, 53, 48, 44, -4, -48 },
  { 12299, 41, 48, 40, 5, -48 },
  { 12545, 43, 48, 36, -3, -48 },
  { 12803, 30, 60, 24, -2, -49 },
  { 13028, 18, 50, 31, 7, -49 },
  { 13141, 30, 60, 24, -4, -49 },
  { 13366, 35, 32, 36, 0, -48 },
  { 13506, 32, 8, 30, -6, 4 },
  { 13538, 16, 10, 24, 10, -51 },
  { 13558, 37, 39, 41, 3, -38 },
  { 13739, 37, 52, 41, 1, -51 },
  { 13980, 32, 39, 34, 3, -38 },
  { 14136, 40, 52, 40, 3, -51 },
  { 14396, 34, 39, 39, 3, -38 },
  { 14562, 41, 67, 27, -7, -51 },
  { 14906, 39, 54, 41, 1, -38 },
  { 15170, 38, 51, 42, 1, -51 },
  { 15413, 23, 52, 22, 1, -52 },
  { 15563, 33, 68, 22, -9, -52 },
  { 15844, 44, 51, 41, 1, -51 },
  { 16125, 23, 51, 22, 1, -51 },
  { 16272, 58, 38, 62, 1, -38 },
  { 16548, 38, 38, 42, 1, -38 },
  { 16729, 35, 39, 41, 3, -38 },
  { 16900, 41, 54, 41, -3, -38 },
  { 17177, 37, 54, 41, 3, -38 },
  { 17427, 31, 38, 29, 1, -38 },
  { 17575, 31, 39, 34, 1, -38 },
  { 17727, 29, 45, 31, 2, -44 },
  { 17891, 38, 38, 42, 3, -37 },
  { 18072, 37, 37, 36, 3, -37 },
  { 18244, 56, 37, 55, 3, -37 },
  { 18503, 46, 37, 38, -4, -37 },
  { 18716, 44, 53, 36, -4, -37 },
  { 19008, 35, 37, 33, -1, -37 },
  { 19170, 30, 59, 24, -1, -48 },
  { 19392, 9, 66, 38, 14, -51 },
  { 19467, 28, 59, 24, -4, -48 },
  { 19674, 33, 13, 39, 3, -30 },
};

const GFXfont NotoSans_BlackItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_BLACKITALIC67PT7B_H_
