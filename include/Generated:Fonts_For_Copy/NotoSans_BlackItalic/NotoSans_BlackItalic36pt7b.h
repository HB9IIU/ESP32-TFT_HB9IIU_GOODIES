#ifndef _NOTOSANS_BLACKITALIC36PT7B_H_
#define _NOTOSANS_BLACKITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x07, 0xC0, 0x7E, 0x7E, 0xFC, 0xFD, 0xF9, 0xFB, 0xF3, 0xE7,
  0xC7, 0xCF, 0x9F, 0x9F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF1, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x03,
  0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x8F, 0x00, 0x0F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFB,
  0x8C, 0x3F, 0xB8, 0x03, 0xFB, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0E, 0xFC, 0x00, 0xEF, 0xCC, 0x0C, 0xFC, 0xF9, 0xDF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0xE0,
  0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0x01, 0xFF, 0xC0, 0x7C, 0x07, 0xEF, 0x81,
  0xF0, 0x0F, 0x9F, 0x07, 0xE0, 0x3F, 0x3E, 0x0F, 0x80, 0x7C, 0x7C, 0x3E,
  0x00, 0xF8, 0xF8, 0xF8, 0x01, 0xF1, 0xF3, 0xF0, 0x03, 0xE7, 0xE7, 0xC7,
  0x87, 0xCF, 0x9F, 0x3F, 0xCF, 0xFF, 0x7C, 0xFF, 0xCF, 0xFD, 0xFB, 0xFF,
  0x9F, 0xF3, 0xE7, 0xFF, 0x0F, 0xCF, 0x9F, 0x9F, 0x00, 0x3E, 0x3E, 0x3E,
  0x00, 0xFC, 0x7C, 0x7C, 0x01, 0xF1, 0xF9, 0xF0, 0x07, 0xC3, 0xE3, 0xE0,
  0x1F, 0x07, 0xC7, 0xC0, 0x7E, 0x0F, 0xDF, 0x80, 0xF8, 0x0F, 0xFE, 0x03,
  0xE0, 0x1F, 0xFC, 0x0F, 0x80, 0x3F, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xC7, 0xFF, 0x87, 0xF3, 0xFF, 0xF3, 0xF9,
  0xFF, 0xFC, 0xFE, 0x7F, 0x3F, 0xFF, 0x3F, 0x8F, 0xFF, 0xCF, 0xE1, 0xFF,
  0xE3, 0xF8, 0x3F, 0xF0, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x3F, 0xC0,
  0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x06, 0x1F, 0x03, 0xCF, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE3, 0xFE, 0xF3, 0xFF, 0x03, 0xF7, 0xC3, 0xFB,
  0xE0, 0x79, 0xF8, 0x08, 0x7C, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0xC7, 0xE3,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x00, 0x7F, 0xEF, 0xFD,
  0xFF, 0xBF, 0xEF, 0xFC, 0x7E, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xF3, 0xF9,
  0xFC, 0x7F, 0x3F, 0x8F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xDF,
  0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x1F, 0xCF, 0xE7, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFE, 0xFC, 0x79, 0xFC, 0x31, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x0F, 0xE0, 0x20, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7D,
  0xFF, 0x02, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE8, 0x01, 0xFE,
  0xF0, 0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF, 0xC1,
  0xF9, 0xFC, 0x3F, 0x1F, 0x83, 0xE1, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF9, 0x00, 0x3F,
  0x8F, 0x07, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xC6, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x9F, 0xCF, 0xF1, 0xFC, 0xFE, 0x0F, 0xCF,
  0xE1, 0xFC, 0xFE, 0x1F, 0xC7, 0xE1, 0xFC, 0x7F, 0x3F, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0xCF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFD, 0xFC, 0x7F, 0x1F, 0x9F,
  0xC3, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xEF, 0xEF, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0x7E, 0x3F, 0xBF, 0x81,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x83, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFE, 0x1F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC1,
  0xFF, 0x80, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x7E, 0xFF, 0x20,
  0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0xFE, 0x1F, 0x3E, 0x0F, 0xFE,
  0x7C, 0xF8, 0x7F, 0xF9, 0xF7, 0xC3, 0xFF, 0xC3, 0xDF, 0x1F, 0x8F, 0x0F,
  0x7C, 0xFC, 0x7C, 0x3D, 0xE3, 0xE1, 0xF1, 0xF7, 0x8F, 0x87, 0x87, 0xFE,
  0x3E, 0x3E, 0x1F, 0xF8, 0xF0, 0xF8, 0xFB, 0xE3, 0xE3, 0xE3, 0xEF, 0x8F,
  0xFF, 0xFF, 0x1E, 0x3F, 0xFF, 0xF8, 0x7C, 0x7F, 0xFF, 0xC1, 0xF1, 0xF8,
  0xFE, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x38,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x7F, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x7E, 0x00, 0xFC,
  0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0xF3, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF3, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFE, 0x07, 0x0F, 0xF0, 0x04, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x20, 0xFF, 0xCF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFC,
  0x1F, 0xE3, 0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0xF8, 0x06, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xEF, 0xE1, 0xFF, 0x9F, 0xC7, 0xFF,
  0x3F, 0x8F, 0xFE, 0x7F, 0x1F, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xFC, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F,
  0xC1, 0xFC, 0x1F, 0xE0, 0x7E, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3,
  0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x1F,
  0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x03,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3E, 0xFC, 0x1F, 0xFC, 0x3E, 0xFC, 0x1F, 0xFC,
  0x7F, 0xFC, 0x3F, 0x7C, 0x7D, 0xF8, 0x3F, 0x7C, 0x7D, 0xF8, 0x3F, 0x7C,
  0xF9, 0xF8, 0x3F, 0x7C, 0xFB, 0xF8, 0x3F, 0x7D, 0xF3, 0xF0, 0x7E, 0x7D,
  0xF3, 0xF0, 0x7E, 0x7F, 0xE3, 0xF0, 0x7E, 0x7F, 0xE3, 0xF0, 0x7E, 0x7F,
  0xC7, 0xF0, 0x7E, 0x7F, 0xC7, 0xE0, 0xFC, 0x7F, 0x87, 0xE0, 0xFC, 0x7F,
  0x87, 0xE0, 0xFC, 0x7F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xE0, 0x07, 0xF8,
  0x07, 0xF0, 0x7F, 0x80, 0x7E, 0x07, 0xFC, 0x07, 0xE0, 0xFF, 0xC0, 0x7E,
  0x0F, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0xFE, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF,
  0xE0, 0xFC, 0x1F, 0xFE, 0x0F, 0xC1, 0xFB, 0xF0, 0xFC, 0x1F, 0xBF, 0x1F,
  0x81, 0xFB, 0xF1, 0xF8, 0x3F, 0x3F, 0x9F, 0x83, 0xF1, 0xF9, 0xF8, 0x3F,
  0x1F, 0x9F, 0x83, 0xF1, 0xFB, 0xF0, 0x3F, 0x0F, 0xFF, 0x07, 0xF0, 0xFF,
  0xF0, 0x7E, 0x0F, 0xFF, 0x07, 0xE0, 0xFF, 0xF0, 0x7E, 0x07, 0xFE, 0x07,
  0xE0, 0x7F, 0xE0, 0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x7F, 0xE0, 0xFC, 0x03,
  0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xF8,
  0x7F, 0x9F, 0xE0, 0x7F, 0x7F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7,
  0xF8, 0x3F, 0xCF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0x9F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1,
  0xFE, 0x3F, 0x9F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xF8,
  0x7F, 0x9F, 0xE0, 0x7F, 0x7F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7,
  0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xF3, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xE0, 0x61, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x60, 0x3F, 0x8F, 0x8F, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F,
  0xFB, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xC0, 0xFE, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0x01, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7F, 0x03, 0xFB, 0xF0, 0x3F, 0xC0, 0xFC, 0xFC, 0x0F,
  0xF0, 0x7F, 0x3F, 0x03, 0xFC, 0x1F, 0x8F, 0xC1, 0xFF, 0x0F, 0xE3, 0xF0,
  0x7F, 0xC3, 0xF8, 0xFC, 0x3F, 0xF0, 0xFC, 0x3F, 0x0F, 0xFC, 0x7F, 0x0F,
  0xC7, 0xDF, 0x1F, 0x83, 0xF1, 0xF7, 0xCF, 0xE0, 0xFC, 0xFD, 0xF3, 0xF0,
  0x3F, 0x3E, 0xFC, 0xFC, 0x0F, 0xCF, 0xBF, 0x7F, 0x03, 0xF7, 0xEF, 0xDF,
  0x80, 0xFD, 0xF3, 0xF7, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F,
  0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF,
  0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xEF, 0xE0, 0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x03,
  0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x7F, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xEF,
  0x00, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1,
  0xF0, 0x7C, 0x03, 0xF1, 0xF0, 0x7F, 0xBF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xF1,
  0xFC, 0x7F, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xDF, 0x81, 0xF9, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xE7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF3, 0xF8,
  0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0xFF, 0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xDF, 0xF0, 0xFC, 0xFE, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xF0, 0xC3, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x87, 0xF0, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0xFC, 0x07, 0xFB, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x87,
  0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xC1, 0xFC, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0x7E, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0xFE,
  0x7F, 0x0F, 0xCF, 0xE3, 0xFB, 0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x1F, 0xEF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xF3, 0xF8, 0x7F, 0x1F,
  0xC7, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E,
  0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xBF, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC3, 0x01, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFD, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFE, 0x7F, 0x8F, 0xF1, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x3F, 0x87, 0xF0, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x0F, 0xE1, 0xFE, 0x0F,
  0xE3, 0xFC, 0x0F, 0xE7, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0xCF, 0xE0, 0x1F,
  0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0x3F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xCF, 0xE1, 0xFC, 0x0F, 0xDF, 0xF3, 0xFE, 0x0F, 0xFF, 0xF7,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xE7, 0xFC,
  0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0xCF, 0xC0,
  0x7E, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFB,
  0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF1, 0xFC,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0x9F, 0xCF, 0xE3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF,
  0xE1, 0xFD, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x9F,
  0xCF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x3F, 0x7F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xDF, 0xE0, 0xFE, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x7F, 0xBF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F,
  0xE7, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0,
  0xFC, 0xFE, 0x1F, 0xCF, 0xF1, 0xFC, 0x7F, 0x3F, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFB, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xCF, 0x87, 0xEF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xC4, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F,
  0x9E, 0x7F, 0x06, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x80, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x10, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0x87, 0xF3, 0xF8, 0x7F,
  0x3F, 0x87, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFD, 0xF0, 0x7F, 0xBF, 0x03, 0xF3, 0xF0, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFC,
  0x1F, 0xC1, 0xFF, 0xF0, 0xFF, 0x0F, 0xEF, 0xC3, 0xFC, 0x3F, 0xBF, 0x0F,
  0xF1, 0xFC, 0xFC, 0x7F, 0xC7, 0xF3, 0xF1, 0xFF, 0x1F, 0x8F, 0xC7, 0xFC,
  0xFE, 0x3F, 0x3F, 0xF3, 0xF0, 0xFC, 0xF7, 0xDF, 0xC3, 0xF7, 0xDF, 0x7E,
  0x0F, 0xDF, 0x7D, 0xF8, 0x3F, 0x79, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x01,
  0xFF, 0x9E, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F,
  0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x83, 0xF8, 0x7F, 0x81, 0xFE, 0x7F, 0x80,
  0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE1,
  0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x0F, 0xC0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F,
  0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x07,
  0xEF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x70, 0x00, 0x7F, 0x00,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00,
  0x70,
};

const GFXglyph NotoSans_BlackItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 26, 11, 0, -26 },
  { 40, 15, 10, 16, 3, -26 },
  { 59, 24, 26, 23, 0, -26 },
  { 137, 20, 29, 21, 1, -27 },
  { 210, 31, 26, 33, 2, -26 },
  { 311, 26, 26, 26, 0, -26 },
  { 396, 7, 10, 9, 3, -26 },
  { 405, 15, 32, 13, 1, -26 },
  { 465, 14, 32, 13, -2, -26 },
  { 521, 17, 18, 20, 3, -28 },
  { 560, 17, 17, 21, 2, -21 },
  { 597, 10, 9, 11, -2, -4 },
  { 609, 11, 5, 12, 0, -12 },
  { 616, 7, 6, 11, 0, -6 },
  { 622, 21, 26, 17, -2, -26 },
  { 691, 19, 26, 21, 1, -26 },
  { 753, 16, 26, 21, 3, -26 },
  { 805, 21, 26, 21, -1, -26 },
  { 874, 20, 26, 21, 0, -26 },
  { 939, 20, 26, 21, 0, -26 },
  { 1004, 21, 26, 21, 0, -26 },
  { 1073, 20, 26, 21, 1, -26 },
  { 1138, 21, 26, 21, 1, -26 },
  { 1207, 19, 26, 21, 1, -26 },
  { 1269, 18, 26, 21, 2, -26 },
  { 1328, 11, 20, 11, 0, -20 },
  { 1356, 13, 25, 11, -2, -20 },
  { 1397, 17, 20, 21, 2, -23 },
  { 1440, 17, 13, 21, 2, -19 },
  { 1468, 17, 20, 21, 2, -23 },
  { 1511, 16, 26, 18, 3, -26 },
  { 1563, 30, 29, 32, 1, -26 },
  { 1672, 24, 26, 24, -2, -26 },
  { 1750, 21, 26, 23, 1, -26 },
  { 1819, 22, 26, 23, 2, -26 },
  { 1891, 23, 26, 25, 1, -26 },
  { 1966, 20, 26, 20, 1, -26 },
  { 2031, 20, 26, 20, 1, -26 },
  { 2096, 23, 26, 25, 2, -26 },
  { 2171, 25, 26, 26, 1, -26 },
  { 2253, 18, 26, 15, -1, -26 },
  { 2312, 20, 34, 13, -6, -26 },
  { 2397, 26, 26, 24, 1, -26 },
  { 2482, 16, 26, 19, 1, -26 },
  { 2534, 32, 26, 33, 1, -26 },
  { 2638, 28, 26, 28, 1, -26 },
  { 2729, 23, 26, 27, 2, -26 },
  { 2804, 21, 26, 22, 1, -26 },
  { 2873, 23, 32, 27, 2, -26 },
  { 2965, 21, 26, 23, 1, -26 },
  { 3034, 19, 26, 20, 1, -26 },
  { 3096, 19, 26, 20, 3, -26 },
  { 3158, 23, 26, 25, 2, -26 },
  { 3233, 22, 26, 22, 3, -26 },
  { 3305, 34, 26, 34, 3, -26 },
  { 3416, 29, 26, 24, -2, -26 },
  { 3511, 22, 26, 22, 3, -26 },
  { 3583, 23, 26, 19, -2, -26 },
  { 3658, 16, 32, 13, -1, -26 },
  { 3722, 10, 26, 17, 4, -26 },
  { 3755, 16, 32, 13, -2, -26 },
  { 3819, 19, 17, 19, 0, -26 },
  { 3860, 17, 5, 16, -3, 2 },
  { 3871, 9, 6, 13, 5, -28 },
  { 3878, 20, 20, 22, 1, -20 },
  { 3928, 20, 27, 22, 0, -27 },
  { 3996, 18, 20, 18, 1, -20 },
  { 4041, 22, 27, 22, 1, -27 },
  { 4116, 19, 20, 21, 1, -20 },
  { 4164, 22, 37, 15, -4, -28 },
  { 4266, 21, 29, 22, 0, -20 },
  { 4343, 21, 27, 22, 0, -27 },
  { 4414, 13, 28, 12, 0, -28 },
  { 4460, 18, 37, 12, -5, -28 },
  { 4544, 24, 27, 22, 0, -27 },
  { 4625, 13, 27, 12, 0, -27 },
  { 4669, 32, 20, 33, 0, -20 },
  { 4749, 21, 20, 22, 0, -20 },
  { 4802, 19, 20, 22, 1, -20 },
  { 4850, 21, 29, 22, -1, -20 },
  { 4927, 20, 29, 22, 1, -20 },
  { 5000, 17, 20, 16, 0, -20 },
  { 5043, 16, 20, 18, 1, -20 },
  { 5083, 16, 24, 16, 1, -24 },
  { 5131, 20, 20, 22, 2, -20 },
  { 5181, 20, 20, 20, 2, -20 },
  { 5231, 30, 20, 30, 2, -20 },
  { 5306, 25, 20, 20, -2, -20 },
  { 5369, 24, 29, 20, -2, -20 },
  { 5456, 19, 20, 17, -1, -20 },
  { 5504, 16, 32, 13, 0, -26 },
  { 5568, 5, 35, 20, 8, -27 },
  { 5590, 15, 32, 13, -2, -26 },
  { 5650, 17, 7, 21, 2, -16 },
};

const GFXfont NotoSans_BlackItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_BLACKITALIC36PT7B_H_
