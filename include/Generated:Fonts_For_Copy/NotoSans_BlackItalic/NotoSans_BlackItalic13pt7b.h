#ifndef _NOTOSANS_BLACKITALIC13PT7B_H_
#define _NOTOSANS_BLACKITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x76, 0x66, 0x0E, 0xE0, 0x7F, 0x6D, 0x80, 0x1B, 0x0D, 0x1F,
  0xEF, 0xF3, 0x67, 0xFB, 0xFC, 0xD8, 0x68, 0x00, 0x04, 0x7D, 0xFB, 0x47,
  0x87, 0x87, 0xEB, 0xFC, 0x60, 0x80, 0x71, 0xDB, 0x63, 0x4C, 0x7B, 0x6F,
  0xDE, 0x36, 0xC6, 0xD9, 0x9E, 0x63, 0xC0, 0x3E, 0x1B, 0x0D, 0x87, 0xC7,
  0x9F, 0xFF, 0xBD, 0xFE, 0x7F, 0x80, 0x7B, 0x00, 0x0C, 0x63, 0x1C, 0x61,
  0x86, 0x38, 0xE1, 0x86, 0x18, 0x10, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0x9D,
  0xC0, 0x1A, 0x4F, 0xCF, 0xF9, 0x61, 0x00, 0x30, 0xC3, 0x3F, 0x30, 0xC3,
  0x00, 0x36, 0x6C, 0xFF, 0xFC, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30,
  0x70, 0xE0, 0x3E, 0xFD, 0xDB, 0x36, 0x7D, 0xFB, 0xBE, 0x78, 0x1D, 0xEF,
  0x96, 0x38, 0xE3, 0x0C, 0x70, 0x3E, 0xFC, 0x98, 0x71, 0xC7, 0x1C, 0x7E,
  0xFC, 0x7E, 0x7C, 0x19, 0xE3, 0xC1, 0xC3, 0xFE, 0xF8, 0x0E, 0x1C, 0x79,
  0xF6, 0xDF, 0xFF, 0x8E, 0x1C, 0x3E, 0x7C, 0xC3, 0xE7, 0xE1, 0xC3, 0xFE,
  0xF8, 0x1F, 0x3E, 0x70, 0x7E, 0x7E, 0xE6, 0x6E, 0x7C, 0x3C, 0x7F, 0x7F,
  0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x3E, 0x6D, 0xD9, 0xF3, 0xCD,
  0xFB, 0xFF, 0x7C, 0x7B, 0xFC, 0xF3, 0xFF, 0xB1, 0xBE, 0xF0, 0x77, 0x00,
  0x0E, 0xE0, 0x39, 0xC0, 0x00, 0x39, 0x8C, 0xC0, 0x0C, 0xFF, 0x30, 0x78,
  0x70, 0x40, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x83, 0x87, 0x7B, 0x88, 0x00,
  0xFB, 0xF1, 0xCE, 0x71, 0x80, 0x38, 0xC0, 0x3F, 0x98, 0x7C, 0xFF, 0x69,
  0xB2, 0x6D, 0xBB, 0xFB, 0x6C, 0xE2, 0x1F, 0x80, 0x07, 0x07, 0x83, 0xC3,
  0x61, 0xB9, 0xFC, 0xFE, 0xC7, 0xE3, 0x80, 0x3F, 0x3F, 0x37, 0x7E, 0x7E,
  0x66, 0x66, 0x7E, 0xFC, 0x3F, 0x7E, 0xE0, 0xC0, 0xC0, 0xC0, 0xC4, 0xFC,
  0x7C, 0x3E, 0x3F, 0x33, 0x73, 0x73, 0x63, 0x67, 0x7E, 0xFC, 0x3F, 0x3E,
  0x30, 0x7E, 0x7C, 0x60, 0x60, 0x7C, 0xFC, 0x3F, 0x3E, 0x30, 0x7E, 0x7C,
  0x7C, 0x60, 0x60, 0xE0, 0x3F, 0x7E, 0xE0, 0xE1, 0xDE, 0xDE, 0xCE, 0xFE,
  0x7C, 0x39, 0x99, 0xCC, 0xEF, 0xF7, 0xF3, 0x19, 0x9C, 0xCE, 0xE6, 0x00,
  0x7C, 0xE3, 0x8C, 0x31, 0xC7, 0x3E, 0xF0, 0x0E, 0x1C, 0x30, 0x61, 0xC3,
  0x86, 0x0C, 0x18, 0x73, 0xC7, 0x00, 0x3B, 0xCD, 0xC3, 0x61, 0xF8, 0x7C,
  0x1F, 0x86, 0xE1, 0x98, 0xE7, 0x00, 0x38, 0xC3, 0x1C, 0x71, 0x86, 0x1F,
  0xFC, 0x38, 0xF3, 0x8E, 0x39, 0xE6, 0x9E, 0x6B, 0x66, 0xBE, 0x6E, 0xC6,
  0xEC, 0xEC, 0xC0, 0x38, 0xCF, 0x33, 0xCD, 0xB7, 0x6D, 0x99, 0xE6, 0x79,
  0x9E, 0xE7, 0x00, 0x3E, 0x7F, 0xE3, 0xE3, 0xC3, 0xC7, 0xC6, 0xFE, 0x7C,
  0x3E, 0x3F, 0x37, 0x77, 0x7E, 0x7C, 0x60, 0x60, 0xE0, 0x3E, 0x7F, 0xE3,
  0xE3, 0xC3, 0xC7, 0xC6, 0xFE, 0x7C, 0x1C, 0x0E, 0x3E, 0x3F, 0x37, 0x77,
  0x7E, 0x7C, 0x6E, 0x66, 0xE7, 0x3E, 0xFD, 0xC3, 0xC3, 0xC3, 0xA3, 0x7E,
  0xF8, 0xFF, 0xFC, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0xE0, 0x73, 0x67, 0x67,
  0xE6, 0xE6, 0xCE, 0xCE, 0xFC, 0x78, 0xC7, 0xC6, 0xCE, 0xEC, 0xFC, 0xF8,
  0xD8, 0x70, 0x70, 0xC6, 0x7C, 0xE6, 0xCE, 0x6D, 0xEE, 0xDE, 0xCD, 0xEC,
  0xF7, 0x8F, 0x78, 0xE7, 0x00, 0x39, 0xE3, 0x30, 0x7E, 0x07, 0x81, 0xE0,
  0x3E, 0x0F, 0xC3, 0x98, 0xE3, 0x80, 0xE7, 0x6E, 0x6C, 0x78, 0x78, 0x30,
  0x70, 0x70, 0x60, 0x3F, 0x9F, 0x81, 0x81, 0xC1, 0xC1, 0xC1, 0xC0, 0xFC,
  0xFE, 0x00, 0x3C, 0xE3, 0x0C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x38, 0xE6,
  0x66, 0x66, 0x73, 0x30, 0x1C, 0xF0, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3,
  0x3C, 0x18, 0x38, 0xF3, 0x66, 0x58, 0xC0, 0xFC, 0xCC, 0x77, 0xFB, 0x36,
  0x6D, 0xDF, 0xBE, 0x00, 0x38, 0x60, 0xC1, 0xF7, 0xEC, 0xD9, 0xB7, 0xFF,
  0xB8, 0x7F, 0xEC, 0x30, 0xC3, 0xEF, 0x80, 0x06, 0x0C, 0x3B, 0xFF, 0xD9,
  0xB3, 0x6E, 0xFD, 0xF0, 0x7F, 0xBC, 0xFE, 0xC3, 0xEF, 0x80, 0x0F, 0x1E,
  0x1C, 0x3E, 0x3C, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0xF0, 0xE0, 0x3B,
  0x7E, 0x66, 0x66, 0x6E, 0x7E, 0x7C, 0x0C, 0xFC, 0xF8, 0x38, 0x60, 0xC1,
  0xF7, 0xEE, 0xD9, 0xB3, 0xEF, 0xDC, 0x39, 0x80, 0x67, 0x39, 0x8C, 0xE7,
  0x00, 0x0E, 0x18, 0x00, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE7, 0x8F,
  0x00, 0x38, 0x18, 0x0C, 0x2E, 0xE7, 0x63, 0x61, 0xF0, 0xF8, 0xEE, 0x77,
  0x00, 0x39, 0x8C, 0x67, 0x39, 0x8C, 0xE7, 0x00, 0x3E, 0xEF, 0xFD, 0xDD,
  0xB3, 0x36, 0x67, 0xDD, 0xFB, 0xB8, 0x3E, 0xFD, 0xDB, 0x36, 0x7D, 0xFB,
  0x80, 0x7F, 0xFC, 0xF3, 0xDF, 0xEF, 0x00, 0x1F, 0x3F, 0x33, 0x33, 0x37,
  0x7F, 0x7E, 0x60, 0x60, 0xE0, 0x77, 0xFB, 0x36, 0x6D, 0xDF, 0xBE, 0x0C,
  0x38, 0x70, 0x3D, 0xF7, 0x18, 0x63, 0x8E, 0x00, 0x7D, 0x97, 0x0E, 0x1F,
  0xFF, 0x80, 0x18, 0xC7, 0xFF, 0x71, 0x86, 0x1E, 0x78, 0xEF, 0xDF, 0x36,
  0x6D, 0xDF, 0xBF, 0x00, 0xCF, 0xBB, 0x66, 0xCF, 0x1E, 0x38, 0x00, 0xDC,
  0xF7, 0x7D, 0x5B, 0xFE, 0xFF, 0x3B, 0xCE, 0xE0, 0x3B, 0x8F, 0x87, 0x83,
  0x83, 0xE3, 0xB3, 0x9C, 0x33, 0x9B, 0x8D, 0x86, 0xC3, 0xC1, 0xE0, 0xE0,
  0x70, 0xF0, 0x70, 0x00, 0x7E, 0xF8, 0x61, 0x87, 0x1F, 0xBE, 0x00, 0x1C,
  0xE3, 0x0C, 0xF3, 0x06, 0x18, 0x61, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x38, 0xE1, 0x8E, 0x1C, 0x73, 0x0C, 0x63, 0x8E, 0x00, 0xE7, 0xF9, 0x80,
};

const GFXglyph NotoSans_BlackItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 6, 3, 6, 1, -9 },
  { 9, 9, 9, 8, 0, -9 },
  { 20, 7, 11, 8, 0, -10 },
  { 30, 11, 9, 12, 1, -9 },
  { 43, 9, 9, 10, 0, -9 },
  { 54, 3, 3, 3, 1, -9 },
  { 56, 6, 12, 5, 0, -10 },
  { 65, 5, 12, 5, -1, -10 },
  { 73, 6, 7, 7, 1, -10 },
  { 79, 6, 7, 8, 1, -8 },
  { 85, 4, 4, 4, -1, -2 },
  { 87, 4, 2, 4, 0, -4 },
  { 88, 3, 2, 4, 0, -2 },
  { 89, 8, 9, 6, -1, -9 },
  { 98, 7, 9, 8, 0, -9 },
  { 106, 6, 9, 8, 1, -9 },
  { 113, 7, 9, 8, 0, -9 },
  { 121, 7, 9, 8, 0, -9 },
  { 129, 7, 9, 8, 0, -9 },
  { 137, 7, 9, 8, 0, -9 },
  { 145, 8, 9, 8, 0, -9 },
  { 154, 8, 9, 8, 0, -9 },
  { 163, 7, 9, 8, 0, -9 },
  { 171, 6, 9, 8, 1, -9 },
  { 178, 4, 7, 4, 0, -7 },
  { 182, 5, 9, 4, -1, -7 },
  { 188, 6, 7, 8, 1, -8 },
  { 194, 6, 5, 8, 1, -7 },
  { 198, 6, 7, 8, 1, -8 },
  { 204, 6, 9, 6, 1, -9 },
  { 211, 10, 10, 12, 1, -9 },
  { 224, 9, 9, 9, -1, -9 },
  { 235, 8, 9, 8, 0, -9 },
  { 244, 8, 9, 8, 1, -9 },
  { 253, 8, 9, 9, 0, -9 },
  { 262, 8, 9, 7, 0, -9 },
  { 271, 8, 9, 7, 0, -9 },
  { 280, 8, 9, 9, 1, -9 },
  { 289, 9, 9, 9, 0, -9 },
  { 300, 6, 9, 6, 0, -9 },
  { 307, 7, 12, 5, -2, -9 },
  { 318, 10, 9, 9, 0, -9 },
  { 330, 6, 9, 7, 0, -9 },
  { 337, 12, 9, 12, 0, -9 },
  { 351, 10, 9, 10, 0, -9 },
  { 363, 8, 9, 10, 1, -9 },
  { 372, 8, 9, 8, 0, -9 },
  { 381, 8, 11, 10, 1, -9 },
  { 392, 8, 9, 8, 0, -9 },
  { 401, 7, 9, 7, 0, -9 },
  { 409, 7, 9, 7, 1, -9 },
  { 417, 8, 9, 9, 1, -9 },
  { 426, 8, 9, 8, 1, -9 },
  { 435, 12, 9, 12, 1, -9 },
  { 449, 11, 9, 9, -1, -9 },
  { 462, 8, 9, 8, 1, -9 },
  { 471, 9, 9, 7, -1, -9 },
  { 482, 6, 12, 5, 0, -10 },
  { 491, 4, 9, 6, 1, -9 },
  { 496, 6, 12, 5, -1, -10 },
  { 505, 7, 6, 7, 0, -9 },
  { 511, 6, 1, 6, -1, 1 },
  { 512, 3, 2, 5, 2, -10 },
  { 513, 7, 7, 8, 1, -7 },
  { 520, 7, 10, 8, 0, -10 },
  { 529, 6, 7, 7, 1, -7 },
  { 535, 7, 10, 8, 1, -10 },
  { 544, 6, 7, 8, 1, -7 },
  { 550, 8, 13, 5, -1, -10 },
  { 563, 8, 10, 8, 0, -7 },
  { 573, 7, 10, 8, 0, -10 },
  { 582, 5, 10, 4, 0, -10 },
  { 589, 7, 13, 4, -2, -10 },
  { 601, 9, 10, 8, 0, -10 },
  { 613, 5, 10, 4, 0, -10 },
  { 620, 11, 7, 12, 0, -7 },
  { 630, 7, 7, 8, 0, -7 },
  { 637, 6, 7, 8, 1, -7 },
  { 643, 8, 10, 8, -1, -7 },
  { 653, 7, 10, 8, 1, -7 },
  { 662, 6, 7, 6, 0, -7 },
  { 668, 6, 7, 7, 0, -7 },
  { 674, 6, 9, 6, 0, -9 },
  { 681, 7, 7, 8, 1, -7 },
  { 688, 7, 7, 7, 1, -7 },
  { 695, 10, 7, 11, 1, -7 },
  { 704, 9, 7, 7, -1, -7 },
  { 712, 9, 10, 7, -1, -7 },
  { 724, 7, 7, 6, 0, -7 },
  { 731, 6, 11, 5, 0, -9 },
  { 740, 2, 13, 7, 3, -10 },
  { 744, 6, 11, 5, -1, -9 },
  { 753, 6, 3, 8, 1, -6 },
};

const GFXfont NotoSans_BlackItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_BLACKITALIC13PT7B_H_
