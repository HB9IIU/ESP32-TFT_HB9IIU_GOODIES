#ifndef _NOTOSANS_BLACKITALIC43PT7B_H_
#define _NOTOSANS_BLACKITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x04,
  0x00, 0x7F, 0x9F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F,
  0x9F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0x87, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xEF,
  0x3C, 0x1F, 0xEF, 0x04, 0x1F, 0xCE, 0x00, 0x1F, 0xEE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3B,
  0xF8, 0x00, 0x79, 0xFC, 0x80, 0x79, 0xFC, 0xF0, 0x7B, 0xF8, 0xFF, 0x7F,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xFE, 0x00,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0xFC, 0x01, 0xFC,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC7, 0xE0, 0x7E, 0x00, 0x7E, 0x3F, 0x07, 0xE0,
  0x03, 0xF1, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0xF0, 0x3F, 0x3F, 0x3F, 0x1F, 0xF1,
  0xFF, 0xFB, 0xFB, 0xFF, 0xCF, 0xFF, 0x9F, 0x9F, 0xFE, 0x3F, 0xF9, 0xF9,
  0xFF, 0xF9, 0xFF, 0x9F, 0x9F, 0xDF, 0xC3, 0xF9, 0xFC, 0xFE, 0x7E, 0x00,
  0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0xFC, 0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0xFC, 0x00, 0xFE, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x7F, 0x00, 0x7E,
  0x07, 0xE3, 0xF0, 0x07, 0xE0, 0x3F, 0x3F, 0x80, 0x7F, 0x01, 0xFF, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x7F, 0x87, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFC, 0x7F, 0xFF, 0xC7, 0xF9, 0xFF, 0xFF, 0xDF, 0xE3, 0xFC, 0xFF, 0xFF,
  0xCF, 0xF8, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0xF8,
  0x7F, 0xC1, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xBF, 0x9F, 0xCF,
  0xE7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x02, 0x07, 0xE0, 0x1C, 0x3F, 0x01, 0xF9, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0x3C, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xBF, 0x00, 0xF9, 0xFC, 0x03, 0xC7, 0xE0, 0x0C, 0x3F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE3, 0xFC,
  0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0,
  0x00, 0x3F, 0xF9, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFB, 0xFF,
  0xC0, 0x04, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x10, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x8F, 0xF8, 0xFF,
  0x1F, 0xE1, 0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF7,
  0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F, 0xEF, 0xF8,
  0x7F, 0xDF, 0xF0, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0x9F,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x3F, 0xC3, 0xE7,
  0xF8, 0x18, 0x7F, 0x81, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xF0,
  0xFF, 0x01, 0xC0, 0xFF, 0x00, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0x01, 0x81, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0xC0, 0x07, 0xFC, 0xF8, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xFC, 0x03, 0xFB,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0x87,
  0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0x8F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF1, 0x80, 0x0F, 0xF8, 0xF8, 0x1F, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF,
  0xC3, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x08,
  0x03, 0xFD, 0xFE, 0x07, 0xF7, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF3, 0xFE, 0x1F, 0xE7,
  0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC3, 0xFE, 0x7F,
  0x87, 0xFC, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F,
  0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xBF, 0xE3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0x9F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x81,
  0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE7, 0xFE, 0xFF, 0x9F, 0xF1, 0xFF, 0x7F, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xEF, 0xE3,
  0xFF, 0xFF, 0x87, 0xFD, 0xFE, 0x07, 0xC7, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x81, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x01, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFC, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xCF,
  0xF9, 0xC0, 0xFF, 0x20, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x7E, 0x0F, 0xC7, 0xF0, 0x7F, 0xF8, 0xFC, 0xFC, 0x1F, 0xFF, 0x9F,
  0xBF, 0x07, 0xFF, 0xE1, 0xF7, 0xE1, 0xFF, 0xFC, 0x3E, 0xF8, 0x7F, 0x1F,
  0x87, 0xFF, 0x0F, 0xC3, 0xF0, 0xFF, 0xE3, 0xF0, 0x7C, 0x1F, 0xF8, 0x7E,
  0x1F, 0x87, 0xFF, 0x1F, 0x83, 0xF0, 0xFF, 0xE3, 0xF0, 0x7E, 0x1F, 0x7C,
  0x7E, 0x0F, 0x87, 0xEF, 0x8F, 0xC3, 0xF0, 0xFD, 0xF1, 0xF8, 0xFE, 0x3F,
  0x3E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F, 0xEF,
  0xFC, 0x1F, 0x87, 0xF8, 0xFF, 0x01, 0xF8, 0x18, 0x07, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x1E, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC3,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0x7F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x9F, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x78, 0x1F,
  0xF0, 0x01, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0xC0, 0x7F, 0xF3, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x38,
  0x1F, 0xF8, 0x00, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xFC, 0x7F, 0x87, 0xFF,
  0xCF, 0xF8, 0x7F, 0xFC, 0xFF, 0x87, 0xFF, 0x8F, 0xF8, 0xFF, 0xF8, 0xFF,
  0x8F, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0x07,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC,
  0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0x83, 0xFF, 0x00, 0xFF, 0x0F, 0xFC, 0x01, 0xFE, 0x1F,
  0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x1F,
  0xF1, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0x7E, 0x1F, 0xBF, 0x81, 0xFD, 0xF8, 0x7E, 0xFE,
  0x07, 0xF7, 0xE3, 0xF3, 0xF8, 0x1F, 0xDF, 0x8F, 0xDF, 0xE0, 0x7F, 0x7E,
  0x7E, 0x7F, 0x83, 0xFD, 0xF9, 0xF9, 0xFC, 0x0F, 0xE7, 0xEF, 0xC7, 0xF0,
  0x3F, 0x9F, 0xBF, 0x1F, 0xC0, 0xFE, 0x7F, 0xFC, 0xFF, 0x07, 0xF9, 0xFF,
  0xE3, 0xFC, 0x1F, 0xE7, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0xF0, 0xFE, 0x07, 0xF1, 0xFF, 0x87, 0xF8, 0x3F, 0xC7, 0xFE,
  0x1F, 0xC0, 0xFF, 0x1F, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0xC1, 0xFC, 0x0F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0x80,
  0x1F, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0xF8,
  0x07, 0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF,
  0x81, 0xFE, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF,
  0xF8, 0x3F, 0x81, 0xFD, 0xFC, 0x3F, 0xC0, 0xFE, 0xFE, 0x1F, 0xE0, 0xFE,
  0x7F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF1, 0xFC, 0x0F, 0xE3, 0xFD, 0xFE, 0x0F, 0xF0, 0xFE, 0xFE, 0x07,
  0xF0, 0x7F, 0x7F, 0x03, 0xF8, 0x3F, 0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0xC1,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF0,
  0x3F, 0x80, 0x7F, 0xF8, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xE0, 0x1F, 0xFC,
  0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x0F,
  0xF8, 0x7F, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFE,
  0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xC7,
  0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0xBF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F,
  0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF7, 0xF8,
  0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1C, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x20, 0x07, 0xF8, 0x70,
  0x0F, 0xF0, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07,
  0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8,
  0x3F, 0xE0, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF,
  0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0,
  0x7F, 0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F,
  0xF3, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE7, 0xF8, 0x0F, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xFC, 0x0F, 0xF1, 0xFE,
  0x07, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFF,
  0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0xC1, 0xFC, 0x0F, 0xE1, 0xFF, 0xE1, 0xFE,
  0x07, 0xF0, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0xFD, 0xF8, 0x7F, 0x01, 0xFC,
  0x7E, 0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x7E, 0x3F, 0x80, 0x7F, 0x3F, 0x3F,
  0x3F, 0xC0, 0x3F, 0x9F, 0x9F, 0x9F, 0xC0, 0x1F, 0xDF, 0xCF, 0xCF, 0xE0,
  0x0F, 0xEF, 0xC7, 0xEF, 0xF0, 0x07, 0xFF, 0xE3, 0xF7, 0xF0, 0x03, 0xF7,
  0xE1, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xEF, 0xF0, 0x0F,
  0xF9, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F,
  0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xF7, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x1F, 0x01,
  0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7C, 0x3F, 0x80, 0xFC, 0x7E,
  0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x03, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFF, 0x9F,
  0xE7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF0, 0x7C, 0x01, 0xF8, 0x7F, 0x07, 0xFE,
  0x7E, 0x0F, 0xFE, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x83,
  0xFC, 0xFF, 0x83, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF9,
  0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0,
  0xFF, 0x1F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3,
  0xFE, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0x7F, 0xE0, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x3F, 0xF1, 0xC7, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x8F, 0xF8, 0x70, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x7E, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xDF, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3,
  0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF9,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0xFF, 0xDF, 0xF3, 0xFC, 0x3F, 0xDF, 0xF0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE,
  0x3F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0x0F,
  0xFE, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x10, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x8F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x81, 0xFF, 0x9F, 0x81, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xF8, 0x7F, 0xC3,
  0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0x9F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x20, 0x07, 0xF8,
  0x1C, 0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF9,
  0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFE,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x7F,
  0xC3, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x08, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0xFF, 0xC1, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x87,
  0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0,
  0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0,
  0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF1, 0xFC, 0x0F,
  0xE0, 0x1F, 0xCF, 0xF8, 0x7F, 0xC0, 0x7F, 0x7F, 0xF3, 0xFF, 0x81, 0xFF,
  0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xCF, 0xFE, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x83,
  0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xFB, 0xFF, 0x01, 0xFD, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFE,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x87,
  0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x8F, 0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F,
  0xDF, 0xF0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFE, 0xFF, 0x0F, 0xFB, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x7F, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFE,
  0xFF, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x7F, 0x07, 0xFE, 0x7E, 0x0F, 0xFE, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xF7, 0xFC, 0x7F,
  0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0x83, 0xF8, 0xFF,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xDF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xF1, 0xF8, 0x3F,
  0x9F, 0x81, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFE, 0x7C, 0x3F, 0xC0, 0xC3, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xCC, 0x07, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xC7, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF1, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0xFF,
  0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF,
  0x9F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF7, 0xF0, 0x3F, 0xE7, 0xF0, 0x1F, 0xC7, 0xE0, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0x7F,
  0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F,
  0x1F, 0xE0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x3F,
  0x7F, 0x80, 0x3F, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0xFF, 0x07, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF,
  0xC3, 0xFC, 0xFF, 0x0F, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xC3, 0xF8, 0x7F,
  0x1F, 0xFC, 0x7F, 0x87, 0xF1, 0xFF, 0xC7, 0xF0, 0x7F, 0x3F, 0xFC, 0xFF,
  0x07, 0xF3, 0xFF, 0xCF, 0xE0, 0x7F, 0x3E, 0xFD, 0xFE, 0x07, 0xF7, 0xEF,
  0xDF, 0xC0, 0x7F, 0x7E, 0xF9, 0xFC, 0x07, 0xF7, 0xCF, 0xBF, 0x80, 0x7F,
  0xFC, 0xFB, 0xF8, 0x07, 0xFF, 0x8F, 0xBF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0,
  0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE1, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0xFF, 0xD0, 0x01, 0xF8,
};

const GFXglyph NotoSans_BlackItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 32, 13, 0, -31 },
  { 61, 18, 11, 20, 4, -31 },
  { 86, 29, 31, 28, 0, -31 },
  { 199, 24, 36, 25, 1, -33 },
  { 307, 37, 31, 40, 2, -31 },
  { 451, 31, 31, 32, 0, -31 },
  { 572, 9, 11, 10, 4, -31 },
  { 585, 18, 39, 16, 1, -32 },
  { 673, 18, 39, 16, -3, -32 },
  { 761, 21, 21, 23, 3, -33 },
  { 817, 21, 21, 25, 2, -26 },
  { 873, 11, 11, 13, -2, -5 },
  { 889, 13, 7, 14, 0, -15 },
  { 901, 9, 9, 13, 0, -8 },
  { 912, 25, 31, 20, -2, -31 },
  { 1009, 23, 31, 25, 1, -31 },
  { 1099, 20, 31, 25, 3, -31 },
  { 1177, 24, 31, 25, -1, -31 },
  { 1270, 24, 31, 25, 0, -31 },
  { 1363, 24, 31, 25, 0, -31 },
  { 1456, 25, 31, 25, 0, -31 },
  { 1553, 23, 31, 25, 2, -31 },
  { 1643, 26, 31, 25, 1, -31 },
  { 1744, 23, 31, 25, 1, -31 },
  { 1834, 22, 31, 25, 2, -31 },
  { 1920, 13, 25, 13, 0, -24 },
  { 1961, 15, 30, 13, -2, -24 },
  { 2018, 21, 23, 25, 2, -27 },
  { 2079, 21, 15, 25, 2, -23 },
  { 2119, 21, 23, 25, 2, -27 },
  { 2180, 19, 32, 21, 3, -31 },
  { 2256, 35, 35, 39, 2, -31 },
  { 2410, 29, 31, 29, -3, -31 },
  { 2523, 26, 31, 27, 1, -31 },
  { 2624, 27, 31, 27, 2, -31 },
  { 2729, 27, 31, 29, 1, -31 },
  { 2834, 24, 31, 24, 1, -31 },
  { 2927, 24, 31, 24, 1, -31 },
  { 3020, 28, 31, 30, 2, -31 },
  { 3129, 30, 31, 31, 1, -31 },
  { 3246, 23, 31, 18, -2, -31 },
  { 3336, 23, 41, 16, -7, -31 },
  { 3454, 31, 31, 29, 1, -31 },
  { 3575, 19, 31, 23, 1, -31 },
  { 3649, 38, 31, 39, 1, -31 },
  { 3797, 33, 31, 34, 1, -31 },
  { 3925, 28, 31, 32, 2, -31 },
  { 4034, 25, 31, 27, 1, -31 },
  { 4131, 28, 38, 32, 2, -31 },
  { 4264, 25, 31, 28, 1, -31 },
  { 4361, 23, 31, 24, 1, -31 },
  { 4451, 23, 31, 24, 3, -31 },
  { 4541, 27, 31, 30, 3, -31 },
  { 4646, 27, 31, 27, 3, -31 },
  { 4751, 41, 31, 40, 3, -31 },
  { 4910, 35, 31, 29, -3, -31 },
  { 5046, 27, 31, 26, 3, -31 },
  { 5151, 28, 31, 23, -2, -31 },
  { 5260, 19, 39, 15, -1, -32 },
  { 5353, 11, 31, 20, 5, -31 },
  { 5396, 20, 39, 15, -3, -32 },
  { 5494, 23, 20, 23, 0, -31 },
  { 5552, 21, 5, 19, -4, 3 },
  { 5566, 10, 7, 15, 6, -33 },
  { 5575, 24, 24, 26, 2, -24 },
  { 5647, 24, 33, 26, 0, -33 },
  { 5746, 20, 24, 22, 2, -24 },
  { 5806, 26, 33, 26, 2, -33 },
  { 5914, 22, 24, 25, 2, -24 },
  { 5980, 26, 43, 18, -4, -33 },
  { 6120, 25, 34, 26, 1, -24 },
  { 6227, 25, 33, 27, 0, -33 },
  { 6331, 15, 33, 14, 0, -33 },
  { 6393, 21, 43, 14, -6, -33 },
  { 6506, 29, 33, 27, 0, -33 },
  { 6626, 16, 33, 14, 0, -33 },
  { 6692, 38, 24, 40, 0, -24 },
  { 6806, 25, 24, 27, 0, -24 },
  { 6881, 22, 24, 26, 2, -24 },
  { 6947, 26, 34, 26, -2, -24 },
  { 7058, 24, 34, 26, 2, -24 },
  { 7160, 21, 24, 19, 0, -24 },
  { 7223, 20, 24, 22, 1, -24 },
  { 7283, 19, 29, 20, 1, -29 },
  { 7352, 24, 24, 27, 2, -24 },
  { 7424, 24, 24, 23, 2, -24 },
  { 7496, 36, 24, 35, 2, -24 },
  { 7604, 30, 24, 24, -3, -24 },
  { 7694, 29, 34, 23, -3, -24 },
  { 7818, 23, 24, 21, -1, -24 },
  { 7887, 19, 38, 15, 0, -31 },
  { 7978, 6, 43, 24, 9, -33 },
  { 8011, 19, 38, 15, -3, -31 },
  { 8102, 21, 8, 25, 2, -19 },
};

const GFXfont NotoSans_BlackItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_BLACKITALIC43PT7B_H_
