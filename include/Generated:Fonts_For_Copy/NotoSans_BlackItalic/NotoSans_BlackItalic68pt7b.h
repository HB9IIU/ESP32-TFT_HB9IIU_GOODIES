#ifndef _NOTOSANS_BLACKITALIC68PT7B_H_
#define _NOTOSANS_BLACKITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xFC, 0x7F, 0xF3, 0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0x7F, 0xF3,
  0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0,
  0xFF, 0xE7, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x7F, 0x80, 0xFF, 0xF3, 0xE0, 0x38, 0x0F, 0xFF, 0x1F, 0x00, 0x40, 0x7F,
  0xF9, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xC0, 0x00, 0x1F, 0xFE, 0x7E, 0x00,
  0x00, 0xFF, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xBF, 0xFC, 0x00, 0x00, 0x7C, 0xFF, 0xF0, 0x00, 0x03,
  0xE3, 0xFF, 0x88, 0x00, 0x3F, 0x1F, 0xFC, 0x60, 0x01, 0xF8, 0xFF, 0xE3,
  0xE0, 0x0F, 0x8F, 0xFE, 0x1F, 0xF0, 0x7C, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xF1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xF8, 0x7F, 0xF7, 0xFE, 0x0F, 0xFF,
  0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x3F, 0xF0, 0x00, 0x70,
  0x0F, 0xF8, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x3F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x78, 0x1F, 0xF8,
  0x00, 0x0E, 0x07, 0xFE, 0x00, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xE3, 0xFF,
  0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0x9F, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF,
  0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xF3,
  0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F,
  0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xFC,
  0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x3F,
  0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8,
  0x07, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x8F,
  0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xBF, 0xFC, 0x3F, 0xFE, 0x7F, 0xF8, 0x3F, 0xF9, 0xFF,
  0xF0, 0x3F, 0xE3, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0x80, 0x78, 0x1F, 0xFF,
  0x00, 0xE0, 0x3F, 0xFE, 0x00, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0x02, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0xF0,
  0x01, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC8, 0x00, 0x00, 0x7F, 0xFE, 0x70, 0x00, 0x07, 0xFF, 0xF3,
  0xF0, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xFF,
  0xBF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xF0,
  0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x80, 0x00,
  0x0F, 0xFF, 0xC3, 0x80, 0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x18, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF,
  0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x03, 0xFF, 0xE3,
  0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF,
  0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xFF, 0xF0,
  0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xF8, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F, 0xFE, 0x7F, 0xFC, 0x07,
  0xFF, 0xBF, 0xFF, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFB,
  0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xFC, 0x01, 0xFC,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x08,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0x07, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0x0C, 0x00, 0x3F, 0xFC,
  0x20, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xF8, 0xFF, 0x81, 0xFF, 0x7F, 0xC0,
  0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x01, 0xFE, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0xFF,
  0x87, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0x87, 0xFF, 0x3F, 0xFE, 0x7F, 0xF0,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x00,
  0x00, 0x3F, 0xFD, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFE, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x07,
  0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x80, 0x1F, 0xFF,
  0xC0, 0x01, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x47, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0x87,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7C, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF3,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0xFF, 0xBF, 0xF8,
  0x01, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0x80,
  0x7F, 0xDF, 0xFE, 0x00, 0x7F, 0xF7, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x07,
  0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x03, 0xFF,
  0x7F, 0xF8, 0x01, 0xFF, 0xCF, 0xF8, 0x1F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFE,
  0x7F, 0xC0, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF,
  0xE0, 0x07, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xFF, 0x00, 0x3F, 0xF8, 0xFF,
  0x87, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xF9, 0xFF, 0x8F, 0xFF, 0x00, 0x3F,
  0xFC, 0x7F, 0xCF, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFE, 0xFF, 0xC3,
  0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF7, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0xDF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE7, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x83,
  0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x07, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x9F,
  0xFF, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xCF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF3,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x7F, 0xFD, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x9F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x18, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x81, 0x80, 0x00, 0x7F, 0xFC, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x7E,
  0x00, 0x3F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x01,
  0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xF3, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x9F, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xEF, 0xFC, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xEF,
  0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xCF,
  0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xF8, 0x00,
  0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x0F,
  0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x00,
  0x7F, 0xF7, 0xFF, 0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFE, 0x0F,
  0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xDF, 0xFF, 0x00, 0x07, 0xFF, 0xE7, 0xFF, 0xC0, 0x03, 0xFF, 0xF1, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0xFF, 0xF1, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0xE3, 0xFF,
  0x80, 0x3F, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xF7, 0xFF,
  0x00, 0x0F, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC7,
  0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F,
  0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFE, 0x3F, 0xFC,
  0x03, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x7F, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF,
  0xFF, 0xFC, 0x07, 0xFF, 0x3F, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF8, 0x3F, 0xFF, 0x80, 0x10, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0xC0, 0xFF, 0xFC,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xEF,
  0xFE, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xF3, 0xFF,
  0xE0, 0x3F, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xF3,
  0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x20, 0x7F, 0xFC, 0x00, 0x1C, 0x0F, 0xFF, 0xC0, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFF,
  0xCF, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF1, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xEF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0xC0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x20, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF7, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0xFF,
  0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF,
  0x9F, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0xFC, 0x07,
  0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F,
  0xFF, 0xDF, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F, 0xFC,
  0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xF7, 0xFF, 0xF0, 0x00, 0xFF, 0xF1, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xE0, 0x07, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFF, 0xCF, 0xFE, 0x01,
  0xFF, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF,
  0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x1F, 0xF9, 0xFF, 0xF0, 0x00, 0x07, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0x01, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xCF,
  0xFE, 0x01, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xBF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x08, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xF8, 0x0F, 0xFF, 0x80,
  0x30, 0x0F, 0xFF, 0x80, 0x10, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x80, 0x01, 0xFF, 0xF8, 0xE0, 0x01, 0xFF, 0xF0, 0xF8, 0x01, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x60, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0x9F, 0xF8,
  0x00, 0xFF, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0xFF, 0xBF,
  0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF,
  0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xFF,
  0x8F, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xE0,
  0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x9F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFE, 0x07,
  0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFD, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xE3, 0xFE, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF,
  0x7F, 0x87, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0x3F, 0xC7, 0xFF, 0x80, 0x3F,
  0xFC, 0xFF, 0x9F, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xCF, 0xF1, 0xFF,
  0xC0, 0x07, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xE3, 0xFE, 0xFF, 0xF0, 0x00, 0xFF,
  0xDF, 0xF1, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0xFF, 0xBF, 0xF8,
  0x00, 0x3F, 0xF7, 0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE1, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00,
  0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x4F, 0xFF,
  0xF0, 0x00, 0x77, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xEE, 0x00, 0x0F, 0xFF, 0xF2, 0x00, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x00,
  0x00, 0x00,
};

const GFXglyph NotoSans_BlackItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 23, 50, 21, 0, -49 },
  { 145, 28, 18, 31, 6, -49 },
  { 208, 45, 49, 44, 0, -49 },
  { 484, 37, 56, 39, 2, -52 },
  { 743, 58, 50, 63, 4, -49 },
  { 1106, 49, 50, 50, 0, -49 },
  { 1413, 14, 18, 16, 6, -49 },
  { 1445, 28, 61, 25, 2, -50 },
  { 1659, 27, 61, 25, -4, -50 },
  { 1865, 34, 34, 37, 5, -52 },
  { 2010, 34, 33, 40, 3, -41 },
  { 2151, 18, 17, 21, -3, -8 },
  { 2190, 20, 10, 22, 1, -23 },
  { 2215, 14, 13, 21, 0, -12 },
  { 2238, 39, 50, 32, -3, -49 },
  { 2482, 36, 50, 39, 2, -49 },
  { 2707, 31, 49, 39, 5, -49 },
  { 2897, 39, 49, 39, -2, -49 },
  { 3136, 37, 50, 39, 0, -49 },
  { 3368, 39, 49, 39, 0, -49 },
  { 3607, 38, 50, 39, 1, -49 },
  { 3845, 37, 50, 39, 3, -49 },
  { 4077, 41, 49, 39, 1, -49 },
  { 4329, 36, 50, 39, 2, -49 },
  { 4554, 34, 50, 39, 4, -49 },
  { 4767, 21, 39, 21, 0, -38 },
  { 4870, 25, 47, 21, -4, -38 },
  { 5017, 34, 37, 40, 3, -43 },
  { 5175, 34, 24, 40, 3, -36 },
  { 5277, 34, 37, 40, 3, -43 },
  { 5435, 30, 50, 33, 5, -49 },
  { 5623, 56, 55, 61, 3, -49 },
  { 6008, 45, 49, 46, -4, -49 },
  { 6284, 41, 49, 43, 1, -49 },
  { 6536, 42, 50, 43, 3, -49 },
  { 6799, 43, 49, 47, 1, -49 },
  { 7063, 39, 49, 38, 1, -49 },
  { 7302, 39, 49, 39, 1, -49 },
  { 7541, 44, 50, 47, 3, -49 },
  { 7816, 48, 49, 49, 1, -49 },
  { 8110, 35, 49, 29, -2, -49 },
  { 8325, 37, 64, 25, -11, -49 },
  { 8621, 50, 49, 45, 1, -49 },
  { 8928, 31, 49, 36, 1, -49 },
  { 9118, 61, 49, 62, 1, -49 },
  { 9492, 53, 49, 54, 1, -49 },
  { 9817, 45, 50, 50, 3, -49 },
  { 10099, 41, 49, 42, 1, -49 },
  { 10351, 45, 61, 50, 3, -49 },
  { 10695, 40, 49, 44, 1, -49 },
  { 10940, 37, 50, 37, 1, -49 },
  { 11172, 37, 49, 38, 5, -49 },
  { 11399, 44, 50, 48, 4, -49 },
  { 11674, 42, 49, 42, 5, -49 },
  { 11932, 64, 49, 64, 5, -49 },
  { 12324, 54, 49, 45, -4, -49 },
  { 12655, 42, 49, 41, 5, -49 },
  { 12913, 43, 49, 37, -3, -49 },
  { 13177, 31, 61, 24, -2, -50 },
  { 13414, 19, 50, 32, 7, -49 },
  { 13533, 30, 61, 24, -4, -50 },
  { 13762, 36, 32, 36, 0, -49 },
  { 13906, 33, 9, 31, -6, 4 },
  { 13944, 16, 11, 24, 10, -52 },
  { 13966, 38, 39, 41, 3, -38 },
  { 14152, 37, 53, 41, 1, -52 },
  { 14398, 32, 39, 34, 3, -38 },
  { 14554, 41, 53, 41, 3, -52 },
  { 14826, 35, 39, 39, 3, -38 },
  { 14997, 42, 68, 28, -7, -52 },
  { 15354, 40, 54, 41, 1, -38 },
  { 15624, 38, 52, 42, 1, -52 },
  { 15871, 23, 53, 22, 1, -53 },
  { 16024, 33, 69, 22, -9, -53 },
  { 16309, 45, 52, 42, 1, -52 },
  { 16602, 24, 52, 22, 1, -52 },
  { 16758, 59, 38, 63, 1, -38 },
  { 17039, 38, 38, 42, 1, -38 },
  { 17220, 35, 39, 41, 3, -38 },
  { 17391, 41, 54, 41, -3, -38 },
  { 17668, 38, 54, 41, 3, -38 },
  { 17925, 32, 38, 30, 1, -38 },
  { 18077, 32, 39, 34, 1, -38 },
  { 18233, 30, 46, 31, 2, -45 },
  { 18406, 39, 39, 42, 3, -38 },
  { 18597, 38, 38, 37, 3, -38 },
  { 18778, 57, 38, 56, 3, -38 },
  { 19049, 47, 38, 38, -4, -38 },
  { 19273, 45, 54, 37, -4, -38 },
  { 19577, 35, 38, 33, -1, -38 },
  { 19744, 30, 60, 24, -1, -49 },
  { 19969, 9, 66, 38, 15, -51 },
  { 20044, 29, 60, 24, -4, -49 },
  { 20262, 34, 13, 40, 3, -30 },
};

const GFXfont NotoSans_BlackItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_BLACKITALIC68PT7B_H_
