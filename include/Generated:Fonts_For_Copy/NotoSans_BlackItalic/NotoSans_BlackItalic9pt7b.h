#ifndef _NOTOSANS_BLACKITALIC9PT7B_H_
#define _NOTOSANS_BLACKITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x25, 0x80, 0xFA, 0x39, 0xF3, 0xBF, 0x51, 0xC0, 0x13, 0xD4,
  0xE3, 0xFD, 0xC8, 0x20, 0x76, 0x54, 0xFB, 0x55, 0x35, 0x67, 0x10, 0xF1,
  0xE3, 0xBF, 0xDB, 0x3F, 0x00, 0xE0, 0x32, 0x44, 0xCC, 0xC4, 0x23, 0x11,
  0x33, 0x2E, 0x2A, 0x7E, 0x20, 0x27, 0xC8, 0x40, 0xE0, 0xE0, 0x70, 0x18,
  0x8C, 0x46, 0x62, 0x00, 0x13, 0xD7, 0xBD, 0xE9, 0xC0, 0x7E, 0x66, 0x66,
  0x13, 0xD6, 0x22, 0x63, 0xC0, 0x23, 0xC6, 0xE1, 0xCF, 0xC0, 0x19, 0xDD,
  0xFF, 0x98, 0x7B, 0x1C, 0x39, 0xF8, 0x0B, 0xD1, 0xFD, 0xED, 0xC0, 0x7C,
  0x63, 0x0C, 0x63, 0x00, 0x13, 0xDE, 0xE5, 0xED, 0xC0, 0x23, 0xD7, 0xB7,
  0x9B, 0x80, 0x68, 0x2C, 0x32, 0x00, 0x6C, 0x09, 0xF8, 0xE1, 0x80, 0xF8,
  0x3E, 0x87, 0x0E, 0xEC, 0x00, 0x4F, 0x36, 0xC8, 0xC0, 0x08, 0x36, 0x5F,
  0x75, 0xEF, 0xFE, 0x44, 0x38, 0x1C, 0x53, 0x4F, 0x7F, 0x10, 0x7D, 0xB7,
  0x96, 0xDB, 0xC0, 0x10, 0xF6, 0x10, 0xC1, 0xA7, 0x80, 0x79, 0xB6, 0xD3,
  0xDB, 0xC0, 0x7B, 0x1E, 0x8C, 0x78, 0x7B, 0x1E, 0xEC, 0x60, 0x08, 0xF6,
  0x17, 0xDD, 0xA7, 0x80, 0x65, 0xB7, 0xD3, 0xCB, 0x60, 0x76, 0x66, 0x4E,
  0x33, 0x33, 0x26, 0xEC, 0x6E, 0xF1, 0xC3, 0xCD, 0x9B, 0x00, 0x66, 0x64,
  0xCF, 0x77, 0x77, 0x57, 0x5A, 0xDA, 0xD6, 0x76, 0xAD, 0x5A, 0xED, 0xD9,
  0x80, 0x10, 0xF6, 0x51, 0xCD, 0xB7, 0x80, 0x79, 0xB7, 0x9C, 0xC3, 0x00,
  0x10, 0xF6, 0x51, 0xCD, 0xB7, 0x86, 0x0C, 0x7B, 0x5E, 0xED, 0xEC, 0x13,
  0xD8, 0xE3, 0x5B, 0xC0, 0xFB, 0x10, 0x8C, 0x60, 0xDE, 0xF7, 0x3B, 0x78,
  0x9C, 0xAD, 0x4E, 0x60, 0x9B, 0xBA, 0xBE, 0xFC, 0xDC, 0xDC, 0x37, 0x1C,
  0x18, 0x3C, 0x2C, 0xEC, 0xDF, 0xB8, 0x84, 0x60, 0x79, 0x8C, 0xCC, 0x78,
  0x77, 0x44, 0x4C, 0xCC, 0xC0, 0xAF, 0x54, 0x33, 0x13, 0x32, 0x26, 0xE0,
  0x33, 0x95, 0x30, 0xF8, 0xD0, 0x7B, 0xF7, 0xB7, 0x00, 0x63, 0x1E, 0xF5,
  0xEF, 0xC0, 0x7B, 0x71, 0xA7, 0x00, 0x0C, 0x27, 0x9E, 0xDB, 0x67, 0x00,
  0x7A, 0xFF, 0x97, 0x00, 0x1C, 0x53, 0x9C, 0x30, 0x86, 0x18, 0xE0, 0x7B,
  0xF7, 0xB7, 0x5B, 0xC0, 0x63, 0x1E, 0xF5, 0xEF, 0x60, 0x65, 0xB5, 0xB0,
  0x31, 0x33, 0x26, 0x66, 0xC0, 0x61, 0x86, 0xDE, 0x73, 0x4D, 0x80, 0x6D,
  0xB5, 0xB0, 0x7F, 0x7B, 0x5B, 0xDB, 0xDA, 0x7B, 0xD7, 0xBD, 0x80, 0x7B,
  0xF7, 0xB7, 0x00, 0x7B, 0xD7, 0xBF, 0x62, 0x00, 0x7B, 0xF7, 0xB7, 0x08,
  0xC0, 0x77, 0x4C, 0xC0, 0x75, 0x7B, 0xE0, 0x2F, 0x64, 0xC6, 0x6D, 0x65,
  0xB6, 0x78, 0xDA, 0xDC, 0xE6, 0x00, 0xDB, 0x5A, 0x6E, 0x6C, 0x6C, 0x3E,
  0x70, 0x61, 0xCE, 0xC0, 0x6C, 0xB2, 0x8E, 0x30, 0xCE, 0x00, 0x79, 0x99,
  0x8F, 0x00, 0x36, 0x68, 0x44, 0xC0, 0xFF, 0x80, 0x33, 0x21, 0x26, 0xC0,
  0xFC, 0x80,
};

const GFXglyph NotoSans_BlackItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 3, 0, -6 },
  { 4, 4, 2, 4, 1, -6 },
  { 5, 6, 6, 6, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 8, 7, 8, 0, -7 },
  { 22, 7, 7, 7, 0, -7 },
  { 29, 2, 2, 2, 1, -6 },
  { 30, 4, 8, 3, 0, -7 },
  { 34, 4, 8, 3, -1, -7 },
  { 38, 4, 5, 5, 1, -7 },
  { 41, 5, 4, 5, 0, -5 },
  { 44, 2, 2, 3, 0, -1 },
  { 45, 3, 1, 3, 0, -3 },
  { 46, 2, 2, 3, 0, -2 },
  { 47, 5, 7, 4, 0, -7 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 4, 6, 5, 1, -6 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 5, 7, 5, 0, -7 },
  { 83, 6, 6, 5, 0, -6 },
  { 88, 5, 7, 5, 0, -7 },
  { 93, 5, 7, 5, 0, -7 },
  { 98, 3, 5, 3, 0, -5 },
  { 100, 4, 6, 3, -1, -5 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 5, 3, 5, 0, -5 },
  { 109, 5, 5, 5, 0, -6 },
  { 113, 4, 7, 4, 1, -7 },
  { 117, 8, 8, 8, 0, -7 },
  { 125, 6, 6, 6, -1, -6 },
  { 130, 6, 6, 6, 0, -6 },
  { 135, 6, 7, 6, 0, -7 },
  { 141, 6, 6, 6, 0, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 6, 6, 6, 0, -6 },
  { 165, 4, 6, 4, 0, -6 },
  { 168, 4, 8, 3, -1, -6 },
  { 172, 7, 6, 6, 0, -6 },
  { 178, 4, 6, 5, 0, -6 },
  { 181, 8, 6, 8, 0, -6 },
  { 187, 7, 6, 7, 0, -6 },
  { 193, 6, 7, 7, 0, -7 },
  { 199, 6, 6, 6, 0, -6 },
  { 204, 6, 9, 7, 0, -7 },
  { 211, 5, 6, 6, 0, -6 },
  { 215, 5, 7, 5, 0, -7 },
  { 220, 5, 6, 5, 1, -6 },
  { 224, 5, 6, 6, 1, -6 },
  { 228, 5, 6, 6, 1, -6 },
  { 232, 8, 6, 8, 1, -6 },
  { 238, 8, 6, 6, -1, -6 },
  { 244, 5, 6, 5, 1, -6 },
  { 248, 5, 6, 5, 0, -6 },
  { 252, 4, 9, 3, 0, -7 },
  { 257, 2, 7, 4, 1, -7 },
  { 259, 4, 9, 3, -1, -7 },
  { 264, 5, 4, 5, 0, -6 },
  { 267, 5, 1, 4, -1, 1 },
  { 268, 2, 2, 3, 1, -7 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 5, 7, 5, 0, -7 },
  { 278, 5, 5, 5, 0, -5 },
  { 282, 6, 7, 5, 0, -7 },
  { 288, 5, 5, 5, 0, -5 },
  { 292, 6, 9, 4, -1, -7 },
  { 299, 5, 7, 5, 0, -5 },
  { 304, 5, 7, 6, 0, -7 },
  { 309, 3, 7, 3, 0, -7 },
  { 312, 4, 9, 3, -1, -7 },
  { 317, 6, 7, 6, 0, -7 },
  { 323, 3, 7, 3, 0, -7 },
  { 326, 8, 5, 8, 0, -5 },
  { 331, 5, 5, 6, 0, -5 },
  { 335, 5, 5, 5, 0, -5 },
  { 339, 5, 7, 5, 0, -5 },
  { 344, 5, 7, 5, 0, -5 },
  { 349, 4, 5, 4, 0, -5 },
  { 352, 4, 5, 5, 0, -5 },
  { 355, 4, 6, 4, 0, -6 },
  { 358, 6, 5, 6, 0, -5 },
  { 362, 5, 5, 5, 0, -5 },
  { 366, 8, 5, 7, 0, -5 },
  { 371, 7, 5, 5, -1, -5 },
  { 376, 6, 7, 5, -1, -5 },
  { 382, 5, 5, 4, 0, -5 },
  { 386, 4, 7, 3, 0, -6 },
  { 390, 1, 9, 5, 2, -7 },
  { 392, 4, 7, 3, -1, -6 },
  { 396, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_BlackItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_BLACKITALIC9PT7B_H_
