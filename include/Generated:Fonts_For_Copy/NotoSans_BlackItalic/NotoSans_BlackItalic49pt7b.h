#ifndef _NOTOSANS_BLACKITALIC49PT7B_H_
#define _NOTOSANS_BLACKITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x01, 0x00, 0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x7F, 0x8F,
  0xF3, 0xFC, 0x7F, 0x1F, 0xE7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xEF, 0x0E, 0x07, 0xF9, 0xE0, 0x40, 0xFF, 0x3C, 0x00, 0x1F, 0xEF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1E,
  0x7F, 0x80, 0x03, 0xCF, 0xF3, 0x00, 0x79, 0xFE, 0x7C, 0x1E, 0x7F, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x80,
  0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xF8,
  0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x07, 0xF1,
  0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x7F, 0x1F, 0xF1, 0xFC, 0xFE, 0x3F,
  0x9F, 0xFC, 0xFF, 0xFF, 0x3F, 0x9F, 0xFF, 0x3F, 0xFF, 0x3F, 0x9F, 0xFF,
  0xDF, 0xFF, 0x3F, 0x9F, 0xFF, 0xE7, 0xFF, 0x1F, 0xCF, 0xF7, 0xF1, 0xFF,
  0x1F, 0xCF, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x8F, 0xF0, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x0F,
  0xF7, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF, 0x87,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3,
  0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x20, 0x3F,
  0x00, 0x78, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0xBE, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x7E, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x7F, 0xDF, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0x0F,
  0xE0, 0x06, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x06, 0x0F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0x0F,
  0xFC, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFC,
  0x0F, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x7F,
  0xEF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xE0,
  0xFF, 0xCF, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0xCF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFD, 0xFF, 0x1F, 0xE7, 0xF8, 0x3F, 0x3F, 0xE0, 0xF0, 0xFF,
  0x81, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x3F, 0xF0, 0x0E, 0x03, 0xFF, 0x00, 0x40,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0x83, 0xFF, 0x00, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0x00, 0x07, 0xFE, 0x7C, 0x03, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xCF, 0xF8, 0x03, 0xF8, 0xFF,
  0x00, 0x7F, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3C,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xC0,
  0x01, 0xFF, 0x8F, 0x80, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x02, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE,
  0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x07, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03,
  0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFD, 0xFE, 0x3F,
  0xFB, 0xFE, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x80, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xC1, 0xFF, 0x38, 0x0F,
  0xF9, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0xFE, 0x7F, 0x3F, 0x81, 0xFF, 0xFE, 0x3F,
  0x3F, 0x83, 0xFF, 0xFC, 0x3F, 0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0x7F, 0x0F,
  0xF9, 0xFC, 0x3F, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x7E, 0x1F, 0xC1, 0xF8,
  0x3F, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0xFC,
  0x3F, 0x83, 0xF8, 0x3F, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0xFC, 0x3F, 0x03,
  0xF0, 0x7E, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0xFC, 0x3F, 0x9F, 0xF3, 0xFC, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xFD, 0xFF, 0xE0, 0x7F, 0x0F, 0xF8, 0xFF,
  0xC0, 0x7F, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xF0, 0x1F, 0xFC,
  0x01, 0xE0, 0x7F, 0xF0, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x18, 0x07,
  0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x80,
  0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0xE0,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0x00, 0x38, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE1, 0xFF,
  0xFC, 0x7F, 0xE1, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x80, 0xFF, 0x7F, 0x07,
  0xF7, 0xF8, 0x0F, 0xF7, 0xF0, 0x7E, 0xFF, 0x80, 0xFF, 0x7F, 0x0F, 0xEF,
  0xF0, 0x0F, 0xF7, 0xF0, 0xFC, 0xFF, 0x01, 0xFF, 0x7F, 0x1F, 0xCF, 0xF0,
  0x1F, 0xF7, 0xF1, 0xFD, 0xFF, 0x01, 0xFE, 0x7F, 0x3F, 0x9F, 0xF0, 0x1F,
  0xE7, 0xF3, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x7F, 0x1F, 0xE0, 0x3F, 0xE7,
  0xF7, 0xF1, 0xFE, 0x03, 0xFE, 0x7F, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFF,
  0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFF, 0xC3,
  0xFC, 0x07, 0xFC, 0x7F, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFF, 0x87, 0xFC,
  0x07, 0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xFC, 0x07, 0xF7, 0xFC, 0x1F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x7F, 0x80, 0xFF, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF3, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0xFF, 0x01,
  0xFF, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0xCF, 0xF0, 0x1F, 0xE0, 0xFF,
  0x3F, 0xC0, 0x7F, 0x83, 0xFD, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE3, 0xFF,
  0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x1F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE3, 0xFF,
  0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC7, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xFE,
  0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFC,
  0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x7C, 0x0F, 0xF8, 0x02, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x20, 0x01, 0xFF, 0x0F, 0x00, 0xFF, 0xC3, 0xF8, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01,
  0xFF, 0xBF, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0xFF,
  0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE1,
  0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFC, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xCF, 0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x0F,
  0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0x87, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFB, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xEF, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xBF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFC,
  0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF3, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0x8F,
  0xE7, 0xF8, 0x03, 0xFC, 0xFE, 0x3F, 0xBF, 0xE0, 0x0F, 0xF7, 0xF8, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xC3, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFC,
  0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x07,
  0xF3, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x07, 0xE0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0x9F, 0xC0, 0x07, 0xEF, 0xE0,
  0x01, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x7F,
  0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x18, 0x00, 0x00,
  0x1F, 0xE1, 0xFC, 0x0F, 0xFE, 0x7F, 0x83, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x3F, 0xC7, 0xFE,
  0x07, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFF, 0x07, 0xF8,
  0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x82, 0x00, 0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F,
  0xF8, 0x3F, 0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0xC7, 0xF8, 0x1F,
  0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF8, 0xFF,
  0x83, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x83, 0xFD, 0xFF, 0xE0, 0x7F, 0x1F, 0xF8, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0x06, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xF8, 0x18, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0x0F, 0xFE, 0x0E,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xC1, 0xFF, 0x00, 0x3F, 0xCF,
  0xF8, 0x07, 0xFF, 0x7F, 0xC0, 0x7F, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x83, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xF1,
  0xFF, 0x3F, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xEF, 0xF8,
  0x7F, 0xF7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x8F, 0xFC, 0x01, 0x87, 0xFF, 0x07, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x01, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F,
  0x87, 0xFE, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0xFF, 0xC0,
  0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x83, 0x00, 0x1F, 0xF3, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1,
  0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF9, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0x1F,
  0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0x00, 0x7E, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x38, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x9F, 0xF8, 0x7F, 0xF0, 0x1F, 0xCF,
  0xFF, 0x3F, 0xFE, 0x0F, 0xF7, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x1F, 0xF1, 0xFF,
  0x83, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF1, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xEF, 0xFE, 0x03, 0xFB, 0xFF, 0xE0, 0xFF,
  0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF1,
  0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF8, 0xFF, 0x83,
  0xFF, 0x3F, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7, 0xFE, 0x3F, 0xF0,
  0xFF, 0xCF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x7F,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0x03, 0xFE,
  0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0x7F, 0xEF, 0xF8, 0x1F, 0xF3, 0xFF, 0x0F,
  0xFC, 0xFF, 0xC7, 0xFF, 0x3F, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xF7, 0xFE, 0x00, 0x3F, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF,
  0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1F, 0xE1, 0xFC, 0x0F, 0xFE, 0x7F, 0x83, 0xFF, 0xEF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xF0,
  0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x3F, 0xC7,
  0xFE, 0x07, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFF, 0x07,
  0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xDF, 0xF0, 0x07, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0C, 0x1F, 0xE3, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0xFF, 0x0F,
  0xF7, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFC, 0x21, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xF8, 0x38, 0x3F, 0xF0, 0x10, 0x7F, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x8C, 0x01, 0xFF, 0x1F, 0x8F, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x18, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xFF,
  0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFE, 0x03, 0xFF, 0x9F, 0xE0,
  0x1F, 0xF1, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF,
  0x80, 0xFF, 0xC7, 0xF8, 0x0F, 0xFC, 0x7F, 0x81, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xCF,
  0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x9F, 0xE0, 0x7F, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0xF0, 0x7F, 0xC7,
  0xF8, 0x3F, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F,
  0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xFF, 0x8F,
  0xF8, 0x3F, 0xC7, 0xEF, 0xC7, 0xFC, 0x1F, 0xE3, 0xF7, 0xE7, 0xFC, 0x0F,
  0xF3, 0xFB, 0xF3, 0xFE, 0x07, 0xF9, 0xF9, 0xF9, 0xFE, 0x03, 0xFC, 0xFC,
  0xFD, 0xFF, 0x01, 0xFE, 0xFE, 0xFE, 0xFF, 0x00, 0xFF, 0x7E, 0x7F, 0xFF,
  0x80, 0x7F, 0xBF, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x03, 0xFF, 0xC3,
  0xFF, 0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F,
  0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFC,
};

const GFXglyph NotoSans_BlackItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 17, 36, 15, 0, -35 },
  { 78, 21, 13, 22, 4, -35 },
  { 113, 32, 35, 32, 0, -35 },
  { 253, 27, 40, 28, 1, -37 },
  { 388, 41, 35, 46, 3, -35 },
  { 568, 36, 36, 36, 0, -36 },
  { 730, 10, 13, 12, 4, -35 },
  { 747, 20, 44, 18, 2, -36 },
  { 857, 20, 44, 18, -3, -36 },
  { 967, 24, 25, 27, 4, -38 },
  { 1042, 24, 24, 29, 2, -29 },
  { 1114, 14, 12, 15, -3, -6 },
  { 1135, 14, 8, 16, 1, -17 },
  { 1149, 10, 10, 15, 0, -9 },
  { 1162, 28, 35, 23, -2, -35 },
  { 1285, 26, 36, 28, 2, -36 },
  { 1402, 22, 35, 28, 4, -35 },
  { 1499, 28, 35, 28, -1, -35 },
  { 1622, 27, 35, 28, 0, -35 },
  { 1741, 28, 35, 28, 0, -35 },
  { 1864, 28, 35, 28, 0, -35 },
  { 1987, 27, 35, 28, 2, -35 },
  { 2106, 30, 35, 28, 1, -35 },
  { 2238, 27, 36, 28, 1, -36 },
  { 2360, 24, 35, 28, 3, -35 },
  { 2465, 15, 28, 15, 0, -27 },
  { 2518, 18, 33, 15, -3, -27 },
  { 2593, 24, 27, 29, 2, -31 },
  { 2674, 25, 17, 29, 2, -26 },
  { 2728, 24, 27, 29, 2, -31 },
  { 2809, 21, 36, 24, 4, -35 },
  { 2904, 40, 39, 44, 2, -35 },
  { 3099, 33, 35, 33, -3, -35 },
  { 3244, 29, 35, 31, 1, -35 },
  { 3371, 31, 36, 31, 2, -36 },
  { 3511, 31, 35, 34, 1, -35 },
  { 3647, 28, 35, 28, 1, -35 },
  { 3770, 28, 35, 28, 1, -35 },
  { 3893, 32, 36, 34, 2, -36 },
  { 4037, 34, 35, 35, 1, -35 },
  { 4186, 26, 35, 21, -2, -35 },
  { 4300, 26, 46, 18, -8, -35 },
  { 4450, 35, 35, 33, 1, -35 },
  { 4604, 22, 35, 26, 1, -35 },
  { 4701, 44, 35, 45, 1, -35 },
  { 4894, 38, 35, 39, 1, -35 },
  { 5061, 33, 36, 36, 2, -36 },
  { 5210, 29, 35, 31, 1, -35 },
  { 5337, 33, 44, 36, 2, -36 },
  { 5519, 29, 35, 32, 1, -35 },
  { 5646, 26, 35, 27, 1, -35 },
  { 5760, 26, 35, 27, 4, -35 },
  { 5874, 32, 35, 34, 3, -35 },
  { 6014, 30, 35, 30, 4, -35 },
  { 6146, 46, 35, 46, 4, -35 },
  { 6348, 39, 35, 32, -3, -35 },
  { 6519, 30, 35, 30, 4, -35 },
  { 6651, 31, 35, 26, -2, -35 },
  { 6787, 22, 44, 18, -1, -36 },
  { 6908, 14, 35, 23, 5, -35 },
  { 6970, 22, 44, 18, -3, -36 },
  { 7091, 26, 23, 26, 0, -35 },
  { 7166, 23, 6, 22, -4, 3 },
  { 7184, 12, 8, 17, 7, -38 },
  { 7196, 27, 28, 30, 2, -28 },
  { 7291, 27, 37, 30, 1, -37 },
  { 7416, 23, 28, 25, 2, -28 },
  { 7497, 29, 37, 30, 2, -37 },
  { 7632, 25, 28, 28, 2, -28 },
  { 7720, 30, 49, 20, -5, -37 },
  { 7904, 28, 40, 30, 1, -28 },
  { 8044, 27, 37, 30, 1, -37 },
  { 8169, 16, 38, 16, 1, -38 },
  { 8245, 24, 50, 16, -6, -38 },
  { 8395, 32, 37, 30, 1, -37 },
  { 8543, 17, 37, 16, 1, -37 },
  { 8622, 42, 28, 45, 1, -28 },
  { 8769, 27, 28, 30, 1, -28 },
  { 8864, 26, 28, 30, 2, -28 },
  { 8955, 30, 40, 30, -2, -28 },
  { 9105, 27, 40, 30, 2, -28 },
  { 9240, 22, 28, 21, 1, -28 },
  { 9317, 23, 28, 25, 1, -28 },
  { 9398, 21, 33, 22, 2, -33 },
  { 9485, 28, 27, 30, 2, -27 },
  { 9580, 28, 27, 27, 2, -27 },
  { 9675, 41, 27, 40, 2, -27 },
  { 9814, 34, 27, 28, -3, -27 },
  { 9929, 32, 39, 27, -3, -27 },
  { 10085, 26, 27, 24, -1, -27 },
  { 10173, 21, 43, 18, 0, -35 },
  { 10286, 6, 48, 28, 11, -37 },
  { 10322, 21, 43, 18, -3, -35 },
  { 10435, 24, 9, 29, 2, -22 },
};

const GFXfont NotoSans_BlackItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_BLACKITALIC49PT7B_H_
