#ifndef _NOTOSANS_BLACKITALIC52PT7B_H_
#define _NOTOSANS_BLACKITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0x00, 0x00, 0x7F, 0xC7, 0xFB, 0xFE, 0x7F, 0xDF, 0xE3, 0xFE, 0xFF,
  0x1F, 0xE7, 0xF8, 0xFF, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0x9F, 0xE1, 0xFC,
  0xFF, 0x1F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFB, 0xC7, 0xC0,
  0xFF, 0x9E, 0x06, 0x07, 0xFC, 0xF0, 0x00, 0x3F, 0xEF, 0x80, 0x01, 0xFF,
  0x78, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xDF, 0xF0, 0x00, 0x1E, 0x7F, 0x88, 0x01, 0xF3,
  0xFC, 0x78, 0x0F, 0x1F, 0xE3, 0xF8, 0x7B, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x8F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xE1, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x83, 0xC0, 0xFE, 0x3F, 0xCF, 0xF1,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFE, 0x3F, 0xFC, 0xFF, 0xFF, 0x9F, 0xC7, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0x9F, 0xFF, 0xF3,
  0xFF, 0xC7, 0xF1, 0xFE, 0xFF, 0x1F, 0xF8, 0xFE, 0x3F, 0xC7, 0xF0, 0x3C,
  0x1F, 0xE3, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x3F,
  0x87, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF1, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE3, 0xFF, 0x1F, 0xFD, 0xFF, 0xDF, 0xF8, 0x7F, 0xE3, 0xFF,
  0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0x80, 0xFE, 0x00, 0xF0,
  0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0xDF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0x87, 0xFF, 0xE0,
  0x0F, 0xFB, 0xF0, 0x0F, 0xFD, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFC, 0x7F,
  0x80, 0x1E, 0x1F, 0xC0, 0x06, 0x0F, 0xF0, 0x01, 0x07, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0x1F, 0x87, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x7F, 0x83, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3,
  0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03,
  0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xFB, 0xFE,
  0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xC3, 0xF9, 0xFF, 0x87, 0xE3, 0xFF, 0x07,
  0x07, 0xFC, 0x08, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0xFF, 0xC0, 0x1C, 0x07, 0xFE, 0x00, 0xC0,
  0x3F, 0xF0, 0x02, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xF8, 0x7F, 0xF8, 0x07, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC8, 0x00, 0x0F, 0xFE, 0x70, 0x00, 0xFF,
  0xF3, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFE,
  0x7F, 0xC0, 0x0F, 0xF3, 0xFF, 0x00, 0x7F, 0x8F, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x87, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7C, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0x00, 0x03, 0xFF, 0x8E, 0x00,
  0x3F, 0xF8, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x60, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xF9, 0xFF, 0xE0, 0x7F, 0xDF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x1F, 0xFC,
  0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F,
  0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE3, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC7, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xFC, 0x07, 0xFC, 0xFF,
  0xC0, 0x7F, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xE1, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF, 0x9F, 0xF8, 0x3F, 0xEF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xEF, 0xF8, 0xFF, 0xF7, 0xFE, 0x0F, 0xF9, 0xFF, 0x00,
  0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x0C, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0x87, 0xFE, 0x38, 0x0F, 0xFC, 0x40, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0x0F,
  0xE1, 0xFC, 0x07, 0xFF, 0xF8, 0xFE, 0x7F, 0x83, 0xFF, 0xFE, 0x1F, 0xCF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xF9, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0x7F, 0x07,
  0xF8, 0x7F, 0x0F, 0xEF, 0xE1, 0xFE, 0x0F, 0xC1, 0xFD, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0xBF, 0x0F, 0xF0, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x0F, 0xE0,
  0xFF, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xFF, 0x87, 0xF0, 0x7F, 0x03, 0xF7,
  0xF1, 0xFC, 0x0F, 0xE0, 0xFE, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0x9F, 0xC7,
  0xF0, 0x7F, 0x87, 0xF3, 0xF8, 0xFF, 0x1F, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xE1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC3, 0xFF, 0x9F, 0xFE, 0x03, 0xF8, 0x3F, 0xE3, 0xFF, 0x00,
  0x7F, 0x81, 0xE0, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xE0,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x9F,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x3F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xF8, 0x1F, 0xFC,
  0x00, 0x30, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0x80, 0xFF, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1E, 0x07, 0xFF,
  0x80, 0x02, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE1, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0x9F,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x80,
  0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0x7F,
  0x03, 0xFB, 0xFE, 0x01, 0xFE, 0xFE, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFC,
  0x1F, 0xDF, 0xF0, 0x0F, 0xFB, 0xF8, 0x3F, 0xBF, 0xE0, 0x1F, 0xF7, 0xF0,
  0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xE1, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xC7,
  0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0x8F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0x3F,
  0x8F, 0xF8, 0x07, 0xFC, 0xFE, 0x7F, 0x1F, 0xF0, 0x0F, 0xF9, 0xFD, 0xFE,
  0x3F, 0xC0, 0x3F, 0xE3, 0xFB, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0xF1,
  0xFF, 0x00, 0xFF, 0x8F, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0x87,
  0xFC, 0x03, 0xFC, 0x3F, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0xE0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFC, 0x07, 0xFB, 0xFE, 0x07, 0xFC, 0x07, 0xFB, 0xFE, 0x07, 0xFC,
  0x07, 0xFB, 0xFE, 0x07, 0xF8, 0x07, 0xF9, 0xFF, 0x0F, 0xF8, 0x0F, 0xF9,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF9, 0xFF, 0x0F, 0xF8, 0x0F, 0xF9, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF0, 0x7F,
  0xDF, 0xF0, 0x1F, 0xF0, 0x7F, 0xDF, 0xE0, 0x3F, 0xE0, 0x7F, 0xDF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xFE, 0x07, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xF0, 0x07,
  0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x9F,
  0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF,
  0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0x1F, 0xC0, 0xFF, 0xC0, 0x38, 0x0F, 0xFC, 0x00, 0x80, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x08, 0x00, 0x3F, 0xF0, 0xE0, 0x03, 0xFF, 0x0F,
  0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF,
  0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFB, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFD,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFC, 0xFF, 0x3F, 0xF0, 0x07, 0xF9, 0xFE,
  0x7F, 0x9F, 0xF0, 0x03, 0xFC, 0xFF, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF,
  0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0x8F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF,
  0x87, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE,
  0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xFE,
  0x3F, 0xC0, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0,
  0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF, 0x81, 0xFF,
  0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFB,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xFC, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE7,
  0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF,
  0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFE, 0x03, 0xFF, 0x3F, 0xE0, 0x7F,
  0xE3, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0xE7, 0xFF, 0x1F, 0xFC, 0x7F,
  0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF, 0xE0, 0xFF, 0x3F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xF8, 0x0C, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0x0F, 0xFE, 0x03,
  0x07, 0xFF, 0xCF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xF8, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x87, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0xF8, 0xFF, 0xC3, 0xFF, 0x3F,
  0xF0, 0x3F, 0xE7, 0xFE, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x41, 0xFF, 0xC0, 0x38, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xDF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x03, 0xFF,
  0x8F, 0xF0, 0x1F, 0xFF, 0x7F, 0xC0, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF,
  0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xC1, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x7F, 0xC0, 0x07, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x80, 0x07, 0xFE, 0x03, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x7F, 0xEF, 0xFE, 0x03, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xCF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC7, 0xFF,
  0x07, 0xFE, 0x01, 0xFE, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xF7, 0xFF, 0xE7,
  0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC7,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC7,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xFF, 0x01, 0xFE, 0x7F, 0xF8, 0x0F, 0xF7,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F,
  0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC7,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F,
  0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xE7, 0xFF,
  0x3F, 0xF8, 0x7F, 0xE7, 0xFE, 0x0F, 0xFD, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0,
  0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03,
  0xFF, 0x7F, 0xE0, 0xFF, 0xEF, 0xFC, 0x1F, 0xF9, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x03,
  0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF,
  0x81, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0x00,
  0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFE, 0x04, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xFE,
  0x3F, 0xC0, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0,
  0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF,
  0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFB,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFC, 0x3F, 0x07, 0xF8, 0xFF, 0x07, 0xF9, 0xFE, 0x07, 0xFB, 0xFE, 0x07,
  0xFB, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0x04, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFD, 0xFC, 0x1F,
  0xF8, 0x3C, 0x1F, 0xF8, 0x08, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x80, 0x0F, 0xFC, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE1, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x08, 0x1F, 0xFD,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF,
  0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xE7, 0xFC, 0x07, 0xFE, 0x3F, 0xE0,
  0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F, 0x87, 0xFC, 0x03,
  0xFC, 0x7F, 0xE0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFD,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFB, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xCF,
  0xF8, 0x3F, 0xFC, 0x1F, 0xF9, 0xFF, 0x07, 0xFF, 0x83, 0xFE, 0x3F, 0xE1,
  0xFF, 0xF0, 0xFF, 0xC7, 0xFC, 0x3F, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFF,
  0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0x7F, 0x1F,
  0xF0, 0x7F, 0xC7, 0xEF, 0xE7, 0xFC, 0x0F, 0xF9, 0xFD, 0xFC, 0xFF, 0x81,
  0xFF, 0x3F, 0xBF, 0x3F, 0xE0, 0x3F, 0xEF, 0xE7, 0xE7, 0xFC, 0x07, 0xFD,
  0xFC, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0x1F, 0xBF, 0xE0, 0x0F, 0xFF, 0xE3,
  0xF7, 0xFC, 0x01, 0xFF, 0xFC, 0x7E, 0xFF, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xE3,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x27, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x4F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xC0, 0x03, 0xFF, 0x20, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_BlackItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 18, 38, 16, 0, -37 },
  { 87, 21, 13, 24, 5, -37 },
  { 122, 34, 37, 34, 0, -37 },
  { 280, 29, 43, 30, 1, -40 },
  { 436, 44, 39, 48, 3, -38 },
  { 651, 38, 39, 38, 0, -38 },
  { 837, 10, 13, 12, 5, -37 },
  { 854, 21, 46, 19, 2, -38 },
  { 975, 21, 46, 19, -3, -38 },
  { 1096, 25, 26, 28, 4, -40 },
  { 1178, 26, 25, 30, 2, -31 },
  { 1260, 14, 13, 16, -3, -6 },
  { 1283, 15, 8, 17, 1, -18 },
  { 1298, 11, 10, 16, 0, -9 },
  { 1312, 30, 39, 24, -2, -38 },
  { 1459, 27, 39, 30, 2, -38 },
  { 1591, 23, 37, 30, 4, -37 },
  { 1698, 29, 38, 30, -1, -38 },
  { 1836, 29, 39, 30, 0, -38 },
  { 1978, 30, 37, 30, 0, -37 },
  { 2117, 29, 38, 30, 1, -37 },
  { 2255, 29, 39, 30, 2, -38 },
  { 2397, 31, 37, 30, 1, -37 },
  { 2541, 28, 39, 30, 1, -38 },
  { 2678, 26, 39, 30, 3, -38 },
  { 2805, 16, 30, 16, 0, -29 },
  { 2865, 19, 36, 16, -3, -29 },
  { 2951, 26, 28, 30, 2, -33 },
  { 3042, 26, 19, 30, 2, -28 },
  { 3104, 26, 28, 30, 2, -33 },
  { 3195, 23, 39, 25, 4, -38 },
  { 3308, 43, 43, 47, 2, -38 },
  { 3540, 35, 37, 35, -3, -37 },
  { 3702, 31, 37, 33, 1, -37 },
  { 3846, 32, 39, 33, 3, -38 },
  { 4002, 33, 37, 36, 1, -37 },
  { 4155, 30, 37, 29, 1, -37 },
  { 4294, 30, 37, 30, 1, -37 },
  { 4433, 33, 39, 36, 3, -38 },
  { 4594, 36, 37, 37, 1, -37 },
  { 4761, 27, 37, 22, -2, -37 },
  { 4886, 28, 49, 19, -8, -37 },
  { 5058, 38, 37, 35, 1, -37 },
  { 5234, 24, 37, 27, 1, -37 },
  { 5345, 47, 37, 47, 1, -37 },
  { 5563, 40, 37, 41, 1, -37 },
  { 5748, 34, 39, 38, 3, -38 },
  { 5914, 31, 37, 32, 1, -37 },
  { 6058, 34, 47, 38, 3, -38 },
  { 6258, 31, 37, 34, 1, -37 },
  { 6402, 28, 39, 29, 1, -38 },
  { 6539, 28, 37, 29, 4, -37 },
  { 6669, 34, 38, 36, 3, -37 },
  { 6831, 32, 37, 32, 4, -37 },
  { 6979, 49, 37, 49, 4, -37 },
  { 7206, 41, 37, 34, -3, -37 },
  { 7396, 32, 37, 31, 4, -37 },
  { 7544, 33, 37, 28, -2, -37 },
  { 7697, 23, 47, 19, -1, -38 },
  { 7833, 14, 39, 24, 6, -38 },
  { 7902, 23, 47, 19, -3, -38 },
  { 8038, 27, 24, 28, 0, -37 },
  { 8119, 25, 7, 23, -5, 3 },
  { 8141, 13, 8, 18, 7, -40 },
  { 8154, 29, 30, 32, 2, -29 },
  { 8263, 28, 41, 32, 1, -40 },
  { 8407, 25, 30, 26, 2, -29 },
  { 8501, 31, 41, 31, 2, -40 },
  { 8660, 27, 30, 30, 2, -29 },
  { 8762, 32, 52, 21, -5, -40 },
  { 8970, 30, 41, 32, 1, -29 },
  { 9124, 29, 40, 32, 1, -40 },
  { 9269, 17, 40, 17, 1, -40 },
  { 9354, 26, 52, 17, -7, -40 },
  { 9523, 34, 40, 32, 1, -40 },
  { 9693, 18, 40, 17, 1, -40 },
  { 9783, 45, 29, 48, 1, -29 },
  { 9947, 29, 29, 32, 1, -29 },
  { 10053, 27, 30, 32, 2, -29 },
  { 10155, 31, 41, 32, -2, -29 },
  { 10314, 29, 41, 32, 2, -29 },
  { 10463, 24, 29, 23, 1, -29 },
  { 10550, 24, 30, 26, 1, -29 },
  { 10640, 22, 36, 24, 2, -35 },
  { 10739, 30, 30, 32, 2, -29 },
  { 10852, 29, 29, 28, 2, -29 },
  { 10958, 43, 29, 43, 3, -29 },
  { 11114, 36, 29, 29, -3, -29 },
  { 11245, 34, 41, 28, -3, -29 },
  { 11420, 27, 29, 25, -1, -29 },
  { 11518, 22, 45, 19, 0, -37 },
  { 11642, 7, 51, 29, 11, -39 },
  { 11687, 22, 45, 19, -3, -37 },
  { 11811, 26, 10, 30, 2, -23 },
};

const GFXfont NotoSans_BlackItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_BLACKITALIC52PT7B_H_
