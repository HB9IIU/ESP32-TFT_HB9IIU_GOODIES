#ifndef _NOTOSANS_BLACKITALIC38PT7B_H_
#define _NOTOSANS_BLACKITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3F,
  0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x3F, 0x3F, 0x7F,
  0x3F, 0x7E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0x7C, 0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE3, 0xE0, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x3E, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xDC, 0x60, 0xFD, 0xE0, 0x0F, 0xEE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xCF, 0xC8, 0x0E,
  0x7E, 0x70, 0x77, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xF8,
  0x1F, 0xF8, 0x03, 0xF0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xC0,
  0x7E, 0x7C, 0x0F, 0xC0, 0x7C, 0x7C, 0x1F, 0x80, 0x7C, 0x7C, 0x1F, 0x00,
  0xFC, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0xFC, 0x00,
  0xF8, 0xFC, 0xF8, 0x60, 0xFD, 0xF9, 0xF1, 0xFC, 0xFF, 0xFB, 0xF7, 0xFE,
  0x7F, 0xF7, 0xEF, 0xFF, 0x7F, 0xE7, 0xCF, 0xFF, 0x3F, 0xCF, 0x9F, 0x9F,
  0x02, 0x1F, 0x9F, 0x9F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1F,
  0x00, 0x7C, 0x3F, 0x1F, 0x00, 0xFC, 0x3F, 0x1F, 0x00, 0xF8, 0x3F, 0x3F,
  0x01, 0xF0, 0x3F, 0x7E, 0x03, 0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x1F, 0xFC,
  0x07, 0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x10, 0x7F, 0xF8, 0xFE, 0x1F, 0xFF, 0x0F,
  0xE3, 0xFF, 0xF1, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xFB, 0xFF, 0xFC, 0xFF,
  0x1F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0x0F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE7, 0xF8, 0x3F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x20, 0x7C, 0x07, 0x0F, 0x80, 0xF9, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFB,
  0xE1, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x0C, 0x7E,
  0x00, 0x87, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x1F, 0x87,
  0xE1, 0xF0, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF,
  0xFE, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xEF, 0xF1, 0xFC, 0x7F, 0x3F, 0xC7, 0xF3,
  0xF8, 0x7F, 0x7F, 0x87, 0xF7, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xEF, 0xE1, 0xFE, 0xFE, 0x1F, 0xEF, 0xF3, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xF9,
  0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xFE, 0x3E, 0x7F, 0x0C, 0x3F, 0x84, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF0, 0xFF, 0x01, 0x83, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x00, 0x08, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x1F, 0xE0, 0x40, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x60, 0x0F, 0xFB,
  0xF3, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0xC0, 0x1F, 0xE3, 0xF3, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xF0, 0x43, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x8F, 0xE7, 0xF8, 0x7F, 0xBF, 0xC3, 0xF9,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFE, 0xFF, 0x8F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xE3, 0xF1,
  0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0xEF, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xF9, 0xFC, 0x7F, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFE, 0xFE, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xE7, 0xFB, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xEF, 0xC7, 0xFB, 0xF8, 0x7E,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x31, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x07,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xF0, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFC, 0x1F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFD, 0xF1, 0xFE, 0x60, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x3F, 0x07, 0xFC, 0x7C, 0x7C, 0x3F, 0xFC, 0xFD, 0xF0, 0xFF, 0xF8,
  0xFB, 0xE3, 0xFF, 0xF1, 0xFF, 0x87, 0xE3, 0xE3, 0xFF, 0x1F, 0x8F, 0x87,
  0xFE, 0x3E, 0x1F, 0x0F, 0xFC, 0xFC, 0x3E, 0x1F, 0xF1, 0xF0, 0x7C, 0x3D,
  0xE3, 0xE1, 0xF0, 0xFB, 0xC7, 0xC3, 0xE1, 0xF7, 0x8F, 0x8F, 0xCF, 0xCF,
  0x9F, 0xFF, 0xFF, 0x1F, 0x1F, 0xFF, 0xFC, 0x3E, 0x3F, 0xDF, 0xF0, 0x7E,
  0x3F, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x08, 0x00, 0xFE,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0,
  0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC,
  0xFF, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF0,
  0x1C, 0x3F, 0xC0, 0x08, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x18, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x07, 0xFC, 0x7F,
  0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xF0, 0x0C, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xFE, 0xFF, 0x1F, 0xFE,
  0xFF, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x3F, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x83, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x87,
  0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0xFE, 0x0F, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF,
  0x1F, 0xE0, 0x1F, 0xC7, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0xC0,
  0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF3, 0xFC, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF,
  0x83, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xBF, 0x07, 0xEF, 0x83, 0xFF, 0xC1, 0xFB, 0xE1,
  0xF7, 0xE0, 0x7E, 0xF8, 0x7D, 0xF8, 0x1F, 0xBE, 0x3E, 0x7E, 0x0F, 0xEF,
  0x8F, 0xBF, 0x83, 0xFB, 0xE7, 0xEF, 0xE0, 0xFC, 0xF9, 0xF3, 0xF0, 0x3F,
  0x3E, 0xFC, 0xFC, 0x0F, 0xCF, 0xBE, 0x7F, 0x07, 0xF3, 0xFF, 0x9F, 0xC1,
  0xFC, 0xFF, 0xC7, 0xF0, 0x7E, 0x3F, 0xF1, 0xF8, 0x1F, 0x8F, 0xF8, 0x7E,
  0x07, 0xE3, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x00, 0x07, 0xFC,
  0x01, 0xF8, 0x3F, 0xE0, 0x1F, 0xC1, 0xFF, 0x80, 0xFE, 0x0F, 0xFC, 0x07,
  0xE0, 0xFF, 0xE0, 0x3F, 0x07, 0xFF, 0x01, 0xF8, 0x3F, 0xFC, 0x1F, 0xC1,
  0xFF, 0xE0, 0xFE, 0x0F, 0xBF, 0x07, 0xE0, 0xFD, 0xFC, 0x3F, 0x07, 0xEF,
  0xE3, 0xF8, 0x3F, 0x3F, 0x1F, 0xC1, 0xF9, 0xF8, 0xFE, 0x1F, 0xCF, 0xE7,
  0xE0, 0xFE, 0x3F, 0x3F, 0x07, 0xF1, 0xF9, 0xF8, 0x3F, 0x0F, 0xFF, 0xC1,
  0xF8, 0x7F, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x07, 0xE0,
  0x7F, 0xF8, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xFC, 0x1F, 0xC0, 0x7F,
  0xE0, 0xFE, 0x03, 0xFF, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0x00, 0x7F, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF7, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF,
  0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFE, 0x3F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC7, 0xF1,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x3F, 0xCF, 0xF0, 0x3F,
  0xE7, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x9F, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x3F,
  0xC7, 0xF3, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0xFF, 0x07, 0xF9, 0xFC, 0x1F, 0xC7,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x3F, 0xC1, 0xFC,
  0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xC0, 0x00, 0x08, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xE3, 0xC1, 0xFC, 0x04, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x80,
  0x3F, 0x8E, 0x07, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F,
  0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC1, 0xF8, 0x7F, 0x03,
  0xF1, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xEF,
  0xE0, 0x7F, 0x81, 0xFC, 0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x83,
  0xF8, 0xFE, 0x0F, 0xF8, 0x3F, 0x8F, 0xE1, 0xFF, 0x83, 0xF0, 0xFE, 0x1F,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0xFE, 0x3E, 0xF8, 0xFE, 0x0F,
  0xE3, 0xEF, 0x8F, 0xE0, 0xFE, 0x7F, 0xF8, 0xFC, 0x0F, 0xE7, 0xDF, 0x9F,
  0xC0, 0xFC, 0xFD, 0xF9, 0xF8, 0x0F, 0xCF, 0xDF, 0xBF, 0x80, 0xFC, 0xF9,
  0xFB, 0xF8, 0x0F, 0xDF, 0x9F, 0xBF, 0x00, 0xFD, 0xF1, 0xFF, 0xF0, 0x0F,
  0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFC,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFE, 0x7F, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF9,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0x07, 0xE1, 0xFC, 0x0F,
  0xE7, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF,
  0x80, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF0,
  0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xFF,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x03, 0xF1, 0xF8, 0x7F, 0xDF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xEF, 0xF1, 0xFE,
  0x3F, 0x8F, 0xE1, 0xFC, 0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF1,
  0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFF, 0x1F, 0xEF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xBF, 0x03,
  0xFB, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x1F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87,
  0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0xFF, 0x0F, 0xF7, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xBF, 0xE0, 0xFC, 0x7F, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xF3,
  0xC7, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x43, 0xFE, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF3, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0x7F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE3, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xF7, 0xE0, 0x3F, 0xBF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x1F, 0xDF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x47, 0xF8, 0x38, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFD, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x7E, 0x07, 0xFD, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFE, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x60, 0x1F, 0xE0, 0xF8, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xCF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC3,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC,
  0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0x00, 0x60,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x03, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x07, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F,
  0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xE7,
  0xF0, 0x7E, 0x03, 0xE7, 0xFC, 0xFF, 0x83, 0xF7, 0xFE, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xDF, 0xFB, 0xFC, 0x7F,
  0x87, 0xF8, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0x0F, 0xF3,
  0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC1, 0xFC,
  0x7F, 0x0F, 0xE0, 0xFE, 0x7F, 0x87, 0xF0, 0xFF, 0x3F, 0x83, 0xF8, 0x7F,
  0x1F, 0xC3, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xCF, 0xF0, 0xFE, 0x1F,
  0xE0, 0x07, 0xE7, 0xF0, 0x1F, 0x3F, 0xE0, 0xFD, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xCF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F,
  0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xF8, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0xFF, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xE1, 0xFE, 0xFE, 0x3F,
  0xCF, 0xE3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x01, 0xF7, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE3,
  0xFC, 0x0F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF1,
  0xF8, 0x7F, 0xDF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F,
  0xEF, 0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFF, 0x0F, 0xE7, 0xF0, 0x7F,
  0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0x7F, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0xFD, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xD8, 0x7F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFC, 0x10, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFA, 0x03,
  0xF9, 0x81, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0xF9, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF7, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC3, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC3,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFF, 0x1F,
  0xEF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xBF,
  0x03, 0xF9, 0xF8, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xFD,
  0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xC7,
  0xF0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xF8, 0x7F, 0x87, 0xF7,
  0xF1, 0xFF, 0x0F, 0xEF, 0xE3, 0xFE, 0x3F, 0x9F, 0xC7, 0xFC, 0x7F, 0x3F,
  0x9F, 0xF8, 0xFC, 0x7F, 0x3F, 0xF3, 0xF8, 0xFE, 0x7B, 0xE7, 0xE1, 0xFD,
  0xF7, 0xDF, 0xC1, 0xFB, 0xEF, 0xBF, 0x03, 0xFF, 0x9F, 0x7E, 0x07, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF1,
  0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE7, 0xF8, 0x03,
  0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x81,
  0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xF0,
  0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xF0, 0x03,
  0xF3, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xA0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_BlackItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 27, 12, 0, -27 },
  { 45, 16, 10, 17, 3, -27 },
  { 65, 25, 27, 25, 0, -27 },
  { 150, 21, 31, 22, 1, -29 },
  { 232, 32, 28, 35, 2, -28 },
  { 344, 28, 28, 28, 0, -28 },
  { 442, 8, 10, 9, 3, -27 },
  { 452, 16, 34, 14, 1, -28 },
  { 520, 15, 34, 14, -2, -28 },
  { 584, 19, 19, 21, 3, -29 },
  { 630, 19, 19, 22, 2, -23 },
  { 676, 10, 9, 12, -2, -4 },
  { 688, 12, 6, 13, 0, -13 },
  { 697, 8, 7, 12, 0, -7 },
  { 704, 22, 28, 18, -2, -28 },
  { 781, 20, 28, 22, 1, -28 },
  { 851, 17, 27, 22, 3, -27 },
  { 909, 22, 28, 22, -1, -28 },
  { 986, 21, 28, 22, 0, -28 },
  { 1060, 22, 27, 22, 0, -27 },
  { 1135, 22, 27, 22, 0, -27 },
  { 1210, 21, 28, 22, 1, -28 },
  { 1284, 23, 27, 22, 1, -27 },
  { 1362, 20, 28, 22, 1, -28 },
  { 1432, 19, 28, 22, 2, -28 },
  { 1499, 11, 21, 12, 0, -21 },
  { 1528, 13, 26, 12, -2, -21 },
  { 1571, 18, 21, 22, 2, -24 },
  { 1619, 19, 13, 22, 2, -20 },
  { 1650, 18, 21, 22, 2, -24 },
  { 1698, 17, 28, 19, 3, -28 },
  { 1758, 31, 31, 34, 2, -28 },
  { 1879, 25, 27, 26, -2, -27 },
  { 1964, 23, 27, 24, 1, -27 },
  { 2042, 23, 28, 24, 2, -28 },
  { 2123, 24, 27, 26, 1, -27 },
  { 2204, 21, 27, 21, 1, -27 },
  { 2275, 21, 27, 22, 1, -27 },
  { 2346, 24, 28, 27, 2, -28 },
  { 2430, 26, 27, 27, 1, -27 },
  { 2518, 19, 27, 16, -1, -27 },
  { 2583, 20, 36, 14, -6, -27 },
  { 2673, 27, 27, 25, 1, -27 },
  { 2765, 17, 27, 20, 1, -27 },
  { 2823, 34, 27, 35, 1, -27 },
  { 2938, 29, 27, 30, 1, -27 },
  { 3036, 25, 28, 28, 2, -28 },
  { 3124, 22, 27, 24, 1, -27 },
  { 3199, 25, 34, 28, 2, -28 },
  { 3306, 22, 27, 25, 1, -27 },
  { 3381, 20, 28, 21, 1, -28 },
  { 3451, 20, 27, 21, 3, -27 },
  { 3519, 25, 27, 27, 2, -27 },
  { 3604, 23, 27, 23, 3, -27 },
  { 3682, 36, 27, 36, 3, -27 },
  { 3804, 30, 27, 25, -2, -27 },
  { 3906, 23, 27, 23, 3, -27 },
  { 3984, 25, 27, 20, -2, -27 },
  { 4069, 17, 34, 14, -1, -28 },
  { 4142, 10, 28, 18, 4, -28 },
  { 4177, 17, 34, 14, -2, -28 },
  { 4250, 20, 18, 20, 0, -27 },
  { 4295, 18, 5, 17, -3, 2 },
  { 4307, 10, 6, 13, 5, -29 },
  { 4315, 21, 21, 23, 2, -21 },
  { 4371, 22, 29, 23, 0, -29 },
  { 4451, 18, 21, 19, 2, -21 },
  { 4499, 22, 29, 23, 2, -29 },
  { 4579, 19, 21, 22, 2, -21 },
  { 4629, 23, 38, 16, -4, -29 },
  { 4739, 23, 30, 23, 0, -21 },
  { 4826, 22, 29, 24, 0, -29 },
  { 4906, 13, 30, 12, 0, -30 },
  { 4955, 19, 39, 12, -5, -30 },
  { 5048, 26, 29, 23, 0, -29 },
  { 5143, 14, 29, 12, 0, -29 },
  { 5194, 33, 21, 35, 0, -21 },
  { 5281, 22, 21, 24, 0, -21 },
  { 5339, 20, 21, 23, 2, -21 },
  { 5392, 24, 30, 23, -2, -21 },
  { 5482, 21, 30, 23, 2, -21 },
  { 5561, 18, 21, 17, 0, -21 },
  { 5609, 17, 21, 19, 1, -21 },
  { 5654, 17, 25, 17, 1, -25 },
  { 5708, 21, 21, 24, 2, -21 },
  { 5764, 21, 21, 21, 2, -21 },
  { 5820, 31, 21, 31, 2, -21 },
  { 5902, 26, 21, 22, -2, -21 },
  { 5971, 25, 30, 21, -2, -21 },
  { 6065, 20, 21, 18, -1, -21 },
  { 6118, 16, 33, 14, 0, -27 },
  { 6184, 5, 38, 22, 8, -29 },
  { 6208, 16, 33, 14, -2, -27 },
  { 6274, 19, 7, 22, 2, -17 },
};

const GFXfont NotoSans_BlackItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_BLACKITALIC38PT7B_H_
