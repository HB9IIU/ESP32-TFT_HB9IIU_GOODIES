#ifndef _NOTOSANS_BLACKITALIC16PT7B_H_
#define _NOTOSANS_BLACKITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8C, 0x71, 0xC7, 0x00, 0x63, 0x8E, 0x00, 0x7E, 0xDD,
  0xB6, 0x60, 0x0D, 0xC1, 0xB0, 0x66, 0x3F, 0xF7, 0xFC, 0x36, 0x3F, 0xF7,
  0xFE, 0x36, 0x0C, 0xC1, 0xB8, 0x00, 0x02, 0x0F, 0xCF, 0xE6, 0x97, 0x41,
  0xE0, 0x7C, 0x1E, 0x8B, 0x7F, 0xBF, 0x82, 0x01, 0x00, 0x10, 0x11, 0xE1,
  0x8E, 0xCE, 0x33, 0x30, 0xDD, 0x83, 0x6D, 0xEF, 0xFF, 0x89, 0xB7, 0x0C,
  0xD8, 0x63, 0x63, 0x8F, 0x9C, 0x3C, 0x06, 0x01, 0xF8, 0x3F, 0x83, 0xB8,
  0x3B, 0x81, 0xF1, 0x7E, 0xEF, 0xEE, 0xE7, 0xCF, 0x7C, 0xFF, 0xC7, 0xFE,
  0x76, 0x6C, 0x1C, 0xE3, 0x1C, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x86, 0x00, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x8E, 0x31,
  0x8E, 0x00, 0x0C, 0x4C, 0xF8, 0x7F, 0x3F, 0x7C, 0x6E, 0x08, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x37, 0x6E, 0x7F, 0xFE, 0x7F, 0x80,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C,
  0x07, 0x03, 0x80, 0x06, 0x0F, 0x8F, 0xEF, 0x77, 0x3B, 0x9D, 0xCE, 0xE7,
  0xF7, 0x3B, 0x9F, 0x87, 0x80, 0x0E, 0x7F, 0xFB, 0x75, 0xC3, 0x87, 0x0E,
  0x1C, 0x70, 0xE0, 0x04, 0x1F, 0x9F, 0xE6, 0x70, 0x78, 0x38, 0x38, 0x38,
  0x38, 0x3F, 0xBF, 0xDF, 0xE0, 0x0C, 0x3F, 0x8F, 0xE4, 0x70, 0x70, 0xF8,
  0xF8, 0x0E, 0x07, 0x47, 0xBF, 0xDF, 0x80, 0x03, 0x83, 0xC3, 0xC3, 0xE3,
  0xF3, 0xB9, 0xFF, 0xFF, 0xFF, 0x07, 0x03, 0x80, 0x1F, 0x9F, 0xCE, 0x07,
  0x07, 0xE3, 0xF8, 0x1C, 0x0E, 0x8F, 0x7F, 0xBF, 0x00, 0x07, 0x3F, 0x7F,
  0x70, 0xEC, 0xFE, 0xFF, 0xE7, 0xEF, 0xEE, 0xFE, 0x7C, 0x3F, 0xDF, 0xF0,
  0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x00, 0x06,
  0x0F, 0xCF, 0xE7, 0x73, 0xB9, 0xF8, 0xFC, 0xEE, 0xE7, 0x73, 0x9F, 0xC7,
  0xC0, 0x18, 0x7E, 0xFF, 0xE7, 0xE7, 0xEF, 0xFF, 0x76, 0x0E, 0x9E, 0xFC,
  0xF0, 0x39, 0xCC, 0x00, 0x01, 0x9C, 0xE0, 0x1C, 0x71, 0x80, 0x00, 0x00,
  0x1C, 0x71, 0x8E, 0x00, 0x03, 0x0F, 0x3E, 0xF8, 0xE0, 0x7C, 0x1F, 0x07,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x0F, 0x3E,
  0xF0, 0xC0, 0x80, 0x19, 0xFD, 0xFA, 0x71, 0xE7, 0x9E, 0x38, 0x00, 0xC3,
  0x87, 0x00, 0x03, 0x00, 0xFF, 0x0E, 0x1C, 0xC4, 0x7E, 0xFD, 0xEE, 0xCF,
  0x66, 0x7B, 0x37, 0xDB, 0xB6, 0xFF, 0x38, 0x00, 0xE3, 0x03, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0x61, 0xCC, 0x39, 0x8F, 0xF1, 0xFE, 0x7F,
  0xEE, 0x1F, 0x83, 0x80, 0x3F, 0x8F, 0xF3, 0x9C, 0xE7, 0x3F, 0x9F, 0xC7,
  0x39, 0xCE, 0x77, 0x9F, 0xCF, 0xE0, 0x06, 0x0F, 0xF7, 0xF9, 0xC2, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x87, 0xE0, 0xF8, 0x3F, 0x8F, 0xF3,
  0x9C, 0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xCF, 0x7F, 0x9F, 0xCF, 0xE0, 0x3F,
  0x9F, 0xCE, 0x07, 0x03, 0xF3, 0xF9, 0xC0, 0xE0, 0x7F, 0x3F, 0x3F, 0x80,
  0x3F, 0x9F, 0xCE, 0x07, 0x03, 0xF3, 0xF9, 0xFC, 0xE0, 0x70, 0x38, 0x38,
  0x00, 0x07, 0x07, 0xF3, 0xF9, 0xE2, 0xF0, 0x39, 0xEE, 0xFB, 0xBE, 0xE3,
  0xBC, 0xE7, 0xF0, 0xFC, 0x3C, 0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xC7,
  0xFC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x80, 0x1F, 0x9F, 0x83,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x3F, 0x3F, 0x00, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x8F,
  0xC7, 0xC1, 0x80, 0x3C, 0xF3, 0x9C, 0x3B, 0x83, 0xF8, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0x70, 0x73, 0x87, 0x38, 0xE3, 0xC0, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x7F, 0x7E, 0xFE, 0x3E, 0x3E, 0x7C, 0x78, 0xF9,
  0xF1, 0xB3, 0xE3, 0x6D, 0xCE, 0xDB, 0x1D, 0xFE, 0x3B, 0xDC, 0x77, 0xB8,
  0xCE, 0x63, 0x9D, 0xC0, 0x3C, 0x39, 0xF1, 0x8F, 0x9C, 0x6C, 0xE3, 0x77,
  0x3B, 0xB1, 0xDD, 0x8E, 0x7C, 0x73, 0xE3, 0x1F, 0x38, 0x70, 0x06, 0x07,
  0xE3, 0xFD, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xFD, 0xE7, 0xF0,
  0xF8, 0x3F, 0x8F, 0xE3, 0x9C, 0xE7, 0x3B, 0xDF, 0xE7, 0xF1, 0xC0, 0x70,
  0x1C, 0x0E, 0x00, 0x06, 0x07, 0xE3, 0xFD, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE3, 0xFD, 0xE7, 0xF0, 0xF8, 0x0F, 0x01, 0xC0, 0x78, 0x3F, 0x8F,
  0xF3, 0x9C, 0xE7, 0x3F, 0x9F, 0xE7, 0xF1, 0xDC, 0x77, 0x9C, 0xEE, 0x3C,
  0x06, 0x0F, 0xCF, 0xC7, 0x23, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x67, 0xBF,
  0x9F, 0x80, 0x7F, 0xFF, 0x87, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x00, 0x79, 0xDC, 0x77, 0x1D, 0xCE, 0x73, 0xB8, 0xEE, 0x3B,
  0x8E, 0xF7, 0x3F, 0xC7, 0xE0, 0xE3, 0xF8, 0xEE, 0x3B, 0x9C, 0x67, 0x1B,
  0x86, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0xE3, 0x8F, 0xC7, 0x1B, 0x9E,
  0x77, 0x3C, 0xEE, 0xFB, 0x9D, 0xB7, 0x3F, 0x6C, 0x7C, 0xF8, 0xF9, 0xE0,
  0xF3, 0xC1, 0xC7, 0x80, 0x1C, 0x78, 0xE7, 0x03, 0xF8, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x39, 0xC3, 0xCE, 0x3C, 0x78, 0xF3, 0xDD,
  0xE7, 0x71, 0xF8, 0x3E, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00,
  0x1F, 0xE7, 0xF8, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x7F,
  0x8F, 0xF3, 0xFC, 0x00, 0x1E, 0x7C, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x60,
  0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x00, 0xCC, 0xCE, 0xE6, 0x66, 0x67, 0x77,
  0x1E, 0x3C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x9E,
  0x3C, 0x00, 0x0C, 0x0E, 0x1E, 0x3E, 0x33, 0x63, 0xE3, 0xFF, 0xFC, 0xF7,
  0x3B, 0xBF, 0xBD, 0xDC, 0xEE, 0x77, 0x33, 0xB9, 0xFC, 0xFE, 0x00, 0x1C,
  0x1C, 0x0E, 0x07, 0xE3, 0xF9, 0xDD, 0xCE, 0xE7, 0x73, 0xBB, 0xBF, 0xDF,
  0xC0, 0x3E, 0xFF, 0xD7, 0x0E, 0x1C, 0x39, 0x7E, 0x7C, 0x03, 0x81, 0xC0,
  0xE7, 0x67, 0xF7, 0xBB, 0x9D, 0xCE, 0xE6, 0x77, 0x3F, 0x9F, 0xC0, 0x3E,
  0x7F, 0xF7, 0xE7, 0xFE, 0xF8, 0xE2, 0xFE, 0x7C, 0x03, 0xC1, 0xF0, 0x70,
  0x3E, 0x1F, 0x83, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x3E, 0x0F, 0x83, 0xC0, 0x1D, 0xCF, 0xE7, 0xB9, 0xCE, 0x73, 0x9C, 0xC7,
  0x71, 0xFC, 0x7F, 0x01, 0xCD, 0xE3, 0xF8, 0x78, 0x00, 0x1C, 0x1C, 0x0E,
  0x07, 0xE3, 0xF9, 0xDD, 0xCE, 0xE7, 0x73, 0xB9, 0xFD, 0xDC, 0xE0, 0x1C,
  0xE0, 0x0E, 0x38, 0xE7, 0x1C, 0x71, 0xCF, 0x38, 0x07, 0x0F, 0x00, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0xF8, 0xF0, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0xF3, 0xB8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E,
  0x0E, 0xE3, 0xDC, 0x73, 0xC0, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71,
  0xCF, 0x38, 0x37, 0x38, 0xFF, 0xF3, 0xBD, 0xDC, 0xE7, 0x73, 0x9D, 0xCE,
  0x77, 0x3B, 0xBD, 0xCE, 0xE7, 0x38, 0x37, 0x1F, 0xCE, 0xEE, 0x77, 0x3B,
  0x9D, 0xCF, 0xEE, 0xE7, 0x00, 0x3E, 0x7F, 0xF7, 0xE7, 0xE7, 0xE7, 0xEE,
  0xFE, 0x7C, 0x1B, 0x87, 0xF1, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xB9, 0xFE,
  0x77, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x3B, 0xBF, 0xBD, 0xDC, 0xEE,
  0x77, 0x33, 0xB9, 0xFC, 0x7E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0x37, 0x3E,
  0x3E, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0x3F, 0x7E, 0x72, 0x78, 0x3E,
  0x1E, 0x8E, 0xFE, 0xFC, 0x0C, 0x30, 0xFB, 0xFB, 0x8E, 0x1C, 0x38, 0x74,
  0xF9, 0xF0, 0x73, 0xBB, 0xB9, 0xDC, 0xEE, 0x77, 0x3B, 0xB9, 0xFC, 0xFE,
  0x00, 0xE7, 0xF3, 0xBB, 0x9D, 0xCF, 0xC7, 0xE1, 0xE0, 0xF0, 0x70, 0x00,
  0xE7, 0x3F, 0x79, 0xBB, 0xDD, 0xDE, 0xCF, 0xBE, 0x7D, 0xF3, 0xCF, 0x1E,
  0x78, 0xF3, 0x80, 0x3D, 0xE3, 0xB8, 0x7E, 0x0F, 0x80, 0xF0, 0x3E, 0x0F,
  0xC3, 0xDC, 0xF3, 0x80, 0x39, 0xE7, 0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0x7E,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x83, 0xE0, 0x78, 0x0E, 0x00, 0x3F, 0x7F,
  0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xFE, 0xFC, 0x1E, 0x38, 0x61, 0xC3, 0x9E,
  0x38, 0x78, 0x70, 0xE1, 0x83, 0x87, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x38, 0x78, 0x70, 0xE1, 0x83, 0xC3, 0x9E, 0x38, 0x60, 0xC7,
  0x8E, 0x10, 0x00, 0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_BlackItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 11, 5, 0, -11 },
  { 10, 7, 4, 7, 1, -11 },
  { 14, 11, 11, 10, 0, -11 },
  { 30, 9, 13, 9, 0, -12 },
  { 45, 14, 12, 15, 1, -12 },
  { 66, 12, 12, 12, 0, -12 },
  { 84, 4, 4, 4, 1, -11 },
  { 86, 6, 15, 6, 1, -12 },
  { 98, 6, 15, 6, -1, -12 },
  { 110, 8, 8, 9, 1, -12 },
  { 118, 8, 8, 9, 1, -10 },
  { 126, 4, 4, 5, -1, -2 },
  { 128, 5, 3, 5, 0, -6 },
  { 130, 3, 3, 5, 0, -3 },
  { 132, 10, 12, 7, -1, -12 },
  { 147, 9, 12, 9, 0, -12 },
  { 161, 7, 11, 9, 1, -11 },
  { 171, 9, 12, 9, 0, -12 },
  { 185, 9, 12, 9, 0, -12 },
  { 199, 9, 11, 9, 0, -11 },
  { 212, 9, 11, 9, 0, -11 },
  { 225, 8, 12, 9, 1, -12 },
  { 237, 10, 11, 9, 0, -11 },
  { 251, 9, 12, 9, 0, -12 },
  { 265, 8, 12, 9, 1, -12 },
  { 277, 5, 9, 5, 0, -9 },
  { 283, 6, 11, 5, -1, -9 },
  { 292, 8, 9, 9, 1, -10 },
  { 301, 8, 5, 9, 1, -8 },
  { 306, 8, 9, 9, 1, -10 },
  { 315, 7, 12, 8, 1, -12 },
  { 326, 13, 13, 14, 1, -12 },
  { 348, 11, 11, 11, -1, -11 },
  { 364, 10, 11, 10, 0, -11 },
  { 378, 10, 12, 10, 1, -12 },
  { 393, 10, 11, 11, 0, -11 },
  { 407, 9, 11, 9, 0, -11 },
  { 420, 9, 11, 9, 0, -11 },
  { 433, 10, 12, 11, 1, -12 },
  { 448, 12, 11, 11, 0, -11 },
  { 465, 9, 11, 7, -1, -11 },
  { 478, 9, 15, 6, -3, -11 },
  { 495, 12, 11, 11, 0, -11 },
  { 512, 8, 11, 8, 0, -11 },
  { 523, 15, 11, 15, 0, -11 },
  { 544, 13, 11, 13, 0, -11 },
  { 562, 10, 12, 12, 1, -12 },
  { 577, 10, 11, 10, 0, -11 },
  { 591, 10, 15, 12, 1, -12 },
  { 610, 10, 11, 10, 0, -11 },
  { 624, 9, 12, 9, 0, -12 },
  { 638, 9, 11, 9, 1, -11 },
  { 651, 10, 11, 11, 1, -11 },
  { 665, 10, 11, 10, 1, -11 },
  { 679, 15, 11, 15, 1, -11 },
  { 700, 13, 11, 11, -1, -11 },
  { 718, 10, 11, 10, 1, -11 },
  { 732, 11, 11, 9, -1, -11 },
  { 748, 7, 15, 6, 0, -12 },
  { 762, 4, 12, 7, 2, -12 },
  { 768, 7, 15, 6, -1, -12 },
  { 782, 8, 7, 9, 0, -11 },
  { 789, 7, 2, 7, -1, 1 },
  { 791, 4, 2, 6, 2, -12 },
  { 792, 9, 9, 10, 1, -9 },
  { 803, 9, 12, 10, 0, -12 },
  { 817, 7, 9, 8, 1, -9 },
  { 825, 9, 12, 10, 1, -12 },
  { 839, 8, 9, 9, 1, -9 },
  { 848, 10, 16, 7, -2, -12 },
  { 868, 10, 13, 10, 0, -9 },
  { 885, 9, 12, 10, 0, -12 },
  { 899, 6, 12, 5, 0, -12 },
  { 908, 8, 16, 5, -2, -12 },
  { 924, 11, 12, 10, 0, -12 },
  { 941, 6, 12, 5, 0, -12 },
  { 950, 14, 9, 15, 0, -9 },
  { 966, 9, 9, 10, 0, -9 },
  { 977, 8, 9, 10, 1, -9 },
  { 986, 10, 13, 10, -1, -9 },
  { 1003, 9, 13, 10, 1, -9 },
  { 1018, 8, 9, 7, 0, -9 },
  { 1027, 8, 9, 8, 0, -9 },
  { 1036, 7, 11, 7, 0, -11 },
  { 1046, 9, 9, 10, 1, -9 },
  { 1057, 9, 9, 9, 1, -9 },
  { 1068, 13, 9, 13, 1, -9 },
  { 1083, 11, 9, 9, -1, -9 },
  { 1096, 11, 13, 9, -1, -9 },
  { 1114, 8, 9, 8, 0, -9 },
  { 1123, 7, 14, 6, 0, -11 },
  { 1136, 3, 16, 9, 3, -12 },
  { 1142, 7, 14, 6, -1, -11 },
  { 1155, 8, 3, 9, 1, -7 },
};

const GFXfont NotoSans_BlackItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_BLACKITALIC16PT7B_H_
