#ifndef _NOTOSANS_BLACKITALIC26PT7B_H_
#define _NOTOSANS_BLACKITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xF0, 0xFC, 0x7C, 0x1E, 0x00, 0x7D,
  0xEF, 0x3D, 0xE7, 0xBD, 0xE7, 0x3C, 0xE7, 0xBC, 0xE0, 0x01, 0xCF, 0x00,
  0xE7, 0x80, 0xF3, 0x80, 0x71, 0xC0, 0x39, 0xE1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x07, 0x3C, 0x07, 0x9C, 0x03, 0x8E, 0x1F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x73, 0xC0, 0x39, 0xE0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E,
  0x78, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0x07, 0xFF, 0x3F, 0xF8, 0xFF,
  0xE7, 0xD8, 0x9F, 0x60, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x1B, 0xE8, 0x6F, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x87, 0xF8, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x07, 0x00, 0xF0, 0x3F, 0x01, 0xC0, 0xFF,
  0x07, 0x83, 0xDE, 0x1E, 0x07, 0xBC, 0x38, 0x0E, 0x78, 0xE0, 0x3C, 0xF3,
  0xC0, 0x79, 0xEF, 0x00, 0x77, 0x9C, 0xF8, 0xFF, 0x7B, 0xF9, 0xFD, 0xEF,
  0xF0, 0xE7, 0xBC, 0xF0, 0x0E, 0x79, 0xE0, 0x3C, 0xF3, 0x80, 0xF1, 0xE7,
  0x03, 0xC3, 0xDE, 0x07, 0x07, 0xFC, 0x1E, 0x07, 0xF0, 0x78, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xF3, 0xE0,
  0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x7D,
  0xFF, 0x9F, 0x3F, 0xFB, 0xEF, 0x9F, 0xF9, 0xF1, 0xFF, 0x3E, 0x1F, 0xC7,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x7E, 0x00, 0x7D, 0xE7,
  0x9E, 0x71, 0xCF, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0x78, 0x3E, 0x00, 0x03, 0x40, 0x3C, 0x11, 0xE0, 0xCF, 0x0F,
  0xF0, 0x7F, 0xFC, 0xFF, 0xE3, 0xFF, 0x3F, 0x87, 0xFC, 0x1E, 0xF0, 0x27,
  0x80, 0x10, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x00, 0x3E, 0xF9, 0xF3, 0xCF, 0x1E, 0x00, 0x7F, 0x7F, 0x7F, 0xFE, 0x23,
  0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3E, 0xF9,
  0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xBE, 0x3E,
  0xF8, 0xFB, 0xE7, 0xEF, 0x9F, 0x3F, 0xFC, 0xFF, 0xE1, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xFE, 0x7F, 0xEF, 0xFE, 0x7B, 0xC6,
  0x7C, 0x47, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF0, 0xF7, 0xE0, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xE0, 0x7F, 0xE3, 0xFF, 0xC7,
  0xFF, 0x0C, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x0F, 0xF0, 0x3F, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE8, 0x0F, 0xBF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xBC, 0x0F, 0xF8, 0x3D, 0xF0, 0xF3,
  0xE3, 0xC7, 0x8F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xC3, 0xE0, 0x07, 0x80, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x20, 0x3E, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0xFC, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xBE,
  0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x9F, 0xBF, 0xFC, 0x7F, 0xF0, 0xFF, 0x81,
  0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3E,
  0x7C, 0xF1, 0xF3, 0xE7, 0x8F, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xFF, 0x1F,
  0x7C, 0xF8, 0xF3, 0xC3, 0xEF, 0x0F, 0x3E, 0x7C, 0xFF, 0xF1, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0xCF, 0xBE, 0x3F,
  0xE1, 0xFF, 0x1F, 0xFC, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF1, 0xCF, 0x80,
  0xF8, 0x0F, 0xDF, 0xFC, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x04, 0x1F, 0x1F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x78, 0xF8, 0xF8, 0xF8,
  0x02, 0x07, 0xC3, 0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x80, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x03, 0xF8, 0x7F, 0x9F, 0xF1, 0xFC, 0x0F, 0x80, 0x70, 0x02,
  0x00, 0x00, 0x1F, 0x0F, 0xFB, 0xFF, 0xBF, 0xF7, 0x1E, 0x03, 0xC0, 0xF8,
  0x7F, 0x1F, 0xC7, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x0C, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x07, 0xE0, 0x7C, 0x1E, 0x00, 0xF8, 0xF0, 0xF9, 0xE7, 0x8F, 0xF3,
  0x9C, 0x7F, 0xCE, 0x73, 0xCF, 0x3F, 0xCE, 0x3C, 0xEF, 0x78, 0xE3, 0xB9,
  0xE3, 0x8E, 0xE7, 0x9E, 0x7B, 0x9F, 0xFB, 0xCF, 0x3F, 0xFE, 0x3C, 0xFB,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0x08, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x81,
  0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1E, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3E, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7C, 0x0F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x7E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7C, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0,
  0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x9E, 0x3E, 0x02,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x18, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xF7,
  0xF8, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF1, 0xF9, 0xF1, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFC, 0xE1, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0xFF, 0x7E, 0x7F, 0xBE, 0x3F, 0xDF, 0x3F, 0xCF, 0x83, 0xE7, 0xE1,
  0xF1, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00,
  0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x9F, 0x83, 0xFE, 0x0F, 0xF0,
  0x3F, 0x80, 0xF8, 0x00, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07,
  0xCF, 0xC1, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0xC0, 0x7C,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x87, 0xC3, 0xE0,
  0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xBC, 0x1F, 0xE7, 0xBC, 0x3F, 0xE7,
  0xFC, 0x3F, 0xEF, 0x7C, 0x3D, 0xEF, 0x78, 0x3D, 0xEE, 0x78, 0x3D, 0xFE,
  0x78, 0x7D, 0xFC, 0xF8, 0x7D, 0xFC, 0xF8, 0x79, 0xF8, 0xF0, 0x79, 0xF8,
  0xF0, 0xF9, 0xF1, 0xF0, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0x83, 0xF8, 0x3C,
  0x1F, 0xC1, 0xE1, 0xFE, 0x1F, 0x0F, 0xF8, 0xF8, 0x7F, 0xC7, 0x83, 0xDE,
  0x3C, 0x1E, 0xF1, 0xE1, 0xF7, 0xDF, 0x0F, 0x9E, 0xF8, 0x78, 0xF7, 0x83,
  0xC7, 0xFC, 0x1E, 0x3F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x78, 0x3F,
  0x83, 0xC0, 0xFC, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xE0, 0xF9,
  0xF0, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x7F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xF9, 0xF9,
  0xF8, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xE1, 0xF9, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x3F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7E,
  0x7C, 0x3E, 0xF8, 0x3F, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E,
  0x31, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x88, 0x3E, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0,
  0x3F, 0xC0, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF9, 0xF0, 0x79, 0xE0, 0x7B, 0xE0,
  0x7B, 0xC0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x3C, 0x0F, 0xFC, 0x1E, 0x0F, 0xBE, 0x1F,
  0x07, 0xDF, 0x0F, 0x87, 0xCF, 0x8F, 0xC3, 0xE7, 0xC7, 0xE1, 0xE3, 0xE7,
  0xF1, 0xF1, 0xF3, 0xF8, 0xF0, 0xF9, 0xDC, 0xF8, 0x7D, 0xEE, 0x7C, 0x3C,
  0xF7, 0x3C, 0x1E, 0xF3, 0xBE, 0x0F, 0x79, 0xDE, 0x07, 0xB8, 0xEF, 0x03,
  0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF8, 0xFC,
  0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F,
  0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x3F, 0xF8, 0x3E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0xF8, 0x7D, 0xF0, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0xF1, 0xE3, 0xC7,
  0x8F, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x3C, 0x78, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0xF7, 0x07, 0x9C, 0x1C, 0x78, 0xF1, 0xE7, 0x83, 0x9C, 0x0E, 0xF0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFB, 0xE7, 0x8F, 0x06, 0x02, 0x3F, 0x78,
  0xFF, 0xF1, 0xFF, 0xE7, 0xEF, 0xCF, 0x8F, 0x1F, 0x1E, 0x7C, 0x7C, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xBC,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE6,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x7E, 0xFC, 0xF8, 0xF9, 0xF1, 0xF3,
  0xC3, 0xE7, 0x8F, 0x9F, 0x1F, 0x3E, 0x7E, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xC7, 0x9F, 0x00, 0x01, 0x80, 0xFF, 0x1F, 0xF3, 0xFF, 0x7E, 0x67, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x4F, 0xFC, 0x7F, 0xC7, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x07, 0x3E, 0x1F, 0xBC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7C, 0x78,
  0x7C, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3E, 0xF0, 0x01, 0x80, 0x7F, 0x87, 0xFE, 0x7F,
  0xF7, 0xC7, 0xBE, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xF0, 0x3E, 0x05,
  0xF9, 0xC7, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03,
  0x01, 0x0F, 0xDE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x7E, 0x3E, 0x3C, 0x3E,
  0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF0, 0x81, 0xF0, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE6, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x7E, 0x7C,
  0xFC, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF9, 0xF3, 0xE7, 0xC7, 0xC0, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0x00, 0x00, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7E,
  0x3E, 0x7E, 0x1F, 0x7E, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x1F,
  0x1F, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x00, 0x00, 0x38, 0x30, 0x3D, 0xF9, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xF3, 0xF3, 0xE7, 0xE7, 0xC7, 0xCF, 0x8F, 0x8F, 0x9F,
  0x1F, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3,
  0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0x3E, 0x00, 0x00,
  0x30, 0x3D, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xFB, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9F, 0x1F, 0x3E, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x9F, 0x3E, 0x3E, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7E,
  0xFD, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBF,
  0xFC, 0x7F, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x18, 0x0F, 0x7C, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x7D,
  0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x06, 0x02, 0x3F, 0x78, 0xFF, 0xF1, 0xFF, 0xE7, 0xEF, 0xCF, 0x8F,
  0x1F, 0x1E, 0x7C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFE, 0x0F, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x31, 0xEF, 0x1F, 0xF1, 0xFF, 0x3F,
  0xF3, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0x80, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xE2,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x20, 0xF9, 0xC7, 0xCF,
  0xFE, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x7C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xCF, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xFF,
  0x3F, 0xE3, 0xFC, 0x7F, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF1, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xF3,
  0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0x07, 0xDE, 0x00, 0xF8, 0x7F, 0xF0, 0xFB,
  0xE3, 0xE3, 0xC7, 0xC7, 0x9F, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0xFC, 0x7F, 0xE3, 0xE3, 0xEF, 0x9F, 0x8F, 0x9E, 0x7E, 0x7C, 0x79, 0xF9,
  0xF1, 0xEF, 0xE7, 0x87, 0xBB, 0xBE, 0x1F, 0xEE, 0xF0, 0x7F, 0x3F, 0xC1,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0xC1, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x3E, 0x3E, 0x3F, 0x8F, 0x80, 0x1F, 0x0F,
  0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x3E, 0x03, 0xCF, 0x80,
  0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC3, 0xF8, 0x7C,
  0x0F, 0x81, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3F, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x04, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x80, 0xF0, 0x7E, 0x1F, 0xC3, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x3F, 0x0F, 0xC1, 0xF8, 0x3C, 0x00, 0x18, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
};

const GFXglyph NotoSans_BlackItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 19, 8, 0, -19 },
  { 23, 11, 7, 12, 2, -19 },
  { 33, 17, 19, 17, 0, -19 },
  { 74, 14, 22, 15, 1, -20 },
  { 113, 23, 19, 24, 1, -19 },
  { 168, 19, 19, 19, 0, -19 },
  { 214, 6, 7, 6, 2, -19 },
  { 220, 10, 23, 10, 1, -19 },
  { 249, 11, 23, 10, -2, -19 },
  { 281, 13, 13, 14, 2, -20 },
  { 303, 13, 13, 15, 1, -16 },
  { 325, 7, 6, 8, -1, -3 },
  { 331, 8, 4, 9, 0, -9 },
  { 335, 5, 5, 8, 0, -5 },
  { 339, 15, 19, 12, -1, -19 },
  { 375, 14, 19, 15, 1, -19 },
  { 409, 12, 19, 15, 2, -19 },
  { 438, 15, 19, 15, -1, -19 },
  { 474, 14, 19, 15, 0, -19 },
  { 508, 15, 19, 15, 0, -19 },
  { 544, 15, 19, 15, 0, -19 },
  { 580, 14, 19, 15, 1, -19 },
  { 614, 16, 19, 15, 0, -19 },
  { 652, 14, 19, 15, 1, -19 },
  { 686, 13, 19, 15, 1, -19 },
  { 717, 8, 15, 8, 0, -15 },
  { 732, 9, 18, 8, -1, -15 },
  { 753, 13, 15, 15, 1, -17 },
  { 778, 13, 9, 15, 1, -14 },
  { 793, 13, 15, 15, 1, -17 },
  { 818, 11, 19, 13, 2, -19 },
  { 845, 22, 21, 23, 1, -19 },
  { 903, 18, 19, 18, -2, -19 },
  { 946, 16, 19, 16, 0, -19 },
  { 984, 16, 19, 16, 1, -19 },
  { 1022, 17, 19, 18, 0, -19 },
  { 1063, 15, 19, 15, 0, -19 },
  { 1099, 15, 19, 15, 0, -19 },
  { 1135, 17, 19, 18, 1, -19 },
  { 1176, 19, 19, 19, 0, -19 },
  { 1222, 14, 19, 11, -1, -19 },
  { 1256, 14, 25, 10, -4, -19 },
  { 1300, 19, 19, 17, 0, -19 },
  { 1346, 12, 19, 14, 0, -19 },
  { 1375, 24, 19, 24, 0, -19 },
  { 1432, 21, 19, 21, 0, -19 },
  { 1482, 17, 19, 19, 1, -19 },
  { 1523, 16, 19, 16, 0, -19 },
  { 1561, 17, 23, 19, 1, -19 },
  { 1610, 16, 19, 17, 0, -19 },
  { 1648, 14, 19, 14, 1, -19 },
  { 1682, 14, 19, 14, 2, -19 },
  { 1716, 16, 19, 18, 2, -19 },
  { 1754, 16, 19, 16, 2, -19 },
  { 1792, 25, 19, 24, 2, -19 },
  { 1852, 21, 19, 17, -2, -19 },
  { 1902, 16, 19, 16, 2, -19 },
  { 1940, 16, 19, 14, -1, -19 },
  { 1978, 12, 23, 9, -1, -19 },
  { 2013, 7, 19, 12, 3, -19 },
  { 2030, 12, 23, 9, -2, -19 },
  { 2065, 14, 13, 14, 0, -19 },
  { 2088, 12, 3, 12, -2, 2 },
  { 2093, 6, 4, 9, 4, -20 },
  { 2096, 15, 15, 16, 1, -15 },
  { 2125, 15, 20, 16, 0, -20 },
  { 2163, 12, 15, 13, 1, -15 },
  { 2186, 16, 20, 16, 1, -20 },
  { 2226, 13, 15, 15, 1, -15 },
  { 2251, 16, 26, 11, -3, -20 },
  { 2303, 16, 21, 16, 0, -15 },
  { 2345, 15, 20, 16, 0, -20 },
  { 2383, 9, 20, 8, 0, -20 },
  { 2406, 12, 26, 8, -3, -20 },
  { 2445, 17, 20, 16, 0, -20 },
  { 2488, 9, 20, 8, 0, -20 },
  { 2511, 23, 15, 24, 0, -15 },
  { 2555, 15, 15, 16, 0, -15 },
  { 2584, 14, 15, 16, 1, -15 },
  { 2611, 16, 21, 16, -1, -15 },
  { 2653, 15, 21, 16, 1, -15 },
  { 2693, 12, 15, 11, 0, -15 },
  { 2716, 13, 15, 13, 0, -15 },
  { 2741, 11, 17, 12, 1, -17 },
  { 2765, 15, 14, 16, 1, -14 },
  { 2792, 15, 14, 14, 1, -14 },
  { 2819, 22, 14, 21, 1, -14 },
  { 2858, 18, 14, 15, -2, -14 },
  { 2890, 18, 20, 14, -2, -14 },
  { 2935, 14, 14, 13, -1, -14 },
  { 2960, 11, 23, 9, 0, -19 },
  { 2992, 3, 26, 15, 6, -20 },
  { 3002, 11, 23, 9, -2, -19 },
  { 3034, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_BlackItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_BLACKITALIC26PT7B_H_
