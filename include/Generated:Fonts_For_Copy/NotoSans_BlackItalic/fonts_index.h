#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_BlackItalic6pt7b, 6, "NotoSans_BlackItalic6pt7b" },
  { &NotoSans_BlackItalic7pt7b, 7, "NotoSans_BlackItalic7pt7b" },
  { &NotoSans_BlackItalic8pt7b, 8, "NotoSans_BlackItalic8pt7b" },
  { &NotoSans_BlackItalic9pt7b, 9, "NotoSans_BlackItalic9pt7b" },
  { &NotoSans_BlackItalic10pt7b, 10, "NotoSans_BlackItalic10pt7b" },
  { &NotoSans_BlackItalic11pt7b, 11, "NotoSans_BlackItalic11pt7b" },
  { &NotoSans_BlackItalic12pt7b, 12, "NotoSans_BlackItalic12pt7b" },
  { &NotoSans_BlackItalic13pt7b, 13, "NotoSans_BlackItalic13pt7b" },
  { &NotoSans_BlackItalic14pt7b, 14, "NotoSans_BlackItalic14pt7b" },
  { &NotoSans_BlackItalic15pt7b, 15, "NotoSans_BlackItalic15pt7b" },
  { &NotoSans_BlackItalic16pt7b, 16, "NotoSans_BlackItalic16pt7b" },
  { &NotoSans_BlackItalic17pt7b, 17, "NotoSans_BlackItalic17pt7b" },
  { &NotoSans_BlackItalic18pt7b, 18, "NotoSans_BlackItalic18pt7b" },
  { &NotoSans_BlackItalic19pt7b, 19, "NotoSans_BlackItalic19pt7b" },
  { &NotoSans_BlackItalic20pt7b, 20, "NotoSans_BlackItalic20pt7b" },
  { &NotoSans_BlackItalic21pt7b, 21, "NotoSans_BlackItalic21pt7b" },
  { &NotoSans_BlackItalic22pt7b, 22, "NotoSans_BlackItalic22pt7b" },
  { &NotoSans_BlackItalic23pt7b, 23, "NotoSans_BlackItalic23pt7b" },
  { &NotoSans_BlackItalic24pt7b, 24, "NotoSans_BlackItalic24pt7b" },
  { &NotoSans_BlackItalic25pt7b, 25, "NotoSans_BlackItalic25pt7b" },
  { &NotoSans_BlackItalic26pt7b, 26, "NotoSans_BlackItalic26pt7b" },
  { &NotoSans_BlackItalic27pt7b, 27, "NotoSans_BlackItalic27pt7b" },
  { &NotoSans_BlackItalic28pt7b, 28, "NotoSans_BlackItalic28pt7b" },
  { &NotoSans_BlackItalic29pt7b, 29, "NotoSans_BlackItalic29pt7b" },
  { &NotoSans_BlackItalic30pt7b, 30, "NotoSans_BlackItalic30pt7b" },
  { &NotoSans_BlackItalic31pt7b, 31, "NotoSans_BlackItalic31pt7b" },
  { &NotoSans_BlackItalic32pt7b, 32, "NotoSans_BlackItalic32pt7b" },
  { &NotoSans_BlackItalic33pt7b, 33, "NotoSans_BlackItalic33pt7b" },
  { &NotoSans_BlackItalic34pt7b, 34, "NotoSans_BlackItalic34pt7b" },
  { &NotoSans_BlackItalic35pt7b, 35, "NotoSans_BlackItalic35pt7b" },
  { &NotoSans_BlackItalic36pt7b, 36, "NotoSans_BlackItalic36pt7b" },
  { &NotoSans_BlackItalic37pt7b, 37, "NotoSans_BlackItalic37pt7b" },
  { &NotoSans_BlackItalic38pt7b, 38, "NotoSans_BlackItalic38pt7b" },
  { &NotoSans_BlackItalic39pt7b, 39, "NotoSans_BlackItalic39pt7b" },
  { &NotoSans_BlackItalic40pt7b, 40, "NotoSans_BlackItalic40pt7b" },
  { &NotoSans_BlackItalic41pt7b, 41, "NotoSans_BlackItalic41pt7b" },
  { &NotoSans_BlackItalic42pt7b, 42, "NotoSans_BlackItalic42pt7b" },
  { &NotoSans_BlackItalic43pt7b, 43, "NotoSans_BlackItalic43pt7b" },
  { &NotoSans_BlackItalic44pt7b, 44, "NotoSans_BlackItalic44pt7b" },
  { &NotoSans_BlackItalic45pt7b, 45, "NotoSans_BlackItalic45pt7b" },
  { &NotoSans_BlackItalic46pt7b, 46, "NotoSans_BlackItalic46pt7b" },
  { &NotoSans_BlackItalic47pt7b, 47, "NotoSans_BlackItalic47pt7b" },
  { &NotoSans_BlackItalic48pt7b, 48, "NotoSans_BlackItalic48pt7b" },
  { &NotoSans_BlackItalic49pt7b, 49, "NotoSans_BlackItalic49pt7b" },
  { &NotoSans_BlackItalic50pt7b, 50, "NotoSans_BlackItalic50pt7b" },
  { &NotoSans_BlackItalic51pt7b, 51, "NotoSans_BlackItalic51pt7b" },
  { &NotoSans_BlackItalic52pt7b, 52, "NotoSans_BlackItalic52pt7b" },
  { &NotoSans_BlackItalic53pt7b, 53, "NotoSans_BlackItalic53pt7b" },
  { &NotoSans_BlackItalic54pt7b, 54, "NotoSans_BlackItalic54pt7b" },
  { &NotoSans_BlackItalic55pt7b, 55, "NotoSans_BlackItalic55pt7b" },
  { &NotoSans_BlackItalic56pt7b, 56, "NotoSans_BlackItalic56pt7b" },
  { &NotoSans_BlackItalic57pt7b, 57, "NotoSans_BlackItalic57pt7b" },
  { &NotoSans_BlackItalic58pt7b, 58, "NotoSans_BlackItalic58pt7b" },
  { &NotoSans_BlackItalic59pt7b, 59, "NotoSans_BlackItalic59pt7b" },
  { &NotoSans_BlackItalic60pt7b, 60, "NotoSans_BlackItalic60pt7b" },
  { &NotoSans_BlackItalic61pt7b, 61, "NotoSans_BlackItalic61pt7b" },
  { &NotoSans_BlackItalic62pt7b, 62, "NotoSans_BlackItalic62pt7b" },
  { &NotoSans_BlackItalic63pt7b, 63, "NotoSans_BlackItalic63pt7b" },
  { &NotoSans_BlackItalic64pt7b, 64, "NotoSans_BlackItalic64pt7b" },
  { &NotoSans_BlackItalic65pt7b, 65, "NotoSans_BlackItalic65pt7b" },
  { &NotoSans_BlackItalic66pt7b, 66, "NotoSans_BlackItalic66pt7b" },
  { &NotoSans_BlackItalic67pt7b, 67, "NotoSans_BlackItalic67pt7b" },
  { &NotoSans_BlackItalic68pt7b, 68, "NotoSans_BlackItalic68pt7b" },
  { &NotoSans_BlackItalic69pt7b, 69, "NotoSans_BlackItalic69pt7b" },
  { &NotoSans_BlackItalic70pt7b, 70, "NotoSans_BlackItalic70pt7b" },
  { &NotoSans_BlackItalic71pt7b, 71, "NotoSans_BlackItalic71pt7b" },
  { &NotoSans_BlackItalic72pt7b, 72, "NotoSans_BlackItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
