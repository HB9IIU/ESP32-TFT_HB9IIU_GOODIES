#ifndef _NOTOSANS_BLACKITALIC42PT7B_H_
#define _NOTOSANS_BLACKITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x01, 0x80, 0x00, 0x7F, 0x3F, 0xBF, 0x9F,
  0xDF, 0x8F, 0xEF, 0xC7, 0xE7, 0xE3, 0xF7, 0xF3, 0xFB, 0xF1, 0xF9, 0xF8,
  0xFC, 0xFC, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC3, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xDC, 0x30, 0x7F, 0x38,
  0x00, 0xFE, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x7F, 0x20, 0x1C, 0xFE, 0x70,
  0x39, 0xFC, 0xFE, 0x77, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0x07, 0xF3, 0xF0, 0x3F, 0x00, 0x7E, 0x3F,
  0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x7E, 0x00, 0x7E, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x7E, 0x3F, 0x87, 0xFF, 0xCF, 0xCF, 0xFC, 0x7F, 0xFC,
  0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0x9F, 0xFF, 0x3F, 0xF3, 0xF3, 0xFF, 0xF1,
  0xFE, 0x7E, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x3F, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x3F, 0x00, 0x3F,
  0x07, 0xE3, 0xF0, 0x07, 0xE0, 0x7C, 0x7E, 0x00, 0xFC, 0x07, 0xE7, 0xE0,
  0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x7F,
  0xF8, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x3F, 0xC1, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE,
  0x3F, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xCF, 0xF1, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFC, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F,
  0xC0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0xFE, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x03, 0x07, 0xC0, 0x3E, 0x3E, 0x01, 0xFD, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xF7, 0xC0, 0x3F,
  0x3F, 0x00, 0xF9, 0xF8, 0x01, 0x87, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0x80, 0x3F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xE7, 0xFF, 0x7F, 0xF8, 0x3F, 0x3F, 0xBF, 0xFF, 0xFF, 0xF7,
  0xF9, 0xF8, 0x20, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F,
  0x83, 0xFC, 0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0,
  0x7F, 0xDF, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x07,
  0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE1, 0xFF,
  0x3F, 0xC3, 0xFC, 0x3F, 0xCF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xF7, 0xF0,
  0xF9, 0xFE, 0x1E, 0x3F, 0xC1, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xF9, 0xFF, 0x01, 0xE0, 0xFF,
  0x00, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xF0, 0xFF, 0x80, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xA0, 0x01, 0xFF,
  0x78, 0x0F, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF8, 0x07, 0xE7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0x87, 0xF0,
  0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x80, 0x07, 0xF8,
  0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x7E, 0x03, 0xFB, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xCF, 0xF9, 0xFF, 0x1F,
  0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x9F, 0xC1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0x7F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE1, 0xFF, 0x3F, 0xC3, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0,
  0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xBF,
  0x87, 0xFD, 0xFC, 0x1F, 0x9F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x90, 0x1F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x1F, 0x81,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x10,
  0x00, 0x00, 0x20, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x07, 0xF9, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x07,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7E, 0x3F, 0x81, 0xFF, 0x0F, 0xCF, 0xC1, 0xFF, 0xF3, 0xF7, 0xE0,
  0xFF, 0xFC, 0x7D, 0xF8, 0x7F, 0xFE, 0x1F, 0x7C, 0x3F, 0x8F, 0x87, 0xFF,
  0x1F, 0xC3, 0xE1, 0xFF, 0xC7, 0xE1, 0xF8, 0x7F, 0xE1, 0xF0, 0x7E, 0x1F,
  0xF8, 0xFC, 0x1F, 0x07, 0xFE, 0x3F, 0x0F, 0xC3, 0xFF, 0x8F, 0xC3, 0xF0,
  0xFB, 0xE3, 0xF0, 0xFC, 0x7E, 0xF8, 0xFC, 0x7F, 0x3F, 0x3E, 0x3F, 0xFF,
  0xFF, 0xCF, 0x8F, 0xFF, 0xFF, 0xE3, 0xF1, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F,
  0xCF, 0xF0, 0x1F, 0x83, 0x80, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x04, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xDF,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0xFF, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1,
  0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC1, 0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xE7, 0xFE, 0x0F, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE,
  0x0F, 0xF8, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F,
  0xC0, 0x18, 0x3F, 0xE0, 0x02, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x01, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0x83, 0xE0, 0xFF, 0xC0, 0x08, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xFC,
  0xFF, 0x0F, 0xFF, 0x3F, 0xE1, 0xFF, 0xE7, 0xFC, 0x7F, 0xFC, 0xFF, 0x0F,
  0xFF, 0x9F, 0xE1, 0xFF, 0xE3, 0xFC, 0x3F, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0x0F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x87, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xE0, 0x1F, 0xE1,
  0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF3, 0xFE,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFE,
  0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFE,
  0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xBF, 0x0F, 0xDF, 0xC1, 0xFD, 0xF8, 0x7E, 0xFE, 0x0F, 0xEF, 0xC7, 0xEF,
  0xF0, 0x7F, 0x7E, 0x3F, 0x7F, 0x03, 0xFB, 0xF3, 0xF3, 0xF8, 0x1F, 0xDF,
  0x9F, 0x9F, 0xC1, 0xFC, 0xFC, 0xF9, 0xFE, 0x0F, 0xE7, 0xEF, 0xCF, 0xE0,
  0x7F, 0x3F, 0x7C, 0x7F, 0x03, 0xF9, 0xFF, 0xE3, 0xF8, 0x3F, 0xCF, 0xFF,
  0x1F, 0xC1, 0xFC, 0x7F, 0xF1, 0xFE, 0x0F, 0xE3, 0xFF, 0x8F, 0xE0, 0x7F,
  0x1F, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0xC3, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F,
  0xC1, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x7F, 0x07,
  0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x80, 0xFE, 0x07,
  0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x0F, 0xFF, 0xC0, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x0F, 0xDF, 0xC1, 0xFC, 0x0F,
  0xCF, 0xE1, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x1F, 0xCF, 0xE3, 0xFC, 0x1F,
  0xCF, 0xF3, 0xF8, 0x1F, 0xC7, 0xF3, 0xF8, 0x1F, 0xC7, 0xF3, 0xF8, 0x3F,
  0x87, 0xF3, 0xF8, 0x3F, 0x87, 0xFB, 0xF0, 0x3F, 0x83, 0xFF, 0xF0, 0x3F,
  0x83, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xF0, 0x7F,
  0x01, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xE0, 0xFF,
  0x00, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE,
  0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87,
  0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xE1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0xE1, 0xFF,
  0x81, 0xFE, 0x3F, 0xF0, 0x1F, 0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x0F,
  0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F,
  0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03,
  0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF,
  0xF8, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x87, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xE7, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0x0F, 0x07, 0xF8, 0x04, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE2, 0x00, 0x7F, 0x8C, 0x01, 0xFE, 0x3E, 0x1F, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F,
  0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xF0,
  0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x01, 0xFC,
  0xFF, 0x01, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFF, 0x03, 0xF8, 0xFF, 0x03,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFF, 0x07,
  0xF0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF,
  0x0F, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0, 0x7F, 0x1F, 0xFF,
  0x1F, 0xC0, 0x7F, 0x3F, 0x7F, 0x3F, 0xC0, 0x7E, 0x3F, 0x7F, 0x3F, 0x80,
  0x7E, 0x7F, 0x7F, 0x7F, 0x80, 0x7E, 0x7E, 0x7E, 0x7F, 0x00, 0x7E, 0x7E,
  0x7E, 0x7F, 0x00, 0x7E, 0xFC, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x7E, 0xFE,
  0x00, 0x7F, 0xFC, 0x7E, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x3F,
  0xE7, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xCF, 0xF0, 0x07,
  0xF7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC,
  0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xCF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF0, 0x3F, 0x07,
  0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xF7,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE, 0x1F,
  0x83, 0xF0, 0x7C, 0x00, 0x60, 0x00, 0x07, 0xF9, 0xFC, 0x1F, 0xFB, 0xF8,
  0x7F, 0xF7, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xE3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x07, 0xF3, 0xFE, 0x0F, 0xE7, 0xF8,
  0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0xC0, 0x07, 0xFB, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF,
  0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFE,
  0x3F, 0xC3, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7E, 0x7F, 0xE0, 0xFE, 0x3F, 0x80,
  0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFC, 0x08, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0x0F, 0xF8, 0x70, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x61, 0xFE, 0x01, 0xFC, 0xFF, 0x01, 0xFF, 0x7F, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xE0, 0xFE, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xBF,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xF8,
  0x7F, 0x7F, 0x83, 0xFB, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x06, 0x3F, 0xF1, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x02, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFE, 0x7F, 0x03, 0xFF, 0x7F, 0x07, 0xFF, 0x7E,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFC, 0x3F, 0xC1, 0xFC, 0x7F, 0xC1, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x0F, 0xCF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x80, 0x3F, 0xC0, 0xE0, 0x7F, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x60, 0x07, 0xFB, 0xFC,
  0x07, 0xF7, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x87, 0xF8, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x9F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0x87, 0xFC, 0x07, 0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xF3, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03,
  0xFC, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87,
  0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x3F, 0x9F, 0xE0, 0xFF, 0x01, 0xFD, 0xFF,
  0x8F, 0xFC, 0x0F, 0xDF, 0xFC, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xF8,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x07, 0xF3, 0xFC, 0x07, 0xF7, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8,
  0xFF, 0x87, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFE, 0xFF, 0x9F, 0xF1,
  0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFE, 0xFF,
  0x0F, 0xF3, 0xFC, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF,
  0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3,
  0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xF7, 0xFE, 0x01, 0xFD, 0xFF, 0x00,
  0x7F, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xF9, 0xFC, 0x1F, 0xFB, 0xF8, 0x7F, 0xF7, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F,
  0xC7, 0xF8, 0xFF, 0x07, 0xF3, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0,
  0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x7F, 0x3F, 0x07, 0xF7, 0xF0, 0x7E, 0xFE,
  0x07, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF0, 0xE1, 0xFE, 0x04, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x90, 0x0F, 0xF3, 0xF7, 0xFE, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x88, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xE0, 0x7F, 0xEF, 0xE0,
  0x1F, 0xCF, 0xE0, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7,
  0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x8F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F,
  0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xFB,
  0xFC, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xE0, 0xFF, 0x7F,
  0x87, 0xFC, 0x3F, 0xCF, 0xF1, 0xFF, 0x87, 0xF9, 0xFE, 0x3F, 0xF0, 0xFE,
  0x3F, 0xC7, 0xFE, 0x3F, 0xC3, 0xF9, 0xFF, 0xC7, 0xF0, 0x7F, 0x3E, 0xF9,
  0xFE, 0x0F, 0xEF, 0xDF, 0x3F, 0x81, 0xFD, 0xFB, 0xE7, 0xF0, 0x3F, 0xBE,
  0x7D, 0xFC, 0x07, 0xFF, 0xCF, 0xBF, 0x80, 0xFD, 0xF1, 0xFF, 0xE0, 0x1F,
  0xBE, 0x7F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xE0,
  0x0F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F,
  0x80, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x8F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0B, 0xFF,
  0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xD0, 0x03, 0xFC,
};

const GFXglyph NotoSans_BlackItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 31, 13, 0, -30 },
  { 56, 17, 11, 19, 4, -30 },
  { 80, 28, 30, 27, 0, -30 },
  { 185, 23, 34, 24, 1, -32 },
  { 283, 36, 30, 39, 2, -30 },
  { 418, 31, 30, 31, 0, -30 },
  { 535, 8, 11, 10, 4, -30 },
  { 546, 18, 38, 16, 1, -31 },
  { 632, 17, 38, 16, -3, -31 },
  { 713, 21, 21, 23, 3, -32 },
  { 769, 21, 20, 25, 2, -25 },
  { 822, 11, 10, 13, -2, -5 },
  { 836, 13, 6, 14, 0, -14 },
  { 846, 9, 8, 13, 0, -7 },
  { 855, 24, 30, 20, -2, -30 },
  { 945, 23, 30, 24, 1, -30 },
  { 1032, 19, 30, 24, 3, -30 },
  { 1104, 24, 30, 24, -1, -30 },
  { 1194, 23, 30, 24, 0, -30 },
  { 1281, 24, 30, 24, 0, -30 },
  { 1371, 24, 30, 24, 0, -30 },
  { 1461, 23, 30, 24, 2, -30 },
  { 1548, 25, 30, 24, 1, -30 },
  { 1642, 23, 30, 24, 1, -30 },
  { 1729, 21, 30, 24, 2, -30 },
  { 1808, 13, 25, 13, 0, -24 },
  { 1849, 15, 29, 13, -2, -24 },
  { 1904, 21, 23, 25, 2, -27 },
  { 1965, 21, 15, 25, 2, -22 },
  { 2005, 21, 23, 25, 2, -27 },
  { 2066, 19, 31, 21, 3, -30 },
  { 2140, 34, 34, 38, 2, -30 },
  { 2285, 28, 30, 28, -2, -30 },
  { 2390, 25, 30, 27, 1, -30 },
  { 2484, 26, 30, 26, 2, -30 },
  { 2582, 26, 30, 29, 1, -30 },
  { 2680, 24, 30, 24, 1, -30 },
  { 2770, 24, 30, 24, 1, -30 },
  { 2860, 27, 30, 29, 2, -30 },
  { 2962, 29, 30, 30, 1, -30 },
  { 3071, 22, 30, 18, -2, -30 },
  { 3154, 23, 39, 16, -7, -30 },
  { 3267, 30, 30, 28, 1, -30 },
  { 3380, 19, 30, 22, 1, -30 },
  { 3452, 37, 30, 38, 1, -30 },
  { 3591, 32, 30, 33, 1, -30 },
  { 3711, 28, 30, 31, 2, -30 },
  { 3816, 25, 30, 26, 1, -30 },
  { 3910, 28, 37, 31, 2, -30 },
  { 4040, 25, 30, 27, 1, -30 },
  { 4134, 22, 30, 23, 1, -30 },
  { 4217, 23, 30, 23, 3, -30 },
  { 4304, 27, 30, 29, 3, -30 },
  { 4406, 26, 30, 26, 3, -30 },
  { 4504, 40, 30, 39, 3, -30 },
  { 4654, 34, 30, 28, -3, -30 },
  { 4782, 26, 30, 25, 3, -30 },
  { 4880, 27, 30, 23, -2, -30 },
  { 4982, 19, 38, 15, -1, -31 },
  { 5073, 11, 30, 20, 5, -30 },
  { 5115, 19, 38, 15, -3, -31 },
  { 5206, 22, 20, 22, 0, -30 },
  { 5261, 20, 5, 19, -4, 3 },
  { 5274, 10, 7, 15, 6, -32 },
  { 5283, 23, 24, 26, 2, -24 },
  { 5352, 24, 32, 26, 0, -32 },
  { 5448, 20, 24, 21, 2, -24 },
  { 5508, 25, 32, 25, 2, -32 },
  { 5608, 21, 24, 24, 2, -24 },
  { 5671, 26, 42, 17, -4, -32 },
  { 5808, 24, 34, 26, 1, -24 },
  { 5910, 24, 32, 26, 0, -32 },
  { 6006, 15, 33, 14, 0, -33 },
  { 6068, 20, 43, 14, -5, -33 },
  { 6176, 28, 32, 26, 0, -32 },
  { 6288, 15, 32, 14, 0, -32 },
  { 6348, 37, 24, 39, 0, -24 },
  { 6459, 24, 24, 26, 0, -24 },
  { 6531, 22, 24, 26, 2, -24 },
  { 6597, 26, 34, 26, -2, -24 },
  { 6708, 23, 34, 26, 2, -24 },
  { 6806, 20, 24, 18, 0, -24 },
  { 6866, 19, 24, 21, 1, -24 },
  { 6923, 19, 28, 19, 1, -28 },
  { 6990, 24, 23, 26, 2, -23 },
  { 7059, 23, 23, 23, 2, -23 },
  { 7126, 35, 23, 35, 2, -23 },
  { 7227, 28, 23, 24, -2, -23 },
  { 7308, 28, 33, 23, -3, -23 },
  { 7424, 22, 23, 20, -1, -23 },
  { 7488, 18, 37, 15, 0, -30 },
  { 7572, 6, 42, 24, 9, -32 },
  { 7604, 18, 37, 15, -3, -30 },
  { 7688, 21, 8, 25, 2, -19 },
};

const GFXfont NotoSans_BlackItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_BLACKITALIC42PT7B_H_
