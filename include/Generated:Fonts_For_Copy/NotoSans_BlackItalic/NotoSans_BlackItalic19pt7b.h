#ifndef _NOTOSANS_BLACKITALIC19PT7B_H_
#define _NOTOSANS_BLACKITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x70, 0x00, 0x07, 0x8F,
  0x1E, 0x00, 0xFF, 0xEE, 0xEE, 0xEE, 0xCC, 0x07, 0x70, 0x33, 0x03, 0xB8,
  0x1D, 0xC7, 0xFF, 0xBF, 0xF8, 0x77, 0x03, 0x38, 0xFF, 0xF7, 0xFF, 0x8E,
  0xE0, 0x66, 0x03, 0x30, 0x3B, 0x80, 0x02, 0x07, 0xF7, 0xFD, 0xF6, 0x74,
  0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x82, 0xED, 0xFB, 0xFC, 0xFE, 0x04, 0x03,
  0x00, 0x1C, 0x0E, 0x7E, 0x1C, 0x7E, 0x38, 0xEE, 0x30, 0xEE, 0x60, 0xEE,
  0xE0, 0xFD, 0xDE, 0x7D, 0xBF, 0x33, 0xB3, 0x07, 0x73, 0x0E, 0x77, 0x0C,
  0x77, 0x1C, 0x7E, 0x38, 0x3C, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x07, 0x38,
  0x1D, 0xE0, 0x7F, 0x01, 0xFB, 0xDF, 0xCE, 0x7F, 0xFB, 0xDF, 0xCF, 0x3F,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFE, 0xEE, 0xC0, 0x0E, 0x38, 0xE1,
  0xC7, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x70,
  0x1C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC7,
  0x0E, 0x38, 0xE0, 0x08, 0x03, 0x84, 0xE1, 0xF8, 0xFF, 0xC7, 0xF3, 0xE5,
  0xD8, 0x37, 0x01, 0x80, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xFF, 0xFC, 0x70,
  0x38, 0x1C, 0x00, 0x3B, 0x9D, 0xC0, 0x7D, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x0F, 0xE3, 0xF9, 0xEF,
  0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xB9, 0xEE, 0x7B, 0xFC, 0xFE, 0x1F,
  0x00, 0x03, 0x87, 0xC7, 0xEF, 0xEF, 0xF3, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x03, 0x81, 0xFC, 0x7F, 0x8E, 0xF0, 0x8E,
  0x03, 0xC0, 0x70, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3F, 0xE7, 0xFD, 0xFF,
  0x80, 0x0F, 0x0F, 0xF3, 0xFC, 0x47, 0x01, 0xC0, 0xF1, 0xF8, 0x7E, 0x07,
  0x80, 0xF8, 0x3F, 0xFF, 0xFF, 0xBF, 0x80, 0x01, 0xE0, 0x3C, 0x0F, 0x03,
  0xE0, 0xFC, 0x3F, 0x8E, 0xF1, 0xDC, 0x73, 0x9F, 0xFB, 0xFF, 0x03, 0x80,
  0x70, 0x1E, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x0E, 0x03, 0xC0, 0x7E, 0x0F,
  0xE3, 0xFE, 0x03, 0xC0, 0x7A, 0x0F, 0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0x07,
  0xC7, 0xF3, 0xFD, 0xE0, 0x70, 0x3F, 0xCF, 0xFB, 0xFE, 0xF3, 0xB8, 0xEE,
  0x7B, 0xFE, 0x7F, 0x0F, 0x80, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x80, 0x07, 0x83, 0xF8, 0xFF, 0x9E, 0xF3, 0xDE, 0x7F, 0x87, 0xE1,
  0xFC, 0x7B, 0xCE, 0x7B, 0xCF, 0x3D, 0xE7, 0xF8, 0x7E, 0x00, 0x1E, 0x0F,
  0xC7, 0xFB, 0xCE, 0xF3, 0xFC, 0xFF, 0x7B, 0xFE, 0x7B, 0x89, 0xE0, 0xF3,
  0xFC, 0xFE, 0x3E, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0xF3, 0xCF,
  0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xC3, 0x8E,
  0x00, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x87, 0x81, 0xF0, 0x3F, 0x07, 0x80,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x80, 0x70, 0x3E,
  0x07, 0xC0, 0xF8, 0x3C, 0x7F, 0xF8, 0xF0, 0x60, 0x00, 0x1E, 0x7F, 0x9F,
  0xEC, 0xF0, 0x78, 0x78, 0xF8, 0x78, 0x78, 0x00, 0x00, 0x0E, 0x0F, 0x03,
  0x80, 0x03, 0xE0, 0x1F, 0xF0, 0xF8, 0xF1, 0xC0, 0x77, 0x3F, 0x7C, 0xFC,
  0xFB, 0x99, 0xE6, 0x73, 0xCC, 0xE7, 0xB9, 0xDF, 0x3F, 0xF7, 0x7B, 0xCE,
  0x00, 0x0F, 0x1C, 0x0F, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0x80, 0xFC,
  0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xC3, 0xCE, 0x1C, 0x71, 0xFF, 0x8F,
  0xFC, 0xF0, 0xE7, 0x07, 0x78, 0x3C, 0x1F, 0x81, 0xFE, 0x1F, 0xF1, 0xCF,
  0x3C, 0xF3, 0xDE, 0x3F, 0xC3, 0xFC, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xFC,
  0x7F, 0xCF, 0xF0, 0x07, 0x81, 0xFF, 0x3F, 0xE7, 0xC6, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x8F, 0xF8, 0x7F, 0x83, 0xF8,
  0x1F, 0x01, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0x73, 0xC7, 0x3C, 0x73, 0x87,
  0x78, 0xF7, 0x8F, 0x79, 0xE7, 0xFE, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8E, 0x03, 0xC0, 0x7F, 0x8F, 0xF1, 0xFC, 0x78, 0x0F, 0x01, 0xE0,
  0x3F, 0xC7, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03, 0xC0,
  0x78, 0x0F, 0xF1, 0xFC, 0x7F, 0x8F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0xC1, 0xFF, 0x3F, 0xE7, 0xC6, 0x78, 0x0F, 0x00, 0xF3, 0xEF,
  0x7E, 0xF7, 0xEF, 0x1E, 0xF1, 0xEF, 0xFC, 0x7F, 0xC3, 0xFC, 0x1E, 0x3C,
  0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x78, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x80, 0x1F,
  0xC7, 0xF1, 0xFC, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0xF8, 0x7F, 0x3F, 0x80, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE3,
  0xF8, 0xFC, 0x3E, 0x00, 0x1E, 0x3C, 0x79, 0xE1, 0xCF, 0x07, 0x3C, 0x3D,
  0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xC1, 0xEF, 0x07, 0xBC, 0x1C,
  0x78, 0x71, 0xE3, 0xC7, 0xC0, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0xF7, 0xFF, 0xF8, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF3, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xDC,
  0x7E, 0xEE, 0x7F, 0x6F, 0x3B, 0xF7, 0x1D, 0xF3, 0x8E, 0xF9, 0xC7, 0x7C,
  0xE7, 0xBC, 0xF0, 0x1E, 0x0E, 0x3E, 0x1C, 0x7C, 0x78, 0xF8, 0xE3, 0xF9,
  0xC7, 0x73, 0x8E, 0xE7, 0x1D, 0xDE, 0x7B, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3,
  0x8F, 0xC7, 0x0F, 0x9E, 0x1E, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xF7, 0xCF,
  0x78, 0x77, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0xFE,
  0x7F, 0xC3, 0xF0, 0x1F, 0x01, 0xFC, 0x1F, 0xE1, 0xDF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0x07, 0x81, 0xFE, 0x3F, 0xF7, 0xCF, 0x78, 0x77, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0xFE, 0x7F, 0xC3, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x01, 0xFE, 0x1F, 0xE1, 0xCF, 0x3C, 0xF3, 0xCE, 0x3F,
  0xE3, 0xFC, 0x7F, 0x87, 0xB8, 0x7B, 0xC7, 0x1C, 0x71, 0xEF, 0x1E, 0x07,
  0x83, 0xFC, 0xFF, 0x1E, 0x63, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF2, 0x1E, 0x7F, 0xCF, 0xF0, 0xFC, 0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x4F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x00, 0x3C, 0x73, 0xC7, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8E,
  0x70, 0xE7, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xF0,
  0xF0, 0xFF, 0x0F, 0x71, 0xE7, 0x1E, 0x71, 0xC7, 0x3C, 0x73, 0x87, 0x78,
  0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0xE1, 0xFC,
  0x78, 0xFF, 0x1E, 0x39, 0xC7, 0x8E, 0x73, 0xE7, 0x9C, 0xF9, 0xC7, 0x7E,
  0xF1, 0xDF, 0xB8, 0x7E, 0xEE, 0x1F, 0xBF, 0x07, 0xCF, 0xC1, 0xF3, 0xF0,
  0x7C, 0xF8, 0x1E, 0x3E, 0x00, 0x1E, 0x1E, 0x3C, 0x78, 0x39, 0xE0, 0x7B,
  0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0xF7, 0x81, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x00, 0xE1, 0xFC, 0x7B, 0xCF,
  0x7B, 0xC7, 0x70, 0xFE, 0x1F, 0x83, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xFC, 0xFF, 0xCF,
  0xFC, 0x0F, 0x87, 0xC3, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xF8, 0xFC, 0x00, 0xE7, 0x38, 0xC7,
  0x39, 0xCE, 0x71, 0x8E, 0x73, 0x9C, 0x1F, 0x1F, 0x07, 0x07, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0xF8, 0xF8, 0x02,
  0x01, 0xC0, 0xF0, 0x3C, 0x1F, 0x8E, 0xE3, 0x99, 0xC6, 0xE1, 0xC0, 0x7F,
  0xBF, 0xFF, 0xE0, 0xEF, 0x70, 0x1D, 0xCF, 0xF7, 0xFD, 0xEF, 0xF3, 0xBC,
  0xEE, 0x3B, 0x9E, 0xFF, 0xBF, 0xC7, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0xC3, 0xFC, 0x7F, 0xCF, 0x79, 0xCF, 0x79, 0xEF, 0x39, 0xEF, 0x3F, 0xE7,
  0xF9, 0xDE, 0x00, 0x0E, 0x1F, 0xDF, 0xCF, 0x2F, 0x07, 0x83, 0x81, 0xC2,
  0xFE, 0x7F, 0x1F, 0x80, 0x01, 0xE0, 0x3C, 0x07, 0x8C, 0xE3, 0xFC, 0xFF,
  0x9E, 0xF7, 0x9C, 0xF3, 0x9C, 0x73, 0x9E, 0x7F, 0xCF, 0xF0, 0xFE, 0x00,
  0x0E, 0x0F, 0xE7, 0xF9, 0xCF, 0xF3, 0xBF, 0xEF, 0xE3, 0x80, 0xF3, 0x3F,
  0xC7, 0xE0, 0x00, 0xC0, 0x3F, 0x03, 0xE0, 0x78, 0x07, 0xE1, 0xFC, 0x1F,
  0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0xBC, 0x0F, 0xC0, 0xF8, 0x06, 0x00, 0x0E, 0xE3, 0xFC, 0xFF,
  0x9E, 0xF7, 0x9C, 0xF3, 0x9C, 0x73, 0x9E, 0x7F, 0xCF, 0xF0, 0xEE, 0x01,
  0xC8, 0x79, 0xFE, 0x3F, 0x81, 0xC0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0xC3,
  0xFC, 0x7F, 0xCF, 0x79, 0xCF, 0x79, 0xEF, 0x39, 0xE7, 0x39, 0xE7, 0x3D,
  0xE7, 0x80, 0x0C, 0x3C, 0x78, 0x03, 0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xE3,
  0xC7, 0x0E, 0x3C, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x3C,
  0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0xFC, 0x7C,
  0x3C, 0x08, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0xF3, 0xCF, 0x1E,
  0xF0, 0xEF, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xE7, 0x87, 0x3C,
  0x79, 0xF0, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF1, 0xE3,
  0x87, 0x1E, 0x00, 0x39, 0x86, 0x1D, 0xEF, 0x8F, 0xFF, 0xE7, 0xBE, 0xF3,
  0x9E, 0x7B, 0xCF, 0x39, 0xE7, 0x9C, 0xF3, 0x9E, 0x71, 0xCF, 0x39, 0xE7,
  0xBC, 0xF3, 0x80, 0x39, 0x87, 0x78, 0xFF, 0x9E, 0xF3, 0x9E, 0xF3, 0xDE,
  0x73, 0xCE, 0x73, 0xCE, 0x7B, 0xCF, 0x00, 0x0E, 0x0F, 0xE7, 0xF9, 0xCF,
  0xF3, 0xFC, 0xFE, 0x3B, 0x9E, 0xFF, 0xBF, 0xC7, 0xE0, 0x1C, 0xC1, 0xFE,
  0x1F, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xE3, 0xDE, 0x3F, 0xE3, 0xFC,
  0x7F, 0x87, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x1D, 0xCF, 0xF7,
  0xFD, 0xEF, 0xF3, 0xBC, 0xEE, 0x3B, 0x9E, 0xFF, 0xBF, 0xC7, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x39, 0x9D, 0xCF, 0xE7, 0xE3, 0xC3, 0xC1,
  0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x00, 0x0E, 0x1F, 0xDF, 0xEF, 0x27, 0xC1,
  0xF8, 0x7C, 0x0E, 0xEF, 0x7F, 0xBF, 0x80, 0x1C, 0x18, 0x3F, 0xFF, 0xFE,
  0x78, 0x70, 0x70, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x79, 0xEF, 0x39, 0xC7,
  0x39, 0xEF, 0x3D, 0xE7, 0xBC, 0xE7, 0xBC, 0xFF, 0x9F, 0xF1, 0xEC, 0x00,
  0xE1, 0xF8, 0xFE, 0x3B, 0x9E, 0xF7, 0x3F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0x80, 0xE3, 0xCF, 0xE7, 0xCE, 0xE7, 0xDE, 0xE7, 0x9C, 0xEF, 0xBC,
  0xED, 0xB8, 0xED, 0xB8, 0xFD, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0x79, 0xE0,
  0x3C, 0x78, 0xF7, 0x87, 0xB8, 0x3F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x3F, 0xC3, 0xDE, 0x3C, 0x78, 0x38, 0x73, 0x8F, 0x3C, 0xE3, 0xDE,
  0x3D, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x0F, 0x80, 0xF8, 0x0C, 0x00, 0x3F, 0xCF, 0xE3, 0xF9, 0x3C, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xFF, 0x3F, 0xCF, 0xF0, 0x03, 0x0F, 0x1F, 0x1C,
  0x1C, 0x1C, 0x3C, 0xF8, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x1C, 0x3E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1F, 0x0F, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0xF0, 0xF0,
  0xE0, 0x20, 0xFE, 0x7F, 0xF1, 0xF0,
};

const GFXglyph NotoSans_BlackItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 14, 6, 0, -14 },
  { 14, 8, 5, 9, 2, -14 },
  { 19, 13, 14, 12, 0, -14 },
  { 42, 10, 15, 11, 1, -14 },
  { 61, 16, 14, 18, 1, -14 },
  { 89, 14, 14, 14, 0, -14 },
  { 114, 4, 5, 5, 2, -14 },
  { 117, 7, 17, 7, 1, -14 },
  { 132, 7, 17, 7, -1, -14 },
  { 147, 10, 10, 10, 1, -15 },
  { 160, 9, 9, 11, 1, -11 },
  { 171, 5, 4, 6, -1, -2 },
  { 174, 6, 3, 6, 0, -7 },
  { 177, 4, 3, 6, 0, -3 },
  { 179, 11, 14, 9, -1, -14 },
  { 199, 10, 14, 11, 1, -14 },
  { 217, 9, 14, 11, 1, -14 },
  { 233, 11, 14, 11, -1, -14 },
  { 253, 10, 14, 11, 0, -14 },
  { 271, 11, 14, 11, 0, -14 },
  { 291, 11, 14, 11, 0, -14 },
  { 311, 10, 14, 11, 1, -14 },
  { 329, 12, 14, 11, 0, -14 },
  { 350, 11, 14, 11, 0, -14 },
  { 370, 10, 14, 11, 1, -14 },
  { 388, 6, 11, 6, 0, -11 },
  { 397, 7, 13, 6, -1, -11 },
  { 409, 9, 10, 11, 1, -12 },
  { 421, 9, 7, 11, 1, -10 },
  { 429, 9, 10, 11, 1, -12 },
  { 441, 9, 14, 9, 1, -14 },
  { 457, 15, 16, 17, 1, -14 },
  { 487, 13, 14, 13, -1, -14 },
  { 510, 12, 14, 12, 0, -14 },
  { 531, 12, 14, 12, 1, -14 },
  { 552, 12, 14, 13, 0, -14 },
  { 573, 11, 14, 11, 0, -14 },
  { 593, 11, 14, 11, 0, -14 },
  { 613, 12, 14, 13, 1, -14 },
  { 634, 14, 14, 14, 0, -14 },
  { 659, 10, 14, 8, -1, -14 },
  { 677, 10, 18, 7, -3, -14 },
  { 700, 14, 14, 13, 0, -14 },
  { 725, 9, 14, 10, 0, -14 },
  { 741, 17, 14, 17, 0, -14 },
  { 771, 15, 14, 15, 0, -14 },
  { 798, 12, 14, 14, 1, -14 },
  { 819, 12, 14, 12, 0, -14 },
  { 840, 12, 17, 14, 1, -14 },
  { 866, 12, 14, 12, 0, -14 },
  { 887, 11, 14, 10, 0, -14 },
  { 907, 11, 14, 10, 1, -14 },
  { 927, 12, 14, 13, 1, -14 },
  { 948, 12, 14, 12, 1, -14 },
  { 969, 18, 14, 18, 1, -14 },
  { 1001, 15, 14, 13, -1, -14 },
  { 1028, 11, 14, 11, 2, -14 },
  { 1048, 12, 14, 10, -1, -14 },
  { 1069, 9, 17, 7, -1, -14 },
  { 1089, 5, 14, 9, 2, -14 },
  { 1098, 8, 17, 7, -1, -14 },
  { 1115, 10, 9, 10, 0, -14 },
  { 1127, 9, 3, 9, -2, 1 },
  { 1131, 4, 3, 7, 3, -15 },
  { 1133, 10, 11, 12, 1, -11 },
  { 1147, 11, 14, 12, 0, -14 },
  { 1167, 9, 11, 10, 1, -11 },
  { 1180, 11, 14, 11, 1, -14 },
  { 1200, 10, 11, 11, 1, -11 },
  { 1214, 12, 20, 8, -2, -15 },
  { 1244, 11, 16, 12, 0, -11 },
  { 1266, 11, 14, 12, 0, -14 },
  { 1286, 7, 15, 6, 0, -15 },
  { 1300, 9, 20, 6, -2, -15 },
  { 1323, 13, 14, 12, 0, -14 },
  { 1346, 7, 14, 6, 0, -14 },
  { 1359, 17, 11, 18, 0, -11 },
  { 1383, 11, 11, 12, 0, -11 },
  { 1399, 10, 11, 12, 1, -11 },
  { 1413, 12, 16, 12, -1, -11 },
  { 1437, 10, 16, 12, 1, -11 },
  { 1457, 9, 11, 8, 0, -11 },
  { 1470, 9, 11, 10, 0, -11 },
  { 1483, 8, 13, 9, 1, -13 },
  { 1496, 11, 11, 12, 1, -11 },
  { 1512, 10, 11, 10, 1, -11 },
  { 1526, 16, 11, 16, 1, -11 },
  { 1548, 13, 11, 11, -1, -11 },
  { 1566, 12, 16, 10, -1, -11 },
  { 1590, 10, 11, 9, 0, -11 },
  { 1604, 8, 17, 7, 0, -14 },
  { 1621, 3, 18, 11, 4, -14 },
  { 1628, 8, 17, 7, -1, -14 },
  { 1645, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_BlackItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_BLACKITALIC19PT7B_H_
