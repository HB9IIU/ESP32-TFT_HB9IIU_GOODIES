#ifndef _NOTOSANS_BLACKITALIC51PT7B_H_
#define _NOTOSANS_BLACKITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xCF, 0xFB, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7,
  0xF0, 0xFE, 0x3F, 0x8F, 0xF3, 0xFC, 0x7F, 0x9F, 0xC3, 0xFC, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0x9E, 0x1C, 0x0F, 0xFB, 0xE0, 0x40, 0xFF, 0x3C, 0x00, 0x0F, 0xFB,
  0xC0, 0x00, 0xFF, 0xBC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xF7, 0xFC, 0x00, 0x1F, 0x7F, 0xC8, 0x01, 0xE3, 0xFC, 0xE0,
  0x1E, 0x7F, 0xCF, 0xC1, 0xEF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x3F,
  0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF7, 0xF8, 0x07,
  0xF0, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x83, 0xF8, 0x00, 0x7F,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x7F,
  0x8F, 0xF0, 0xFF, 0x7F, 0x8F, 0xE7, 0xFF, 0x9F, 0xFF, 0xF3, 0xF9, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xCF, 0xFF, 0xF3,
  0xFF, 0xC7, 0xF3, 0xFF, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0x9F, 0xC1, 0xF8,
  0x7F, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x0F, 0xF1, 0xFE,
  0x00, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x07,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0xDF, 0xF9, 0xFF, 0x8F,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xE7,
  0xF9, 0xFE, 0x7F, 0x1F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x02, 0x01, 0xFC, 0x01, 0x81, 0xFC, 0x00, 0xF0, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xF9, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7C, 0x7F, 0x80, 0x1C, 0x1F, 0xC0,
  0x02, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFC, 0x0F, 0x87, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF7, 0xFE, 0x7F, 0x83, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF,
  0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8,
  0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81,
  0xFF, 0xBF, 0xE0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x9F,
  0xF0, 0x3F, 0xF3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE1, 0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF1, 0xFF, 0xBF, 0xE3, 0xFE, 0xFF, 0x83, 0xF1, 0xFF, 0x07, 0xC3, 0xFE,
  0x06, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x3F,
  0xF8, 0x07, 0xC0, 0xFF, 0xC0, 0x1C, 0x07, 0xFE, 0x00, 0x80, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xF0, 0x3F, 0xF0, 0x08, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC8, 0x00, 0x0F, 0xFC, 0xE0, 0x01, 0xFF,
  0xCF, 0xE0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03,
  0xFD, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xC7,
  0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE3, 0xFF, 0x01, 0xFE, 0x1F, 0xF8,
  0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x04, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x80, 0x01, 0xFF, 0x8C, 0x00, 0x3F, 0xF8, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xFE, 0x07, 0xFD, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x87, 0xFE,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8,
  0xFF, 0xF7, 0xFC, 0x3F, 0xF3, 0xFE, 0x07, 0xE3, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC4, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3E, 0x07, 0xFC, 0x60, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0x83, 0xF8, 0x7F, 0x81,
  0xFF, 0xFC, 0x7F, 0x1F, 0xC0, 0xFF, 0xFF, 0x1F, 0xCF, 0xE0, 0xFF, 0xFF,
  0xC7, 0xF3, 0xF8, 0x3F, 0xFF, 0xE1, 0xFD, 0xFC, 0x1F, 0xF3, 0xF8, 0x3F,
  0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xDF, 0x83, 0xF8, 0x3F, 0x83, 0xF7, 0xE1,
  0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0xFF, 0x8F, 0xE0, 0x7F, 0x07, 0xEF, 0xE3, 0xF8, 0x1F, 0x81,
  0xFB, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x3F,
  0x8F, 0xE1, 0xFE, 0x3F, 0xCF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC3, 0xFF, 0xBF,
  0xFC, 0x07, 0xF0, 0x7F, 0x87, 0xFE, 0x01, 0xFE, 0x07, 0x80, 0x7C, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x8F, 0xFF, 0x03, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F, 0xFC, 0x00,
  0xE0, 0xFF, 0xF0, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x08, 0x0F, 0xFF,
  0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC,
  0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC,
  0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8,
  0x07, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xF8,
  0x1F, 0xFF, 0x00, 0x18, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xFC,
  0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xFC,
  0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFD,
  0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xBF, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0xFC, 0x07, 0xF7, 0xF8, 0x07,
  0xFB, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xEF, 0xC0, 0xFE, 0xFF, 0x80, 0xFF,
  0xBF, 0x03, 0xFB, 0xFC, 0x03, 0xFE, 0xFC, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3,
  0xF0, 0x7F, 0x7F, 0xC0, 0x3F, 0xCF, 0xC3, 0xF9, 0xFF, 0x00, 0xFF, 0x3F,
  0x0F, 0xE7, 0xFC, 0x07, 0xFC, 0xFC, 0x7F, 0x1F, 0xE0, 0x1F, 0xF3, 0xF1,
  0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xCF, 0xF3, 0xFE, 0x01, 0xFE, 0x3F, 0x3F,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFC, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xF7, 0xF0,
  0xFF, 0x00, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0xC1, 0xFE,
  0x01, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xF8,
  0x07, 0xFB, 0xFC, 0x0F, 0xF8, 0x07, 0xFB, 0xFE, 0x0F, 0xF8, 0x07, 0xFB,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFB, 0xFE, 0x0F, 0xF0, 0x0F, 0xF9, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x9F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x9F, 0xE0, 0x1F, 0xF0, 0xFF, 0x9F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF,
  0x8F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x3F, 0xF0, 0x07, 0xFF,
  0x1F, 0xF8, 0x07, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC7,
  0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87,
  0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF,
  0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFE, 0x0F, 0x81, 0xFF, 0x80, 0x20, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC2, 0x00, 0x1F, 0xF8, 0x60, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xE1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x01,
  0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xC0, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xF7, 0xF0,
  0xFF, 0x80, 0xFF, 0x8F, 0xF7, 0xF0, 0xFF, 0x80, 0xFF, 0x8F, 0xF7, 0xF1,
  0xFF, 0x00, 0xFF, 0x8F, 0xE7, 0xF1, 0xFF, 0x00, 0xFF, 0x9F, 0xE7, 0xF1,
  0xFE, 0x00, 0xFF, 0x9F, 0xC7, 0xF3, 0xFE, 0x00, 0x7F, 0xBF, 0xC7, 0xF3,
  0xFE, 0x00, 0x7F, 0xBF, 0xC7, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0x87, 0xF7,
  0xFC, 0x00, 0x7F, 0x7F, 0x87, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x07, 0xF7,
  0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xE1,
  0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF,
  0x80, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFE,
  0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00,
  0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x1F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xBF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xCF, 0xF0, 0x3F,
  0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x3F,
  0xF0, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F,
  0xFC, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFE, 0x01, 0xFF,
  0x9F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x1C, 0x00,
  0x7F, 0xEF, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF,
  0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0x1F, 0xE0, 0x3F,
  0xF3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0x7F, 0xFC, 0x0F, 0xF3, 0xFF, 0x80, 0xFE, 0x1F,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFC, 0x1C, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x30, 0xFF, 0xF1, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x70, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF9,
  0xFF, 0x00, 0x7F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF,
  0x81, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xE0, 0x03, 0xFF,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF,
  0x3F, 0xF0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF7, 0xFE, 0x07, 0xFD, 0xFF, 0x83,
  0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x04, 0x3F, 0xF8, 0x07, 0x07, 0xFF, 0x9F,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xCC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x3F, 0xF9, 0xFE, 0x03, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFE, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF9,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00,
  0x7F, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x80, 0x0F, 0xFE, 0x07, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x1E, 0x00, 0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x1F, 0xFC, 0x1F,
  0xF1, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x1F,
  0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF, 0x07,
  0xFE, 0x3F, 0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xC7,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0,
  0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE,
  0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7F, 0x8F,
  0xFC, 0x0F, 0xF8, 0x07, 0xF9, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xBF, 0xFE,
  0x3F, 0xFE, 0x07, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x3F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC7,
  0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x7F, 0x8F, 0xF8, 0x07, 0xF9, 0xFF, 0xC0, 0x7F, 0xBF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x1F, 0xFC, 0x1F, 0xF1, 0xFF,
  0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x3F,
  0xF3, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F,
  0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F,
  0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xCF,
  0xFC, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC,
  0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF,
  0xF8, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F,
  0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xDF, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x1F, 0xC0,
  0x07, 0xFE, 0x0C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x3F, 0xF0,
  0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFC,
  0x7F, 0xC0, 0x7F, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC,
  0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF,
  0xE0, 0x0F, 0xF7, 0xFE, 0x00, 0x10, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x0F, 0xF1, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xDF, 0xF0, 0x7F,
  0xBF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xB0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xF8, 0x78, 0x3F,
  0xF0, 0x18, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x80,
  0x1F, 0xF8, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x38, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF,
  0x01, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00,
  0x18, 0x10, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F,
  0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x03,
  0xFC, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFB,
  0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xEF, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFB, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0x3F, 0xE1, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0xF8, 0x7F, 0xE3, 0xFE,
  0x3F, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xDF, 0x87, 0xFC, 0x3F, 0xE3, 0xF7,
  0xE3, 0xFE, 0x0F, 0xF9, 0xFD, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0x7E, 0x7F,
  0xC0, 0xFF, 0x9F, 0xBF, 0x9F, 0xF0, 0x3F, 0xEF, 0xEF, 0xE7, 0xF8, 0x0F,
  0xFB, 0xFB, 0xFB, 0xFE, 0x03, 0xFE, 0xFC, 0xFE, 0xFF, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0xC0, 0x1F, 0xDF, 0x8F, 0xFF, 0xE0, 0x07, 0xF7, 0xE3, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x20, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFE, 0x00, 0x37, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0x20, 0x00, 0x3F,
  0x00,
};

const GFXglyph NotoSans_BlackItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 18, 37, 16, 0, -36 },
  { 85, 21, 13, 23, 5, -36 },
  { 120, 34, 36, 33, 0, -36 },
  { 273, 28, 42, 30, 1, -39 },
  { 420, 43, 38, 47, 3, -37 },
  { 625, 37, 38, 37, 0, -37 },
  { 801, 10, 13, 12, 5, -36 },
  { 818, 20, 45, 19, 2, -37 },
  { 931, 20, 45, 19, -3, -37 },
  { 1044, 25, 25, 28, 4, -39 },
  { 1123, 26, 24, 30, 2, -30 },
  { 1201, 14, 13, 16, -3, -6 },
  { 1224, 15, 8, 17, 1, -18 },
  { 1239, 11, 10, 16, 0, -9 },
  { 1253, 29, 38, 24, -2, -37 },
  { 1391, 27, 38, 30, 2, -37 },
  { 1520, 23, 36, 30, 4, -36 },
  { 1624, 29, 37, 30, -1, -37 },
  { 1759, 28, 38, 30, 0, -37 },
  { 1892, 29, 36, 30, 0, -36 },
  { 2023, 28, 37, 30, 1, -36 },
  { 2153, 28, 38, 30, 2, -37 },
  { 2286, 31, 36, 30, 1, -36 },
  { 2426, 28, 38, 30, 1, -37 },
  { 2559, 25, 38, 30, 3, -37 },
  { 2678, 15, 30, 16, 0, -29 },
  { 2735, 18, 36, 16, -3, -29 },
  { 2816, 25, 28, 30, 2, -32 },
  { 2904, 26, 18, 30, 2, -27 },
  { 2963, 25, 28, 30, 2, -32 },
  { 3051, 22, 38, 25, 4, -37 },
  { 3156, 42, 42, 46, 2, -37 },
  { 3377, 34, 36, 34, -3, -36 },
  { 3530, 31, 36, 32, 1, -36 },
  { 3670, 31, 38, 32, 3, -37 },
  { 3818, 32, 36, 35, 1, -36 },
  { 3962, 29, 36, 29, 1, -36 },
  { 4093, 29, 36, 29, 1, -36 },
  { 4224, 32, 38, 36, 3, -37 },
  { 4376, 36, 36, 36, 1, -36 },
  { 4538, 27, 36, 22, -2, -36 },
  { 4660, 27, 47, 19, -8, -36 },
  { 4819, 37, 36, 34, 1, -36 },
  { 4986, 23, 36, 27, 1, -36 },
  { 5090, 46, 36, 46, 1, -36 },
  { 5297, 40, 36, 40, 1, -36 },
  { 5477, 33, 38, 38, 3, -37 },
  { 5634, 30, 36, 32, 1, -36 },
  { 5769, 33, 46, 38, 3, -37 },
  { 5959, 30, 36, 33, 1, -36 },
  { 6094, 27, 38, 28, 1, -37 },
  { 6223, 27, 36, 28, 4, -36 },
  { 6345, 33, 37, 36, 3, -36 },
  { 6498, 31, 36, 31, 4, -36 },
  { 6638, 48, 36, 48, 4, -36 },
  { 6854, 41, 36, 34, -3, -36 },
  { 7039, 31, 36, 31, 4, -36 },
  { 7179, 32, 36, 27, -2, -36 },
  { 7323, 23, 46, 18, -1, -37 },
  { 7456, 13, 38, 24, 6, -37 },
  { 7518, 23, 46, 18, -3, -37 },
  { 7651, 27, 24, 27, 0, -36 },
  { 7732, 25, 6, 23, -5, 3 },
  { 7751, 13, 8, 18, 7, -39 },
  { 7764, 28, 30, 31, 2, -29 },
  { 7869, 28, 40, 31, 1, -39 },
  { 8009, 24, 30, 26, 2, -29 },
  { 8099, 31, 40, 31, 2, -39 },
  { 8254, 26, 30, 30, 2, -29 },
  { 8352, 31, 51, 21, -5, -39 },
  { 8550, 29, 41, 31, 1, -29 },
  { 8699, 28, 39, 32, 1, -39 },
  { 8836, 17, 40, 17, 1, -40 },
  { 8921, 25, 52, 17, -7, -40 },
  { 9084, 33, 39, 31, 1, -39 },
  { 9245, 17, 39, 17, 1, -39 },
  { 9328, 44, 29, 47, 1, -29 },
  { 9488, 28, 29, 32, 1, -29 },
  { 9590, 27, 30, 31, 2, -29 },
  { 9692, 31, 41, 31, -2, -29 },
  { 9851, 28, 41, 31, 2, -29 },
  { 9995, 23, 29, 22, 1, -29 },
  { 10079, 24, 30, 26, 1, -29 },
  { 10169, 22, 35, 23, 2, -34 },
  { 10266, 29, 29, 32, 2, -28 },
  { 10372, 29, 28, 28, 2, -28 },
  { 10474, 42, 28, 42, 3, -28 },
  { 10621, 35, 28, 29, -3, -28 },
  { 10744, 34, 40, 28, -3, -28 },
  { 10914, 27, 28, 25, -1, -28 },
  { 11009, 22, 44, 18, 0, -36 },
  { 11130, 7, 51, 29, 11, -39 },
  { 11175, 22, 44, 18, -3, -36 },
  { 11296, 26, 10, 30, 2, -23 },
};

const GFXfont NotoSans_BlackItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_BLACKITALIC51PT7B_H_
