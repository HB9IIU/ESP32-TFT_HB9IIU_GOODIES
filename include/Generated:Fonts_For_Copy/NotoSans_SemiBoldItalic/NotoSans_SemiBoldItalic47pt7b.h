#ifndef _NOTOSANS_SEMIBOLDITALIC47PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x08, 0x00, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xE7, 0x0E, 0x0F, 0xC7, 0x02, 0x0F, 0xC7, 0x00, 0x0F, 0xC7, 0x00, 0x0F,
  0xCF, 0x00, 0x0F, 0xCE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1D, 0xFC, 0x00, 0x3C, 0xFC, 0x00, 0x38, 0xFC, 0x00,
  0x38, 0xFC, 0x00, 0x38, 0xFC, 0xC0, 0x79, 0xFC, 0xF0, 0x73, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xFF, 0x00,
  0x0F, 0x80, 0xFF, 0xE0, 0x03, 0xE0, 0x7F, 0xF8, 0x01, 0xF0, 0x3F, 0x3E,
  0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xF0,
  0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0x81, 0xE0, 0x0F,
  0x83, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x3E, 0x00,
  0x3E, 0x0F, 0x8F, 0x06, 0x0F, 0x87, 0xC7, 0xCF, 0xF3, 0xE1, 0xF3, 0xE7,
  0xFE, 0xFC, 0xF9, 0xF3, 0xFF, 0xDF, 0xFE, 0x79, 0xFF, 0xF7, 0xFF, 0x3E,
  0x7C, 0x7C, 0xFF, 0x9F, 0x3E, 0x0F, 0x1F, 0x8F, 0x8F, 0x83, 0xC0, 0x03,
  0xC3, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x78,
  0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0xF0, 0x07, 0xC7,
  0xC0, 0x7C, 0x01, 0xFF, 0xF0, 0x3E, 0x00, 0x3F, 0xF8, 0x1F, 0x00, 0x0F,
  0xFC, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x03, 0xF1, 0xFF, 0xF0, 0x1F, 0x8F, 0xF7, 0xE0, 0x7E, 0x7F, 0x1F, 0xC3,
  0xF1, 0xF8, 0x3F, 0x8F, 0xCF, 0xC0, 0x7E, 0x7E, 0x3F, 0x01, 0xFF, 0xF0,
  0xFC, 0x03, 0xFF, 0xC3, 0xF0, 0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F,
  0x00, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0x8F, 0xE0, 0x3F, 0xF8,
  0x3F, 0xC0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE3, 0xC7,
  0x8F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x06, 0x07, 0xC0, 0x1F, 0x0F, 0x00,
  0x3F, 0x9E, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x83, 0x81, 0xF7, 0x80, 0x07,
  0xEF, 0x00, 0x1F, 0x9F, 0x00, 0x7E, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x70,
  0x7C, 0x00, 0x40, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x1E,
  0x0F, 0x80, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x18,
  0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xF0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x87, 0xE0, 0xFE, 0x0F,
  0xF7, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0x3E, 0x3F, 0x3F, 0x0E,
  0x1F, 0x86, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0xF0, 0x0E,
  0x01, 0xFC, 0x03, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xC0, 0x7F,
  0x01, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x80, 0x01, 0xF8, 0xC0, 0x07, 0xF8, 0xFC, 0x7F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE3, 0xF0, 0x07,
  0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x10,
  0x00, 0x7F, 0x0E, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x02,
  0x00, 0x3F, 0x3F, 0xC0, 0x3E, 0x7F, 0xF0, 0x7E, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xC3, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFD,
  0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0xFC, 0x07, 0xF3, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF0, 0x7F, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03,
  0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x9F,
  0x80, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xF7, 0xE0, 0xFF, 0xCF, 0x80, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xFC, 0x1F, 0x7F, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x07, 0xC1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x80, 0x80, 0x00, 0x00, 0x78, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0xDF, 0x07, 0xF2, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x3F,
  0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0xE1, 0xF3, 0xE0, 0x7F, 0xFF, 0x07, 0x9F,
  0x07, 0xF0, 0xF8, 0x3C, 0xF0, 0x3E, 0x07, 0x81, 0xEF, 0x83, 0xE0, 0x7C,
  0x0F, 0x7C, 0x3E, 0x03, 0xE0, 0x7B, 0xC1, 0xF0, 0x1F, 0x03, 0xDE, 0x0F,
  0x00, 0xF0, 0x3F, 0xF0, 0xF8, 0x0F, 0x81, 0xFF, 0x87, 0xC0, 0x7C, 0x0F,
  0x7C, 0x3E, 0x03, 0xE0, 0xFB, 0xE1, 0xF0, 0x3E, 0x07, 0xDF, 0x0F, 0x81,
  0xF0, 0x7C, 0xF8, 0x7C, 0x1F, 0x87, 0xE7, 0xC1, 0xFF, 0xFF, 0xFE, 0x1E,
  0x0F, 0xFE, 0xFF, 0xE0, 0xF8, 0x3F, 0xE7, 0xFE, 0x07, 0xC0, 0xFC, 0x1F,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0xFC, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFC, 0x0F, 0x81, 0xFE, 0x00, 0x20, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0x80, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFC, 0x7F, 0xF0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xF0, 0x7E, 0x01, 0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xE0, 0x01,
  0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0xE7, 0xF0, 0x0F, 0xFF, 0x3F, 0x00, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0x8F,
  0xC0, 0x3F, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07,
  0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0x3E, 0x01,
  0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF3, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xEF, 0x00, 0x1F, 0x7C,
  0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x07, 0xEF, 0x00, 0x3E, 0xFC, 0x07, 0xEF,
  0x00, 0x3E, 0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0xF9, 0xF8, 0x0F,
  0xCF, 0x81, 0xF1, 0xF8, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x0F, 0x8F, 0x83,
  0xE3, 0xF0, 0x0F, 0x8F, 0x87, 0xC3, 0xF0, 0x1F, 0x87, 0x87, 0xC3, 0xF0,
  0x1F, 0x87, 0x8F, 0x83, 0xE0, 0x1F, 0x07, 0x8F, 0x83, 0xE0, 0x1F, 0x07,
  0x9F, 0x07, 0xE0, 0x3F, 0x07, 0xDF, 0x07, 0xE0, 0x3F, 0x07, 0xFE, 0x07,
  0xE0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0x3E, 0x07, 0xFC, 0x07, 0xC0, 0x3E,
  0x07, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x0F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x80,
  0x03, 0xF0, 0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x3E, 0x01, 0xFF,
  0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x0F,
  0xFE, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0xFB, 0xE0, 0x0F, 0xC0,
  0x7E, 0xFC, 0x03, 0xF0, 0x1F, 0x3F, 0x00, 0xFC, 0x07, 0xC7, 0xC0, 0x3E,
  0x01, 0xF1, 0xF8, 0x0F, 0x80, 0x7C, 0x7E, 0x07, 0xE0, 0x3F, 0x0F, 0x81,
  0xF8, 0x0F, 0xC3, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x1F, 0x00, 0xF8, 0x1F,
  0x07, 0xC0, 0x3E, 0x07, 0xE3, 0xF0, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE0,
  0x3F, 0x3F, 0x01, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x01, 0xF3, 0xE0, 0x3F,
  0x00, 0x7E, 0xF8, 0x0F, 0xC0, 0x1F, 0xFE, 0x03, 0xF0, 0x03, 0xFF, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x07, 0xFC,
  0x07, 0xE0, 0x01, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xE1, 0xFF, 0x80, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFE, 0x0F, 0xC1, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8,
  0x0F, 0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0x3C,
  0x0F, 0xE0, 0x04, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x80, 0x07, 0xF0, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x80, 0x0F,
  0xDF, 0x00, 0x1F, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0xE0, 0x07, 0xE7, 0xC0,
  0x0F, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xFC,
  0x01, 0xF0, 0xF8, 0x03, 0xFE, 0x01, 0xF8, 0x7C, 0x03, 0xFF, 0x00, 0xFC,
  0x3E, 0x01, 0xFF, 0x80, 0xFC, 0x1F, 0x01, 0xF7, 0xC0, 0x7E, 0x0F, 0x80,
  0xFB, 0xE0, 0x7E, 0x07, 0xC0, 0xF9, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0xF8,
  0x1F, 0x01, 0xF0, 0x7E, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x3E, 0x0F, 0x80,
  0x7C, 0x3F, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x07, 0x87, 0xE0, 0x1F, 0x8F,
  0x83, 0xC7, 0xE0, 0x0F, 0xCF, 0x81, 0xE3, 0xF0, 0x07, 0xE7, 0xC0, 0xF1,
  0xF0, 0x03, 0xF7, 0xC0, 0x79, 0xF8, 0x01, 0xF3, 0xE0, 0x3C, 0xF8, 0x00,
  0xF9, 0xF0, 0x1E, 0x7C, 0x00, 0x7D, 0xF0, 0x0F, 0x7C, 0x00, 0x3E, 0xF8,
  0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xE7,
  0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x3F,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xC1,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xE7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xF1, 0xE0,
  0x01, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3C,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x7E, 0x1F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x00, 0x7E, 0x00, 0x80, 0xFF, 0x87, 0x80,
  0xFF, 0xE7, 0xC0, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x0F, 0xE0, 0xFF, 0x03, 0xFD,
  0xFF, 0x81, 0xFF, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF1, 0xF0, 0x07,
  0xF0, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0xFC, 0xFF, 0x80, 0x7E, 0xFF, 0xE0, 0x3E, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0xCF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3E, 0xFF,
  0xF0, 0x3E, 0x7F, 0xF0, 0x1F, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF0, 0x30,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x08, 0x3F, 0xEF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xFF, 0x8F, 0x80, 0x3F, 0xF9,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x83,
  0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xBE, 0x00,
  0xFF, 0xE7, 0xC0, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFB, 0xFC, 0x7F, 0x03, 0xF1,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0,
  0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x41, 0xFE, 0x0F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xE1, 0xF0, 0x1F, 0xFC, 0xF8, 0x0F, 0xFF, 0xBE, 0x07,
  0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1,
  0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x0F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xF7, 0xE0, 0x1F, 0xF9, 0xF8, 0x01, 0xFC, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x03, 0x00, 0x3F, 0x00, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xE7, 0xFC, 0x07,
  0xEF, 0xFE, 0x07, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0x0F,
  0xF0, 0x3F, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x04, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x8F, 0xF8, 0x1F,
  0xF0, 0x1F, 0x3F, 0xF8, 0xFF, 0xE0, 0x3E, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F,
  0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0x0F, 0xFE, 0x1F, 0x83, 0xFC, 0x0F, 0xF8,
  0x3F, 0x87, 0xF0, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x1F,
  0x80, 0x7F, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x07, 0xC3,
  0xF0, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0xFC, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC1,
  0xF8, 0x03, 0xE3, 0xFE, 0x01, 0xF3, 0xFF, 0x80, 0xFB, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xE1, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC,
  0x3F, 0x87, 0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x0F, 0xFB, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x3E, 0x3F, 0xE0, 0x07, 0xCF, 0xFE, 0x00, 0xFB, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xF3,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFB, 0xFF, 0xC0, 0x3F, 0x3F, 0xF0, 0x07,
  0xE3, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x80, 0xFF, 0xC7, 0x80, 0xFF,
  0xF7, 0xC0, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xE0, 0x3F, 0xF3, 0xF0, 0x07, 0xF1,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x7C, 0x7F, 0x07, 0xCF, 0xF0, 0x7D, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x0F, 0xE0, 0x30, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x8C, 0x00, 0xFC,
  0x78, 0x1F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC4, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xF8,
  0x07, 0xF0, 0xF8, 0x0F, 0xF0, 0xFC, 0x1F, 0xF0, 0xFE, 0x7F, 0xF0, 0xFF,
  0xFB, 0xE0, 0xFF, 0xF3, 0xE0, 0x7F, 0xE3, 0xE0, 0x3F, 0xC3, 0xE0, 0xFC,
  0x00, 0x7F, 0x7C, 0x00, 0xFE, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0xFE, 0x01, 0xFB, 0xE0,
  0x1F, 0xC0, 0x3F, 0x7C, 0x07, 0xF8, 0x0F, 0xCF, 0x80, 0xFF, 0x01, 0xF9,
  0xF0, 0x3F, 0xE0, 0x7E, 0x3E, 0x07, 0xBE, 0x0F, 0xC7, 0xC1, 0xF7, 0xC3,
  0xF0, 0xF8, 0x3E, 0xF8, 0x7E, 0x1F, 0x87, 0x9F, 0x0F, 0x83, 0xF1, 0xF3,
  0xE3, 0xF0, 0x7E, 0x3C, 0x7C, 0x7C, 0x0F, 0xCF, 0x8F, 0x9F, 0x81, 0xF9,
  0xF1, 0xF3, 0xF0, 0x3F, 0x7C, 0x3E, 0x7C, 0x07, 0xEF, 0x87, 0xDF, 0x80,
  0x79, 0xE0, 0xFB, 0xE0, 0x0F, 0x7C, 0x1F, 0xFC, 0x01, 0xEF, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x01,
  0xF8, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xFC,
  0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFE, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x05,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00,
  0xFF, 0xE8, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 35, 13, 1, -34 },
  { 58, 16, 13, 20, 5, -34 },
  { 84, 30, 34, 30, 1, -34 },
  { 212, 24, 39, 26, 1, -36 },
  { 329, 34, 34, 39, 3, -34 },
  { 474, 30, 34, 33, 2, -34 },
  { 602, 7, 13, 11, 5, -34 },
  { 614, 17, 41, 15, 2, -34 },
  { 702, 16, 41, 15, -3, -34 },
  { 784, 23, 22, 26, 4, -36 },
  { 848, 22, 23, 27, 3, -28 },
  { 912, 10, 11, 13, -2, -5 },
  { 926, 13, 5, 15, 1, -15 },
  { 935, 7, 8, 13, 1, -7 },
  { 942, 24, 34, 19, -2, -34 },
  { 1044, 23, 34, 26, 2, -34 },
  { 1142, 17, 34, 26, 5, -34 },
  { 1215, 26, 34, 26, -1, -34 },
  { 1326, 24, 34, 26, 1, -34 },
  { 1428, 25, 34, 26, 0, -34 },
  { 1535, 25, 34, 26, 1, -34 },
  { 1642, 24, 34, 26, 2, -34 },
  { 1744, 24, 34, 26, 3, -34 },
  { 1846, 24, 34, 26, 2, -34 },
  { 1948, 23, 34, 26, 2, -34 },
  { 2046, 11, 27, 13, 1, -26 },
  { 2084, 14, 32, 13, -2, -26 },
  { 2140, 22, 24, 27, 3, -29 },
  { 2206, 22, 13, 27, 3, -23 },
  { 2242, 22, 24, 27, 3, -29 },
  { 2308, 18, 35, 21, 4, -34 },
  { 2387, 37, 38, 40, 2, -34 },
  { 2563, 29, 34, 28, -3, -34 },
  { 2687, 27, 34, 29, 1, -34 },
  { 2802, 27, 34, 28, 3, -34 },
  { 2917, 29, 34, 32, 1, -34 },
  { 3041, 26, 34, 25, 1, -34 },
  { 3152, 26, 34, 24, 1, -34 },
  { 3263, 29, 34, 32, 3, -34 },
  { 3387, 32, 34, 33, 1, -34 },
  { 3523, 21, 34, 17, -1, -34 },
  { 3613, 22, 44, 15, -7, -34 },
  { 3734, 31, 34, 28, 1, -34 },
  { 3866, 20, 34, 24, 1, -34 },
  { 3951, 40, 34, 41, 1, -34 },
  { 4121, 34, 34, 35, 1, -34 },
  { 4266, 30, 34, 34, 3, -34 },
  { 4394, 27, 34, 28, 1, -34 },
  { 4509, 30, 42, 34, 3, -34 },
  { 4667, 27, 34, 28, 1, -34 },
  { 4782, 24, 34, 24, 1, -34 },
  { 4884, 24, 34, 24, 4, -34 },
  { 4986, 30, 34, 32, 3, -34 },
  { 5114, 27, 34, 27, 4, -34 },
  { 5229, 41, 34, 41, 5, -34 },
  { 5404, 34, 34, 27, -3, -34 },
  { 5549, 26, 34, 26, 4, -34 },
  { 5660, 28, 34, 25, -1, -34 },
  { 5779, 19, 41, 15, -1, -34 },
  { 5877, 10, 34, 19, 5, -34 },
  { 5920, 19, 41, 15, -3, -34 },
  { 6018, 24, 22, 26, 1, -34 },
  { 6084, 19, 3, 19, -4, 4 },
  { 6092, 9, 8, 14, 7, -36 },
  { 6101, 25, 26, 27, 2, -26 },
  { 6183, 25, 36, 28, 1, -36 },
  { 6296, 21, 26, 22, 2, -26 },
  { 6365, 27, 36, 28, 2, -36 },
  { 6487, 22, 26, 25, 2, -26 },
  { 6559, 27, 47, 17, -5, -36 },
  { 6718, 26, 37, 28, 1, -26 },
  { 6839, 24, 36, 28, 1, -36 },
  { 6947, 13, 35, 13, 1, -35 },
  { 7004, 20, 46, 13, -6, -35 },
  { 7119, 26, 36, 25, 1, -36 },
  { 7236, 14, 36, 13, 1, -36 },
  { 7299, 39, 26, 42, 1, -26 },
  { 7426, 25, 26, 28, 1, -26 },
  { 7508, 23, 26, 27, 2, -26 },
  { 7583, 27, 37, 28, -1, -26 },
  { 7708, 25, 37, 28, 2, -26 },
  { 7824, 20, 26, 19, 1, -26 },
  { 7889, 21, 26, 22, 0, -26 },
  { 7958, 17, 31, 18, 2, -31 },
  { 8024, 24, 25, 28, 3, -25 },
  { 8099, 24, 25, 23, 2, -25 },
  { 8174, 35, 25, 36, 3, -25 },
  { 8284, 28, 25, 24, -2, -25 },
  { 8372, 30, 36, 23, -4, -25 },
  { 8507, 23, 25, 22, -1, -25 },
  { 8579, 19, 41, 17, 0, -34 },
  { 8677, 5, 47, 26, 11, -36 },
  { 8707, 19, 41, 17, -2, -34 },
  { 8805, 22, 7, 27, 3, -20 },
};

const GFXfont NotoSans_SemiBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMIBOLDITALIC47PT7B_H_
