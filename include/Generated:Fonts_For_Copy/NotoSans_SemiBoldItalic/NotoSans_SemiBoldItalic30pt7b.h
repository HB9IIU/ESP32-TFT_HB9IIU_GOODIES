#ifndef _NOTOSANS_SEMIBOLDITALIC30PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x1F, 0x07,
  0x80, 0x79, 0xDC, 0xF7, 0x3D, 0xCE, 0xE3, 0xB8, 0xEE, 0x30, 0x01, 0xC3,
  0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x1C,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x70,
  0x07, 0x1C, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xE3, 0x80,
  0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F,
  0x31, 0x1E, 0x60, 0x3C, 0xC0, 0x7B, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0xDF, 0x01, 0x9E, 0x03, 0x3D, 0x06, 0x73, 0xDF, 0xE7,
  0xFF, 0x8F, 0xFE, 0x03, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x7E, 0x01, 0xC3, 0xFC, 0x0E, 0x1E, 0x70, 0x70, 0x71, 0xC3,
  0x83, 0xC7, 0x0E, 0x0E, 0x1C, 0x70, 0x38, 0xF3, 0x80, 0xE3, 0x9C, 0x03,
  0x8E, 0x77, 0xCE, 0x7B, 0xBF, 0xBF, 0xDD, 0xFF, 0x7E, 0xF7, 0x1C, 0x63,
  0x9C, 0x70, 0x1C, 0xE1, 0xC0, 0xE3, 0x87, 0x07, 0x8E, 0x38, 0x1C, 0x38,
  0xE0, 0xE0, 0xE3, 0x87, 0x03, 0xFC, 0x3C, 0x0F, 0xF1, 0xE0, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xCF, 0x00, 0xF0, 0xE0,
  0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x07, 0x7C, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0xF3, 0xFE, 0x1E, 0xF1, 0xE7, 0xBC, 0x3C, 0xF7,
  0x83, 0xFC, 0xF0, 0x3F, 0x1E, 0x07, 0xC3, 0xE1, 0xF8, 0x3F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0x8F, 0x80, 0x7B, 0x9C, 0xEE, 0x73, 0x80, 0x01, 0xE0,
  0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0x81, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x38, 0x10, 0xE0, 0xF3, 0x83, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0x0F, 0x9C,
  0x7E, 0x07, 0x9C, 0x1E, 0x70, 0x31, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x3C, 0xF7, 0x9C, 0x73, 0x8E, 0x00, 0xFF, 0xFF, 0xFE, 0xFE, 0x7B, 0xFE,
  0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFD, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x7D, 0xE0, 0xF1, 0xE3, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x7F, 0x9F, 0xEF, 0xFC, 0xE7, 0x88, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xBF, 0x0C, 0x0F, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x0F, 0xBF, 0x04, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0xC0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x01, 0xFE, 0x03, 0xDE,
  0x07, 0x9C, 0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x78, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x79,
  0x01, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xFC,
  0x1F, 0xF0, 0x7E, 0x21, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x71,
  0xC1, 0xEF, 0xE3, 0xFF, 0xE7, 0xE7, 0xCF, 0x07, 0x9E, 0x07, 0x38, 0x0E,
  0x70, 0x3C, 0xE0, 0x79, 0xC0, 0xF3, 0xC3, 0xC7, 0xFF, 0x07, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8,
  0xF8, 0xF1, 0xE0, 0xE3, 0xC1, 0xC7, 0x83, 0x8F, 0x0F, 0x1F, 0x3C, 0x1F,
  0xF0, 0x1F, 0x80, 0xFF, 0x83, 0xEF, 0x8F, 0x0F, 0x3C, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xFF, 0xC7, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0xFB, 0xE3, 0xC1, 0xE7, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xE0, 0xF9, 0xFF, 0xE3, 0xFD,
  0xC3, 0xF7, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC7,
  0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x06, 0x1F, 0x1F, 0x1E, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x78, 0xF8, 0x70, 0x01,
  0x81, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3C, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x03, 0xE0, 0x0E, 0x00,
  0x20, 0x00, 0x07, 0x03, 0xFE, 0x7F, 0xF7, 0xDF, 0x20, 0xF0, 0x07, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x1E, 0x0E,
  0x00, 0x0E, 0x1C, 0x06, 0x07, 0x38, 0x3F, 0xC7, 0x38, 0x7F, 0xC7, 0x70,
  0xE1, 0xC7, 0x71, 0xC1, 0x87, 0x71, 0xC3, 0x87, 0x63, 0x83, 0x87, 0xE3,
  0x83, 0x87, 0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x1E, 0x73, 0xDF, 0xBC, 0x71,
  0xFB, 0xF8, 0x70, 0xF1, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3D,
  0xE0, 0x0F, 0x78, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0xF0, 0xE0, 0x3C, 0x38,
  0x1E, 0x0E, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x78, 0x0F, 0x1E,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x07, 0xF8, 0x01, 0xC0, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x1E, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0x8F,
  0xC3, 0xC1, 0xE1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x38,
  0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x01, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xF0, 0x11, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x02,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x38, 0x3E, 0x1E, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xCE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x3F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x00, 0x8F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x07, 0xFB, 0xC1, 0xFE, 0xF0, 0x7F,
  0xBC, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x03, 0xC7,
  0xC0, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xC1, 0xE0, 0x3C, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xC0, 0x38, 0x3C, 0x07, 0x83, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xF8, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0,
  0xFF, 0x81, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0x03, 0xF0, 0xF0, 0x7C, 0x0F,
  0x0F, 0x80, 0xE0, 0xF0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01,
  0xEF, 0x00, 0x1D, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0x70, 0xFE,
  0x03, 0xF8, 0x77, 0x03, 0xBC, 0x3B, 0x81, 0xDC, 0x1D, 0xC1, 0xCE, 0x1E,
  0xE1, 0xEF, 0x0F, 0x70, 0xE7, 0x87, 0x1C, 0xF3, 0xC3, 0x8E, 0x71, 0xC1,
  0xC7, 0x78, 0xE1, 0xE3, 0xB8, 0xF0, 0xF1, 0xFC, 0x78, 0x70, 0xFC, 0x3C,
  0x38, 0x7E, 0x1C, 0x3C, 0x3E, 0x0E, 0x1E, 0x1F, 0x0F, 0x0E, 0x0F, 0x07,
  0x80, 0x0F, 0x80, 0x38, 0x7C, 0x03, 0xC3, 0xF0, 0x1E, 0x1F, 0x80, 0xF1,
  0xFC, 0x07, 0x0F, 0xF0, 0x38, 0x73, 0x83, 0xC3, 0x9C, 0x1E, 0x1C, 0xF0,
  0xE1, 0xE3, 0x87, 0x0F, 0x1E, 0x78, 0x70, 0xF3, 0xC3, 0x83, 0x9E, 0x1C,
  0x1E, 0xE1, 0xE0, 0xF7, 0x0F, 0x03, 0xB8, 0x70, 0x1F, 0xC3, 0x80, 0xFE,
  0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0x8F,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3E, 0xF0,
  0x07, 0x9F, 0x01, 0xF1, 0xF0, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xC1, 0xF1, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x0F, 0x1E, 0x1F, 0x8F,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C,
  0x07, 0x8F, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x3E, 0xF0, 0x07, 0x9F, 0x01, 0xF1, 0xF0, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xE1,
  0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1C, 0x1F, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xC7, 0x81, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x01,
  0xE0, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xE0, 0x47, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE3, 0x07,
  0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0xF0, 0xF0, 0x1E, 0x1F, 0x07, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE,
  0x00, 0xE0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xC7,
  0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x78, 0x1C, 0x38,
  0x0E, 0x3C, 0x07, 0x1C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x03, 0xFC, 0x0F, 0x81, 0xEF, 0x03, 0xE0, 0x7B, 0xC1, 0xF8, 0x1C, 0xF0,
  0x7E, 0x0F, 0x3C, 0x1F, 0x83, 0xCF, 0x0E, 0xE1, 0xE3, 0xC3, 0xB8, 0x78,
  0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x0F, 0x3C, 0xE3, 0x83, 0xCE, 0x39,
  0xE0, 0xF7, 0x8E, 0x70, 0x3D, 0xC3, 0xBC, 0x0F, 0x70, 0xEE, 0x03, 0xF8,
  0x3B, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01,
  0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x03,
  0xC0, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0,
  0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x78, 0x1F,
  0x01, 0xE0, 0xF8, 0x07, 0xC0, 0xF0, 0x1F, 0xF0, 0x1E, 0x70, 0x3C, 0x70,
  0x78, 0x78, 0x78, 0x78, 0xF0, 0x39, 0xE0, 0x39, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x7E, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1,
  0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xEE,
  0x03, 0x9C, 0x07, 0x38, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0x63, 0x80, 0xE7,
  0x01, 0xDC, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0x87, 0x1C,
  0x01, 0x00, 0x07, 0xE7, 0x0F, 0xFF, 0x1F, 0xFE, 0x3E, 0x3E, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0x78, 0xF8, 0x7F, 0xF8, 0x7F, 0xB8, 0x3F, 0x38, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x8C, 0x0F,
  0x7E, 0x1D, 0xFC, 0x3F, 0xFC, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xE0, 0xF7, 0xC3, 0xCF,
  0xFF, 0x9D, 0xFE, 0x39, 0xF8, 0x00, 0x00, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F,
  0xF3, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x11, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x04,
  0x3C, 0x0F, 0xDE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x8F, 0x87, 0x83, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x1F, 0x0F, 0x1F, 0x07, 0xFF, 0x83, 0xFD, 0xC0, 0xFC, 0xE0, 0x00,
  0x40, 0x1F, 0xE0, 0xFF, 0xC7, 0xCF, 0x3C, 0x1C, 0xF0, 0xF7, 0x83, 0xDE,
  0x7E, 0x7F, 0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x47,
  0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x07,
  0xE7, 0x1F, 0xFF, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x78,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3E, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x81, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x84, 0x0F, 0x7E,
  0x1D, 0xFE, 0x3F, 0xFC, 0xFC, 0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x1C, 0xF0, 0x79, 0xC0, 0xF7, 0x81, 0xEF, 0x03,
  0x9E, 0x0F, 0x3C, 0x1E, 0x00, 0x02, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70,
  0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0x10, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x1F, 0x1C, 0x3E, 0x3C,
  0x7C, 0x3C, 0x78, 0x3C, 0xF0, 0x3D, 0xE0, 0x3B, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7D, 0xE0, 0x79, 0xE0, 0x71, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x78, 0xF0, 0x7C, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0x00, 0x10, 0x18, 0x1C, 0xFC, 0x7E, 0x1D, 0xFC, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3E, 0x1F, 0x8F, 0x3E, 0x1F, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C,
  0x1E, 0x0F, 0x78, 0x1E, 0x0F, 0x78, 0x3C, 0x0E, 0x78, 0x3C, 0x0E, 0x78,
  0x3C, 0x1E, 0x70, 0x3C, 0x1E, 0xF0, 0x38, 0x1E, 0xF0, 0x78, 0x1C, 0xF0,
  0x78, 0x3C, 0xF0, 0x78, 0x3C, 0x00, 0x10, 0x39, 0xF8, 0x77, 0xF9, 0xFF,
  0xF3, 0xF1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x3D,
  0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xF0,
  0x78, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xC1, 0xEF, 0x83,
  0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81, 0xEF,
  0x03, 0xCF, 0x0F, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x0C, 0x03,
  0x9F, 0x81, 0xDF, 0xC0, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0,
  0xF1, 0xF0, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x39, 0xF8, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x01, 0x00, 0x07, 0xE7, 0x0F, 0xFF, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0x78, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3E, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x11, 0xCF, 0x1D, 0xF1, 0xFF, 0x3F, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x7F, 0xC7, 0xFE, 0x7C, 0xE3, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x40,
  0xFB, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x07,
  0xFE, 0xFF, 0xFF, 0xF9, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xE1, 0xFC, 0x1F, 0x80, 0x3C, 0x1E,
  0x70, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xE7, 0x07, 0xCF, 0x1F, 0x1F, 0xFE,
  0x3F, 0xDC, 0x3F, 0x38, 0xF0, 0x1E, 0xE0, 0x3D, 0xC0, 0xF3, 0x81, 0xC7,
  0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x39, 0xE0, 0x77, 0x80, 0xEF,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xE0, 0xF8,
  0x3F, 0x83, 0xE0, 0xEE, 0x0F, 0x87, 0xB8, 0x7E, 0x1E, 0xE1, 0xF8, 0xF3,
  0x8E, 0xE3, 0xCE, 0x3B, 0x9E, 0x39, 0xCE, 0x78, 0xE7, 0x39, 0xC3, 0x9C,
  0xEF, 0x0E, 0xE3, 0xB8, 0x3B, 0x8F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC3, 0xC3, 0xC0, 0xF1,
  0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x0F,
  0x0E, 0x07, 0x83, 0xC3, 0xC0, 0xF8, 0x1E, 0x03, 0xE1, 0xC0, 0x78, 0x38,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x38,
  0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0xF0, 0x1F, 0x03, 0xF0,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x07,
  0xE0, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3F, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x0C,
  0x00, 0x3C, 0x07, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0x80, 0x70,
};

const GFXglyph NotoSans_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 10, 7, 13, 3, -21 },
  { 34, 19, 21, 19, 1, -21 },
  { 84, 15, 25, 17, 1, -23 },
  { 131, 22, 22, 25, 2, -22 },
  { 192, 19, 22, 21, 1, -22 },
  { 245, 5, 7, 7, 3, -21 },
  { 250, 11, 26, 10, 1, -21 },
  { 286, 10, 27, 10, -2, -22 },
  { 320, 14, 14, 16, 3, -23 },
  { 345, 14, 15, 17, 2, -18 },
  { 372, 6, 7, 8, -1, -3 },
  { 378, 8, 4, 10, 1, -10 },
  { 382, 5, 4, 8, 0, -4 },
  { 385, 15, 22, 12, -1, -22 },
  { 427, 15, 22, 17, 1, -22 },
  { 469, 11, 21, 17, 3, -21 },
  { 498, 16, 22, 17, 0, -22 },
  { 542, 16, 22, 17, 0, -22 },
  { 586, 16, 21, 17, 0, -21 },
  { 628, 15, 21, 17, 1, -21 },
  { 668, 15, 22, 17, 2, -22 },
  { 710, 15, 21, 17, 2, -21 },
  { 750, 15, 22, 17, 1, -22 },
  { 792, 15, 22, 17, 1, -22 },
  { 834, 8, 17, 8, 0, -17 },
  { 851, 10, 21, 8, -2, -17 },
  { 878, 14, 16, 17, 2, -19 },
  { 906, 14, 9, 17, 2, -15 },
  { 922, 14, 16, 17, 2, -19 },
  { 950, 12, 22, 13, 2, -22 },
  { 983, 24, 24, 26, 1, -21 },
  { 1055, 18, 21, 18, -2, -21 },
  { 1103, 17, 21, 18, 1, -21 },
  { 1148, 17, 22, 18, 2, -22 },
  { 1195, 18, 21, 20, 1, -21 },
  { 1243, 16, 21, 16, 1, -21 },
  { 1285, 16, 21, 15, 1, -21 },
  { 1327, 18, 22, 21, 2, -22 },
  { 1377, 20, 21, 21, 1, -21 },
  { 1430, 14, 21, 11, -1, -21 },
  { 1467, 15, 27, 9, -5, -21 },
  { 1518, 20, 21, 18, 1, -21 },
  { 1571, 12, 21, 15, 1, -21 },
  { 1603, 25, 21, 26, 1, -21 },
  { 1669, 21, 21, 22, 1, -21 },
  { 1725, 19, 22, 22, 2, -22 },
  { 1778, 17, 21, 18, 1, -21 },
  { 1823, 19, 27, 22, 2, -22 },
  { 1888, 17, 21, 18, 1, -21 },
  { 1933, 15, 22, 16, 1, -22 },
  { 1975, 15, 21, 16, 3, -21 },
  { 2015, 19, 21, 21, 2, -21 },
  { 2065, 17, 21, 17, 3, -21 },
  { 2110, 26, 21, 26, 3, -21 },
  { 2179, 22, 21, 17, -2, -21 },
  { 2237, 16, 21, 16, 3, -21 },
  { 2279, 18, 21, 16, -1, -21 },
  { 2327, 12, 26, 9, 0, -21 },
  { 2366, 7, 22, 12, 3, -22 },
  { 2386, 12, 26, 9, -2, -21 },
  { 2425, 15, 14, 17, 1, -22 },
  { 2452, 13, 2, 12, -3, 3 },
  { 2456, 6, 5, 9, 4, -23 },
  { 2460, 16, 17, 17, 1, -17 },
  { 2494, 15, 23, 18, 1, -23 },
  { 2538, 13, 17, 14, 1, -17 },
  { 2566, 17, 23, 18, 1, -23 },
  { 2615, 14, 17, 16, 1, -17 },
  { 2645, 17, 30, 11, -3, -23 },
  { 2709, 16, 24, 18, 1, -17 },
  { 2757, 15, 23, 18, 1, -23 },
  { 2801, 8, 23, 8, 1, -23 },
  { 2824, 13, 30, 8, -4, -23 },
  { 2873, 16, 23, 16, 1, -23 },
  { 2919, 8, 23, 8, 1, -23 },
  { 2942, 24, 17, 27, 1, -17 },
  { 2993, 15, 17, 18, 1, -17 },
  { 3025, 15, 17, 17, 1, -17 },
  { 3057, 17, 24, 18, -1, -17 },
  { 3108, 16, 24, 18, 1, -17 },
  { 3156, 12, 17, 12, 1, -17 },
  { 3182, 13, 17, 14, 0, -17 },
  { 3210, 11, 20, 11, 1, -20 },
  { 3238, 15, 16, 18, 2, -16 },
  { 3268, 15, 16, 15, 1, -16 },
  { 3298, 22, 16, 23, 2, -16 },
  { 3342, 18, 16, 15, -1, -16 },
  { 3378, 19, 23, 15, -2, -16 },
  { 3433, 15, 16, 14, -1, -16 },
  { 3463, 12, 26, 11, 0, -21 },
  { 3502, 3, 30, 17, 7, -23 },
  { 3514, 12, 26, 11, -1, -21 },
  { 3553, 14, 5, 17, 2, -13 },
};

const GFXfont NotoSans_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMIBOLDITALIC30PT7B_H_
