#ifndef _NOTOSANS_SEMIBOLDITALIC9PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xB4, 0x29, 0xF2, 0xBE, 0x51, 0x40, 0x13, 0xD8,
  0xC3, 0x59, 0x88, 0x46, 0xAB, 0x37, 0xB5, 0x59, 0xC0, 0x10, 0xA2, 0x8C,
  0x56, 0x67, 0xC0, 0xC0, 0x34, 0x48, 0x88, 0x40, 0x22, 0x11, 0x22, 0x2C,
  0x2A, 0x7A, 0x4F, 0x44, 0xE0, 0xE0, 0xC0, 0x12, 0x24, 0xC8, 0x13, 0xD2,
  0x9D, 0xE9, 0xC0, 0x75, 0xA4, 0x80, 0x13, 0xC2, 0x22, 0x23, 0xC0, 0x32,
  0xC2, 0x65, 0x0B, 0xC0, 0x19, 0x95, 0x2F, 0x98, 0x7A, 0x1C, 0x21, 0x78,
  0x19, 0x50, 0xED, 0xE9, 0xC0, 0x78, 0x84, 0x46, 0x60, 0x13, 0x52, 0x65,
  0x49, 0xC0, 0x22, 0xD2, 0xB7, 0x0B, 0x80, 0x40, 0xC0, 0x40, 0xE0, 0x13,
  0xCC, 0x30, 0xFF, 0x8C, 0x36, 0x80, 0x54, 0xA8, 0x20, 0x3E, 0x5E, 0x65,
  0xAA, 0xB6, 0x40, 0x3C, 0x18, 0x62, 0x4F, 0x47, 0x10, 0x7A, 0x5C, 0x94,
  0xF8, 0x13, 0xE1, 0x08, 0x43, 0xC0, 0x79, 0x14, 0x53, 0x4B, 0xC0, 0x7A,
  0x1C, 0x84, 0x78, 0x7A, 0x1C, 0x84, 0x60, 0x13, 0x61, 0x79, 0xCB, 0xC0,
  0x65, 0x17, 0xD2, 0x4B, 0x20, 0x76, 0x44, 0x4E, 0x12, 0x22, 0x26, 0x4C,
  0x6D, 0x47, 0x14, 0x53, 0x60, 0x64, 0x44, 0x4F, 0x63, 0x66, 0x66, 0x5A,
  0x5A, 0x96, 0x66, 0xA9, 0x52, 0xA4, 0xD1, 0x00, 0x22, 0xE3, 0x18, 0xCF,
  0xC0, 0x7A, 0x52, 0xE4, 0x60, 0x23, 0xE3, 0x18, 0xCF, 0xC6, 0x10, 0x7A,
  0x56, 0xE5, 0x6C, 0x13, 0x50, 0xC1, 0x0B, 0xC0, 0xF4, 0x44, 0x48, 0xCC,
  0x67, 0x29, 0x78, 0x9C, 0xA9, 0x4C, 0x60, 0x93, 0xB2, 0xB4, 0xD4, 0xD4,
  0xC8, 0x26, 0x30, 0x61, 0xC2, 0x99, 0x80, 0x9D, 0x18, 0x84, 0x60, 0x78,
  0x88, 0xC4, 0x78, 0x69, 0x29, 0x30, 0xA9, 0x50, 0x31, 0x22, 0x22, 0xE0,
  0x32, 0x95, 0x10, 0xF0, 0xD0, 0x3A, 0x73, 0xA7, 0x00, 0x22, 0x1E, 0x94,
  0xAF, 0xC0, 0x34, 0xCC, 0x70, 0x0C, 0x23, 0x92, 0xCB, 0x47, 0x00, 0x32,
  0xFD, 0x87, 0x00, 0x18, 0x9E, 0x42, 0x11, 0x88, 0xC0, 0x3A, 0x73, 0xA7,
  0x0B, 0x80, 0x22, 0x1E, 0x94, 0xAA, 0x40, 0x61, 0x24, 0xA0, 0x30, 0x22,
  0x22, 0x44, 0xC0, 0x22, 0x12, 0xA6, 0x3A, 0x40, 0x29, 0x24, 0xA0, 0x7E,
  0x4B, 0x4A, 0x52, 0x92, 0x7A, 0x52, 0xB9, 0x00, 0x32, 0x73, 0xB7, 0x00,
  0x7A, 0x52, 0xBB, 0x42, 0x00, 0x3A, 0x73, 0xA7, 0x08, 0xC0, 0x74, 0x44,
  0x80, 0x74, 0x63, 0xE0, 0x2F, 0x44, 0x46, 0x4A, 0x53, 0xA7, 0x00, 0xCA,
  0x94, 0xC6, 0x00, 0xA6, 0xDD, 0xB6, 0x90, 0x5A, 0x88, 0xC9, 0x00, 0x64,
  0xA2, 0x8C, 0x30, 0x8C, 0x00, 0x73, 0x64, 0xE0, 0x32, 0x48, 0x44, 0x40,
  0xFF, 0x80, 0x69, 0x14, 0xA0, 0xDA,
};

const GFXglyph NotoSans_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 3, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 6, 6, 6, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 7, 8, 1, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 2, 2, 1, -6 },
  { 28, 4, 7, 3, 0, -6 },
  { 32, 4, 8, 3, -1, -7 },
  { 36, 4, 4, 5, 1, -7 },
  { 38, 4, 4, 5, 1, -5 },
  { 40, 2, 2, 2, 0, -1 },
  { 41, 3, 1, 3, 0, -3 },
  { 42, 2, 1, 2, 0, -1 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 5, 6, 5, 0, -6 },
  { 72, 5, 7, 5, 0, -7 },
  { 77, 5, 6, 5, 0, -6 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 2, 5, 2, 0, -5 },
  { 93, 2, 6, 2, 0, -5 },
  { 95, 4, 5, 5, 1, -6 },
  { 98, 4, 2, 5, 1, -4 },
  { 99, 4, 5, 5, 1, -6 },
  { 102, 3, 7, 4, 1, -7 },
  { 105, 8, 7, 8, 0, -6 },
  { 112, 6, 6, 5, -1, -6 },
  { 117, 5, 6, 6, 0, -6 },
  { 121, 5, 7, 5, 1, -7 },
  { 126, 6, 6, 6, 0, -6 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 5, 7, 6, 1, -7 },
  { 144, 6, 6, 6, 0, -6 },
  { 149, 4, 6, 3, 0, -6 },
  { 152, 4, 8, 3, -1, -6 },
  { 156, 6, 6, 5, 0, -6 },
  { 161, 4, 6, 5, 0, -6 },
  { 164, 8, 6, 8, 0, -6 },
  { 170, 7, 6, 7, 0, -6 },
  { 176, 5, 7, 7, 1, -7 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 5, 9, 7, 1, -7 },
  { 191, 5, 6, 5, 0, -6 },
  { 195, 5, 7, 5, 0, -7 },
  { 200, 4, 6, 5, 1, -6 },
  { 203, 5, 6, 6, 1, -6 },
  { 207, 5, 6, 5, 1, -6 },
  { 211, 8, 6, 8, 1, -6 },
  { 217, 7, 6, 5, -1, -6 },
  { 223, 5, 6, 5, 1, -6 },
  { 227, 5, 6, 5, 0, -6 },
  { 231, 3, 7, 3, 0, -6 },
  { 234, 2, 6, 4, 1, -6 },
  { 236, 4, 7, 3, -1, -6 },
  { 240, 5, 4, 5, 0, -6 },
  { 243, 4, 1, 4, -1, 1 },
  { 244, 2, 2, 3, 1, -7 },
  { 245, 5, 5, 5, 0, -5 },
  { 249, 5, 7, 5, 0, -7 },
  { 254, 4, 5, 4, 0, -5 },
  { 257, 6, 7, 5, 0, -7 },
  { 263, 5, 5, 5, 0, -5 },
  { 267, 5, 9, 3, -1, -7 },
  { 273, 5, 7, 5, 0, -5 },
  { 278, 5, 7, 5, 0, -7 },
  { 283, 3, 7, 3, 0, -7 },
  { 286, 4, 9, 3, -1, -7 },
  { 291, 5, 7, 5, 0, -7 },
  { 296, 3, 7, 3, 0, -7 },
  { 299, 8, 5, 8, 0, -5 },
  { 304, 5, 5, 5, 0, -5 },
  { 308, 5, 5, 5, 0, -5 },
  { 312, 5, 7, 5, 0, -5 },
  { 317, 5, 7, 5, 0, -5 },
  { 322, 4, 5, 4, 0, -5 },
  { 325, 4, 5, 4, 0, -5 },
  { 328, 4, 6, 3, 0, -6 },
  { 331, 5, 5, 5, 0, -5 },
  { 335, 5, 5, 4, 0, -5 },
  { 339, 6, 5, 7, 1, -5 },
  { 343, 5, 5, 5, 0, -5 },
  { 347, 6, 7, 4, -1, -5 },
  { 353, 4, 5, 4, 0, -5 },
  { 356, 4, 7, 3, 0, -6 },
  { 360, 1, 9, 5, 2, -7 },
  { 362, 3, 7, 3, 0, -6 },
  { 365, 4, 2, 5, 1, -4 },
};

const GFXfont NotoSans_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMIBOLDITALIC9PT7B_H_
