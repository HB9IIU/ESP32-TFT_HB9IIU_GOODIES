#ifndef _NOTOSANS_SEMIBOLDITALIC38PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x80, 0x80,
  0x7C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0F, 0x78, 0x73, 0xC7, 0x9E,
  0x3C, 0xE1, 0xC7, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xE0, 0xE0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x03,
  0x83, 0x80, 0x03, 0x87, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0x80,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0xC6, 0x1F, 0x38, 0x03,
  0xE7, 0x00, 0x7C, 0xE0, 0x0F, 0x98, 0x01, 0xFB, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xBE, 0x00,
  0x73, 0xE0, 0x0C, 0x7C, 0x01, 0x8F, 0x30, 0x73, 0xE7, 0xEF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x3C, 0x1F,
  0xF0, 0x07, 0x81, 0xFF, 0x80, 0x70, 0x3C, 0x78, 0x0F, 0x03, 0xC7, 0x81,
  0xE0, 0x78, 0x78, 0x3C, 0x07, 0x87, 0x83, 0x80, 0x78, 0x78, 0x78, 0x07,
  0x87, 0x8F, 0x00, 0xF0, 0xF1, 0xE0, 0x0F, 0x0F, 0x1C, 0x30, 0xF0, 0xF3,
  0xCF, 0xE7, 0x9E, 0x7B, 0xFE, 0x7F, 0xEF, 0x3F, 0xF7, 0xFC, 0xE7, 0x8F,
  0x3F, 0x9E, 0x78, 0xF0, 0x43, 0xCF, 0x0F, 0x00, 0x78, 0xF0, 0xF0, 0x07,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0xF0, 0x1E, 0x0F, 0x0F, 0x03, 0xC0, 0xF1,
  0xE0, 0x3C, 0x0F, 0x1E, 0x07, 0x80, 0xF3, 0xC0, 0xF0, 0x0F, 0xFC, 0x1E,
  0x00, 0x7F, 0x83, 0xE0, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xE1,
  0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3E, 0x3F, 0xF8, 0x3E, 0x3F, 0x7E, 0x1F, 0x3F,
  0x1F, 0x1F, 0x1F, 0x07, 0xCF, 0x9F, 0x03, 0xFF, 0x8F, 0x80, 0xFF, 0x87,
  0xC0, 0x3F, 0x83, 0xE0, 0x0F, 0x81, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0x0F, 0xC0, 0x7D, 0xE7,
  0x9E, 0x73, 0xCF, 0x3C, 0xE3, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x20,
  0x70, 0x1E, 0x3C, 0x07, 0xEE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0x7C, 0x3F, 0xC0, 0x1F, 0x78, 0x0F, 0x9E, 0x03, 0xE3, 0xC0,
  0x70, 0xF0, 0x08, 0x3E, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3D, 0xFF, 0xFF, 0x7C, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x80,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xDF, 0xC7, 0xE1, 0xF3, 0xF0, 0x7C, 0xF8,
  0x0F, 0x7E, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xEF,
  0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x1F, 0xBC, 0x07, 0xCF, 0x83, 0xF3, 0xE1,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7C,
  0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0xEF, 0x1E, 0x3C,
  0x31, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xE0, 0x7C, 0x04, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xEF,
  0xF0, 0x30, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCC, 0x00, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x00, 0xFB, 0xC0, 0x1F, 0x3C, 0x03,
  0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0xC0, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xCC, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x7F, 0x07, 0xBF, 0xF0, 0xFF, 0xFF, 0x3F,
  0xCF, 0xE7, 0xF0, 0x7C, 0xFC, 0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xE1, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0x7E, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0x1F, 0x87,
  0xE0, 0xF8, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xC7, 0xC0, 0xF8, 0x7F, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0x9F, 0x8F, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDE,
  0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x0F, 0xDF, 0x07, 0xF7, 0xF7,
  0xFC, 0xFF, 0xFE, 0x3F, 0xF7, 0x83, 0xF3, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x1F, 0x0F, 0xC3, 0xF0, 0x7C, 0x08, 0x00, 0x01, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xE3,
  0xFF, 0xF3, 0xFF, 0xE7, 0xEF, 0xE4, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0xFC, 0x1E, 0x3C, 0x0F, 0xFC,
  0x3C, 0xE0, 0x7F, 0xF0, 0xF7, 0x83, 0xE3, 0xC3, 0xDE, 0x1E, 0x0F, 0x0F,
  0xF0, 0xF0, 0x38, 0x3F, 0xC3, 0xC1, 0xE0, 0xFF, 0x1E, 0x07, 0x83, 0xFC,
  0x78, 0x1E, 0x0E, 0xE1, 0xE0, 0xF0, 0x7B, 0x87, 0x83, 0xC1, 0xEF, 0x1E,
  0x1F, 0x0F, 0x3C, 0x78, 0x7C, 0x7C, 0xF0, 0xFF, 0xFF, 0xE3, 0xC3, 0xFD,
  0xFF, 0x07, 0x87, 0xC3, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0xF8,
  0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F,
  0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x3E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x8F,
  0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0xF8, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF1,
  0xF0, 0x0F, 0xC7, 0xC0, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFC, 0x03, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x40, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7C, 0x1F, 0xC0, 0xF8, 0x0F, 0xC1, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F,
  0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x8F, 0x80, 0xFE, 0x1F, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x0C,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0xFC,
  0x7C, 0x0F, 0xFC, 0x7C, 0x0F, 0xFC, 0xF8, 0x0F, 0xFC, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0,
  0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x03, 0xE0, 0x0F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x0D, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x1F, 0x81, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1E, 0x1F, 0x80, 0x1F, 0x1F,
  0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xCF, 0x80, 0x03, 0xEF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xF0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xDE, 0x07, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xBC, 0x0F, 0x78, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0x3C, 0x0F,
  0x78, 0x0F, 0x7C, 0x1F, 0x38, 0x1E, 0x7C, 0x1F, 0x38, 0x1E, 0x78, 0x1E,
  0x3C, 0x3C, 0x78, 0x1E, 0x3C, 0x3C, 0xF8, 0x1E, 0x3C, 0x78, 0xF8, 0x3E,
  0x3C, 0x78, 0xF8, 0x3E, 0x3C, 0xF0, 0xF0, 0x3C, 0x3D, 0xF0, 0xF0, 0x3C,
  0x3D, 0xE1, 0xF0, 0x3C, 0x3F, 0xE1, 0xF0, 0x7C, 0x3F, 0xC1, 0xF0, 0x7C,
  0x3F, 0x81, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xE0, 0x7E,
  0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0x83, 0xFC, 0x01, 0xF0, 0x7F, 0x80, 0x3C,
  0x0F, 0xF0, 0x07, 0x81, 0xFF, 0x01, 0xF0, 0x7B, 0xE0, 0x3E, 0x0F, 0x3C,
  0x07, 0x81, 0xE7, 0xC0, 0xF0, 0x3C, 0xF8, 0x1E, 0x0F, 0x8F, 0x07, 0xC1,
  0xF1, 0xF0, 0xF8, 0x3C, 0x3E, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x7C,
  0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xC0, 0xF3, 0xE0, 0xF0, 0x1F, 0x78, 0x1E,
  0x01, 0xEF, 0x03, 0xC0, 0x3D, 0xE0, 0xF8, 0x07, 0xFC, 0x1F, 0x00, 0x7F,
  0x83, 0xC0, 0x0F, 0xE0, 0x78, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x3F, 0x03, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x78, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E,
  0x1F, 0x07, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C,
  0x1F, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x3E, 0x07, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFC, 0x00,
  0x08, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0x01, 0x87, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x20, 0x07, 0xC6, 0x01, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0xE0,
  0x03, 0xE7, 0x80, 0x0F, 0x9E, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0xF8, 0x03, 0xC3,
  0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80,
  0x0F, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0xBC, 0x01, 0xF8, 0x07, 0xDE,
  0x01, 0xFC, 0x07, 0xCF, 0x00, 0xFE, 0x03, 0xE7, 0x80, 0xFF, 0x01, 0xE3,
  0xC0, 0x7F, 0x81, 0xF1, 0xE0, 0x3B, 0xC0, 0xF0, 0xF0, 0x3D, 0xE0, 0xF8,
  0x78, 0x1E, 0xF0, 0x7C, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x0F, 0x3C, 0x3E,
  0x0F, 0x0F, 0x1E, 0x1E, 0x07, 0x87, 0x8F, 0x1F, 0x03, 0xE7, 0xC7, 0x8F,
  0x01, 0xF3, 0xC3, 0xCF, 0x80, 0xFB, 0xE1, 0xE7, 0x80, 0x7D, 0xE0, 0xF3,
  0xC0, 0x3C, 0xF0, 0x7B, 0xE0, 0x1E, 0xF0, 0x3D, 0xE0, 0x0F, 0x78, 0x1F,
  0xF0, 0x07, 0xB8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x1E, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3E, 0x78, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC3, 0xC0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF0, 0xF0,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xBC, 0x00, 0xF7, 0x80,
  0x1C, 0x70, 0x07, 0x8F, 0x01, 0xE0, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xC0, 0x38, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0E, 0xF0, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF9, 0xF1, 0xE1, 0xE1, 0xC3, 0xC0,
  0x01, 0xF0, 0xF0, 0x7F, 0x9E, 0x0F, 0xFD, 0xE1, 0xFF, 0xFE, 0x3F, 0x8F,
  0xE3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xEF, 0x07,
  0xFC, 0xF0, 0x3F, 0x9E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x8F, 0x00, 0xFB, 0xFC, 0x0F, 0x7F, 0xC0, 0xFF, 0xFE, 0x1F,
  0xC3, 0xE1, 0xF8, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x0F, 0x87, 0xFF, 0xF8, 0xF7, 0xFF,
  0x0F, 0x3F, 0xE0, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFE, 0x3F, 0x82, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x08, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF1, 0xF0,
  0x3F, 0xCF, 0x03, 0xFF, 0x78, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x1F, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E,
  0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFB, 0xC0, 0xFF,
  0x9E, 0x03, 0xF9, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF3, 0xF0, 0xF9, 0xF0, 0x3D, 0xF0, 0x1E, 0xF8, 0x1F, 0xF8, 0x3F,
  0x7F, 0xFF, 0xBF, 0xFF, 0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x02, 0x3F, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x78, 0x1F, 0xE7, 0x81, 0xFF, 0xBC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7F,
  0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x3F, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xDF, 0x01, 0xF8, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x06, 0x03, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0xFB, 0xFC, 0x0F, 0x7F, 0xE0, 0xFF, 0xFE,
  0x1F, 0xE3, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1E, 0x3F, 0x01,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0x00, 0x80, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0x40, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x07,
  0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xC0, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x3E,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x0F, 0x0F, 0x01, 0xF0, 0x1E, 0x7F, 0x87, 0xF8, 0x3D, 0xFF,
  0x1F, 0xF0, 0x7F, 0xFF, 0x7F, 0xF1, 0xFE, 0x3F, 0xC3, 0xE3, 0xF0, 0x7F,
  0x07, 0xC7, 0xE0, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x1F, 0x3F, 0x03, 0xE0,
  0x3E, 0x7C, 0x07, 0xC0, 0x78, 0xF8, 0x0F, 0x81, 0xF1, 0xF0, 0x1E, 0x03,
  0xE3, 0xC0, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0x0F, 0x9F, 0x01, 0xF0, 0x1E,
  0x3E, 0x03, 0xC0, 0x7C, 0x7C, 0x0F, 0x80, 0xF8, 0xF0, 0x1F, 0x01, 0xF3,
  0xE0, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x07, 0x8F, 0x80, 0xF0, 0x1F, 0x00,
  0x0F, 0x0F, 0x80, 0xF3, 0xFC, 0x0F, 0x7F, 0xE1, 0xFF, 0xFE, 0x1F, 0xE3,
  0xF1, 0xFC, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1E, 0x3F, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0x0F, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x0F, 0x3F, 0xC0, 0x3D,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xF0, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83,
  0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xBF, 0xE0,
  0x3E, 0x7E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x7F, 0x9E, 0x0F, 0xFD, 0xE1,
  0xFF, 0xFE, 0x3F, 0x0F, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFD, 0xF0, 0x3F, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x0F, 0x0F, 0x3F, 0x0F,
  0x7F, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0x20,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x80,
  0x7E, 0x7C, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xE3, 0xFF, 0x0F,
  0xF8, 0x3F, 0xC0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x83, 0xF8, 0xF8, 0x3F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0x8F, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x1E, 0x07,
  0xC3, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x7C,
  0x07, 0xCF, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0xFF, 0xC0, 0xFC, 0x0F, 0xBE, 0x07, 0xE0, 0x7D, 0xF0, 0x7F, 0x07,
  0xCF, 0x83, 0xF8, 0x3E, 0x7C, 0x3D, 0xC1, 0xE1, 0xE1, 0xFE, 0x1F, 0x0F,
  0x0E, 0xF0, 0xF0, 0x78, 0xF7, 0x8F, 0x83, 0xC7, 0xBC, 0x7C, 0x1E, 0x79,
  0xE7, 0xC0, 0xF3, 0xCF, 0x3E, 0x07, 0xBC, 0x39, 0xE0, 0x3D, 0xE1, 0xDF,
  0x01, 0xEE, 0x0E, 0xF0, 0x0F, 0xF0, 0x77, 0x80, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1E, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0, 0x03, 0xE7,
  0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x03, 0xC0,
  0xF8, 0x03, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE3,
  0xE0, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0x80, 0x7F, 0xA0, 0x01, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 28, 11, 1, -27 },
  { 36, 13, 10, 16, 4, -27 },
  { 53, 24, 27, 25, 1, -27 },
  { 134, 19, 31, 21, 1, -29 },
  { 208, 28, 28, 32, 2, -28 },
  { 306, 25, 28, 26, 1, -28 },
  { 394, 6, 10, 9, 4, -27 },
  { 402, 14, 33, 12, 1, -27 },
  { 460, 14, 33, 12, -3, -27 },
  { 518, 18, 18, 21, 3, -29 },
  { 559, 18, 19, 22, 2, -23 },
  { 602, 9, 9, 10, -2, -4 },
  { 613, 10, 4, 12, 1, -12 },
  { 618, 6, 6, 10, 0, -5 },
  { 623, 20, 27, 15, -2, -27 },
  { 691, 18, 28, 21, 2, -28 },
  { 754, 14, 27, 21, 4, -27 },
  { 802, 21, 28, 21, -1, -28 },
  { 876, 20, 28, 21, 0, -28 },
  { 946, 20, 27, 21, 0, -27 },
  { 1014, 20, 27, 21, 1, -27 },
  { 1082, 19, 28, 21, 2, -28 },
  { 1149, 20, 27, 21, 2, -27 },
  { 1217, 20, 28, 21, 1, -28 },
  { 1287, 18, 28, 21, 2, -28 },
  { 1350, 10, 22, 10, 0, -21 },
  { 1378, 12, 26, 10, -2, -21 },
  { 1417, 18, 20, 22, 2, -24 },
  { 1462, 18, 11, 22, 2, -19 },
  { 1487, 18, 20, 22, 2, -24 },
  { 1532, 15, 29, 17, 3, -28 },
  { 1587, 30, 30, 32, 2, -27 },
  { 1700, 23, 27, 23, -2, -27 },
  { 1778, 22, 27, 23, 1, -27 },
  { 1853, 23, 28, 23, 2, -28 },
  { 1934, 23, 27, 26, 1, -27 },
  { 2012, 21, 27, 20, 1, -27 },
  { 2083, 21, 27, 19, 1, -27 },
  { 2154, 24, 28, 26, 2, -28 },
  { 2238, 25, 27, 26, 1, -27 },
  { 2323, 17, 27, 14, -1, -27 },
  { 2381, 18, 35, 12, -6, -27 },
  { 2460, 25, 27, 23, 1, -27 },
  { 2545, 16, 27, 19, 1, -27 },
  { 2599, 32, 27, 33, 1, -27 },
  { 2707, 27, 27, 28, 1, -27 },
  { 2799, 24, 28, 28, 2, -28 },
  { 2883, 22, 27, 23, 1, -27 },
  { 2958, 24, 34, 28, 2, -28 },
  { 3060, 21, 27, 23, 1, -27 },
  { 3131, 19, 28, 20, 1, -28 },
  { 3198, 20, 27, 20, 3, -27 },
  { 3266, 23, 27, 26, 3, -27 },
  { 3344, 22, 27, 22, 3, -27 },
  { 3419, 33, 27, 33, 4, -27 },
  { 3531, 27, 27, 22, -2, -27 },
  { 3623, 21, 27, 21, 3, -27 },
  { 3694, 23, 27, 20, -1, -27 },
  { 3772, 16, 33, 12, -1, -27 },
  { 3838, 8, 27, 15, 4, -27 },
  { 3865, 16, 33, 12, -3, -27 },
  { 3931, 19, 17, 21, 1, -27 },
  { 3972, 15, 3, 15, -3, 3 },
  { 3978, 7, 6, 12, 6, -29 },
  { 3984, 20, 21, 22, 2, -21 },
  { 4037, 20, 29, 22, 1, -29 },
  { 4110, 16, 21, 18, 2, -21 },
  { 4152, 21, 29, 22, 2, -29 },
  { 4229, 17, 21, 20, 2, -21 },
  { 4274, 22, 38, 13, -4, -29 },
  { 4379, 21, 30, 22, 1, -21 },
  { 4458, 20, 29, 23, 1, -29 },
  { 4531, 10, 29, 11, 1, -29 },
  { 4568, 17, 38, 11, -5, -29 },
  { 4649, 21, 29, 21, 1, -29 },
  { 4726, 11, 29, 11, 1, -29 },
  { 4766, 31, 21, 34, 1, -21 },
  { 4848, 20, 21, 23, 1, -21 },
  { 4901, 18, 21, 22, 2, -21 },
  { 4949, 22, 30, 22, -1, -21 },
  { 5032, 20, 30, 22, 2, -21 },
  { 5107, 16, 21, 16, 1, -21 },
  { 5149, 17, 21, 17, 0, -21 },
  { 5194, 13, 25, 14, 2, -25 },
  { 5235, 20, 21, 23, 2, -21 },
  { 5288, 19, 21, 19, 2, -21 },
  { 5338, 29, 21, 29, 2, -21 },
  { 5415, 23, 21, 20, -2, -21 },
  { 5476, 24, 30, 19, -3, -21 },
  { 5566, 19, 21, 17, -1, -21 },
  { 5616, 16, 33, 13, 0, -27 },
  { 5682, 4, 38, 21, 9, -29 },
  { 5701, 15, 33, 13, -2, -27 },
  { 5763, 18, 6, 22, 2, -16 },
};

const GFXfont NotoSans_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMIBOLDITALIC38PT7B_H_
