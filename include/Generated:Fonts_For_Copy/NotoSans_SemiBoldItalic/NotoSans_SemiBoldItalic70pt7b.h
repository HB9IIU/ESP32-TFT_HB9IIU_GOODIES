#ifndef _NOTOSANS_SEMIBOLDITALIC70PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x3F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF1, 0xF0, 0x78, 0x03, 0xFE, 0x1F, 0x01, 0x80, 0x3F, 0xE1,
  0xF0, 0x00, 0x03, 0xFC, 0x1E, 0x00, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0x03,
  0xFC, 0x3E, 0x00, 0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x03, 0xFE, 0x3E, 0x00,
  0x00, 0x3F, 0xE3, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0x3F, 0xF0, 0x00,
  0x01, 0xF1, 0xFF, 0x00, 0x00, 0x1E, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0xFF,
  0x00, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x03, 0xE1, 0xFF, 0x08, 0x00, 0x3C,
  0x1F, 0xF0, 0xC0, 0x03, 0xC3, 0xFF, 0x0F, 0x80, 0x7C, 0x7F, 0xE0, 0xFF,
  0x87, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x81, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0xF0,
  0xFE, 0x1F, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x87, 0xFF, 0xC7, 0xF0, 0x7F,
  0x8F, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0xFC, 0x7F, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xF8, 0xFF, 0x0F, 0xE3, 0xFF, 0xF0, 0xFE, 0x3F, 0xC1, 0xFE,
  0x7F, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xFF, 0x0F, 0xE1, 0xFE, 0x03,
  0xF8, 0x1E, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xFF,
  0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC3, 0xFF, 0x00, 0x7F,
  0xC7, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x40, 0x07, 0xF0, 0x00, 0x18, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFF, 0x87, 0xE0,
  0x00, 0x7F, 0xF9, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x03, 0xFE, 0x1F, 0xC0,
  0x03, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xF0, 0x0F, 0xE0, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x02, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x0F, 0x87, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0xCF, 0xFE, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0,
  0xFC, 0x1F, 0xF0, 0x7C, 0x0F, 0xF8, 0x18, 0x07, 0xF8, 0x08, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0x00,
  0x01, 0xFF, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x08, 0x00, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x00, 0x0F, 0xFE, 0x0E, 0x00,
  0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0x9F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFE,
  0x03, 0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE,
  0x3F, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFF,
  0x3F, 0xC0, 0x3F, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xC7, 0xFC, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F,
  0x80, 0x3F, 0xF0, 0xE0, 0x01, 0xFF, 0x08, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7E, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7E, 0x1F, 0xC0,
  0x3F, 0xF0, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x7F,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFE, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x07, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x7E, 0x03, 0xFC,
  0x1F, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xFC, 0x7F, 0xFF,
  0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x04, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xFF, 0xE1, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xF3, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x0F,
  0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFC,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE1,
  0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x00, 0x7F,
  0x83, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFC,
  0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01,
  0xFD, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xC0,
  0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xE7, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC7,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC7,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xC0, 0x1F, 0xFC, 0x00, 0x1C, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x0C, 0x00, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xE0, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x03, 0xF9, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xFE, 0x3F, 0x80, 0x07, 0xFF, 0xE1, 0xFC,
  0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x1F, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F,
  0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0xFF, 0xE0, 0x0F,
  0xE1, 0xFF, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x30,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x20, 0x3F, 0xF8, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x70, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF, 0xCF, 0xF0, 0x01,
  0xFF, 0xFF, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xF3, 0xF8, 0x00, 0x1F, 0xFF,
  0xE3, 0xF8, 0x00, 0x0F, 0xFF, 0xC3, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x80, 0xFF, 0xE0, 0x01, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x3C, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF7, 0xFC, 0x00, 0x7F, 0xFF,
  0xCF, 0xF0, 0x00, 0x7F, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x04, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xFF, 0x80, 0x1F, 0xE3, 0xFF,
  0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF0,
  0x3F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0x01,
  0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x0E, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0x83, 0xFF, 0xF0, 0x01, 0xFC, 0x3F,
  0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0xFF, 0x00, 0x7F, 0x3F, 0xFF, 0xF8, 0x07,
  0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xC1, 0xFF,
  0xF0, 0x00, 0x1F, 0xC7, 0xFF, 0xF8, 0x00, 0x1F, 0xCF, 0xFF, 0xFC, 0x00,
  0x1F, 0xDF, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xFF, 0xF7, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0xFF, 0x00, 0x0F, 0xF9,
  0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xF0,
  0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xC0,
  0x07, 0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xFC,
  0x7F, 0x00, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xCF, 0xF0,
  0x01, 0xFF, 0xFC, 0x7F, 0x80, 0x07, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x0F, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x87, 0xFE, 0x03, 0xF8, 0x7F, 0xF0,
  0x1F, 0xC7, 0xFF, 0x80, 0xFE, 0x7F, 0xF8, 0x0F, 0xF7, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x80,
  0xFC, 0x0F, 0xFC, 0x00, 0x60, 0x3F, 0xE0, 0x00, 0x80, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x08,
  0x00, 0x07, 0xFC, 0x38, 0x00, 0x3F, 0xF0, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE7, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x80,
  0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x7F, 0xBF, 0x80, 0xFF, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0x3F,
  0x80, 0x7F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFF,
  0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF7,
  0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xBF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0x83, 0xFC,
  0x03, 0xFB, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0xC0,
  0xFF, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0xFE, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF3, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xF8,
  0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0xC0, 0x1F, 0xE1,
  0xFC, 0x3F, 0x87, 0xFC, 0x00, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xE0, 0x07,
  0xF8, 0xFE, 0x07, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x3F, 0x1F, 0xF0,
  0x01, 0xFE, 0x7F, 0x01, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x0F, 0xC7,
  0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x7E, 0x7F, 0x80, 0x03, 0xFD, 0xFC, 0x03,
  0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x1F, 0xBF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x00, 0x3F,
  0xBF, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x08, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x47,
  0xFF, 0xC0, 0x00, 0x37, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0xE0, 0x00, 0xFF, 0xFF, 0x20, 0x00, 0x0F,
  0xFF, 0x08, 0x00, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 20, 51, 19, 1, -50 },
  { 129, 24, 18, 30, 7, -50 },
  { 183, 44, 50, 45, 2, -50 },
  { 458, 36, 57, 39, 2, -53 },
  { 715, 51, 52, 58, 5, -51 },
  { 1047, 45, 52, 49, 2, -51 },
  { 1340, 11, 18, 17, 7, -50 },
  { 1365, 25, 61, 22, 3, -50 },
  { 1556, 25, 62, 23, -5, -51 },
  { 1750, 34, 34, 38, 6, -54 },
  { 1895, 34, 34, 40, 4, -42 },
  { 2040, 15, 17, 19, -3, -8 },
  { 2072, 19, 8, 22, 1, -23 },
  { 2091, 11, 11, 19, 1, -10 },
  { 2107, 36, 50, 28, -3, -50 },
  { 2332, 35, 52, 39, 3, -51 },
  { 2560, 25, 50, 39, 8, -50 },
  { 2717, 38, 51, 39, -1, -51 },
  { 2960, 36, 52, 39, 1, -51 },
  { 3194, 37, 50, 39, 0, -50 },
  { 3426, 36, 51, 39, 2, -50 },
  { 3656, 35, 52, 39, 4, -51 },
  { 3884, 37, 50, 39, 4, -50 },
  { 4116, 36, 52, 39, 2, -51 },
  { 4350, 34, 52, 39, 3, -51 },
  { 4571, 17, 40, 19, 1, -39 },
  { 4656, 22, 48, 19, -4, -39 },
  { 4788, 34, 36, 40, 4, -43 },
  { 4941, 34, 20, 40, 4, -35 },
  { 5026, 34, 36, 40, 4, -43 },
  { 5179, 28, 52, 31, 5, -51 },
  { 5361, 56, 56, 60, 3, -50 },
  { 5753, 42, 50, 42, -4, -50 },
  { 6016, 40, 50, 43, 2, -50 },
  { 6266, 41, 52, 42, 4, -51 },
  { 6533, 43, 50, 47, 2, -50 },
  { 6802, 38, 50, 37, 2, -50 },
  { 7040, 38, 50, 36, 2, -50 },
  { 7278, 43, 52, 48, 4, -51 },
  { 7558, 47, 50, 49, 2, -50 },
  { 7852, 31, 50, 25, -2, -50 },
  { 8046, 33, 64, 22, -11, -50 },
  { 8310, 46, 50, 42, 2, -50 },
  { 8598, 29, 50, 35, 2, -50 },
  { 8780, 59, 50, 61, 2, -50 },
  { 9149, 50, 50, 52, 2, -50 },
  { 9462, 45, 52, 51, 4, -51 },
  { 9755, 40, 50, 42, 2, -50 },
  { 10005, 45, 63, 51, 4, -51 },
  { 10360, 39, 50, 42, 2, -50 },
  { 10604, 36, 52, 36, 1, -51 },
  { 10838, 36, 50, 36, 6, -50 },
  { 11063, 44, 51, 48, 5, -50 },
  { 11344, 41, 50, 40, 6, -50 },
  { 11601, 61, 50, 62, 7, -50 },
  { 11983, 50, 50, 41, -4, -50 },
  { 12296, 38, 50, 38, 6, -50 },
  { 12534, 43, 50, 37, -2, -50 },
  { 12803, 28, 61, 22, -1, -50 },
  { 13017, 15, 50, 28, 8, -50 },
  { 13111, 28, 61, 22, -5, -50 },
  { 13325, 35, 32, 39, 2, -50 },
  { 13465, 29, 5, 28, -6, 6 },
  { 13484, 14, 12, 21, 10, -54 },
  { 13505, 37, 40, 41, 3, -39 },
  { 13690, 36, 54, 41, 2, -53 },
  { 13933, 31, 40, 33, 3, -39 },
  { 14088, 40, 54, 41, 3, -53 },
  { 14358, 33, 40, 37, 3, -39 },
  { 14523, 41, 71, 25, -8, -54 },
  { 14887, 39, 56, 41, 1, -39 },
  { 15160, 36, 53, 42, 2, -53 },
  { 15399, 19, 53, 20, 2, -53 },
  { 15525, 30, 70, 20, -9, -53 },
  { 15788, 40, 53, 38, 1, -53 },
  { 16053, 21, 53, 20, 1, -53 },
  { 16193, 57, 39, 63, 2, -39 },
  { 16471, 37, 39, 42, 1, -39 },
  { 16652, 34, 40, 40, 3, -39 },
  { 16822, 40, 56, 41, -2, -39 },
  { 17102, 37, 56, 41, 3, -39 },
  { 17361, 29, 39, 29, 2, -39 },
  { 17503, 30, 40, 32, 1, -39 },
  { 17653, 25, 47, 27, 3, -46 },
  { 17800, 36, 39, 42, 4, -38 },
  { 17976, 35, 38, 35, 3, -38 },
  { 18143, 53, 38, 53, 4, -38 },
  { 18395, 42, 38, 36, -3, -38 },
  { 18595, 44, 55, 35, -5, -38 },
  { 18898, 33, 38, 32, -1, -38 },
  { 19055, 29, 61, 25, 0, -50 },
  { 19277, 6, 69, 39, 17, -53 },
  { 19329, 28, 61, 25, -3, -50 },
  { 19543, 34, 11, 40, 4, -30 },
};

const GFXfont NotoSans_SemiBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMIBOLDITALIC70PT7B_H_
