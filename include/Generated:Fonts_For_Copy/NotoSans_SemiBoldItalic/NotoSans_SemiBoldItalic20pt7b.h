#ifndef _NOTOSANS_SEMIBOLDITALIC20PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x0C, 0x31, 0xC0, 0x18, 0xE3, 0x80,
  0x6F, 0xDB, 0x36, 0x6C, 0xC0, 0x03, 0x30, 0x33, 0x01, 0x98, 0x0C, 0xC3,
  0xFF, 0x9F, 0xFC, 0x33, 0x01, 0x18, 0x7F, 0xF7, 0xFF, 0x86, 0x60, 0x62,
  0x03, 0x30, 0x19, 0x80, 0x02, 0x01, 0xC3, 0xFC, 0xF6, 0x74, 0x1D, 0x07,
  0xC0, 0xF8, 0x0F, 0x02, 0xE0, 0xBA, 0x6E, 0xFF, 0x3F, 0x81, 0x00, 0xC0,
  0x3C, 0x1C, 0xEC, 0x31, 0x98, 0xC3, 0x33, 0x0C, 0x6C, 0x19, 0x9B, 0xBB,
  0x6F, 0xBD, 0xB3, 0x06, 0x66, 0x0D, 0xCC, 0x33, 0x18, 0xC6, 0x63, 0x0F,
  0xCE, 0x0F, 0x00, 0x02, 0x00, 0x7C, 0x07, 0x70, 0x71, 0x83, 0x9C, 0x0D,
  0xC0, 0x7C, 0x07, 0x81, 0x7E, 0x37, 0x3B, 0xB0, 0xF9, 0x87, 0x8E, 0x3C,
  0x7F, 0xF1, 0xFB, 0xC0, 0x7F, 0x6C, 0x0E, 0x30, 0xE1, 0x87, 0x0C, 0x38,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0x60, 0x1C, 0x18, 0x30,
  0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x87, 0x0C, 0x30, 0xC0,
  0x0E, 0x06, 0x33, 0x1F, 0x11, 0xF9, 0xE5, 0xF1, 0xCC, 0x26, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x3B, 0x98, 0xCC, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0xE0, 0x30, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0xC0, 0x00, 0x04, 0x07, 0xE3, 0xF9, 0xC7, 0x71, 0xD8, 0x7E,
  0x1F, 0x87, 0xC1, 0xB0, 0x6C, 0x3B, 0x0E, 0xE7, 0x3F, 0x87, 0xC0, 0x0E,
  0x7D, 0xFF, 0x74, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x00,
  0x1F, 0xC7, 0xF8, 0x43, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x43,
  0x80, 0x70, 0x0C, 0x07, 0x87, 0xC0, 0xFC, 0x01, 0xC0, 0x38, 0x07, 0x41,
  0xCF, 0xF9, 0xFC, 0x00, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0x60, 0xDC, 0x3B,
  0x0E, 0x63, 0x8C, 0x63, 0x9F, 0xFF, 0xFF, 0x01, 0x80, 0x30, 0x0E, 0x00,
  0x0F, 0xE3, 0xFC, 0x60, 0x0C, 0x03, 0x80, 0x7E, 0x0F, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x41, 0xCF, 0xF8, 0xFC, 0x00, 0x00, 0x83, 0xF1, 0xFC,
  0xE0, 0x70, 0x18, 0x06, 0xF3, 0xFE, 0xE3, 0xB8, 0x6C, 0x1B, 0x8E, 0xE3,
  0x1F, 0xC3, 0xE0, 0x7F, 0xEF, 0xF8, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x00, 0x02,
  0x07, 0xE3, 0xBC, 0xC7, 0x31, 0xCC, 0x63, 0xF8, 0x78, 0x7F, 0x38, 0xEC,
  0x3B, 0x0E, 0xC3, 0xBF, 0xC7, 0xE0, 0x04, 0x0F, 0xC3, 0xF9, 0xC6, 0x61,
  0xF8, 0x7E, 0x1D, 0x8E, 0x7F, 0x8E, 0xE0, 0x38, 0x1C, 0x0F, 0x3F, 0x8F,
  0x80, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x67, 0x38, 0x1C, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xC7, 0x18, 0xE3, 0x00, 0x00, 0xC0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xF1,
  0xF1, 0xF0, 0xE0, 0x20, 0x00, 0xFE, 0xFE, 0x87, 0x06, 0x0E, 0x1C, 0x38,
  0x70, 0x60, 0x60, 0x00, 0xC0, 0xE0, 0xC0, 0x07, 0xF8, 0x0F, 0x1C, 0x38,
  0x06, 0x30, 0x06, 0x63, 0xF3, 0x66, 0x33, 0xCC, 0x63, 0xCC, 0x63, 0xCC,
  0x66, 0xCC, 0xE6, 0xCF, 0xFC, 0xC7, 0x38, 0x60, 0x00, 0x70, 0x20, 0x3F,
  0xE0, 0x0F, 0x80, 0x01, 0xC0, 0x3E, 0x03, 0x60, 0x76, 0x06, 0x60, 0xE6,
  0x0C, 0x61, 0xC6, 0x1F, 0xE3, 0xFE, 0x30, 0x77, 0x07, 0x60, 0x7E, 0x07,
  0x3F, 0xC7, 0xFC, 0xE3, 0x98, 0x73, 0x0E, 0xE7, 0x9F, 0xC3, 0xFC, 0x61,
  0xCC, 0x3B, 0x87, 0x71, 0xEF, 0xF9, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x38,
  0x23, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x08, 0x7F, 0x81, 0xF8, 0x3F, 0xC3, 0xFE, 0x38, 0xE3, 0x07, 0x30,
  0x77, 0x07, 0x70, 0x77, 0x07, 0x60, 0x66, 0x0E, 0xE1, 0xEE, 0x3C, 0xFF,
  0x8F, 0xE0, 0x3F, 0xCF, 0xF3, 0x80, 0xC0, 0x30, 0x1F, 0xE7, 0xF9, 0xFC,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xFF, 0x3F, 0x80, 0x3F, 0xCF, 0xF3, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0xF9, 0xFC, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x00, 0x0F, 0xF1, 0xFF, 0x3C, 0x13, 0x80, 0x70, 0x06, 0x00, 0xE1,
  0xFE, 0x3E, 0xE0, 0x6E, 0x06, 0xE0, 0xE7, 0x0E, 0x7F, 0xC1, 0xFC, 0x38,
  0x39, 0xC1, 0xCE, 0x0C, 0x60, 0x63, 0x07, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC,
  0x60, 0x63, 0x07, 0x38, 0x39, 0xC1, 0x8E, 0x0C, 0x60, 0xE0, 0x1F, 0x87,
  0x81, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x07,
  0xE7, 0xE0, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0xF8, 0x78, 0x00, 0x38,
  0x79, 0xC7, 0x0E, 0x70, 0x67, 0x03, 0x70, 0x3B, 0x01, 0xF8, 0x0F, 0xC0,
  0x77, 0x03, 0x38, 0x38, 0xC1, 0xC7, 0x0C, 0x38, 0x60, 0xE0, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xFF, 0xFE,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1B, 0x3C, 0x1F, 0x3C, 0x36, 0x76, 0x36,
  0x76, 0x66, 0x66, 0x6E, 0x66, 0xCE, 0x66, 0xCC, 0xE7, 0x8C, 0xC7, 0x8C,
  0xC7, 0x1C, 0xC7, 0x1C, 0x3C, 0x1C, 0xF0, 0x63, 0xC1, 0x8F, 0x86, 0x36,
  0x19, 0xD8, 0xE7, 0x73, 0x18, 0xCC, 0x63, 0xB1, 0x8E, 0xCE, 0x1F, 0x30,
  0x78, 0xC1, 0xE3, 0x03, 0x80, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x70, 0xE7,
  0x03, 0xB8, 0x1D, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x1D, 0xC0,
  0xE7, 0x0E, 0x3F, 0xE0, 0x7E, 0x00, 0x3F, 0x87, 0xF8, 0xE3, 0x98, 0x73,
  0x0E, 0xE1, 0xDC, 0xF3, 0xFC, 0x7E, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x70, 0xE7, 0x03, 0xB8, 0x1D,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x1D, 0xC0, 0xE7, 0x0E, 0x3F,
  0xE0, 0x7E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0x87, 0xF8, 0xE3,
  0x98, 0x73, 0x0E, 0xE3, 0x9F, 0xF3, 0xF8, 0x67, 0x0C, 0xE3, 0x8C, 0x71,
  0xCE, 0x19, 0x83, 0x80, 0x0F, 0xE3, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x70, 0x06, 0x41, 0xCF, 0xF0, 0xFC, 0x00,
  0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x38, 0x39, 0xC1, 0xCC, 0x0C, 0x60,
  0x67, 0x07, 0x38, 0x39, 0xC1, 0x8C, 0x0C, 0x60, 0xE7, 0x07, 0x38, 0x38,
  0xE3, 0x87, 0xF8, 0x1F, 0x80, 0xC0, 0xF8, 0x1B, 0x07, 0x70, 0xCE, 0x39,
  0xC6, 0x39, 0xC3, 0x30, 0x6E, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE0,
  0x00, 0xC1, 0xC3, 0xE0, 0xE1, 0xF0, 0xF0, 0xD8, 0x78, 0xEC, 0x6C, 0x66,
  0x36, 0x73, 0x3B, 0x31, 0x99, 0x98, 0xDC, 0xDC, 0x6C, 0x6C, 0x36, 0x3E,
  0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x30, 0xE0, 0xE7,
  0x01, 0xB8, 0x06, 0xC0, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x77,
  0x01, 0x8C, 0x0E, 0x38, 0x70, 0xE3, 0x81, 0x80, 0xE1, 0xFC, 0x31, 0x8E,
  0x33, 0x86, 0x60, 0xFC, 0x0F, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0x8F,
  0xF8, 0x1F, 0x1E, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0xC0, 0xF0, 0xF0, 0xC7, 0x18, 0xC6, 0x31, 0x8E, 0x31,
  0x8C, 0x63, 0x1C, 0x1F, 0x1E, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF0, 0xF0, 0x06, 0x00, 0xE0, 0x3C,
  0x06, 0xC1, 0x98, 0x63, 0x0C, 0x33, 0x06, 0xE0, 0x60, 0xFF, 0xE6, 0x30,
  0x1E, 0xCF, 0xF7, 0x1D, 0x87, 0xE1, 0xB8, 0x6E, 0x3B, 0x0E, 0xE7, 0xBF,
  0xC7, 0xB0, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xBC, 0x7F, 0x8F, 0x39,
  0xC7, 0x30, 0xE6, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0xFF, 0x3B, 0xC0, 0x1F,
  0x9F, 0x9C, 0x4C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xE2, 0x3F, 0x1F, 0x80,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x61, 0xEC, 0x7F, 0x9C, 0x73, 0x0E, 0xE1,
  0x9C, 0x33, 0x06, 0x61, 0xCE, 0x79, 0xFE, 0x1E, 0xC0, 0x1F, 0x1F, 0xDC,
  0x6C, 0x3E, 0x7F, 0xFB, 0xC1, 0x80, 0xE1, 0x3F, 0x9F, 0x80, 0x01, 0xE0,
  0x7C, 0x0C, 0x03, 0x80, 0xFC, 0x3F, 0x81, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x03, 0xC0,
  0x70, 0x00, 0x0F, 0x63, 0xFC, 0xE3, 0x98, 0x77, 0x0C, 0xE1, 0x9C, 0x73,
  0x0E, 0x73, 0xCF, 0xF0, 0xF6, 0x01, 0xC0, 0x39, 0x8E, 0x3F, 0x83, 0xE0,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xBC, 0x7F, 0xCF, 0x39, 0xC7, 0x38,
  0xE6, 0x19, 0xC3, 0x38, 0x66, 0x1C, 0xC3, 0xB8, 0x60, 0x0C, 0x70, 0x80,
  0x18, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x61, 0x8E, 0x00, 0x01, 0x81, 0xC0,
  0x40, 0x00, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x30, 0x38, 0x1C, 0x1C, 0x3E, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0xF3, 0x9C, 0x39, 0x83, 0x30, 0x36, 0x03, 0xE0, 0x7F,
  0x07, 0x70, 0x63, 0x86, 0x38, 0xE1, 0xC0, 0x0C, 0x71, 0xC6, 0x18, 0xE3,
  0x8E, 0x30, 0xC7, 0x1C, 0x61, 0x8E, 0x00, 0x1B, 0xCF, 0x1F, 0xEF, 0xCF,
  0x3C, 0xE7, 0x1C, 0x73, 0x0E, 0x39, 0x86, 0x19, 0xC3, 0x0C, 0xE3, 0x86,
  0x61, 0xC7, 0x30, 0xC3, 0xB8, 0x61, 0x80, 0x1B, 0xC7, 0xFC, 0xF3, 0x9C,
  0x73, 0x8E, 0x61, 0x9C, 0x33, 0x8E, 0x61, 0xCC, 0x3B, 0x86, 0x00, 0x1F,
  0x0F, 0xE7, 0x19, 0x87, 0xE1, 0xF8, 0x7C, 0x1B, 0x0E, 0xE3, 0x9F, 0xC3,
  0xE0, 0x0D, 0xE1, 0xFE, 0x1E, 0x71, 0xC7, 0x18, 0x71, 0x87, 0x38, 0x73,
  0x8E, 0x38, 0xE3, 0xFC, 0x37, 0x87, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0x1E, 0xCF, 0xF7, 0x1D, 0x87, 0xE1, 0xB8, 0x6C, 0x1B, 0x0E, 0xE7,
  0xBF, 0xC7, 0xB0, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x1B, 0x9F, 0xCF,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x00, 0x1F, 0x1F,
  0xDC, 0x4E, 0x03, 0x81, 0xF0, 0x3C, 0x0E, 0x87, 0x7F, 0x3F, 0x00, 0x18,
  0x61, 0xFF, 0xF7, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0xC7, 0x80, 0x30,
  0xDC, 0x37, 0x1D, 0x87, 0x61, 0xF8, 0x6E, 0x3B, 0x8E, 0xE7, 0xBF, 0xC7,
  0xB0, 0xC1, 0xF8, 0x6E, 0x3B, 0x8C, 0x67, 0x19, 0x86, 0xE1, 0xB0, 0x78,
  0x1E, 0x07, 0x00, 0xE3, 0x8F, 0xC7, 0x1F, 0x9E, 0x37, 0x3C, 0xEE, 0xD9,
  0x9D, 0xB7, 0x3E, 0x6C, 0x3C, 0xD8, 0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x00,
  0x18, 0x71, 0xCE, 0x0D, 0xC0, 0xD8, 0x0F, 0x80, 0x70, 0x0F, 0x01, 0xF0,
  0x3B, 0x87, 0x18, 0xE1, 0xC0, 0x18, 0x38, 0xE1, 0x87, 0x1C, 0x38, 0xC0,
  0xCE, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x03, 0xE0, 0x1E, 0x00, 0x3F, 0x9F, 0xC0, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x7F, 0xBF, 0x80, 0x07, 0x0F, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0xF8, 0xE0, 0x70, 0x30, 0x30, 0x30, 0x70, 0x70, 0x78,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x1E, 0x06, 0x0E, 0x0C, 0x0C,
  0x0C, 0x0E, 0x07, 0x1F, 0x18, 0x18, 0x38, 0x30, 0x30, 0xF0, 0xE0, 0x30,
  0x7F, 0xBC, 0xFC,
};

const GFXglyph NotoSans_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 6, 0, -14 },
  { 12, 7, 5, 9, 2, -14 },
  { 17, 13, 14, 13, 0, -14 },
  { 40, 10, 16, 11, 1, -15 },
  { 60, 15, 14, 17, 1, -14 },
  { 87, 13, 15, 14, 1, -15 },
  { 112, 3, 5, 5, 2, -14 },
  { 114, 7, 17, 6, 1, -14 },
  { 129, 7, 17, 6, -1, -14 },
  { 144, 9, 9, 11, 2, -15 },
  { 155, 10, 10, 11, 1, -12 },
  { 168, 5, 5, 6, -1, -2 },
  { 172, 6, 2, 6, 0, -6 },
  { 174, 3, 3, 6, 0, -3 },
  { 176, 11, 14, 8, -1, -14 },
  { 196, 10, 15, 11, 1, -15 },
  { 215, 7, 14, 11, 2, -14 },
  { 228, 11, 14, 11, 0, -14 },
  { 248, 11, 14, 11, 0, -14 },
  { 268, 11, 14, 11, 0, -14 },
  { 288, 11, 14, 11, 0, -14 },
  { 308, 10, 15, 11, 1, -15 },
  { 327, 11, 14, 11, 1, -14 },
  { 347, 10, 15, 11, 1, -15 },
  { 366, 10, 15, 11, 1, -15 },
  { 385, 5, 11, 6, 0, -11 },
  { 392, 6, 14, 6, -1, -11 },
  { 403, 10, 10, 11, 1, -12 },
  { 416, 10, 6, 11, 1, -10 },
  { 424, 10, 10, 11, 1, -12 },
  { 437, 8, 14, 9, 2, -14 },
  { 451, 16, 16, 17, 1, -14 },
  { 483, 12, 14, 12, -1, -14 },
  { 504, 11, 14, 12, 1, -14 },
  { 524, 12, 14, 12, 1, -14 },
  { 545, 12, 14, 13, 1, -14 },
  { 566, 10, 14, 11, 1, -14 },
  { 584, 10, 14, 10, 1, -14 },
  { 602, 12, 14, 14, 1, -14 },
  { 623, 13, 14, 14, 1, -14 },
  { 646, 9, 14, 7, -1, -14 },
  { 662, 9, 18, 6, -3, -14 },
  { 683, 13, 14, 12, 1, -14 },
  { 706, 8, 14, 10, 1, -14 },
  { 720, 16, 14, 17, 1, -14 },
  { 748, 14, 14, 15, 1, -14 },
  { 773, 13, 15, 15, 1, -15 },
  { 798, 11, 14, 12, 1, -14 },
  { 818, 13, 18, 15, 1, -15 },
  { 848, 11, 14, 12, 1, -14 },
  { 868, 11, 14, 10, 0, -14 },
  { 888, 10, 14, 10, 2, -14 },
  { 906, 13, 14, 14, 1, -14 },
  { 929, 11, 14, 12, 2, -14 },
  { 949, 17, 14, 18, 2, -14 },
  { 979, 14, 14, 12, -1, -14 },
  { 1004, 11, 14, 11, 2, -14 },
  { 1024, 12, 14, 11, 0, -14 },
  { 1045, 8, 17, 6, 0, -14 },
  { 1062, 5, 14, 8, 2, -14 },
  { 1071, 8, 17, 6, -1, -14 },
  { 1088, 11, 9, 11, 0, -14 },
  { 1101, 8, 1, 8, -2, 2 },
  { 1102, 4, 3, 6, 3, -15 },
  { 1104, 10, 11, 12, 1, -11 },
  { 1118, 11, 15, 12, 0, -15 },
  { 1139, 9, 11, 9, 1, -11 },
  { 1152, 11, 15, 12, 1, -15 },
  { 1173, 9, 11, 11, 1, -11 },
  { 1186, 11, 20, 7, -2, -15 },
  { 1214, 11, 16, 12, 0, -11 },
  { 1236, 11, 15, 12, 0, -15 },
  { 1257, 6, 15, 6, 0, -15 },
  { 1269, 9, 20, 6, -3, -15 },
  { 1292, 12, 15, 11, 0, -15 },
  { 1315, 6, 15, 6, 0, -15 },
  { 1327, 17, 11, 18, 0, -11 },
  { 1351, 11, 11, 12, 0, -11 },
  { 1367, 10, 11, 12, 1, -11 },
  { 1381, 12, 16, 12, -1, -11 },
  { 1405, 10, 16, 12, 1, -11 },
  { 1425, 9, 11, 8, 0, -11 },
  { 1438, 9, 11, 9, 0, -11 },
  { 1451, 7, 13, 8, 1, -13 },
  { 1463, 10, 11, 12, 1, -11 },
  { 1477, 10, 11, 10, 1, -11 },
  { 1491, 15, 11, 15, 1, -11 },
  { 1512, 12, 11, 10, -1, -11 },
  { 1529, 13, 16, 10, -2, -11 },
  { 1555, 9, 11, 9, 0, -11 },
  { 1568, 8, 17, 7, 0, -14 },
  { 1585, 2, 20, 11, 5, -15 },
  { 1590, 8, 17, 7, -1, -14 },
  { 1607, 10, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMIBOLDITALIC20PT7B_H_
