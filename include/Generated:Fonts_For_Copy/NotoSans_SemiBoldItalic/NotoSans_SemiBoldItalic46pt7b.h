#ifndef _NOTOSANS_SEMIBOLDITALIC46PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x01, 0x00, 0x00, 0x7E, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x4F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x7C,
  0x0F, 0xE7, 0x04, 0x0F, 0xC7, 0x00, 0x0F, 0xC7, 0x00, 0x0F, 0xCE, 0x00,
  0x0F, 0xCE, 0x00, 0x0F, 0xEE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x3B, 0xF8, 0x00, 0x39, 0xF8, 0x00, 0x38, 0xFC, 0x00, 0x38, 0xFC,
  0x00, 0x38, 0xF8, 0x80, 0x71, 0xF8, 0xF0, 0x73, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x0F, 0x01,
  0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0xF8, 0x03, 0xE0, 0x3E, 0x3E, 0x01, 0xF0,
  0x1F, 0x8F, 0x80, 0x78, 0x07, 0xC1, 0xE0, 0x3E, 0x01, 0xF0, 0xF8, 0x1F,
  0x00, 0x78, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x83, 0xC0, 0x0F, 0x83, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0x3E, 0x1F,
  0x1E, 0x3F, 0x8F, 0x87, 0xCF, 0x9F, 0xF3, 0xE3, 0xE7, 0xCF, 0xFE, 0xFF,
  0xFB, 0xE7, 0xFF, 0x9F, 0xFC, 0xF3, 0xF3, 0xE3, 0xFE, 0x7C, 0xF8, 0x7C,
  0x7E, 0x3E, 0x3C, 0x1F, 0x00, 0x1F, 0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC1,
  0xE0, 0x03, 0xE1, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x3E, 0x00, 0x78, 0x3E,
  0x0F, 0x80, 0x3C, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xE0, 0xF0, 0x0F, 0x80,
  0xF8, 0x7C, 0x03, 0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0xF8,
  0x01, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x7F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x01, 0xF8, 0xFF, 0xF8, 0x0F, 0xCF, 0xFF, 0xC0, 0xFC, 0xFE, 0x3F, 0x07,
  0xE7, 0xE0, 0xFC, 0x7E, 0x7E, 0x07, 0xF3, 0xE3, 0xF0, 0x1F, 0xBF, 0x1F,
  0x00, 0x7F, 0xF0, 0xF8, 0x03, 0xFF, 0x07, 0xC0, 0x0F, 0xF8, 0x3F, 0x00,
  0x3F, 0x81, 0xFC, 0x07, 0xFC, 0x0F, 0xF9, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x7E, 0x07, 0xFF, 0xE3, 0xF8, 0x0F, 0xFC, 0x0F, 0xE0,
  0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x80, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x40, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0xCF,
  0x00, 0xFF, 0xF8, 0x0C, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x03, 0xFD, 0xFC, 0x1F, 0xF0, 0x00, 0xFD, 0xE0, 0x07, 0xE7, 0x80, 0x3F,
  0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0x10, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xBF, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x03,
  0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xF3, 0xFC,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xF8, 0xFF, 0xF9, 0xFF, 0x7C, 0x7F, 0x7E, 0x3E, 0x3F, 0x0C, 0x1F, 0x04,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0xE0, 0x0C, 0x01, 0xF8, 0x02, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFB, 0xFE, 0x03, 0x80, 0x7E, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x02, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x80, 0x03, 0xF8, 0xC0, 0x07, 0xF0, 0xFC,
  0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0x9F,
  0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x06, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x80, 0x03, 0xF8, 0xC0, 0x07, 0xF0, 0xFC, 0x3F,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xDE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x3E, 0x7F, 0xE0, 0x7E, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x81, 0xF8, 0x7F, 0x01, 0xF8, 0xFE, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0xFF, 0x3F, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9,
  0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xF0, 0x7F, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xF7,
  0xF8, 0x7F, 0x07, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7C,
  0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0xCF, 0xFC, 0xFF, 0xFF,
  0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0x7E, 0x07, 0xF9, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0xF1, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0,
  0xFC, 0x1F, 0x81, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x3E, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xE0, 0xFC, 0x04, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0x7F, 0xCC, 0x03, 0xF2, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x03, 0xFC, 0x0F,
  0x87, 0xC0, 0x7F, 0xFC, 0x3C, 0x7C, 0x07, 0xFF, 0xC1, 0xE3, 0xE0, 0xFF,
  0xFE, 0x0F, 0x1E, 0x07, 0xC1, 0xF0, 0x79, 0xF0, 0x7C, 0x0F, 0x83, 0xEF,
  0x07, 0xC0, 0x78, 0x1E, 0x78, 0x3E, 0x03, 0xC0, 0xF3, 0xC1, 0xE0, 0x3E,
  0x07, 0xBE, 0x1F, 0x01, 0xE0, 0x3D, 0xF0, 0xF8, 0x0F, 0x03, 0xEF, 0x87,
  0x80, 0xF8, 0x1E, 0x7C, 0x3C, 0x07, 0xC1, 0xF3, 0xE1, 0xF0, 0x7E, 0x0F,
  0x9F, 0x0F, 0x83, 0xF0, 0xF8, 0xF8, 0x7E, 0x7F, 0xDF, 0x83, 0xC1, 0xFF,
  0xBF, 0xF8, 0x1E, 0x0F, 0xF8, 0xFF, 0x80, 0xF8, 0x1F, 0x83, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x83,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3E, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x00, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xF8, 0x07, 0x03, 0xFC, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x0C, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x83, 0xE0, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0,
  0x7C, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x1C, 0x0F,
  0xF0, 0x00, 0x40, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0xFC, 0x03,
  0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0xFC, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x07, 0xF8, 0x03, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xE0, 0xFE, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3E, 0xF8,
  0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3E, 0x78,
  0x03, 0xEF, 0xC0, 0x7C, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x1F, 0x3E,
  0x03, 0xF3, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0xF9, 0xF8, 0x0F, 0x8F,
  0x83, 0xE3, 0xF0, 0x1F, 0x1F, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x1F, 0x0F,
  0x80, 0xFC, 0x7C, 0x3E, 0x3F, 0x01, 0xF0, 0xF8, 0xF8, 0x7E, 0x03, 0xE1,
  0xF1, 0xE0, 0xFC, 0x07, 0xC3, 0xE7, 0xC1, 0xF0, 0x1F, 0x83, 0xCF, 0x03,
  0xE0, 0x3F, 0x07, 0xBE, 0x0F, 0xC0, 0x7C, 0x0F, 0x78, 0x1F, 0x80, 0xF8,
  0x1F, 0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0x80,
  0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x01, 0xFC, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xE0, 0x3F, 0xC0,
  0x03, 0xF0, 0x3F, 0xE0, 0x01, 0xF0, 0x1F, 0xF8, 0x00, 0xF8, 0x0F, 0xFC,
  0x00, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x3E, 0x03, 0xE7,
  0xC0, 0x1F, 0x01, 0xF3, 0xF0, 0x0F, 0x80, 0xF9, 0xF8, 0x0F, 0xC0, 0x7C,
  0x7C, 0x07, 0xE0, 0x3E, 0x3F, 0x03, 0xE0, 0x3F, 0x1F, 0x81, 0xF0, 0x1F,
  0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x7E, 0x07,
  0xE0, 0x7C, 0x3E, 0x03, 0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0x1F, 0x8F, 0x80,
  0xF8, 0x07, 0xCF, 0xC0, 0x7C, 0x03, 0xF7, 0xE0, 0x7E, 0x01, 0xFB, 0xE0,
  0x3F, 0x00, 0x7D, 0xF0, 0x1F, 0x00, 0x3F, 0xF8, 0x0F, 0x80, 0x1F, 0xFC,
  0x07, 0xC0, 0x07, 0xFC, 0x07, 0xE0, 0x03, 0xFE, 0x03, 0xF0, 0x01, 0xFF,
  0x01, 0xF0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xF0,
  0xFC, 0x03, 0xF8, 0x3F, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x1F, 0x81, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF0,
  0x1C, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x80, 0x07, 0xF0, 0xE0, 0x0F, 0xE0, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE3, 0xF0, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x1F, 0xC0,
  0x0F, 0xC7, 0xC0, 0x0F, 0xE0, 0x07, 0xE3, 0xE0, 0x0F, 0xF0, 0x07, 0xE1,
  0xF0, 0x07, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x7C, 0x03,
  0xFE, 0x01, 0xF8, 0x3E, 0x01, 0xEF, 0x00, 0xFC, 0x1F, 0x01, 0xF7, 0xC0,
  0xFC, 0x0F, 0x80, 0xFB, 0xE0, 0x7E, 0x07, 0xC0, 0xF9, 0xF0, 0x7E, 0x03,
  0xE0, 0x7C, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x0F, 0x8F,
  0xC0, 0x1F, 0x1F, 0x87, 0xC7, 0xC0, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0x07,
  0xC7, 0xC1, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x1F, 0x7C,
  0x00, 0x3E, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x79, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E,
  0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x0F, 0x80,
  0x3C, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0xFE, 0x1F, 0x03,
  0xFF, 0x9F, 0x07, 0xFF, 0x9F, 0x0F, 0xFF, 0xFE, 0x0F, 0xF3, 0xFE, 0x1F,
  0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x3F, 0xF0, 0x7F,
  0xFD, 0xF0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xE3, 0xE0, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x07, 0xEF, 0xFC, 0x07,
  0xDF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF0, 0x7B,
  0xFF, 0xE0, 0xF9, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xF1, 0xE1, 0xFC, 0x02, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x10, 0x7F, 0x8F,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0x0F,
  0xFC, 0xFC, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xE0,
  0x7F, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xFC,
  0x07, 0xF1, 0xFF, 0x01, 0xFF, 0xF7, 0xC0, 0x7F, 0xFD, 0xE0, 0x0F, 0xFC,
  0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0x8F, 0xC0, 0x7C, 0xFE, 0x03, 0xE7,
  0xE0, 0x1F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x8F, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x87, 0xF0, 0x3C,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0x98, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0x80, 0xFF, 0xE7, 0xC0, 0xFF, 0xF3, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0x9F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFE,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xE0,
  0xFF, 0x03, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xC0, 0x3F,
  0xF7, 0xE0, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0x00, 0x7F, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE3,
  0xF8, 0x07, 0xEF, 0xFC, 0x07, 0xDF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFC,
  0x7F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF0, 0x00, 0x20, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x01,
  0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC3, 0xF8, 0x0F,
  0xE0, 0x1F, 0x3F, 0xF0, 0xFF, 0xC0, 0x7D, 0xFF, 0xC7, 0xFF, 0x81, 0xEF,
  0xFF, 0xBF, 0xFE, 0x0F, 0xBC, 0xFE, 0xF3, 0xFC, 0x3F, 0xC1, 0xFF, 0x03,
  0xF0, 0xFE, 0x03, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xE0, 0x1F,
  0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0xFC, 0x01,
  0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F,
  0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC3, 0xF8, 0x07, 0xCF,
  0xFC, 0x07, 0xDF, 0xFE, 0x0F, 0xBF, 0xFF, 0x0F, 0xBE, 0xFF, 0x0F, 0xF8,
  0x3F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xF3, 0xF8,
  0x7F, 0x07, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0x7D, 0xF8,
  0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x3F, 0x1F, 0x81, 0xFC, 0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x7C,
  0xFF, 0xC0, 0x1F, 0x7F, 0xF8, 0x07, 0xBF, 0xFE, 0x03, 0xFF, 0x3F, 0x80,
  0xFF, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xF7, 0xFF, 0x80, 0xFC, 0xFF,
  0xC0, 0x3F, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0x03, 0xFF, 0x9F, 0x07, 0xFF,
  0x9F, 0x0F, 0xFF, 0xFE, 0x0F, 0xF3, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFB,
  0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x7C, 0xFE, 0x07, 0xDF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xC0, 0xE1, 0xF8, 0x02, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC8, 0x00, 0xFC, 0xF0, 0x3F, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFD, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x08, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x7C, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0x7E,
  0x0F, 0xF0, 0x7F, 0x3F, 0xF0, 0x7F, 0xFD, 0xF0, 0x7F, 0xF9, 0xF0, 0x3F,
  0xF1, 0xE0, 0x1F, 0xE1, 0xE0, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x00,
  0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF8, 0x3F,
  0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x00,
  0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0x01, 0xFB, 0xE0, 0x3F, 0xC0, 0x7E, 0xF8, 0x0F,
  0xF0, 0x3F, 0x3E, 0x07, 0xBC, 0x0F, 0xCF, 0x81, 0xEF, 0x07, 0xE3, 0xE0,
  0xFB, 0xC1, 0xF8, 0xF8, 0x3C, 0xF0, 0x7C, 0x3E, 0x1F, 0x3C, 0x3F, 0x0F,
  0x87, 0xCF, 0x0F, 0x83, 0xE1, 0xE3, 0xC7, 0xE0, 0xF8, 0xF8, 0xF1, 0xF0,
  0x3E, 0x3C, 0x3C, 0xFC, 0x0F, 0x9F, 0x0F, 0x3E, 0x03, 0xE7, 0x83, 0xCF,
  0x80, 0xFB, 0xE0, 0xF7, 0xE0, 0x3E, 0xF8, 0x3D, 0xF0, 0x07, 0xBC, 0x0F,
  0x7C, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x05, 0xFF,
  0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xE8, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 34, 13, 1, -33 },
  { 57, 16, 12, 20, 5, -33 },
  { 81, 29, 33, 30, 1, -33 },
  { 201, 24, 38, 25, 1, -35 },
  { 315, 34, 33, 38, 3, -33 },
  { 456, 29, 33, 32, 2, -33 },
  { 576, 7, 12, 11, 5, -33 },
  { 587, 16, 40, 15, 2, -33 },
  { 667, 16, 40, 15, -3, -33 },
  { 747, 22, 22, 25, 4, -35 },
  { 808, 22, 22, 26, 3, -27 },
  { 869, 10, 11, 13, -2, -5 },
  { 883, 12, 5, 15, 1, -15 },
  { 891, 7, 8, 13, 1, -7 },
  { 898, 24, 33, 18, -2, -33 },
  { 997, 23, 33, 25, 2, -33 },
  { 1092, 17, 33, 25, 5, -33 },
  { 1163, 26, 33, 25, -1, -33 },
  { 1271, 24, 33, 25, 1, -33 },
  { 1370, 25, 33, 25, 0, -33 },
  { 1474, 24, 33, 25, 1, -33 },
  { 1573, 24, 33, 25, 2, -33 },
  { 1672, 25, 33, 25, 2, -33 },
  { 1776, 23, 33, 25, 2, -33 },
  { 1871, 22, 33, 25, 2, -33 },
  { 1962, 11, 26, 13, 1, -25 },
  { 1998, 14, 31, 13, -2, -25 },
  { 2053, 22, 23, 26, 3, -28 },
  { 2117, 22, 13, 26, 3, -23 },
  { 2153, 22, 23, 26, 3, -28 },
  { 2217, 18, 34, 21, 4, -33 },
  { 2294, 37, 37, 39, 2, -33 },
  { 2466, 28, 33, 28, -3, -33 },
  { 2582, 27, 33, 28, 1, -33 },
  { 2694, 27, 33, 28, 3, -33 },
  { 2806, 29, 33, 31, 1, -33 },
  { 2926, 25, 33, 24, 1, -33 },
  { 3030, 25, 33, 24, 1, -33 },
  { 3134, 28, 33, 32, 3, -33 },
  { 3250, 31, 33, 32, 1, -33 },
  { 3378, 20, 33, 17, -1, -33 },
  { 3461, 22, 42, 14, -7, -33 },
  { 3577, 31, 33, 27, 1, -33 },
  { 3705, 19, 33, 23, 1, -33 },
  { 3784, 39, 33, 40, 1, -33 },
  { 3945, 33, 33, 34, 1, -33 },
  { 4082, 29, 33, 33, 3, -33 },
  { 4202, 26, 33, 27, 1, -33 },
  { 4310, 29, 41, 33, 3, -33 },
  { 4459, 26, 33, 28, 1, -33 },
  { 4567, 24, 33, 24, 1, -33 },
  { 4666, 24, 33, 24, 4, -33 },
  { 4765, 29, 33, 32, 3, -33 },
  { 4885, 27, 33, 27, 4, -33 },
  { 4997, 41, 33, 40, 4, -33 },
  { 5167, 33, 33, 27, -3, -33 },
  { 5304, 25, 33, 25, 4, -33 },
  { 5408, 28, 33, 25, -1, -33 },
  { 5524, 19, 40, 15, -1, -33 },
  { 5619, 10, 33, 18, 5, -33 },
  { 5661, 18, 40, 15, -3, -33 },
  { 5751, 23, 21, 26, 1, -33 },
  { 5812, 19, 3, 18, -4, 4 },
  { 5820, 9, 7, 14, 7, -35 },
  { 5828, 24, 25, 27, 2, -25 },
  { 5903, 24, 35, 27, 1, -35 },
  { 6008, 20, 25, 22, 2, -25 },
  { 6071, 26, 35, 27, 2, -35 },
  { 6185, 21, 25, 25, 2, -25 },
  { 6251, 27, 46, 16, -5, -35 },
  { 6407, 25, 36, 27, 1, -25 },
  { 6520, 24, 35, 27, 1, -35 },
  { 6625, 13, 35, 13, 1, -35 },
  { 6682, 20, 46, 13, -6, -35 },
  { 6797, 26, 35, 25, 1, -35 },
  { 6911, 13, 35, 13, 1, -35 },
  { 6968, 38, 25, 41, 1, -25 },
  { 7087, 24, 25, 27, 1, -25 },
  { 7162, 22, 25, 27, 2, -25 },
  { 7231, 26, 36, 27, -1, -25 },
  { 7348, 24, 36, 27, 2, -25 },
  { 7456, 20, 25, 19, 1, -25 },
  { 7519, 20, 25, 21, 0, -25 },
  { 7582, 17, 30, 18, 2, -30 },
  { 7646, 24, 25, 27, 2, -25 },
  { 7721, 23, 25, 23, 2, -25 },
  { 7793, 34, 25, 35, 3, -25 },
  { 7900, 28, 25, 24, -2, -25 },
  { 7988, 29, 36, 23, -4, -25 },
  { 8119, 22, 25, 21, -1, -25 },
  { 8188, 19, 40, 16, 0, -33 },
  { 8283, 4, 46, 25, 11, -35 },
  { 8306, 18, 40, 16, -2, -33 },
  { 8396, 22, 7, 26, 3, -20 },
};

const GFXfont NotoSans_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMIBOLDITALIC46PT7B_H_
