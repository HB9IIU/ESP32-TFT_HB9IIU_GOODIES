#ifndef _NOTOSANS_SEMIBOLDITALIC21PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC4, 0x00, 0x63, 0xCE,
  0x00, 0x66, 0xCD, 0xBE, 0x6C, 0xC0, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x01,
  0x98, 0x3F, 0xFC, 0xFF, 0xF0, 0xC6, 0x03, 0x30, 0x0C, 0xC1, 0xFF, 0xEF,
  0xFF, 0x06, 0x60, 0x11, 0x80, 0xC4, 0x03, 0x30, 0x00, 0x03, 0x00, 0x81,
  0xFC, 0xFF, 0x76, 0x5D, 0x87, 0x40, 0xF0, 0x1F, 0x03, 0xE0, 0x98, 0x26,
  0x8B, 0xBF, 0xCF, 0xE0, 0x40, 0x10, 0x00, 0x3E, 0x0E, 0x3E, 0x1C, 0x66,
  0x18, 0x66, 0x30, 0xE6, 0x60, 0xE6, 0xE0, 0xEE, 0xDE, 0x7D, 0xBE, 0x7B,
  0x73, 0x07, 0x63, 0x06, 0x67, 0x0C, 0x66, 0x18, 0x66, 0x38, 0x7C, 0x70,
  0x3C, 0x0F, 0x80, 0xFE, 0x06, 0x30, 0x31, 0x81, 0x9C, 0x0D, 0xC0, 0x7C,
  0x07, 0xC3, 0x77, 0x3F, 0x39, 0xB0, 0xFD, 0x83, 0xCE, 0x3C, 0x7F, 0xF1,
  0xF9, 0xC0, 0x6D, 0xEC, 0x0E, 0x18, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xE1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC0, 0x0E, 0x06, 0x06, 0x07,
  0x07, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x30, 0xF0, 0x06, 0x01, 0x84, 0xC3, 0xF0, 0x7F, 0xC7, 0xF3, 0x41, 0xD8,
  0x66, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3B, 0x98, 0xCC, 0x00, 0x7D, 0xFF, 0xC0,
  0x6F, 0xE0, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x00, 0x0F,
  0x87, 0xF3, 0x9D, 0xC3, 0x70, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1B, 0x8E, 0xE7, 0x1F, 0xC7, 0xC0, 0x07, 0x1F, 0x3E, 0xF6, 0x6E, 0x0E,
  0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x0F, 0xC7, 0xFC,
  0x63, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xC7, 0xFC, 0x63, 0x80, 0x30,
  0x0E, 0x01, 0xC3, 0xE0, 0xF8, 0x03, 0xC0, 0x38, 0x03, 0x00, 0xE8, 0x3D,
  0xFF, 0x3F, 0xC0, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x6C, 0x19, 0x86,
  0x71, 0xCE, 0x71, 0x9C, 0x33, 0xFF, 0xFF, 0xF0, 0x38, 0x06, 0x01, 0xC0,
  0x0F, 0xE1, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0F, 0xE1, 0xFE, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0xEC, 0x3D, 0xFF, 0x1F, 0xC0, 0x07, 0xE1, 0xF8,
  0x70, 0x1C, 0x07, 0x00, 0xCC, 0x1B, 0xE7, 0xDC, 0xE1, 0xDC, 0x3B, 0x87,
  0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x0F, 0x8F, 0xF3, 0x8C, 0xC3, 0x30, 0xCE, 0x71, 0xF8,
  0xFC, 0x73, 0xB8, 0xEC, 0x1B, 0x06, 0xE3, 0xBF, 0xE7, 0xE0, 0x1F, 0x0F,
  0xE7, 0x1D, 0xC7, 0x61, 0xF8, 0x76, 0x1D, 0xDF, 0x7F, 0xC6, 0x60, 0x38,
  0x0C, 0x07, 0x3F, 0x8F, 0xC0, 0x19, 0xCE, 0x20, 0x00, 0x00, 0x03, 0x3D,
  0xC0, 0x0C, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x23, 0x1C, 0x63, 0x8C,
  0x00, 0x00, 0x40, 0x70, 0x7C, 0x78, 0x78, 0x38, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x7C, 0x7C, 0x78, 0x38, 0x08,
  0x00, 0x7E, 0xFF, 0x47, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0x00,
  0x00, 0xE0, 0xE0, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x07, 0x01, 0x87, 0x00,
  0x67, 0x1F, 0xB3, 0x1F, 0x8D, 0x98, 0xC7, 0x9C, 0x63, 0xCC, 0x73, 0x66,
  0x31, 0xB3, 0x19, 0xD9, 0xF7, 0xCE, 0x73, 0x83, 0x00, 0x01, 0xC0, 0x40,
  0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x07,
  0x60, 0x66, 0x0E, 0x70, 0xC7, 0x1C, 0x71, 0xFF, 0x3F, 0xF3, 0x03, 0x70,
  0x36, 0x03, 0xE0, 0x30, 0x1F, 0xC1, 0xFE, 0x38, 0xF3, 0x87, 0x38, 0x73,
  0x0E, 0x7F, 0xC7, 0xF8, 0x71, 0xC6, 0x0E, 0x60, 0xEE, 0x0E, 0xE3, 0xCF,
  0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0x04, 0x70, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x84,
  0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFE, 0x38, 0xF3, 0x87, 0x38, 0x33,
  0x03, 0x70, 0x37, 0x03, 0x70, 0x77, 0x07, 0x60, 0xFE, 0x0E, 0xE3, 0xCF,
  0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1F,
  0xE3, 0xFC, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFC, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0xFC, 0x7F,
  0x8E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0x07, 0xF8, 0x7F,
  0xC7, 0x84, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x3E, 0xE1, 0xF7,
  0x03, 0xB8, 0x1C, 0xE0, 0xC7, 0x8E, 0x1F, 0xF0, 0x7F, 0x00, 0x1C, 0x1C,
  0x60, 0x63, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xC7, 0xFF, 0x1F, 0xFC,
  0x70, 0x71, 0xC1, 0xC6, 0x06, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x8C, 0x0E,
  0x00, 0x0F, 0xC7, 0xE0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x1F, 0x8F, 0xE0, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x1C, 0x3E, 0x0F, 0x00, 0x18, 0x38, 0xC3, 0x8E,
  0x38, 0x73, 0x83, 0xB8, 0x1B, 0x81, 0xDC, 0x0F, 0xC0, 0x7F, 0x03, 0x38,
  0x18, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0xE3, 0x07, 0x00, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xFF, 0xFF,
  0x1C, 0x07, 0x8F, 0x03, 0xCF, 0x83, 0xE6, 0xC1, 0xF3, 0x61, 0xB1, 0xB0,
  0xD9, 0xD8, 0xDC, 0xEC, 0x6E, 0x66, 0x66, 0x33, 0x33, 0x19, 0xB1, 0x9C,
  0xF9, 0xCE, 0x78, 0xE6, 0x3C, 0x63, 0x1C, 0x30, 0x1C, 0x0E, 0x38, 0x18,
  0xF8, 0x31, 0xB0, 0xE3, 0x61, 0xC6, 0xE3, 0x1C, 0xC6, 0x39, 0x8C, 0x63,
  0xB8, 0xC3, 0x71, 0x86, 0xC7, 0x0F, 0x8E, 0x0F, 0x18, 0x1E, 0x30, 0x3C,
  0x00, 0x07, 0xE0, 0x7F, 0xC1, 0xC3, 0x8E, 0x0E, 0x70, 0x1D, 0xC0, 0x76,
  0x01, 0xF8, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x9C, 0x1C, 0x78, 0xF0,
  0xFF, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xFE, 0x38, 0xE3, 0x86, 0x38, 0x73,
  0x06, 0x70, 0xE7, 0xFC, 0x7F, 0x86, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0xC1, 0xC3, 0x8E, 0x0E, 0x70, 0x1D,
  0xC0, 0x76, 0x01, 0xF8, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x9C, 0x1C,
  0x78, 0xE0, 0xFF, 0x81, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1F, 0x83, 0xFC, 0xE3, 0x9C, 0x33, 0x86, 0x61, 0xDC, 0x7B, 0xFE,
  0x7F, 0x0E, 0x61, 0x8E, 0x71, 0xCE, 0x19, 0xC3, 0xB0, 0x70, 0x0F, 0xE3,
  0xFC, 0x71, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xEC, 0x39, 0xFF, 0x1F, 0x80, 0xFF, 0xFF, 0xF8, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0x30, 0x3B, 0x81, 0x9C, 0x1C, 0xE0, 0xE6, 0x07,
  0x30, 0x33, 0x81, 0x9C, 0x1C, 0xE0, 0xE6, 0x07, 0x30, 0x31, 0x83, 0x8E,
  0x3C, 0x7F, 0xC1, 0xFC, 0x00, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1,
  0xCE, 0x38, 0x63, 0x86, 0x70, 0x67, 0x06, 0xE0, 0x6E, 0x06, 0xC0, 0x7C,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1B, 0x8F,
  0x8E, 0xE3, 0xE3, 0x39, 0xF9, 0xCE, 0x6E, 0x63, 0x9B, 0xB8, 0xEC, 0x6E,
  0x3B, 0x1B, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x1C, 0x07,
  0x07, 0x00, 0x1C, 0x1E, 0x1C, 0x38, 0x38, 0xE0, 0x33, 0x80, 0x7E, 0x00,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x73, 0x01, 0xC7,
  0x03, 0x8E, 0x0E, 0x0C, 0x38, 0x1C, 0x00, 0xE0, 0xFC, 0x39, 0x87, 0x31,
  0xC7, 0x70, 0xEE, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xF1, 0xFF, 0x20, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F,
  0xFC, 0xFF, 0x80, 0x1F, 0x1F, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xF8, 0xF0, 0xE3, 0x18, 0xC6,
  0x31, 0xCE, 0x31, 0x8C, 0x63, 0x1C, 0xE0, 0x1F, 0x1F, 0x06, 0x06, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0xF0,
  0xF0, 0x06, 0x03, 0x80, 0xE0, 0x6C, 0x3B, 0x0C, 0x66, 0x19, 0x86, 0xC0,
  0xF0, 0x30, 0xFF, 0x80, 0xE6, 0x30, 0x0C, 0x03, 0xEC, 0xFF, 0xB8, 0xE6,
  0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9C, 0xF3, 0xF6, 0x3D, 0xC0, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0x98, 0x37, 0xCF, 0xF9, 0xC3, 0x38, 0x66,
  0x0C, 0xC1, 0xB8, 0x77, 0x0E, 0xE3, 0x9F, 0xE7, 0x78, 0x06, 0x0F, 0xCF,
  0xEE, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x9F, 0x87, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x0C, 0xE1, 0xFE, 0x3F, 0xE7, 0x1C, 0x61,
  0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E, 0x78, 0xFD, 0x87, 0xB8, 0x06,
  0x07, 0xE3, 0x9D, 0xC7, 0x61, 0xBF, 0xEF, 0xF3, 0x80, 0xE0, 0x38, 0x47,
  0xF0, 0xFC, 0x01, 0xF0, 0x3E, 0x03, 0x80, 0x30, 0x07, 0x01, 0xFC, 0x1F,
  0xC0, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0xFB, 0x1F, 0xF3, 0x8E, 0x30, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x71, 0xC7,
  0x3C, 0x7F, 0xC3, 0xDC, 0x01, 0x80, 0x38, 0x83, 0x8F, 0xF0, 0x7E, 0x00,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x88, 0x37, 0xCF, 0xF9, 0xE3, 0x38,
  0x67, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE1, 0x98, 0x77, 0x0E, 0x0C, 0x70,
  0xC0, 0x04, 0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC6, 0x38, 0x01, 0x81,
  0xC0, 0x60, 0x00, 0x08, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x1F, 0x0F, 0x00, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x11, 0x8E, 0x39, 0xC3, 0xB8, 0x3F, 0x03,
  0x60, 0x3F, 0x07, 0xF0, 0x73, 0x87, 0x38, 0x61, 0x8E, 0x1C, 0x0C, 0x31,
  0xC7, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC6, 0x38, 0x00, 0x83,
  0x06, 0xFB, 0xE3, 0xFF, 0xFC, 0xF1, 0xC7, 0x38, 0x61, 0xCE, 0x38, 0x63,
  0x0E, 0x19, 0xC3, 0x0E, 0x70, 0xC3, 0x9C, 0x70, 0xE6, 0x1C, 0x33, 0x87,
  0x1C, 0x00, 0x83, 0x7C, 0xFF, 0x9E, 0x33, 0x86, 0x71, 0xCC, 0x3B, 0x87,
  0x70, 0xEE, 0x19, 0x87, 0x70, 0xE0, 0x06, 0x07, 0xE3, 0xFD, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xB8, 0xE7, 0xF0, 0xF8, 0x00, 0xC0, 0xDF,
  0x1F, 0xF1, 0xC3, 0x1C, 0x31, 0x83, 0x18, 0x33, 0x87, 0x38, 0x73, 0x8E,
  0x3F, 0xC3, 0x78, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x0C,
  0x03, 0xEC, 0xFF, 0xB8, 0xE6, 0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9C,
  0x73, 0xFE, 0x3D, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x01,
  0x8D, 0xCF, 0xE7, 0x83, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C,
  0x00, 0x0E, 0x1F, 0xCE, 0x6E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x43,
  0xBF, 0xDF, 0xC0, 0x18, 0x30, 0xE7, 0xFF, 0xEE, 0x1C, 0x38, 0x60, 0xC3,
  0x87, 0x0F, 0x8F, 0x00, 0x30, 0xEE, 0x1D, 0xC3, 0x38, 0x66, 0x1C, 0xC3,
  0xB8, 0x77, 0x1C, 0xE7, 0x9F, 0xB1, 0xE6, 0x00, 0xE1, 0xFC, 0x3B, 0x8E,
  0x71, 0x86, 0x70, 0xCC, 0x1B, 0x83, 0x60, 0x7C, 0x0F, 0x01, 0xE0, 0x00,
  0xE3, 0x87, 0xE3, 0x8E, 0xE6, 0xCE, 0xE6, 0xCC, 0xEE, 0xDC, 0x6C, 0xD8,
  0x6C, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0x1C, 0x78,
  0xE7, 0x03, 0x70, 0x1F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xF0, 0x39,
  0x83, 0x8E, 0x3C, 0x70, 0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x03, 0x18, 0x0C,
  0xE0, 0x33, 0x00, 0xDC, 0x03, 0x60, 0x0F, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x0F, 0x80, 0x3C, 0x00, 0x3F, 0xCF, 0xE0, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x3F, 0xCF, 0xF0, 0x03, 0x83,
  0x83, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0xF0, 0x78, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1C, 0x1E, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x07, 0x07, 0x1E,
  0x18, 0x18, 0x18, 0x38, 0x30, 0xF0, 0xE0, 0x78, 0x7F, 0xF8, 0x7C,
};

const GFXglyph NotoSans_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 6, 0, -15 },
  { 13, 7, 5, 9, 2, -15 },
  { 18, 14, 15, 14, 0, -15 },
  { 45, 10, 17, 12, 1, -16 },
  { 67, 16, 15, 18, 1, -15 },
  { 97, 13, 15, 15, 1, -15 },
  { 122, 3, 5, 5, 2, -15 },
  { 124, 7, 18, 7, 1, -15 },
  { 140, 8, 18, 7, -2, -15 },
  { 158, 10, 10, 12, 2, -16 },
  { 171, 10, 11, 12, 1, -13 },
  { 185, 5, 5, 6, -1, -2 },
  { 189, 6, 3, 7, 0, -7 },
  { 192, 4, 3, 6, 0, -3 },
  { 194, 11, 15, 8, -1, -15 },
  { 215, 10, 15, 12, 1, -15 },
  { 234, 8, 15, 12, 2, -15 },
  { 249, 11, 15, 12, 0, -15 },
  { 270, 11, 15, 12, 0, -15 },
  { 291, 11, 15, 12, 0, -15 },
  { 312, 11, 15, 12, 0, -15 },
  { 333, 11, 15, 12, 1, -15 },
  { 354, 11, 15, 12, 1, -15 },
  { 375, 10, 15, 12, 1, -15 },
  { 394, 10, 15, 12, 1, -15 },
  { 413, 5, 12, 6, 0, -12 },
  { 421, 6, 15, 6, -1, -12 },
  { 433, 10, 11, 12, 1, -13 },
  { 447, 10, 6, 12, 1, -10 },
  { 455, 10, 11, 12, 1, -13 },
  { 469, 8, 15, 9, 2, -15 },
  { 484, 17, 17, 18, 1, -15 },
  { 521, 12, 15, 13, -1, -15 },
  { 544, 12, 15, 13, 1, -15 },
  { 567, 13, 15, 13, 1, -15 },
  { 592, 12, 15, 14, 1, -15 },
  { 615, 11, 15, 11, 1, -15 },
  { 636, 11, 15, 11, 1, -15 },
  { 657, 13, 15, 14, 1, -15 },
  { 682, 14, 15, 15, 1, -15 },
  { 709, 10, 15, 8, -1, -15 },
  { 728, 10, 19, 7, -3, -15 },
  { 752, 13, 15, 12, 1, -15 },
  { 777, 8, 15, 11, 1, -15 },
  { 792, 17, 15, 18, 1, -15 },
  { 824, 15, 15, 16, 1, -15 },
  { 853, 14, 15, 15, 1, -15 },
  { 880, 12, 15, 12, 1, -15 },
  { 903, 14, 19, 15, 1, -15 },
  { 937, 11, 15, 13, 1, -15 },
  { 958, 11, 15, 11, 0, -15 },
  { 979, 11, 15, 11, 2, -15 },
  { 1000, 13, 15, 14, 2, -15 },
  { 1025, 12, 15, 12, 2, -15 },
  { 1048, 18, 15, 18, 2, -15 },
  { 1082, 15, 15, 12, -1, -15 },
  { 1111, 11, 15, 11, 2, -15 },
  { 1132, 12, 15, 11, 0, -15 },
  { 1155, 8, 18, 7, 0, -15 },
  { 1173, 5, 15, 8, 2, -15 },
  { 1183, 8, 18, 7, -1, -15 },
  { 1201, 10, 10, 12, 1, -15 },
  { 1214, 9, 1, 8, -2, 2 },
  { 1216, 4, 3, 6, 3, -16 },
  { 1218, 11, 12, 12, 1, -12 },
  { 1235, 11, 16, 12, 0, -16 },
  { 1257, 9, 12, 10, 1, -12 },
  { 1271, 12, 16, 12, 1, -16 },
  { 1295, 10, 12, 11, 1, -12 },
  { 1310, 12, 21, 7, -2, -16 },
  { 1342, 12, 17, 12, 0, -12 },
  { 1368, 11, 16, 13, 0, -16 },
  { 1390, 6, 16, 6, 0, -16 },
  { 1402, 9, 21, 6, -3, -16 },
  { 1426, 12, 16, 11, 0, -16 },
  { 1450, 6, 16, 6, 0, -16 },
  { 1462, 18, 12, 19, 0, -12 },
  { 1489, 11, 12, 13, 0, -12 },
  { 1506, 10, 12, 12, 1, -12 },
  { 1521, 12, 17, 12, -1, -12 },
  { 1547, 11, 17, 12, 1, -12 },
  { 1571, 9, 12, 9, 0, -12 },
  { 1585, 9, 12, 10, 0, -12 },
  { 1599, 7, 14, 8, 1, -14 },
  { 1612, 11, 11, 13, 1, -11 },
  { 1628, 11, 11, 10, 1, -11 },
  { 1644, 16, 11, 16, 1, -11 },
  { 1666, 13, 11, 11, -1, -11 },
  { 1684, 14, 16, 10, -2, -11 },
  { 1712, 10, 11, 10, 0, -11 },
  { 1726, 9, 18, 7, 0, -15 },
  { 1747, 2, 21, 12, 5, -16 },
  { 1753, 8, 18, 7, -1, -15 },
  { 1771, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMIBOLDITALIC21PT7B_H_
