#ifndef _NOTOSANS_SEMIBOLDITALIC50PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0x38, 0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0x87,
  0xEF, 0xC3, 0xE7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3C, 0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFE, 0xF3, 0xC0, 0x7E, 0x38, 0x10, 0x1F, 0x8E,
  0x00, 0x0F, 0xC3, 0x80, 0x03, 0xF1, 0xE0, 0x00, 0xFE, 0x78, 0x00, 0x1F,
  0x9C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1C, 0x7E, 0x00, 0x07, 0x1F, 0xC0, 0x01,
  0xC7, 0xE0, 0x00, 0xF1, 0xF8, 0x80, 0x3C, 0x7E, 0x38, 0x0E, 0x3F, 0x8F,
  0xE3, 0xBF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xC0,
  0x03, 0xE0, 0x3F, 0xFE, 0x00, 0x3E, 0x01, 0xF9, 0xF0, 0x03, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0xC1, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0xF8, 0x00,
  0x7C, 0x0F, 0x8F, 0x80, 0x03, 0xE0, 0xFC, 0x7C, 0x7E, 0x1F, 0x07, 0xC7,
  0xCF, 0xFC, 0xFC, 0x7E, 0x7C, 0xFF, 0xE3, 0xE7, 0xE7, 0xCF, 0xFF, 0x9F,
  0xFF, 0x3E, 0x7F, 0xFC, 0xFF, 0xF3, 0xE7, 0xE3, 0xF3, 0xFF, 0x3E, 0x3E,
  0x0F, 0x8F, 0xE3, 0xF3, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x0F,
  0x80, 0x0F, 0x83, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x3E, 0x1F, 0x80,
  0x7C, 0x01, 0xF8, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x3F,
  0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0xC0, 0x7E, 0x3F, 0xDF, 0xC0, 0xFE, 0x7F,
  0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0xFC,
  0x03, 0xFB, 0xF0, 0xFC, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0xFC,
  0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x03, 0xFC, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x0C, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7F, 0x1E, 0x00, 0xFF, 0xBC, 0x01,
  0xFF, 0xF8, 0xFC, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x7F, 0xBF, 0xC1, 0xFF, 0x80, 0x07, 0xEF, 0x00, 0x1F, 0x9F, 0x00, 0x7F,
  0x3E, 0x01, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xC0, 0xFC, 0x01, 0x81,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x00,
  0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7,
  0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x01,
  0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00,
  0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xDF, 0x8F, 0xE7, 0xF0, 0xF8, 0xFC, 0x1C,
  0x1F, 0x81, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xF0, 0x0F, 0xE0,
  0x06, 0x00, 0x7F, 0x00, 0x40, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x1F,
  0xE0, 0x18, 0x01, 0xFC, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x20, 0x00, 0x7F, 0x0E, 0x00, 0x7F, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x10, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x20, 0x00, 0x7F, 0x0F, 0x00, 0x7F,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xF0, 0x08, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x7C, 0x01, 0xF9, 0xFF, 0x80, 0xFD, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F,
  0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07,
  0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC,
  0x03, 0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xE3,
  0xF8, 0x07, 0xF0, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x80,
  0xFF, 0x3F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0x7E, 0x07, 0xFE, 0x7E, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xE0, 0xFF, 0x30, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0xE0, 0x3E, 0x1F, 0x80, 0x7F, 0xFC, 0x1E, 0x1F,
  0x01, 0xFF, 0xFC, 0x1F, 0x3F, 0x03, 0xFF, 0xFC, 0x1F, 0x3E, 0x07, 0xF0,
  0x78, 0x1F, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0x7C, 0x3E,
  0x01, 0xF0, 0x1E, 0x78, 0x3E, 0x01, 0xF0, 0x3E, 0xF8, 0x3E, 0x01, 0xF0,
  0x3E, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8,
  0x3E, 0x07, 0xE0, 0x7C, 0xF8, 0x3E, 0x0F, 0xE0, 0xF8, 0x78, 0x3F, 0x1F,
  0xF3, 0xF8, 0x7C, 0x1F, 0xFD, 0xFF, 0xF0, 0x7C, 0x1F, 0xFC, 0xFF, 0xE0,
  0x7C, 0x0F, 0xF8, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x81, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x7F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x83,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF8,
  0x7E, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xC1, 0xF8, 0x1F, 0xF0, 0x01, 0x80, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0x00, 0xFF, 0x80,
  0x78, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x3F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x7F,
  0xC1, 0xF8, 0x03, 0xFE, 0x07, 0xE1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x20, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x00, 0xFF, 0x80, 0x0E,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xC7, 0xF0,
  0x0F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x1F, 0xC0, 0x3F, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0xC3, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x03,
  0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07,
  0xE0, 0xFF, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xE7, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0xC0, 0x7F, 0xF0,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0xF8, 0x07, 0xC7, 0xE0,
  0x3F, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x07, 0xE3,
  0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x1F, 0x0F, 0xC0, 0x7E, 0x3E, 0x0F,
  0xC3, 0xE0, 0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0x07, 0xC3, 0xE1, 0xF8, 0x7E,
  0x03, 0xF0, 0xF8, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xCF, 0x83, 0xF0, 0x0F, 0xC1, 0xF7, 0xE0, 0xFC, 0x03, 0xE0, 0x7D,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xFE, 0x03,
  0xF0, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x00, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0x81, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xF0, 0x00, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0xFC, 0x00,
  0x7E, 0x07, 0xFF, 0x80, 0x0F, 0x80, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0x3F,
  0x00, 0x7E, 0x03, 0xE7, 0xE0, 0x0F, 0xC0, 0x7C, 0xFC, 0x01, 0xF8, 0x1F,
  0x8F, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xF8,
  0x0F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE1,
  0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x01,
  0xF8, 0xFC, 0x0F, 0xC0, 0x3F, 0x1F, 0x81, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x00, 0x7E, 0xFC, 0x07, 0xE0, 0x0F, 0xDF, 0x80, 0xF8, 0x01, 0xFB, 0xF0,
  0x3F, 0x00, 0x1F, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0x80, 0x07, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFC,
  0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFE, 0x0F, 0xC1, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xC0,
  0x7F, 0x00, 0x30, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x30, 0x00, 0xFE, 0x0F, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE3,
  0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xEF, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x8F, 0xC0,
  0x1F, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x0F, 0xC0, 0x3F,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0xF8,
  0x0F, 0xE0, 0xFC, 0x07, 0xEF, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xCF, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0xF8, 0x1F, 0x80,
  0xFC, 0x1F, 0x8F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x00, 0xFC,
  0x3F, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x00, 0x7C, 0x7E,
  0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x0F,
  0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x0F, 0x9F,
  0x80, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x00, 0x7D, 0xF0, 0x0F, 0xBF, 0x00,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F,
  0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0x7D,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x7C, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E,
  0x0F, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE1, 0xF0, 0x1F,
  0xFC, 0x7C, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE,
  0xF8, 0x0F, 0xFF, 0x3E, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xC3, 0xE0, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x06, 0x00, 0x0F, 0xC7, 0xF8, 0x07, 0xF7, 0xFF, 0x01, 0xFB, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xC3, 0xFC,
  0x07, 0xF0, 0xFF, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0x7F,
  0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xDF, 0xFF, 0x81, 0xF7, 0xFF, 0xC0,
  0xF8, 0xFF, 0xE0, 0x3E, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFE, 0x01, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x0C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x03, 0xF0, 0x00, 0xFF,
  0x1F, 0x80, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xBF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80,
  0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFD, 0xF0, 0x01, 0xFF, 0x8F, 0x80, 0x07, 0xF8, 0x7C, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F,
  0x8F, 0xE0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xFB,
  0xF8, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x0C, 0x3F, 0xF1,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x8F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xF8, 0x7C, 0x03, 0xFF, 0x8F, 0x80, 0xFF, 0xFB,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xDF, 0x80, 0x3F, 0xF3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x10, 0x00, 0xFE, 0x03, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x03, 0x00, 0x0F, 0xC7, 0xF8, 0x07, 0xF7, 0xFF, 0x01, 0xFB, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xC3, 0xFE, 0x03,
  0xF0, 0xFF, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x08, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x0F, 0xF0, 0x07, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFE, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xF0, 0xFF, 0x01, 0xFE, 0x01, 0xF9, 0xFF, 0xC1, 0xFF,
  0x80, 0xF9, 0xFF, 0xE3, 0xFF, 0xE0, 0x7D, 0xFF, 0xF9, 0xFF, 0xF8, 0x3E,
  0xFF, 0xFD, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFE, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xF0, 0x0F,
  0xC3, 0xF8, 0x07, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x07, 0xF1, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xF8, 0x7F, 0x80, 0x7E, 0x7F, 0xF0, 0x1F, 0xBF, 0xFE, 0x07, 0xDF,
  0xFF, 0xC1, 0xF7, 0xFF, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F, 0xE0, 0x3F, 0x0F,
  0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFB,
  0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x0F, 0x87, 0xF8, 0x01, 0xF9, 0xFF, 0xC0, 0x1F, 0x3F, 0xFE, 0x01, 0xF7,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F,
  0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFB, 0xFF, 0xC0, 0x3F, 0x3F, 0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x3F, 0x01,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE1, 0xF0, 0x1F,
  0xFC, 0x7C, 0x0F, 0xFF, 0x9F, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0x7E, 0x01, 0xFF, 0x9F, 0x80, 0x3F, 0xC7, 0xE0, 0x01,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x0F, 0xC1, 0xF9, 0xFE, 0x0F, 0xDF,
  0xF0, 0x7E, 0xFF, 0x83, 0xEF, 0xF8, 0x1F, 0xFC, 0x41, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0x83, 0xE0, 0xFC, 0x01, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE2, 0x00, 0x1F, 0x8E, 0x00, 0xFE, 0x3F, 0x1F, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0xC3, 0xF0, 0x0F, 0xF0, 0xFC, 0x07,
  0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xE0, 0x7F,
  0xF9, 0xF0, 0x1F, 0xFC, 0x7C, 0x01, 0xFE, 0x1F, 0x00, 0x08, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F,
  0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xDF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0xC0, 0x3F, 0x3F, 0x01, 0xFF, 0x01, 0xFC, 0xFC, 0x07, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0xF0, 0x1F, 0x8F, 0xC0, 0xFF, 0xC0, 0xFC, 0x3F, 0x03,
  0xDF, 0x03, 0xF0, 0xFC, 0x1F, 0x7C, 0x1F, 0x83, 0xF0, 0x7D, 0xF0, 0x7E,
  0x0F, 0xC3, 0xE7, 0xC3, 0xF8, 0x3F, 0x0F, 0x9F, 0x0F, 0xC0, 0x7C, 0x7E,
  0x7C, 0x7F, 0x01, 0xF1, 0xF1, 0xF1, 0xF8, 0x07, 0xC7, 0xC7, 0xC7, 0xE0,
  0x1F, 0x3E, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x7C, 0xFC, 0x01, 0xF7, 0xC1,
  0xF3, 0xE0, 0x07, 0xDF, 0x07, 0xDF, 0x80, 0x1F, 0x78, 0x1F, 0x7C, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE, 0x7E,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x7C, 0x7F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0xFE, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 37, 14, 1, -36 },
  { 66, 17, 13, 22, 5, -36 },
  { 94, 32, 36, 32, 1, -36 },
  { 238, 26, 41, 28, 1, -38 },
  { 372, 37, 36, 42, 3, -36 },
  { 539, 32, 37, 35, 2, -36 },
  { 687, 8, 13, 12, 5, -36 },
  { 700, 18, 44, 16, 2, -36 },
  { 799, 18, 44, 16, -4, -36 },
  { 898, 23, 24, 27, 5, -38 },
  { 967, 24, 24, 29, 3, -30 },
  { 1039, 11, 12, 14, -2, -6 },
  { 1056, 14, 5, 16, 1, -16 },
  { 1065, 7, 8, 14, 1, -7 },
  { 1072, 26, 36, 20, -2, -36 },
  { 1189, 25, 37, 28, 2, -36 },
  { 1305, 19, 36, 28, 5, -36 },
  { 1391, 28, 36, 28, -1, -36 },
  { 1517, 26, 37, 28, 1, -36 },
  { 1638, 27, 36, 28, 0, -36 },
  { 1760, 26, 37, 28, 1, -36 },
  { 1881, 25, 37, 28, 3, -36 },
  { 1997, 26, 36, 28, 3, -36 },
  { 2114, 25, 37, 28, 2, -36 },
  { 2230, 24, 37, 28, 2, -36 },
  { 2341, 12, 29, 14, 1, -28 },
  { 2385, 16, 34, 14, -3, -28 },
  { 2453, 24, 26, 29, 3, -31 },
  { 2531, 24, 15, 29, 3, -25 },
  { 2576, 24, 26, 29, 3, -31 },
  { 2654, 20, 37, 22, 4, -36 },
  { 2747, 40, 41, 43, 2, -36 },
  { 2952, 30, 36, 30, -3, -36 },
  { 3087, 28, 36, 31, 2, -36 },
  { 3213, 29, 37, 30, 3, -36 },
  { 3348, 30, 36, 34, 2, -36 },
  { 3483, 26, 36, 27, 2, -36 },
  { 3600, 26, 36, 26, 2, -36 },
  { 3717, 31, 37, 34, 3, -36 },
  { 3861, 33, 36, 35, 2, -36 },
  { 4010, 22, 36, 18, -1, -36 },
  { 4109, 24, 46, 16, -8, -36 },
  { 4247, 32, 36, 30, 2, -36 },
  { 4391, 20, 36, 25, 2, -36 },
  { 4481, 42, 36, 43, 2, -36 },
  { 4670, 35, 36, 37, 2, -36 },
  { 4828, 32, 37, 36, 3, -36 },
  { 4976, 28, 36, 30, 2, -36 },
  { 5102, 32, 45, 36, 3, -36 },
  { 5282, 27, 36, 30, 2, -36 },
  { 5404, 26, 37, 26, 1, -36 },
  { 5525, 26, 36, 26, 4, -36 },
  { 5642, 31, 37, 34, 4, -36 },
  { 5786, 28, 36, 29, 5, -36 },
  { 5912, 44, 36, 44, 5, -36 },
  { 6110, 36, 36, 29, -3, -36 },
  { 6272, 27, 36, 27, 5, -36 },
  { 6394, 30, 36, 27, -1, -36 },
  { 6529, 20, 44, 16, -1, -36 },
  { 6639, 11, 36, 20, 5, -36 },
  { 6689, 20, 44, 16, -3, -36 },
  { 6799, 25, 23, 28, 1, -36 },
  { 6871, 21, 4, 20, -5, 4 },
  { 6882, 10, 8, 15, 7, -38 },
  { 6892, 26, 29, 29, 2, -28 },
  { 6987, 26, 39, 29, 1, -38 },
  { 7114, 22, 29, 24, 2, -28 },
  { 7194, 29, 39, 29, 2, -38 },
  { 7336, 23, 29, 27, 2, -28 },
  { 7420, 28, 50, 18, -5, -38 },
  { 7595, 27, 40, 30, 1, -28 },
  { 7730, 26, 38, 30, 1, -38 },
  { 7854, 14, 38, 14, 1, -38 },
  { 7921, 21, 50, 14, -6, -38 },
  { 8053, 28, 38, 27, 1, -38 },
  { 8186, 14, 38, 14, 1, -38 },
  { 8253, 41, 28, 45, 1, -28 },
  { 8397, 26, 28, 30, 1, -28 },
  { 8488, 25, 28, 29, 2, -28 },
  { 8576, 28, 40, 29, -1, -28 },
  { 8716, 26, 40, 29, 2, -28 },
  { 8846, 21, 28, 21, 1, -28 },
  { 8920, 22, 29, 23, 0, -28 },
  { 9000, 18, 34, 19, 2, -33 },
  { 9077, 26, 28, 30, 3, -27 },
  { 9168, 25, 27, 25, 2, -27 },
  { 9253, 38, 27, 38, 3, -27 },
  { 9382, 30, 27, 26, -2, -27 },
  { 9484, 32, 39, 25, -4, -27 },
  { 9640, 24, 27, 23, -1, -27 },
  { 9721, 21, 44, 18, 0, -36 },
  { 9837, 5, 50, 28, 12, -38 },
  { 9869, 20, 44, 18, -2, -36 },
  { 9979, 24, 7, 29, 3, -21 },
};

const GFXfont NotoSans_SemiBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMIBOLDITALIC50PT7B_H_
