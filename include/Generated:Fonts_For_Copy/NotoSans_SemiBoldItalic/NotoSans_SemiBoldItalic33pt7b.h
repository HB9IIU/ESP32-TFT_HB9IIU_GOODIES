#ifndef _NOTOSANS_SEMIBOLDITALIC33PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xE0, 0x78, 0xF7, 0x8E, 0x79, 0xE7,
  0x9E, 0x71, 0xE7, 0x1C, 0x71, 0xC6, 0x1C, 0xE1, 0x80, 0x00, 0x71, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x03, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x71, 0xE0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7D, 0x8C, 0x3C, 0xC0, 0x1E, 0x60, 0x0F, 0x70, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0x7C, 0x01, 0x9E,
  0x00, 0xCF, 0x00, 0xE7, 0x98, 0x67, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC0, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80,
  0x1E, 0x1F, 0xC0, 0x3C, 0x3F, 0xE0, 0x38, 0x39, 0xE0, 0x70, 0x78, 0xE0,
  0xF0, 0x70, 0xE1, 0xE0, 0x70, 0xE1, 0xC0, 0xF1, 0xE3, 0x80, 0xF1, 0xE7,
  0x80, 0xF1, 0xC7, 0x00, 0xF3, 0xCE, 0x7E, 0xF3, 0xDC, 0xFF, 0x7F, 0xBD,
  0xFF, 0x7F, 0x3B, 0xC7, 0x3C, 0x73, 0xC7, 0x00, 0xE3, 0x87, 0x01, 0xE3,
  0x87, 0x01, 0xC7, 0x8F, 0x03, 0x87, 0x8F, 0x07, 0x07, 0x8E, 0x0F, 0x07,
  0x9E, 0x0E, 0x03, 0xFC, 0x1C, 0x03, 0xFC, 0x38, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1C, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0x9F, 0xF8, 0x3D, 0xF3,
  0xE3, 0xCF, 0x0F, 0xBE, 0xF8, 0x3D, 0xE7, 0x81, 0xFE, 0x3C, 0x07, 0xE1,
  0xF0, 0x3F, 0x0F, 0xC7, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF, 0x83, 0xFC,
  0x3E, 0x7B, 0xDE, 0xF7, 0x39, 0xCC, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x41, 0xC0, 0x71, 0xC0, 0xFD, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0x3C, 0xE0, 0x78, 0xE0, 0x10, 0xF0, 0x10,
  0x70, 0x00, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0xF0, 0xFF, 0xFF, 0xBF, 0xDF, 0xE0,
  0x31, 0xEF, 0xFE, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF0, 0xF0, 0x7C, 0xF8, 0x1E, 0x78, 0x0F,
  0x7C, 0x07, 0xBE, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0xF7, 0xC0,
  0x7B, 0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3E, 0x0F, 0x8F,
  0x0F, 0x87, 0xCF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xF0,
  0x3E, 0x07, 0xE1, 0xFE, 0x7F, 0xEF, 0xDC, 0xFB, 0xC6, 0x3C, 0x43, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0x07, 0x81, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x06, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF2, 0x00,
  0x7C, 0xE0, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0x70, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xE0, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x90, 0x07, 0x8E, 0x0F,
  0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x01, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x79, 0xF0, 0x77, 0xF8, 0xFF, 0xFC, 0xFE, 0x7C, 0xF8, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x0F, 0x0F, 0x07, 0xDF, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0xFF, 0x81, 0xFB, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3C,
  0x3F, 0x3F, 0xFF, 0x3F, 0xEF, 0x1F, 0xDE, 0x02, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x81, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x0F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x78, 0xFC, 0xF8, 0x78, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x0F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF, 0xE4, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0x00, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0x38, 0xE0, 0x7F, 0x8E, 0x78, 0x7F, 0xE3, 0x9C, 0x3E, 0x78,
  0xFF, 0x1E, 0x1E, 0x3F, 0x87, 0x07, 0x0F, 0xE3, 0xC1, 0xC3, 0xB8, 0xE0,
  0x70, 0xEE, 0x38, 0x38, 0x3B, 0x8E, 0x0E, 0x1E, 0xE3, 0x87, 0x87, 0x38,
  0xF3, 0xE3, 0xCE, 0x3F, 0xDF, 0xE3, 0x87, 0xE7, 0xF0, 0xF0, 0x60, 0x60,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x03, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7B, 0xC0, 0x07, 0x9C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x01, 0xE3, 0xE0, 0x0F, 0x3C, 0x00,
  0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0x07, 0xF8, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC0,
  0x78, 0x78, 0x1F, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0x78, 0x7E, 0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFC, 0x0C, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0x07, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0,
  0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x7C, 0x78,
  0x0F, 0xC7, 0x81, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xC0, 0x61, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x83, 0xFE, 0xF8, 0x3F, 0xEF, 0x83,
  0xFE, 0xF0, 0x3F, 0xCF, 0x00, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0x87, 0xC0, 0x78, 0x7F, 0x0F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC3, 0xE0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3E,
  0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xE1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x3C, 0x3E, 0x00,
  0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x01, 0xEF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xE7, 0x80,
  0x0F, 0x1E, 0x00, 0x3C, 0x7C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xE0, 0x1E,
  0x0F, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFE, 0x0E, 0xE0, 0x1D, 0xC1, 0xEE, 0x03, 0xFC, 0x1E, 0xE0, 0x3B, 0xC1,
  0xEE, 0x07, 0xBC, 0x1E, 0xE0, 0xF3, 0xC1, 0xCF, 0x0F, 0x78, 0x3C, 0xF1,
  0xE7, 0x83, 0xCF, 0x1C, 0x78, 0x3C, 0xF3, 0xC7, 0x83, 0xC7, 0x38, 0x78,
  0x38, 0x77, 0x8F, 0x07, 0x87, 0x70, 0xF0, 0x78, 0x7F, 0x0F, 0x07, 0x87,
  0xE0, 0xF0, 0x78, 0x7E, 0x0F, 0x07, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x1E, 0x07, 0xC0,
  0x1E, 0x0F, 0xE0, 0x1E, 0x0F, 0xE0, 0x1E, 0x0F, 0xE0, 0x1C, 0x0E, 0xF0,
  0x3C, 0x1E, 0xF0, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78,
  0x38, 0x1E, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x1E,
  0x78, 0x3C, 0x1E, 0x70, 0x38, 0x1E, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F,
  0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0xF0, 0x07,
  0xE0, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xE7, 0x80,
  0x1F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xF3, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xC0, 0xF8,
  0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x0F, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xE7, 0x80,
  0x1F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xF3, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0x07, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xF1, 0xF0, 0x3C,
  0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xE1, 0xE0, 0x78, 0x78, 0x1F, 0x1E, 0x07,
  0xCF, 0x80, 0xF3, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xE1, 0xF0, 0x20, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x10, 0x0F, 0x8E,
  0x1F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03,
  0xE0, 0xF0, 0x1E, 0x07, 0xE3, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xCF, 0x00, 0x39, 0xE0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF0,
  0x07, 0x80, 0x7F, 0x80, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x3D, 0xE0, 0x3F,
  0x03, 0xEF, 0x01, 0xF8, 0x1E, 0x78, 0x1F, 0xC0, 0xF3, 0xC0, 0xFE, 0x0F,
  0x1E, 0x0F, 0xF0, 0x78, 0xF0, 0x7F, 0x87, 0x87, 0x87, 0xBC, 0x3C, 0x1C,
  0x3D, 0xE3, 0xE0, 0xE1, 0xCF, 0x1E, 0x07, 0x1E, 0x38, 0xF0, 0x38, 0xE1,
  0xCF, 0x01, 0xCF, 0x0E, 0x78, 0x0E, 0x70, 0x77, 0x80, 0x77, 0x83, 0xBC,
  0x03, 0xBC, 0x1D, 0xC0, 0x1D, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7C, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00,
  0xF3, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xEF, 0x00, 0x03, 0xCF, 0x80, 0x07, 0xC7, 0x80, 0x0F, 0x87, 0x80, 0x0F,
  0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0xF8,
  0x01, 0xE0, 0xF0, 0x07, 0xFE, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x7C, 0x78,
  0x1E, 0x1E, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xE1,
  0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC7, 0x87, 0x0E,
  0x1C, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x03, 0xF8, 0x1F, 0xC1,
  0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xB8, 0x07, 0x38, 0x0F, 0x38,
  0x0E, 0x1C, 0x1E, 0x1C, 0x1C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xE7, 0x8F, 0x1C, 0x03, 0xE3,
  0xC1, 0xFE, 0xE0, 0xFF, 0xB8, 0x7E, 0x7E, 0x3E, 0x0F, 0x8F, 0x03, 0xE7,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF3, 0xE0,
  0x78, 0xF8, 0x3E, 0x1E, 0x0F, 0x87, 0xCF, 0xE1, 0xFF, 0xF0, 0x3F, 0xDC,
  0x07, 0xC7, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0xFC, 0x1E, 0xFF, 0x0F, 0xFF,
  0x87, 0xE3, 0xE3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0x38, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0xC3, 0xE7,
  0xE3, 0xF3, 0xFF, 0xF1, 0xCF, 0xF0, 0xE3, 0xF0, 0x00, 0x03, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0xF8, 0x63, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x0C, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x1F,
  0x1E, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xE3, 0xF1, 0xF0, 0x7C, 0x78, 0x1F,
  0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F,
  0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3E, 0x3F, 0x0F, 0xFF, 0x81, 0xFE,
  0xE0, 0x3F, 0x38, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF1, 0xF1, 0xF7,
  0xC1, 0xEF, 0x03, 0xFE, 0x0F, 0x78, 0xFE, 0xFF, 0xF9, 0xFF, 0xC3, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x04, 0x7F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xC1,
  0xFE, 0xE0, 0xFF, 0xB8, 0x7E, 0x7E, 0x3E, 0x0F, 0x8F, 0x03, 0xE7, 0xC0,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF3, 0xE0, 0x78,
  0xF8, 0x3E, 0x1E, 0x0F, 0x87, 0xCF, 0xE1, 0xFF, 0xF0, 0x3F, 0xBC, 0x07,
  0xCF, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x20, 0x3E, 0x0F, 0x3F,
  0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x7C, 0x1E, 0xFF, 0x0F, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF3, 0xE0, 0x79,
  0xF0, 0x3C, 0xF0, 0x3E, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x03, 0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x7C, 0xF0,
  0x3C, 0x00, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x20, 0x00, 0x00, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x1F, 0x1E,
  0x0F, 0x87, 0x87, 0xC1, 0xE3, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x0F, 0x7C,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xCF, 0x01,
  0xE3, 0xC0, 0x78, 0xF8, 0x3E, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0,
  0x3E, 0x00, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x00, 0x1E, 0x7E, 0x0F, 0x83, 0xDF,
  0xE7, 0xF8, 0x7F, 0xFD, 0xFF, 0x0F, 0xC7, 0xF9, 0xF1, 0xF0, 0xFC, 0x1E,
  0x7C, 0x1F, 0x03, 0xCF, 0x83, 0xE0, 0xF9, 0xE0, 0x78, 0x1E, 0x3C, 0x0F,
  0x03, 0xC7, 0x81, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x3C, 0x0F, 0x03, 0xE7,
  0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x3E, 0x07, 0x81, 0xE7, 0x81, 0xF0,
  0x3C, 0xF0, 0x3C, 0x0F, 0x9E, 0x07, 0x81, 0xE0, 0x1E, 0x7E, 0x0F, 0x7F,
  0x87, 0xFF, 0xE3, 0xF9, 0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78,
  0x1F, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xF3,
  0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x78, 0x1E, 0x00, 0x07,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x07,
  0x9F, 0x80, 0xF7, 0xF8, 0x1D, 0xFF, 0x03, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x7C, 0x78,
  0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE1, 0xFF,
  0xF8, 0x3D, 0xFE, 0x07, 0x9F, 0x80, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xE7, 0x87, 0xFB, 0x87, 0xFD, 0xC7, 0xC7, 0xE7, 0xC1, 0xF3,
  0xC0, 0xFB, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F,
  0x9E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE3, 0xE3, 0xF1, 0xFF, 0x70, 0x7F,
  0x78, 0x1F, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x7C, 0x7B,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x82,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xEC, 0x0F, 0xBF, 0xFC, 0xFF, 0xE1, 0xFF,
  0x00, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x1F, 0xF7, 0xFF, 0x7F, 0xF9,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x47, 0xF8, 0x7F, 0x83, 0xF8, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0,
  0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0xCF,
  0x07, 0xC7, 0x83, 0xE3, 0xC7, 0xF1, 0xFF, 0xF8, 0x7F, 0xB8, 0x3F, 0x1C,
  0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0,
  0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0x71, 0xF0, 0x71, 0xE0, 0x7B, 0xE0, 0x7B,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0xF0, 0x3C, 0x0F, 0xF8, 0x3E, 0x07, 0xBC, 0x1F, 0x07, 0xDE, 0x1F,
  0x83, 0xCF, 0x0F, 0xE1, 0xE7, 0x87, 0xF1, 0xE3, 0xC7, 0x78, 0xF1, 0xE3,
  0xBC, 0xF0, 0xF3, 0xDE, 0x78, 0x79, 0xCF, 0x78, 0x3D, 0xE7, 0xBC, 0x1E,
  0xE3, 0xDC, 0x07, 0x70, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x03,
  0xE1, 0xE0, 0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x7D, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xF0,
  0x78, 0x1E, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0,
  0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x0E, 0x1F, 0x00,
  0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBC,
  0x00, 0x3D, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x03, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x04, 0x7F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF8, 0x00, 0x0C, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x0F, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0xF8,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC3, 0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 12, 9, 14, 3, -24 },
  { 45, 21, 24, 21, 1, -24 },
  { 108, 17, 27, 18, 1, -25 },
  { 166, 24, 24, 28, 2, -24 },
  { 238, 21, 24, 23, 1, -24 },
  { 301, 5, 9, 8, 3, -24 },
  { 307, 12, 29, 11, 1, -24 },
  { 351, 11, 29, 11, -2, -24 },
  { 391, 16, 16, 18, 3, -25 },
  { 423, 16, 16, 19, 2, -20 },
  { 455, 8, 8, 9, -2, -4 },
  { 463, 9, 4, 11, 1, -11 },
  { 468, 6, 5, 9, 0, -5 },
  { 472, 17, 24, 13, -1, -24 },
  { 523, 17, 24, 18, 1, -24 },
  { 574, 12, 24, 18, 4, -24 },
  { 610, 18, 24, 18, 0, -24 },
  { 664, 18, 24, 18, 0, -24 },
  { 718, 18, 24, 18, 0, -24 },
  { 772, 17, 24, 18, 1, -24 },
  { 823, 16, 24, 18, 2, -24 },
  { 871, 17, 24, 18, 2, -24 },
  { 922, 17, 24, 18, 1, -24 },
  { 973, 16, 24, 18, 1, -24 },
  { 1021, 8, 18, 9, 0, -18 },
  { 1039, 10, 22, 9, -2, -18 },
  { 1067, 16, 17, 19, 2, -20 },
  { 1101, 16, 9, 19, 2, -16 },
  { 1119, 16, 17, 19, 2, -20 },
  { 1153, 13, 24, 15, 3, -24 },
  { 1192, 26, 27, 28, 2, -24 },
  { 1280, 20, 24, 20, -2, -24 },
  { 1340, 19, 24, 20, 1, -24 },
  { 1397, 19, 24, 20, 2, -24 },
  { 1454, 20, 24, 22, 1, -24 },
  { 1514, 18, 24, 18, 1, -24 },
  { 1568, 18, 24, 17, 1, -24 },
  { 1622, 20, 24, 23, 2, -24 },
  { 1682, 22, 24, 23, 1, -24 },
  { 1748, 15, 24, 12, -1, -24 },
  { 1793, 16, 31, 10, -5, -24 },
  { 1855, 22, 24, 20, 1, -24 },
  { 1921, 13, 24, 17, 1, -24 },
  { 1960, 28, 24, 29, 1, -24 },
  { 2044, 24, 24, 24, 1, -24 },
  { 2116, 21, 24, 24, 2, -24 },
  { 2179, 19, 24, 20, 1, -24 },
  { 2236, 21, 30, 24, 2, -24 },
  { 2315, 18, 24, 20, 1, -24 },
  { 2369, 17, 24, 17, 1, -24 },
  { 2420, 17, 24, 17, 3, -24 },
  { 2471, 21, 24, 23, 2, -24 },
  { 2534, 19, 24, 19, 3, -24 },
  { 2591, 29, 24, 29, 3, -24 },
  { 2678, 24, 24, 19, -2, -24 },
  { 2750, 18, 24, 18, 3, -24 },
  { 2804, 20, 24, 18, -1, -24 },
  { 2864, 14, 29, 10, -1, -24 },
  { 2915, 7, 24, 13, 4, -24 },
  { 2936, 13, 29, 10, -2, -24 },
  { 2984, 16, 15, 18, 1, -24 },
  { 3014, 14, 2, 13, -3, 3 },
  { 3018, 6, 5, 10, 5, -25 },
  { 3022, 18, 18, 19, 1, -18 },
  { 3063, 17, 25, 19, 1, -25 },
  { 3117, 15, 18, 16, 1, -18 },
  { 3151, 18, 25, 19, 2, -25 },
  { 3208, 15, 18, 18, 2, -18 },
  { 3242, 19, 33, 12, -4, -25 },
  { 3321, 18, 26, 19, 1, -18 },
  { 3380, 17, 25, 20, 1, -25 },
  { 3434, 9, 25, 9, 1, -25 },
  { 3463, 14, 33, 9, -4, -25 },
  { 3521, 18, 25, 18, 1, -25 },
  { 3578, 9, 25, 9, 1, -25 },
  { 3607, 27, 18, 30, 1, -18 },
  { 3668, 17, 18, 20, 1, -18 },
  { 3707, 16, 18, 19, 2, -18 },
  { 3743, 19, 26, 19, -1, -18 },
  { 3805, 17, 26, 19, 2, -18 },
  { 3861, 14, 18, 14, 1, -18 },
  { 3893, 14, 18, 15, 0, -18 },
  { 3925, 12, 22, 13, 1, -22 },
  { 3958, 17, 18, 20, 2, -18 },
  { 3997, 16, 18, 16, 2, -18 },
  { 4033, 25, 18, 25, 2, -18 },
  { 4090, 19, 18, 17, -1, -18 },
  { 4133, 21, 26, 16, -3, -18 },
  { 4202, 16, 18, 15, -1, -18 },
  { 4238, 14, 29, 12, 0, -24 },
  { 4289, 3, 33, 18, 8, -25 },
  { 4302, 14, 29, 12, -2, -24 },
  { 4353, 16, 5, 19, 2, -14 },
};

const GFXfont NotoSans_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMIBOLDITALIC33PT7B_H_
