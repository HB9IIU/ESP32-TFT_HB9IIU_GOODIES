#ifndef _NOTOSANS_SEMIBOLDITALIC29PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x1F, 0x07,
  0x00, 0x73, 0xDC, 0xF7, 0x39, 0xCE, 0xE3, 0xB8, 0xCE, 0x33, 0x1C, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0x83, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0x86, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x0E, 0x38, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0, 0x18,
  0x60, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x31, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x07, 0xC0, 0x7F, 0xF1, 0xFF, 0xC3, 0xDB, 0x8F, 0x30,
  0x1E, 0xC0, 0x3D, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xDE, 0x01, 0x9C, 0x82, 0x79, 0xCD, 0xF3, 0xFF, 0xC7, 0xFF,
  0x03, 0xF0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x71, 0xFC,
  0x07, 0x1F, 0xE0, 0x70, 0xE7, 0x07, 0x07, 0x18, 0x30, 0x71, 0xC3, 0x83,
  0x8E, 0x38, 0x1C, 0x73, 0x80, 0xE3, 0x9C, 0xE7, 0x39, 0xDF, 0xBF, 0xDD,
  0xFE, 0xFD, 0xCE, 0x73, 0xCE, 0xE3, 0x80, 0xE7, 0x1C, 0x0E, 0x38, 0xE0,
  0xE1, 0xC7, 0x07, 0x1C, 0x70, 0x70, 0xE3, 0x87, 0x03, 0xBC, 0x70, 0x1F,
  0xC7, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x00, 0x7B, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x07, 0x9F, 0xE0, 0xE7, 0x9E, 0x3D, 0xE1,
  0xEF, 0x3C, 0x3F, 0xC7, 0x83, 0xF8, 0xF0, 0x3E, 0x1E, 0x0F, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFC, 0x78, 0x77, 0x77, 0xEE, 0xEC, 0x01, 0xC0,
  0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE1, 0x86, 0x0F, 0x30,
  0x7F, 0xBC, 0x7F, 0xE1, 0xFF, 0x1F, 0x01, 0xDC, 0x3E, 0x60, 0xE3, 0x82,
  0x1C, 0x00, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x3C, 0xE7, 0x9C, 0x73, 0x8E, 0x00, 0xFF, 0xFF,
  0xF8, 0x7B, 0xFE, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF1, 0xE3, 0xC1, 0xC7, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xE0, 0x3B, 0xC0, 0x77, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E,
  0x78, 0x3C, 0xF0, 0x78, 0xE1, 0xE1, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00,
  0x01, 0xE0, 0x78, 0x3F, 0x1F, 0xE7, 0xFD, 0xF7, 0x98, 0xE2, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x01, 0xF8, 0x0F, 0xF8, 0x7F, 0xF8, 0x70,
  0xF0, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x0B, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x80, 0x01, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF8, 0x70, 0xF0, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3D, 0x80, 0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0xF7, 0x01, 0xCE, 0x07, 0x3C, 0x1C, 0x78, 0x78, 0xE1, 0xE1, 0xC7,
  0x87, 0x8E, 0x0F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x79, 0x01, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x07,
  0xFC, 0x1F, 0xF8, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x7B, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0x38, 0x1C, 0x70, 0x78, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0,
  0xF1, 0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x8F, 0x1E, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFF, 0x87, 0xC7, 0x8E, 0x0F, 0x3C, 0x0E, 0x78, 0x1C, 0xF0,
  0x39, 0xE0, 0xF1, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xE0, 0x3F,
  0xE1, 0xFF, 0x8F, 0x8F, 0x3C, 0x3D, 0xE0, 0x77, 0x81, 0xDE, 0x07, 0x78,
  0x3D, 0xE0, 0xF7, 0xCF, 0xCF, 0xFF, 0x1F, 0xB8, 0x10, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x0E, 0x3C,
  0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x3E, 0x38,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x00, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C,
  0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F,
  0xC0, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0x7F, 0xE7,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x3C, 0x01, 0xE0, 0xF0, 0x01, 0xC3, 0x80, 0x01, 0xCE, 0x0F, 0xF3, 0x9C,
  0x3F, 0xC7, 0x70, 0xF3, 0x8E, 0xE3, 0x87, 0x1D, 0xC7, 0x0E, 0x3B, 0x1C,
  0x18, 0x7E, 0x38, 0x70, 0xFC, 0x70, 0xE1, 0xB8, 0xE3, 0xC7, 0x71, 0xEF,
  0x9C, 0x71, 0xFB, 0xF0, 0xE1, 0xE3, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x18, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x0E, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0xF1, 0xE0, 0x38,
  0x78, 0x1E, 0x1E, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x78, 0x0E,
  0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x0E, 0x1F, 0x1E, 0x0F, 0x1E, 0x07,
  0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFC,
  0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x7C,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0xC3, 0xF0, 0xE3, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x04, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x38, 0xFC,
  0x1E, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x38, 0x78, 0x0F, 0x1C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1C, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0x0E, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x2F, 0x07, 0xF3,
  0xC1, 0xFC, 0xF0, 0xFF, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38, 0xF8,
  0x1E, 0x1F, 0x07, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x1E, 0x01, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0E, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01,
  0xE0, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x23, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x07, 0x81, 0xE1, 0xE0,
  0x3C, 0x78, 0x07, 0x9E, 0x00, 0xE7, 0x80, 0x1D, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03,
  0xC3, 0x80, 0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x7F, 0x1F, 0xC0,
  0x7E, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEE, 0x1D, 0xC1, 0xDE, 0x1D, 0xC1,
  0xDE, 0x3D, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC7, 0x3C, 0x39, 0xC7,
  0x3C, 0x79, 0xCE, 0x38, 0x79, 0xCE, 0x38, 0x70, 0xDC, 0x38, 0x70, 0xFC,
  0x78, 0x70, 0xF8, 0x78, 0xF0, 0xF8, 0x70, 0xF0, 0xF0, 0x70, 0xE0, 0xF0,
  0xF0, 0x0F, 0x00, 0x78, 0x7C, 0x03, 0x83, 0xE0, 0x1C, 0x1F, 0x81, 0xE1,
  0xFC, 0x0F, 0x0E, 0xE0, 0x70, 0x77, 0x83, 0x83, 0xBC, 0x1C, 0x1C, 0xE1,
  0xE1, 0xE7, 0x8F, 0x0E, 0x3C, 0x70, 0x70, 0xE3, 0x83, 0x87, 0x9C, 0x3C,
  0x3D, 0xE1, 0xE0, 0xEF, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x80, 0xFC,
  0x3C, 0x07, 0xE1, 0xE0, 0x1F, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3E, 0x3E, 0x07, 0xCF, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF8, 0x0F, 0x1F,
  0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0E, 0x3F, 0x1E, 0x0F, 0x1E, 0x07, 0x1E, 0x07, 0x1C,
  0x0F, 0x1C, 0x0F, 0x3C, 0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3E,
  0x3E, 0x07, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x3E, 0xF8, 0x1F, 0x1F, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x78, 0x78,
  0x70, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0x03, 0xF0, 0x3F, 0xF1,
  0xFF, 0xC7, 0x86, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF2, 0x07, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFC, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x3C, 0x3E, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0x71, 0xE0, 0x71,
  0xE0, 0x73, 0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x77, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xE0, 0x1C, 0x07, 0xF0, 0x1E,
  0x03, 0xF8, 0x0F, 0x03, 0xDC, 0x0F, 0x81, 0xEE, 0x07, 0xC0, 0xE7, 0x07,
  0xE0, 0xF3, 0x83, 0xF0, 0x71, 0xC3, 0xF8, 0x78, 0xE1, 0xDC, 0x3C, 0x70,
  0xEE, 0x3C, 0x38, 0xE7, 0x1E, 0x1C, 0x71, 0x8E, 0x0F, 0x70, 0xEF, 0x07,
  0xB8, 0x77, 0x03, 0xB8, 0x3F, 0x81, 0xDC, 0x1F, 0x80, 0xEE, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0,
  0x1C, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xEE, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x0F, 0x80, 0x78, 0x00, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xF7, 0x83, 0xC7, 0x07, 0x8F, 0x1E, 0x1E, 0x78, 0x1C, 0xF0,
  0x3B, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x20, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0xE0, 0xFC, 0x1F,
  0x80, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x78, 0xE3, 0x8E, 0x38, 0xE3,
  0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x3C, 0x00, 0xF8, 0x07, 0xE0, 0x39, 0x80, 0xE7, 0x07, 0x1C, 0x1C, 0x30,
  0xE0, 0xE7, 0x03, 0x9C, 0x07, 0xE0, 0x1C, 0x7F, 0xFF, 0xFF, 0xF1, 0xE3,
  0x87, 0x07, 0xCE, 0x1F, 0xDC, 0x7F, 0xF9, 0xF1, 0xF3, 0xC3, 0xEF, 0x03,
  0x9E, 0x07, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF,
  0x0F, 0x8F, 0xFF, 0x1F, 0xFC, 0x1F, 0x38, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x3C, 0x0E, 0xFE, 0x3F, 0xFC,
  0x7C, 0x7C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x3C,
  0x1E, 0x70, 0x3C, 0xF0, 0xFB, 0xE1, 0xE7, 0xFF, 0x8E, 0xFE, 0x1C, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x7C, 0x23, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x82, 0x3F, 0xF0,
  0xFF, 0x83, 0xF8, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x1F, 0x38, 0x1F, 0xDC, 0x1F, 0xFE, 0x1F, 0x1F,
  0x0F, 0x0F, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3E, 0x0F, 0xFF, 0x07, 0xFF, 0x01,
  0xF3, 0x80, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x8F, 0x3C, 0x3D, 0xE0,
  0xE7, 0x8F, 0x9F, 0xFC, 0xFF, 0xE3, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x11, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xCE, 0x1F, 0xDC,
  0x7F, 0xF9, 0xF1, 0xF3, 0xC3, 0xEF, 0x03, 0x9E, 0x07, 0x38, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x8F, 0xFF, 0x1F, 0xDC,
  0x1F, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x84, 0x0F, 0x0F, 0xFC, 0x1F,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x3E, 0x0E, 0xFE, 0x3F, 0xFC, 0x7E, 0x3C, 0xF8,
  0x79, 0xE0, 0xF3, 0xC1, 0xCF, 0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x3C,
  0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x00, 0x06, 0x0F,
  0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78,
  0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x30, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x1F, 0x1C, 0x1E,
  0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0xF0, 0x39, 0xE0, 0x3B, 0xC0, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x79, 0xC0, 0x71, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xE0, 0x78, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xE0, 0x1C, 0xF8, 0x7C, 0x3B, 0xF9, 0xFC, 0xFF, 0xF7, 0xF9, 0xF9,
  0xFC, 0xF3, 0xE1, 0xF0, 0xE7, 0x83, 0xC1, 0xCF, 0x07, 0x07, 0xBC, 0x1E,
  0x0F, 0x78, 0x3C, 0x1E, 0xF0, 0x78, 0x3D, 0xC0, 0xE0, 0x73, 0x81, 0xC1,
  0xEF, 0x07, 0x83, 0xDE, 0x0F, 0x07, 0xBC, 0x1E, 0x0E, 0x70, 0x38, 0x3C,
  0x1C, 0xF8, 0x3B, 0xF8, 0xFF, 0xF1, 0xF8, 0xF3, 0xE1, 0xE7, 0x83, 0xCF,
  0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xCF, 0x03,
  0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x3C, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0x8F, 0x3C, 0x3D, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xFC, 0x1E, 0x78, 0x79, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x07, 0x3C,
  0x03, 0xBF, 0x83, 0xFF, 0xC1, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x38,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x03, 0xC3, 0xC3, 0xE3,
  0xE1, 0xE1, 0xFF, 0xE0, 0xEF, 0xF0, 0x73, 0xE0, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07,
  0xC6, 0x1F, 0xDC, 0x7F, 0xF9, 0xF1, 0xF3, 0xC3, 0xEF, 0x03, 0x9E, 0x07,
  0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x8F,
  0xFF, 0x1F, 0xDC, 0x1F, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1C, 0xF1, 0xDF, 0x3F, 0xE3,
  0xFA, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0xE0, 0xFF, 0xCF, 0xFC,
  0x78, 0x23, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xC8, 0x1E, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x07, 0x01, 0xC0,
  0x38, 0x0F, 0xF7, 0xFD, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0x7F, 0x0F, 0xE0, 0xFC, 0x00,
  0x38, 0x1E, 0x70, 0x39, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0xBC,
  0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xF3, 0x83, 0xC7, 0x07, 0x8E, 0x1F,
  0x1F, 0xEE, 0x3F, 0x9C, 0x3E, 0x70, 0xF0, 0x1E, 0xE0, 0x79, 0xC0, 0xF3,
  0x83, 0xC7, 0x07, 0x8E, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xC0, 0x77,
  0x80, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0xE0, 0xF0, 0x3F, 0x07, 0x83, 0xF8, 0x7C, 0x1D, 0xC3, 0xE1, 0xEE, 0x1B,
  0x8F, 0x71, 0xDC, 0xF3, 0x8E, 0xE7, 0x9C, 0xE7, 0x38, 0xE7, 0x3B, 0xC7,
  0x71, 0xDC, 0x3B, 0x8F, 0xE1, 0xD8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x87, 0x87, 0x83, 0xC7,
  0x80, 0xE7, 0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xE7, 0x81, 0xE3, 0xC1,
  0xE0, 0xE1, 0xE0, 0x78, 0x1E, 0x03, 0xC3, 0x81, 0xE0, 0xE0, 0x78, 0x38,
  0x3C, 0x0E, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x07, 0x3C,
  0x01, 0xDE, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC,
  0x00, 0x30, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0C, 0x01, 0xF0, 0x3E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0xF0,
  0x10, 0x00, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xE0, 0x7C,
};

const GFXglyph NotoSans_SemiBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 10, 8, 12, 3, -21 },
  { 35, 18, 21, 19, 1, -21 },
  { 83, 15, 24, 16, 1, -22 },
  { 128, 21, 21, 24, 2, -21 },
  { 184, 19, 21, 20, 1, -21 },
  { 234, 4, 8, 7, 3, -21 },
  { 238, 10, 26, 9, 1, -21 },
  { 271, 10, 26, 9, -2, -21 },
  { 304, 13, 14, 16, 3, -22 },
  { 327, 14, 14, 17, 2, -17 },
  { 352, 6, 7, 8, -1, -3 },
  { 358, 7, 3, 9, 1, -9 },
  { 361, 5, 4, 8, 0, -4 },
  { 364, 15, 21, 12, -1, -21 },
  { 404, 15, 21, 16, 1, -21 },
  { 444, 11, 21, 16, 3, -21 },
  { 473, 15, 21, 16, 0, -21 },
  { 513, 15, 21, 16, 0, -21 },
  { 553, 15, 21, 16, 0, -21 },
  { 593, 15, 21, 16, 1, -21 },
  { 633, 15, 21, 16, 1, -21 },
  { 673, 15, 21, 16, 2, -21 },
  { 713, 15, 21, 16, 1, -21 },
  { 753, 14, 21, 16, 1, -21 },
  { 790, 7, 16, 8, 0, -16 },
  { 804, 9, 20, 8, -2, -16 },
  { 827, 14, 15, 17, 2, -18 },
  { 854, 14, 8, 17, 2, -14 },
  { 868, 14, 15, 17, 2, -18 },
  { 895, 12, 21, 13, 2, -21 },
  { 927, 23, 24, 25, 1, -21 },
  { 996, 18, 21, 17, -2, -21 },
  { 1044, 16, 21, 18, 1, -21 },
  { 1086, 17, 21, 17, 2, -21 },
  { 1131, 18, 21, 20, 1, -21 },
  { 1179, 15, 21, 15, 1, -21 },
  { 1219, 15, 21, 15, 1, -21 },
  { 1259, 18, 21, 20, 2, -21 },
  { 1307, 19, 21, 20, 1, -21 },
  { 1357, 13, 21, 10, -1, -21 },
  { 1392, 14, 27, 9, -5, -21 },
  { 1440, 19, 21, 17, 1, -21 },
  { 1490, 12, 21, 15, 1, -21 },
  { 1522, 24, 21, 25, 1, -21 },
  { 1585, 21, 21, 21, 1, -21 },
  { 1641, 18, 21, 21, 2, -21 },
  { 1689, 16, 21, 17, 1, -21 },
  { 1731, 18, 26, 21, 2, -21 },
  { 1790, 16, 21, 17, 1, -21 },
  { 1832, 14, 21, 15, 1, -21 },
  { 1869, 15, 21, 15, 2, -21 },
  { 1909, 18, 21, 20, 2, -21 },
  { 1957, 16, 21, 17, 3, -21 },
  { 1999, 25, 21, 26, 3, -21 },
  { 2065, 21, 21, 17, -2, -21 },
  { 2121, 15, 21, 16, 3, -21 },
  { 2161, 18, 21, 15, -1, -21 },
  { 2209, 11, 26, 9, 0, -21 },
  { 2245, 6, 21, 12, 3, -21 },
  { 2261, 12, 26, 9, -2, -21 },
  { 2300, 14, 13, 16, 1, -21 },
  { 2323, 12, 2, 12, -3, 3 },
  { 2326, 6, 4, 9, 4, -22 },
  { 2329, 15, 16, 17, 1, -16 },
  { 2359, 15, 22, 17, 1, -22 },
  { 2401, 13, 16, 14, 1, -16 },
  { 2427, 17, 22, 17, 1, -22 },
  { 2474, 14, 16, 16, 1, -16 },
  { 2502, 17, 29, 10, -3, -22 },
  { 2564, 15, 23, 17, 1, -16 },
  { 2608, 15, 22, 17, 1, -22 },
  { 2650, 8, 22, 8, 1, -22 },
  { 2672, 13, 29, 8, -4, -22 },
  { 2720, 16, 22, 16, 1, -22 },
  { 2764, 8, 22, 8, 1, -22 },
  { 2786, 23, 16, 26, 1, -16 },
  { 2832, 15, 16, 17, 1, -16 },
  { 2862, 14, 16, 17, 1, -16 },
  { 2890, 17, 23, 17, -1, -16 },
  { 2939, 15, 23, 17, 1, -16 },
  { 2983, 12, 16, 12, 1, -16 },
  { 3007, 13, 16, 13, 0, -16 },
  { 3033, 11, 19, 11, 1, -19 },
  { 3060, 15, 16, 17, 2, -16 },
  { 3090, 15, 16, 14, 1, -16 },
  { 3120, 21, 16, 22, 2, -16 },
  { 3162, 17, 16, 15, -1, -16 },
  { 3196, 18, 23, 14, -2, -16 },
  { 3248, 14, 16, 13, -1, -16 },
  { 3276, 12, 26, 10, 0, -21 },
  { 3315, 3, 29, 16, 7, -22 },
  { 3326, 11, 26, 10, -1, -21 },
  { 3362, 14, 4, 17, 2, -12 },
};

const GFXfont NotoSans_SemiBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMIBOLDITALIC29PT7B_H_
