#ifndef _NOTOSANS_SEMIBOLDITALIC15PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x62, 0x31, 0x8C, 0x07, 0x30, 0xDE, 0xA5, 0x60, 0x0D,
  0x82, 0x40, 0x91, 0xFF, 0x7F, 0xC4, 0x81, 0x23, 0xFE, 0x24, 0x09, 0x06,
  0xC0, 0x04, 0x1F, 0x35, 0x28, 0x38, 0x1C, 0x0E, 0x0E, 0x96, 0xFC, 0x10,
  0x10, 0x30, 0x4F, 0x13, 0x66, 0x6D, 0x8D, 0xAD, 0xEB, 0xDB, 0xD8, 0xDB,
  0x13, 0x64, 0x69, 0x8F, 0x00, 0x0E, 0x07, 0xC1, 0x30, 0x4C, 0x1E, 0x0E,
  0x06, 0xCD, 0x9E, 0xC3, 0x1B, 0xC7, 0xD8, 0xFA, 0x19, 0x98, 0xCC, 0x63,
  0x10, 0x84, 0x21, 0x8C, 0x00, 0x10, 0xC6, 0x10, 0x84, 0x63, 0x18, 0x8C,
  0xCC, 0x00, 0x08, 0x93, 0xF8, 0xF2, 0x8D, 0x82, 0x00, 0x10, 0x20, 0x47,
  0xF1, 0x02, 0x04, 0x00, 0x36, 0x6C, 0x7F, 0xF8, 0x03, 0x02, 0x06, 0x04,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x1C, 0xFD, 0x9E, 0x3C, 0x78,
  0xF1, 0xE3, 0xCD, 0xB9, 0xE0, 0x19, 0xFF, 0x23, 0x18, 0xC6, 0x63, 0x18,
  0x1E, 0x3F, 0x23, 0x03, 0x03, 0x06, 0x0C, 0x38, 0x70, 0xFE, 0xFE, 0x1E,
  0x3F, 0x03, 0x03, 0x06, 0x18, 0x26, 0x06, 0x06, 0xCE, 0xFC, 0x03, 0x07,
  0x0F, 0x1A, 0x36, 0x26, 0x66, 0xFF, 0xFF, 0x0C, 0x0C, 0x1F, 0x1F, 0x30,
  0x30, 0x3C, 0x7E, 0x06, 0x06, 0x06, 0xCE, 0xFC, 0x0E, 0x7D, 0x83, 0x0D,
  0xDF, 0xB1, 0xE3, 0xCD, 0xB9, 0xE0, 0x7F, 0xFE, 0x06, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0x60, 0xC0, 0x1C, 0xFD, 0x9B, 0x37, 0xC7, 0x3B, 0x62,
  0x85, 0x9B, 0xE0, 0x3C, 0xFF, 0x1E, 0x3C, 0x79, 0xDD, 0x86, 0x0D, 0x73,
  0xC0, 0x37, 0x00, 0x00, 0xEC, 0x19, 0xC0, 0x00, 0x00, 0xCC, 0x66, 0x00,
  0x02, 0x1C, 0xC6, 0x0F, 0x03, 0x81, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x81,
  0xC0, 0x60, 0x31, 0xEE, 0x30, 0x00, 0x7B, 0xF0, 0xC3, 0x18, 0xC6, 0x18,
  0x03, 0x0C, 0x00, 0x07, 0x01, 0xFC, 0x20, 0x64, 0x7A, 0xCD, 0x39, 0x13,
  0x93, 0x29, 0x36, 0x9D, 0xCC, 0x00, 0x60, 0x83, 0xF0, 0x03, 0x03, 0x81,
  0x41, 0xA0, 0x90, 0xCC, 0x46, 0x7F, 0x61, 0xB0, 0xF0, 0x60, 0x1E, 0x1F,
  0xCC, 0x66, 0x33, 0x31, 0xF1, 0x8C, 0xC6, 0x63, 0x3F, 0xBF, 0x80, 0x0F,
  0x1F, 0xDC, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x3F, 0x1F, 0x80,
  0x1E, 0x0F, 0xE3, 0x18, 0xC3, 0x30, 0xCC, 0x36, 0x19, 0x86, 0x63, 0x9F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0x01, 0xF1, 0x80, 0xC0, 0x60,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0x01, 0xF1, 0xF8, 0xC0,
  0x60, 0x30, 0x30, 0x00, 0x0F, 0x1F, 0xDC, 0x0C, 0x0C, 0x06, 0x3F, 0x3D,
  0x86, 0xC3, 0x3B, 0x8F, 0x80, 0x18, 0x4C, 0x33, 0x0C, 0xC3, 0x30, 0xCF,
  0xE6, 0x19, 0x86, 0x61, 0x98, 0x6E, 0x30, 0x3C, 0xF1, 0x8C, 0x30, 0xC3,
  0x08, 0x61, 0x8F, 0x00, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18,
  0x30, 0x61, 0x8F, 0x1C, 0x00, 0x18, 0xCC, 0x63, 0x30, 0xD8, 0x3C, 0x0F,
  0x07, 0xC1, 0x98, 0x66, 0x19, 0x8C, 0x30, 0x18, 0x60, 0xC1, 0x83, 0x06,
  0x18, 0x30, 0x60, 0xFF, 0xF0, 0x18, 0x39, 0xC1, 0xCE, 0x1E, 0x78, 0xA3,
  0xCF, 0x16, 0x59, 0xB6, 0xCD, 0xA6, 0x6F, 0x23, 0x33, 0x31, 0x98, 0x18,
  0x67, 0x0C, 0xF1, 0x9E, 0x23, 0x4C, 0x4D, 0x99, 0xB3, 0x16, 0x63, 0x8C,
  0x73, 0x06, 0x00, 0x0E, 0x1F, 0xDC, 0x6C, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC3, 0x3F, 0x8F, 0x80, 0x1E, 0x1F, 0x8C, 0x66, 0x33, 0x19, 0xF9, 0xF8,
  0xC0, 0x60, 0x30, 0x30, 0x00, 0x0E, 0x1F, 0xDC, 0x6C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0x3F, 0x8F, 0x01, 0x80, 0x60, 0x18, 0x1E, 0x1F, 0x8C,
  0x66, 0x33, 0x39, 0xF9, 0xF0, 0xCC, 0x66, 0x31, 0xB0, 0xC0, 0x1E, 0x3F,
  0x30, 0x30, 0x30, 0x1C, 0x0E, 0x06, 0x06, 0xDC, 0xF8, 0x7F, 0xFF, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x31, 0xB0, 0xD8, 0x6C,
  0x36, 0x1A, 0x1B, 0x0D, 0x86, 0xC3, 0x7F, 0x1F, 0x00, 0xC1, 0xE1, 0x90,
  0xC8, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0xC3, 0x0F,
  0x0C, 0x64, 0x71, 0x91, 0xCC, 0x4F, 0x31, 0x2D, 0x85, 0x96, 0x14, 0x50,
  0x71, 0xC1, 0xC6, 0x06, 0x18, 0x00, 0x18, 0x63, 0x18, 0x66, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xD8, 0x33, 0x0C, 0x63, 0x86, 0x00, 0xC3, 0xB1,
  0x99, 0x8D, 0x86, 0xC1, 0xC0, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x00, 0x3F,
  0x9F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x7F, 0x3F, 0x80,
  0x1C, 0xF3, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xE0, 0x93, 0x6D,
  0x92, 0x6D, 0x80, 0x1C, 0xF0, 0xC2, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C,
  0xE0, 0x08, 0x0C, 0x14, 0x36, 0x22, 0x62, 0xC3, 0xFC, 0xC4, 0x3B, 0x66,
  0xC6, 0xC6, 0xC6, 0xCC, 0xDC, 0xFC, 0x18, 0x30, 0x30, 0x3F, 0x33, 0x73,
  0x63, 0x63, 0x63, 0x66, 0xDC, 0x3D, 0x9C, 0x30, 0xC3, 0x0C, 0x9E, 0x03,
  0x03, 0x03, 0x3A, 0x66, 0xC6, 0xC6, 0xC6, 0xCC, 0xDC, 0xFC, 0x3C, 0xCF,
  0x1F, 0xEF, 0x18, 0x33, 0x3E, 0x07, 0x83, 0x03, 0x03, 0xE0, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x07, 0x81, 0x00, 0x1D, 0x99,
  0x98, 0xCC, 0x66, 0x33, 0x31, 0xB8, 0xFC, 0x06, 0x46, 0x3F, 0x06, 0x00,
  0x18, 0x30, 0x30, 0x3F, 0x3B, 0x73, 0x63, 0x63, 0x62, 0x66, 0xC6, 0x38,
  0x80, 0x63, 0x11, 0x8C, 0x63, 0x30, 0x0E, 0x08, 0x00, 0x60, 0xC1, 0x06,
  0x0C, 0x18, 0x30, 0xC1, 0x83, 0x1C, 0x30, 0x00, 0x18, 0x18, 0x0C, 0x06,
  0x73, 0x63, 0x61, 0xE0, 0xF8, 0x6C, 0x33, 0x31, 0x80, 0x19, 0x8C, 0x63,
  0x31, 0x8C, 0x63, 0x30, 0x3F, 0x71, 0xDC, 0xCC, 0xC6, 0xC6, 0x26, 0x33,
  0x33, 0x19, 0x98, 0xD8, 0xC6, 0x3F, 0x3B, 0x73, 0x63, 0x63, 0x63, 0x66,
  0xC6, 0x3C, 0xCF, 0x1E, 0x3C, 0x79, 0xB7, 0x3C, 0x3F, 0x33, 0x33, 0x63,
  0x63, 0x63, 0x66, 0xDC, 0xC0, 0xC0, 0xC0, 0x80, 0x3B, 0x66, 0xC6, 0xC6,
  0xC6, 0xCC, 0xDC, 0xFC, 0x0C, 0x08, 0x18, 0x18, 0x3E, 0x74, 0xC3, 0x06,
  0x0C, 0x18, 0x60, 0x3E, 0xC9, 0x83, 0xC1, 0xC1, 0xA7, 0x7C, 0x23, 0x3E,
  0xC4, 0x63, 0x18, 0xD7, 0x80, 0x63, 0x66, 0xC6, 0xC6, 0xC6, 0xCC, 0xDC,
  0xFC, 0xC7, 0x9B, 0x36, 0xCD, 0x9E, 0x1C, 0x30, 0xCC, 0x79, 0x9B, 0x7B,
  0x6B, 0x4F, 0x79, 0xCF, 0x39, 0xC7, 0x38, 0x31, 0x8D, 0x87, 0x81, 0x81,
  0xC1, 0xB0, 0xD9, 0xC6, 0x31, 0x99, 0x8C, 0xC6, 0xC3, 0x60, 0xE0, 0x70,
  0x30, 0x18, 0x18, 0x38, 0x18, 0x00, 0x3E, 0x98, 0x30, 0xC3, 0x0C, 0x30,
  0x7E, 0x0C, 0x71, 0x04, 0x30, 0xCE, 0x38, 0x61, 0x86, 0x18, 0x70, 0xFF,
  0xFC, 0x10, 0xE0, 0x86, 0x18, 0x60, 0xC7, 0x30, 0xC3, 0x08, 0xE0, 0xFF,
  0x1C,
};

const GFXglyph NotoSans_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 5, 4, 6, 2, -11 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 8, 12, 8, 0, -11 },
  { 37, 11, 11, 13, 1, -11 },
  { 53, 10, 11, 10, 0, -11 },
  { 67, 2, 4, 4, 2, -11 },
  { 68, 5, 13, 5, 1, -11 },
  { 77, 5, 13, 5, -1, -11 },
  { 86, 7, 7, 8, 1, -11 },
  { 93, 7, 7, 9, 1, -9 },
  { 100, 4, 4, 4, -1, -2 },
  { 102, 4, 2, 5, 0, -5 },
  { 103, 3, 2, 4, 0, -2 },
  { 104, 8, 11, 6, -1, -11 },
  { 115, 7, 11, 8, 1, -11 },
  { 125, 5, 11, 8, 2, -11 },
  { 132, 8, 11, 8, 0, -11 },
  { 143, 8, 11, 8, 0, -11 },
  { 154, 8, 11, 8, 0, -11 },
  { 165, 8, 11, 8, 0, -11 },
  { 176, 7, 11, 8, 1, -11 },
  { 186, 8, 11, 8, 1, -11 },
  { 197, 7, 11, 8, 1, -11 },
  { 207, 7, 11, 8, 1, -11 },
  { 217, 4, 8, 4, 0, -8 },
  { 221, 5, 10, 4, -1, -8 },
  { 228, 7, 7, 9, 1, -9 },
  { 235, 7, 4, 9, 1, -7 },
  { 239, 7, 7, 9, 1, -9 },
  { 246, 6, 11, 7, 1, -11 },
  { 255, 12, 12, 13, 1, -11 },
  { 273, 9, 11, 9, -1, -11 },
  { 286, 9, 11, 9, 0, -11 },
  { 299, 9, 11, 9, 1, -11 },
  { 312, 10, 11, 10, 0, -11 },
  { 326, 9, 11, 8, 0, -11 },
  { 339, 9, 11, 8, 0, -11 },
  { 352, 9, 11, 10, 1, -11 },
  { 365, 10, 11, 10, 0, -11 },
  { 379, 6, 11, 5, 0, -11 },
  { 388, 7, 14, 5, -2, -11 },
  { 401, 10, 11, 9, 0, -11 },
  { 415, 7, 11, 8, 0, -11 },
  { 425, 13, 11, 13, 0, -11 },
  { 443, 11, 11, 11, 0, -11 },
  { 459, 9, 11, 11, 1, -11 },
  { 472, 9, 11, 9, 0, -11 },
  { 485, 9, 14, 11, 1, -11 },
  { 501, 9, 11, 9, 0, -11 },
  { 514, 8, 11, 8, 0, -11 },
  { 525, 8, 11, 8, 1, -11 },
  { 536, 9, 11, 10, 1, -11 },
  { 549, 9, 11, 9, 1, -11 },
  { 562, 14, 11, 13, 1, -11 },
  { 582, 11, 11, 9, -1, -11 },
  { 598, 9, 11, 8, 1, -11 },
  { 611, 9, 11, 8, 0, -11 },
  { 624, 6, 13, 5, 0, -11 },
  { 634, 3, 11, 6, 2, -11 },
  { 639, 6, 13, 5, -1, -11 },
  { 649, 8, 7, 8, 0, -11 },
  { 656, 6, 1, 6, -1, 1 },
  { 657, 3, 2, 5, 2, -11 },
  { 658, 8, 8, 9, 1, -8 },
  { 666, 8, 11, 9, 0, -11 },
  { 677, 6, 8, 7, 1, -8 },
  { 683, 8, 11, 9, 1, -11 },
  { 694, 7, 8, 8, 1, -8 },
  { 701, 9, 15, 5, -2, -11 },
  { 718, 9, 12, 9, 0, -8 },
  { 732, 8, 11, 9, 0, -11 },
  { 743, 5, 11, 4, 0, -11 },
  { 750, 7, 15, 4, -2, -11 },
  { 764, 9, 11, 8, 0, -11 },
  { 777, 5, 11, 4, 0, -11 },
  { 784, 13, 8, 13, 0, -8 },
  { 797, 8, 8, 9, 0, -8 },
  { 805, 7, 8, 9, 1, -8 },
  { 812, 8, 12, 9, 0, -8 },
  { 824, 8, 12, 9, 1, -8 },
  { 836, 7, 8, 6, 0, -8 },
  { 843, 7, 8, 7, 0, -8 },
  { 850, 5, 10, 6, 1, -10 },
  { 857, 8, 8, 9, 1, -8 },
  { 865, 7, 8, 7, 1, -8 },
  { 872, 11, 8, 11, 1, -8 },
  { 883, 9, 8, 8, -1, -8 },
  { 892, 9, 12, 7, -1, -8 },
  { 906, 7, 8, 7, 0, -8 },
  { 913, 6, 13, 5, 0, -11 },
  { 923, 1, 14, 8, 4, -11 },
  { 925, 6, 13, 5, -1, -11 },
  { 935, 7, 2, 9, 1, -6 },
};

const GFXfont NotoSans_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMIBOLDITALIC15PT7B_H_
