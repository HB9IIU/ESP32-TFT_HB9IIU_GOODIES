#ifndef _NOTOSANS_SEMIBOLDITALIC26PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x77, 0xF3, 0xB9, 0xDC,
  0xEE, 0x66, 0x33, 0x18, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x1C, 0x03, 0x18,
  0x07, 0x18, 0x07, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x30, 0x0C, 0x70,
  0x0C, 0x60, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x18, 0xC0, 0x38, 0xC0,
  0x31, 0xC0, 0x31, 0x80, 0x71, 0x80, 0x00, 0xC0, 0x06, 0x00, 0xF0, 0x1F,
  0xF1, 0xFF, 0x9E, 0xC8, 0xE4, 0x07, 0x60, 0x3F, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x6F, 0x03, 0x78, 0x1B, 0xD0, 0xDC, 0xFF, 0xE7, 0xFE, 0x1F,
  0xC0, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x1E, 0x01, 0x87, 0xE0, 0x71, 0xFC,
  0x1C, 0x31, 0x87, 0x0E, 0x30, 0xC1, 0xCE, 0x38, 0x31, 0xCE, 0x06, 0x3B,
  0x80, 0xC6, 0x67, 0xDF, 0xDD, 0xFB, 0xF7, 0x73, 0xBC, 0xCC, 0x70, 0x33,
  0x8E, 0x0E, 0x71, 0x83, 0x8E, 0x30, 0x61, 0xCE, 0x18, 0x39, 0xC7, 0x07,
  0xF1, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xC7,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x39, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x83, 0xCF, 0xE1, 0xCF, 0x79, 0xEF, 0x1E, 0xE7, 0x07, 0xE3, 0x83, 0xF1,
  0xE0, 0xF0, 0xFB, 0xFC, 0x3F, 0xEE, 0x0F, 0xE7, 0x80, 0x7E, 0xEE, 0xEC,
  0xC0, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x80, 0xC0, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03,
  0x83, 0x83, 0x83, 0x83, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0xC6, 0x07,
  0xB0, 0x7F, 0xFC, 0x3F, 0xE1, 0xE7, 0x1F, 0x83, 0xCC, 0x0C, 0x70, 0x23,
  0x80, 0x10, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C,
  0xE7, 0x9C, 0x63, 0x80, 0xFF, 0xF8, 0x27, 0xFF, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0xC3, 0xBC,
  0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xEE, 0x07,
  0x70, 0x7B, 0x83, 0x9E, 0x3C, 0x7F, 0xC3, 0xFC, 0x0F, 0xC0, 0x03, 0x83,
  0xC7, 0xE7, 0xFF, 0xF7, 0xB9, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x00, 0x03, 0xE0, 0x3F, 0xE1,
  0xFF, 0x87, 0x0F, 0x08, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x83,
  0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x07, 0xF0, 0x3E, 0x00,
  0xFE, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xA0, 0x3C, 0xFB, 0xF3,
  0xFF, 0x87, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01,
  0xF8, 0x0E, 0xE0, 0x73, 0x83, 0xDC, 0x0E, 0x70, 0x71, 0xC3, 0x87, 0x1C,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x40, 0x3F, 0xC3, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xD0, 0x3C, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0x00, 0xF8, 0x1F,
  0xC3, 0xFE, 0x3E, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x78, 0x77, 0xE3,
  0xFF, 0x9E, 0x1D, 0xE0, 0xEF, 0x07, 0x78, 0x3B, 0xC1, 0xCE, 0x1C, 0x7B,
  0xE3, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0x73, 0xC3, 0x9E, 0x1C,
  0xF1, 0xE3, 0xDE, 0x0F, 0xE0, 0x7C, 0x0F, 0xF8, 0xF1, 0xCF, 0x0F, 0x70,
  0x3B, 0x81, 0xDC, 0x1E, 0xF9, 0xE3, 0xFF, 0x0F, 0xE0, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x78, 0xE7, 0x87, 0xB8, 0x3D, 0xC1, 0xEE, 0x0F, 0x70, 0x7B,
  0xCF, 0x8F, 0xFC, 0x7E, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0xFF,
  0xC7, 0xFC, 0x3F, 0x80, 0x1C, 0x3C, 0x70, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x83, 0x8F, 0x1E, 0x00, 0x0E, 0x0F, 0x0E, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x0F, 0x00,
  0x80, 0x00, 0x0F, 0x3F, 0xE7, 0xFD, 0x87, 0x01, 0xC0, 0x70, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C,
  0x0F, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1E, 0x01,
  0xC1, 0xC0, 0x07, 0x1C, 0x08, 0x18, 0xC3, 0xFC, 0xEE, 0x3F, 0xC7, 0x63,
  0x86, 0x3B, 0x18, 0x71, 0xF9, 0xC3, 0x8F, 0xCE, 0x18, 0x6E, 0x71, 0xC7,
  0x73, 0x8E, 0x33, 0x8F, 0xFF, 0x8C, 0x7C, 0xF8, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0xEE, 0x01, 0xCE,
  0x01, 0xCE, 0x03, 0x8E, 0x07, 0x8E, 0x07, 0x0E, 0x0F, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0xF0, 0x07,
  0x0F, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0xE1, 0xF1, 0xC1, 0xE3, 0x83, 0xCF,
  0x07, 0x1E, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xC1, 0xC7, 0x83,
  0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x00,
  0x01, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0xF0, 0x63, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0x0F, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x1C, 0x3E, 0x1C, 0x1E, 0x1C, 0x0E,
  0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E,
  0x78, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x10, 0xFF, 0x83, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x06, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0xFE, 0xE0, 0xFC, 0xE1, 0xFC, 0xE0, 0x3C,
  0xE0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0E, 0x03, 0x87, 0x01, 0xC7, 0x81, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0,
  0x38, 0xF0, 0x1C, 0x78, 0x1E, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x3C,
  0x70, 0x1E, 0x38, 0x0E, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x0E, 0x07,
  0x87, 0x07, 0x87, 0x87, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE7, 0x80, 0xF7,
  0x80, 0x7B, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0x38, 0x07,
  0x1C, 0x03, 0x8F, 0x01, 0xC3, 0x80, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x38,
  0x38, 0x1E, 0x00, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x7E, 0x0E, 0xE3, 0xB8, 0x3F, 0x0E, 0xE1,
  0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x39, 0xC3, 0xB8, 0xCF, 0x1C, 0xE7, 0x38,
  0x71, 0x98, 0xE1, 0xC6, 0xE3, 0x87, 0x1B, 0x0E, 0x1C, 0x7C, 0x70, 0xE1,
  0xE1, 0xC3, 0x87, 0x87, 0x0E, 0x1C, 0x1C, 0x00, 0x0E, 0x01, 0xC7, 0xC0,
  0x71, 0xF0, 0x1C, 0x7E, 0x07, 0x1F, 0x83, 0x87, 0xE0, 0xE3, 0xBC, 0x38,
  0xE7, 0x0E, 0x39, 0xC3, 0x8E, 0x79, 0xC3, 0x8E, 0x71, 0xC3, 0x9C, 0x70,
  0xF7, 0x1C, 0x1D, 0xC7, 0x07, 0xE1, 0xC1, 0xF8, 0xE0, 0x3E, 0x38, 0x0F,
  0x8E, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C,
  0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0xE1,
  0xE1, 0xC1, 0xC3, 0x83, 0xCF, 0x07, 0x1E, 0x0E, 0x38, 0x3C, 0x7F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x3E,
  0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x0F, 0xC0, 0x7F, 0xC1, 0xFF, 0x87, 0x0F, 0x1C, 0x1C,
  0x70, 0x73, 0xC1, 0xCF, 0x0F, 0x38, 0x78, 0xFF, 0xE3, 0xFE, 0x1F, 0xF0,
  0x79, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0xF0, 0x73, 0x81, 0xEE, 0x07,
  0x80, 0x03, 0xE0, 0x7F, 0xC7, 0xFC, 0x78, 0x23, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x90, 0x3C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0x7F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x81, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x0F,
  0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1C,
  0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78,
  0xF0, 0x78, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0xF0, 0x0F, 0xE0, 0x3D,
  0xC0, 0x73, 0x81, 0xE7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x70,
  0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x9E, 0x07, 0x38, 0x06, 0xF0, 0x0F, 0xC0,
  0x1B, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x38, 0x0E, 0xE0,
  0x70, 0x3D, 0xC1, 0xE0, 0x73, 0x83, 0xC0, 0xE7, 0x0F, 0x83, 0x8E, 0x1F,
  0x87, 0x1C, 0x37, 0x1E, 0x38, 0xEE, 0x38, 0x71, 0xDC, 0xF0, 0xE7, 0x39,
  0xC1, 0xCE, 0x73, 0x83, 0xB8, 0xEE, 0x07, 0x71, 0xDC, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x01,
  0xE0, 0x78, 0x00, 0x0E, 0x03, 0xC3, 0xC0, 0xE0, 0x70, 0x78, 0x1C, 0x3C,
  0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x70, 0x03, 0x9E, 0x01, 0xE3,
  0x80, 0xF0, 0xE0, 0x78, 0x3C, 0x1C, 0x07, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0xE0, 0x79, 0xC1, 0xE3, 0x83, 0x87, 0x8F, 0x07, 0x1C, 0x0E, 0x70, 0x1D,
  0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8,
  0x0F, 0xC3, 0xF0, 0xFC, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x3F, 0x0F, 0x80, 0xE3, 0x8E, 0x38, 0xE1, 0x87, 0x1C, 0x71,
  0xC7, 0x0C, 0x30, 0xE3, 0x8E, 0x38, 0xE1, 0xC0, 0x07, 0xE0, 0xF8, 0x3F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0xF8, 0x3F, 0x00, 0x01, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xFC,
  0x06, 0x60, 0x73, 0x87, 0x1C, 0x30, 0x63, 0x83, 0x98, 0x0D, 0xC0, 0x70,
  0xFF, 0xFF, 0xF0, 0xE7, 0x9C, 0x70, 0x0F, 0x9C, 0x7F, 0x63, 0xEF, 0x9E,
  0x1E, 0x78, 0x79, 0xC1, 0xEF, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0xC3, 0xCF,
  0x1F, 0x3E, 0xF8, 0x7F, 0xE0, 0xFB, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF7, 0xC7, 0x7E, 0x3E, 0x79, 0xE1, 0xCE,
  0x0E, 0xF0, 0x77, 0x03, 0xB8, 0x3D, 0xC1, 0xEE, 0x0E, 0xF0, 0xF7, 0xDF,
  0x3F, 0xF1, 0x9F, 0x00, 0x0F, 0xF1, 0xFE, 0x3E, 0x67, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xD8, 0x7F, 0x83,
  0xF8, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x83, 0xEF, 0x0F, 0xFC, 0x3E, 0xF8, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xCF,
  0x07, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xF1, 0xF1, 0xF7, 0xC1, 0xFF,
  0x81, 0xF7, 0x00, 0x0F, 0xE1, 0xFF, 0x3C, 0x77, 0x87, 0x70, 0x77, 0x1F,
  0xFF, 0xEF, 0xF8, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x8C, 0x7F, 0xC3, 0xFC,
  0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xFE, 0x07, 0xFC, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x5E, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x0F, 0x9C, 0x7F, 0x63, 0xEF, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xEF,
  0x07, 0x3C, 0x1C, 0xF0, 0x73, 0xC3, 0xCF, 0x1F, 0x3E, 0xF8, 0x7E, 0xE0,
  0xF3, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC3, 0x1F, 0x0F, 0xF8, 0x3F, 0x80,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF7, 0xC7,
  0x7F, 0x3E, 0x79, 0xE1, 0xCE, 0x0E, 0xF0, 0x77, 0x07, 0xB8, 0x39, 0xC1,
  0xCE, 0x0E, 0xF0, 0x77, 0x07, 0xB8, 0x39, 0xC1, 0xC0, 0x04, 0x3C, 0x78,
  0x60, 0x00, 0x0F, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF1,
  0xC3, 0x87, 0x00, 0x00, 0x40, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x07, 0xE0,
  0xF8, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC3, 0xCE, 0x1E, 0x38, 0xF0, 0xE7, 0x83, 0xBC, 0x1D, 0xE0,
  0x7F, 0x01, 0xFE, 0x07, 0xB8, 0x3C, 0xF0, 0xF3, 0xC3, 0x87, 0x0E, 0x1E,
  0x38, 0x3C, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE3,
  0xC7, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x00, 0x39, 0xF1, 0xF1, 0xDF,
  0x9F, 0x8F, 0xDF, 0xDE, 0x78, 0x78, 0x73, 0x83, 0x83, 0xBC, 0x3C, 0x3D,
  0xC1, 0xC1, 0xCE, 0x0E, 0x0E, 0x70, 0x70, 0x73, 0x83, 0x83, 0xBC, 0x3C,
  0x3D, 0xC1, 0xC1, 0xCE, 0x0E, 0x0E, 0x70, 0x70, 0x70, 0x39, 0xF1, 0xDF,
  0xCF, 0x9E, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xE1, 0xEE, 0x0E, 0x70, 0x77,
  0x83, 0xBC, 0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0x70, 0x0F, 0xE0, 0xFF, 0x8F,
  0xBC, 0xF0, 0xF7, 0x07, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x77, 0x03,
  0xBC, 0x3C, 0xF7, 0xC7, 0xFC, 0x0F, 0xC0, 0x0E, 0x7C, 0x1D, 0xF8, 0x3E,
  0x78, 0x78, 0x70, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1E,
  0x38, 0x38, 0xF0, 0xF1, 0xF7, 0xC3, 0xFF, 0x07, 0x7C, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x9C, 0x7F,
  0x63, 0xEF, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xEF, 0x07, 0x3C, 0x1C, 0xE0,
  0x73, 0x83, 0xCF, 0x1F, 0x3E, 0xF8, 0x7F, 0xE0, 0xF3, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x39, 0xE7, 0x78, 0xFF,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x00, 0x0F, 0xE7, 0xFC, 0xF1, 0x9C, 0x03, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x38, 0x07, 0x71, 0xEF, 0xF9, 0xFE, 0x00,
  0x0E, 0x03, 0x01, 0xC5, 0xFE, 0xFF, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xA1, 0xF8, 0x7E, 0x00, 0x3C, 0x1C,
  0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x78, 0x39, 0xC1, 0xE7, 0x07, 0x9C, 0x1C,
  0x70, 0x73, 0xC3, 0xCF, 0x1F, 0x3E, 0xD8, 0x7F, 0x60, 0xF3, 0x80, 0xF0,
  0x7F, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x1E, 0x38, 0xE1, 0xCF, 0x0E, 0x70,
  0x77, 0x83, 0xB8, 0x0D, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE1, 0xE1,
  0xFC, 0x3C, 0x3B, 0x8F, 0x87, 0x71, 0xB1, 0xCE, 0x76, 0x39, 0xCE, 0xCE,
  0x3B, 0x99, 0xC7, 0x73, 0x78, 0xEC, 0x6E, 0x1F, 0x8D, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x1C, 0x78,
  0x38, 0xE0, 0x7B, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1D, 0xC0, 0x73, 0x81, 0xE7, 0x87, 0x87, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E,
  0x78, 0x0E, 0x70, 0x06, 0x70, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xBE, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x20, 0xE0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0xFC, 0xFF, 0xCF, 0xF8,
  0x00, 0x60, 0x7C, 0x1F, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC1, 0xF0, 0x78, 0x0F, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x0F, 0x07, 0xC3, 0xC1,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x00, 0xFC,
  0x1F, 0xFF, 0xCF, 0xF8, 0x1E,
};

const GFXglyph NotoSans_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 11, 3, -19 },
  { 28, 16, 19, 17, 1, -19 },
  { 66, 13, 22, 14, 1, -20 },
  { 102, 19, 19, 22, 2, -19 },
  { 148, 17, 19, 18, 1, -19 },
  { 189, 4, 7, 6, 3, -19 },
  { 193, 9, 23, 8, 1, -19 },
  { 219, 9, 23, 8, -2, -19 },
  { 245, 13, 13, 14, 2, -20 },
  { 267, 12, 13, 15, 2, -16 },
  { 287, 6, 6, 7, -1, -3 },
  { 292, 7, 2, 8, 1, -8 },
  { 294, 4, 4, 7, 0, -4 },
  { 296, 13, 19, 10, -1, -19 },
  { 327, 13, 19, 14, 1, -19 },
  { 358, 9, 19, 14, 3, -19 },
  { 380, 14, 19, 14, 0, -19 },
  { 414, 14, 19, 14, 0, -19 },
  { 448, 14, 19, 14, 0, -19 },
  { 482, 13, 19, 14, 1, -19 },
  { 513, 13, 19, 14, 1, -19 },
  { 544, 14, 19, 14, 1, -19 },
  { 578, 13, 19, 14, 1, -19 },
  { 609, 13, 19, 14, 1, -19 },
  { 640, 7, 14, 7, 0, -14 },
  { 653, 8, 17, 7, -1, -14 },
  { 670, 12, 13, 15, 2, -16 },
  { 690, 12, 8, 15, 2, -13 },
  { 702, 12, 13, 15, 2, -16 },
  { 722, 10, 19, 12, 2, -19 },
  { 746, 21, 21, 22, 1, -19 },
  { 802, 16, 19, 16, -2, -19 },
  { 840, 15, 19, 16, 1, -19 },
  { 876, 15, 19, 16, 2, -19 },
  { 912, 16, 19, 18, 1, -19 },
  { 950, 14, 19, 14, 1, -19 },
  { 984, 14, 19, 13, 1, -19 },
  { 1018, 16, 19, 18, 2, -19 },
  { 1056, 17, 19, 18, 1, -19 },
  { 1097, 12, 19, 9, -1, -19 },
  { 1126, 12, 24, 8, -4, -19 },
  { 1162, 17, 19, 15, 1, -19 },
  { 1203, 10, 19, 13, 1, -19 },
  { 1227, 22, 19, 22, 1, -19 },
  { 1280, 18, 19, 19, 1, -19 },
  { 1323, 16, 19, 19, 2, -19 },
  { 1361, 15, 19, 15, 1, -19 },
  { 1397, 16, 23, 19, 2, -19 },
  { 1443, 14, 19, 16, 1, -19 },
  { 1477, 13, 19, 14, 1, -19 },
  { 1508, 14, 19, 14, 2, -19 },
  { 1542, 16, 19, 18, 2, -19 },
  { 1580, 15, 19, 15, 2, -19 },
  { 1616, 23, 19, 23, 2, -19 },
  { 1671, 18, 19, 15, -1, -19 },
  { 1714, 15, 19, 14, 2, -19 },
  { 1750, 16, 19, 14, -1, -19 },
  { 1788, 10, 23, 8, 0, -19 },
  { 1817, 6, 19, 10, 3, -19 },
  { 1832, 11, 23, 8, -2, -19 },
  { 1864, 13, 12, 15, 1, -19 },
  { 1884, 10, 2, 10, -2, 2 },
  { 1887, 5, 4, 8, 4, -20 },
  { 1890, 14, 14, 15, 1, -14 },
  { 1915, 13, 20, 15, 1, -20 },
  { 1948, 12, 14, 12, 1, -14 },
  { 1969, 15, 20, 15, 1, -20 },
  { 2007, 12, 14, 14, 1, -14 },
  { 2028, 15, 26, 9, -3, -20 },
  { 2077, 14, 20, 15, 1, -14 },
  { 2112, 13, 20, 15, 1, -20 },
  { 2145, 7, 20, 7, 1, -20 },
  { 2163, 11, 26, 7, -3, -20 },
  { 2199, 14, 20, 14, 1, -20 },
  { 2234, 7, 20, 7, 1, -20 },
  { 2252, 21, 14, 23, 1, -14 },
  { 2289, 13, 14, 15, 1, -14 },
  { 2312, 13, 14, 15, 1, -14 },
  { 2335, 15, 20, 15, -1, -14 },
  { 2373, 14, 20, 15, 1, -14 },
  { 2408, 11, 14, 11, 1, -14 },
  { 2428, 11, 14, 12, 0, -14 },
  { 2448, 10, 17, 10, 1, -17 },
  { 2470, 14, 14, 15, 1, -14 },
  { 2495, 13, 14, 13, 1, -14 },
  { 2518, 19, 14, 20, 2, -14 },
  { 2552, 15, 14, 13, -1, -14 },
  { 2579, 16, 20, 13, -2, -14 },
  { 2619, 12, 14, 12, 0, -14 },
  { 2640, 11, 23, 9, 0, -19 },
  { 2672, 3, 26, 14, 6, -20 },
  { 2682, 10, 23, 9, -1, -19 },
  { 2711, 12, 4, 15, 2, -11 },
};

const GFXfont NotoSans_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMIBOLDITALIC26PT7B_H_
