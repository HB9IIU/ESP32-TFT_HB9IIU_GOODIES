#ifndef _NOTOSANS_SEMIBOLDITALIC52PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x06, 0x00,
  0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0x87,
  0x83, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0x38, 0xF0, 0x1F, 0xC7, 0x02, 0x03, 0xF1, 0xE0, 0x00, 0x7E, 0x3C, 0x00,
  0x0F, 0xC7, 0x80, 0x01, 0xF8, 0xE0, 0x00, 0x3F, 0x9C, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0E, 0x7F, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x78, 0xFC, 0x00,
  0x0F, 0x1F, 0x80, 0x01, 0xC3, 0xF1, 0x80, 0x38, 0xFE, 0x3C, 0x0F, 0x3F,
  0xC7, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0,
  0x7F, 0xF0, 0x00, 0x7E, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0xFF, 0x80,
  0x0F, 0x80, 0x7E, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x0F,
  0x83, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x3F, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x3E, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0xFC,
  0x00, 0x3F, 0x07, 0xC3, 0xE1, 0xE0, 0xFC, 0x3F, 0x1F, 0x1F, 0xF3, 0xF0,
  0xFC, 0xF8, 0xFF, 0xE7, 0xC7, 0xE7, 0xE7, 0xFF, 0x9F, 0xFF, 0x1F, 0x3F,
  0xFF, 0x7F, 0xFC, 0xF9, 0xF8, 0x7C, 0xFF, 0xE7, 0xC7, 0xE1, 0xF1, 0xFE,
  0x3F, 0x1F, 0x07, 0xC0, 0xC0, 0xF8, 0xFC, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x7C, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0x07,
  0xC1, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x83,
  0xE0, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0,
  0x07, 0xE1, 0xF0, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0x3F, 0xFE,
  0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x03, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0x01, 0xF8, 0xFF, 0x3F,
  0xC1, 0xFC, 0xFF, 0x0F, 0xE0, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x7F, 0x01,
  0xFE, 0xFE, 0x3F, 0x80, 0x7F, 0xFE, 0x1F, 0x80, 0x1F, 0xFE, 0x0F, 0xC0,
  0x07, 0xFF, 0x07, 0xE0, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xC0,
  0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x40, 0x1F, 0x00, 0x70,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7F, 0x1E, 0x00, 0xFF, 0xDE, 0x00, 0xFF,
  0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0x03, 0xFE, 0x01, 0x07, 0xFF, 0x00, 0x0F, 0xCF, 0x00, 0x1F,
  0x8F, 0x80, 0x7F, 0x8F, 0x80, 0x3F, 0x0F, 0xC0, 0x1E, 0x07, 0xC0, 0x0C,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x80, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x87, 0xE0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xBF,
  0xBF, 0xCF, 0xC7, 0xC3, 0xF0, 0xE0, 0xFC, 0x20, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0x00, 0xFF, 0x00, 0x60, 0x03,
  0xF8, 0x02, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0xF0, 0x0E, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x02, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC4, 0x00, 0x0F, 0xF0, 0xF0, 0x03,
  0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE1, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x30, 0x00, 0x7F, 0x87, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x01, 0xFC, 0xFF, 0xC0, 0x7E, 0x7F, 0xF8,
  0x1F, 0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0x8F, 0xF8, 0xFF, 0x80,
  0xFE, 0x3F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x1F,
  0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03,
  0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x7F,
  0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF8, 0xFF, 0xDF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xC0,
  0xFF, 0xF3, 0xF0, 0x0F, 0xF9, 0xFC, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xC0, 0x3F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFC, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xF0, 0x1F, 0xE6,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0xFF, 0x80, 0xF8, 0x3E, 0x01,
  0xFF, 0xF8, 0x3E, 0x1F, 0x80, 0xFF, 0xFE, 0x0F, 0x87, 0xC0, 0x7F, 0xFF,
  0x83, 0xE3, 0xE0, 0x3F, 0x83, 0xE0, 0x7C, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x3E, 0x0F, 0xC0, 0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x1F, 0x03, 0xE7, 0xC1,
  0xF8, 0x07, 0xC0, 0xF9, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x7C, 0x1F, 0x00,
  0xF8, 0x0F, 0x9F, 0x07, 0xC0, 0x3E, 0x03, 0xE7, 0xC3, 0xF0, 0x1F, 0x81,
  0xF3, 0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0xF8, 0x3E, 0x03, 0xF0, 0x3F, 0x1F,
  0x0F, 0xC0, 0xFC, 0x0F, 0x87, 0xC1, 0xF0, 0x7F, 0x07, 0xE1, 0xF0, 0x7F,
  0x7F, 0xE7, 0xF0, 0x7C, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0x1F,
  0xFC, 0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x00, 0xF8, 0x03, 0x80, 0x38, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFC, 0x1F, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3E, 0x01,
  0xFF, 0x00, 0x18, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x80,
  0x3F, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0x0F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xE1, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFF, 0x0F, 0xE0, 0x07, 0xFC,
  0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7C, 0x03,
  0xFE, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x7F,
  0x00, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xF8, 0xFE,
  0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xE0, 0x3F,
  0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x41, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0x80,
  0x03, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xDF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0x7C, 0x00, 0x1F,
  0x7E, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x00, 0xFB, 0xF0,
  0x1F, 0xBE, 0x00, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x7E,
  0xF8, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x00, 0x3E, 0x7E, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0x8F, 0xE0, 0x3F, 0x1F, 0x03, 0xF1, 0xF8,
  0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0x83, 0xE0, 0xFC, 0x07, 0xE1, 0xF0, 0xFC, 0x3F, 0x81, 0xF8, 0x3E,
  0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xC7, 0xE0, 0xFC, 0x07, 0xE0, 0xF9, 0xF8,
  0x1F, 0x80, 0xFC, 0x1F, 0xBF, 0x07, 0xF0, 0x1F, 0x83, 0xFF, 0xC0, 0xFC,
  0x07, 0xE0, 0x7F, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFF, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x7F,
  0xC0, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0x00, 0x3F,
  0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0xF8,
  0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x07, 0xE0, 0x3F, 0x7E, 0x00, 0x7F, 0x01,
  0xFB, 0xF8, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x7E, 0x7E, 0x00,
  0xFC, 0x03, 0xE3, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0xFC, 0x07,
  0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0x7E, 0x7F, 0x01, 0xF8, 0x03, 0xFB,
  0xF0, 0x0F, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x00, 0x7E, 0xFC, 0x07, 0xE0,
  0x03, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xFC, 0x07, 0xE0, 0x00,
  0x7F, 0xE0, 0x3F, 0x00, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0,
  0x7E, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xFF,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x01,
  0xE0, 0x3F, 0xC0, 0x0C, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x7F, 0x06, 0x00, 0x1F,
  0xE0, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC1,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xC7,
  0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7D, 0xF0, 0x0F, 0xE1, 0xF8,
  0x07, 0xEF, 0x80, 0x7E, 0x0F, 0xE0, 0x3E, 0x7C, 0x07, 0xF0, 0x7F, 0x03,
  0xF3, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x9F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8,
  0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x03, 0xF0, 0x7C, 0x3E,
  0x0F, 0xE0, 0x1F, 0x87, 0xE1, 0xF0, 0x7E, 0x00, 0xFC, 0x3E, 0x0F, 0x87,
  0xF0, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x00, 0x3F, 0x1F, 0x83, 0xE1, 0xF8,
  0x01, 0xF9, 0xF8, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x00,
  0x7E, 0x7C, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x00, 0x1F,
  0xBE, 0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0x07, 0xDF,
  0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xFC, 0x7E, 0x00, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x3F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFE,
  0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xF8, 0x7C, 0x07, 0xFF, 0x8F, 0x81, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFF, 0x7E, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x1F,
  0xC0, 0xFF, 0x83, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xEF,
  0x80, 0xFF, 0xF9, 0xF0, 0x0F, 0xFE, 0x7E, 0x00, 0xFF, 0x0F, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1C, 0x00, 0x3F, 0x1F, 0xF0, 0x07,
  0xE7, 0xFF, 0x00, 0xFD, 0xFF, 0xF0, 0x3F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xE1, 0xFF, 0x87,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xDF, 0xFF, 0xC0, 0xF9, 0xFF, 0xF0, 0x3F,
  0x1F, 0xFC, 0x07, 0xC1, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x02, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x08, 0x3F, 0xC0, 0x70, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x7F,
  0xC7, 0xE0, 0x07, 0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0xFD,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x7C, 0x00, 0xFF, 0xF9, 0xF0, 0x01,
  0xFF, 0xC7, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x3F, 0x1F, 0xE0, 0x3F, 0x1F,
  0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x7F,
  0x0F, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x7F, 0x80, 0x38, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x08,
  0x01, 0xFF, 0x0F, 0x80, 0x3F, 0xFC, 0x7C, 0x03, 0xFF, 0xF7, 0xE0, 0x3F,
  0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0x9F, 0x80, 0x1F, 0xF9,
  0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x20,
  0x00, 0xFE, 0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x3F, 0x1F, 0xF0, 0x07, 0xE7, 0xFF,
  0x00, 0xFD, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFC, 0x1F, 0xF0, 0x3F, 0x87, 0xFC, 0x03, 0xF0, 0xFF, 0x00, 0x7E,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0x87, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x81, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F,
  0x07, 0xF8, 0x01, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xE7, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x01, 0xFB, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x3F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x7C, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0x8F, 0xFE, 0x0F, 0xFE, 0x01, 0xF3, 0xFF, 0xC3, 0xFF, 0xE0, 0x7E,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x3F, 0xE0, 0x0F, 0x8F, 0xFF, 0x03,
  0xF3, 0xFF, 0xE0, 0x7E, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x83,
  0xF8, 0x3F, 0xE0, 0x7F, 0x0F, 0xF8, 0x07, 0xE1, 0xFE, 0x00, 0xFC, 0x3F,
  0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F,
  0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0x07, 0xC7,
  0xFF, 0x00, 0x1F, 0x3F, 0xFE, 0x00, 0xFD, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFD, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0x80, 0x1F,
  0xC7, 0xF8, 0x00, 0x7E, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x7C, 0x07, 0xFF, 0x8F, 0x81, 0xFF,
  0xFB, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0,
  0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xF0, 0x0F, 0xFC, 0x7E, 0x00, 0xFF,
  0x1F, 0xC0, 0x03, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x87,
  0xF0, 0x3E, 0x3F, 0xC0, 0xF9, 0xFF, 0x07, 0xEF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFD, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0x83, 0xF8, 0x06, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x20, 0x01, 0xFC, 0x70, 0x07, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x40, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF8, 0x7E, 0x00,
  0xFF, 0x0F, 0xC0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF8, 0x3F, 0x83, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0x9F, 0x00, 0xFF, 0xE3,
  0xE0, 0x0F, 0xF0, 0x7C, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x7E, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x3E, 0x3F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xF0, 0x0F, 0xCF, 0xC0,
  0x3F, 0xE0, 0x3F, 0x9F, 0x80, 0xFF, 0xC0, 0x7E, 0x3F, 0x01, 0xFF, 0x81,
  0xFC, 0x7E, 0x07, 0xDF, 0x03, 0xF8, 0xFC, 0x0F, 0xBE, 0x07, 0xE1, 0xF8,
  0x3F, 0x7C, 0x1F, 0xC1, 0xF0, 0x7C, 0xF8, 0x3F, 0x03, 0xE0, 0xF9, 0xF0,
  0xFE, 0x07, 0xC3, 0xE3, 0xE1, 0xF8, 0x0F, 0x87, 0xC7, 0xC7, 0xF0, 0x1F,
  0x1F, 0x8F, 0x8F, 0xC0, 0x3E, 0x3E, 0x1F, 0x1F, 0x80, 0x7C, 0xFC, 0x3E,
  0x7E, 0x00, 0xF9, 0xF0, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0xFB, 0xF0, 0x03,
  0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0,
  0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFA, 0x00, 0x1F, 0xF9, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 38, 14, 1, -37 },
  { 73, 18, 13, 22, 5, -37 },
  { 103, 33, 37, 34, 1, -37 },
  { 256, 27, 42, 29, 1, -39 },
  { 398, 38, 38, 43, 3, -38 },
  { 579, 33, 39, 36, 2, -38 },
  { 740, 8, 13, 13, 5, -37 },
  { 753, 18, 45, 17, 2, -37 },
  { 855, 19, 46, 17, -4, -38 },
  { 965, 24, 25, 29, 5, -40 },
  { 1040, 25, 25, 30, 3, -31 },
  { 1119, 11, 13, 14, -2, -6 },
  { 1137, 14, 6, 17, 1, -17 },
  { 1148, 8, 8, 14, 1, -7 },
  { 1156, 27, 37, 21, -2, -37 },
  { 1281, 26, 39, 29, 2, -38 },
  { 1408, 18, 37, 29, 6, -37 },
  { 1492, 29, 38, 29, -1, -38 },
  { 1630, 27, 39, 29, 1, -38 },
  { 1762, 28, 37, 29, 0, -37 },
  { 1892, 27, 38, 29, 1, -37 },
  { 2021, 26, 39, 29, 3, -38 },
  { 2148, 27, 37, 29, 3, -37 },
  { 2273, 26, 39, 29, 2, -38 },
  { 2400, 26, 39, 29, 2, -38 },
  { 2527, 12, 30, 14, 1, -29 },
  { 2572, 16, 36, 14, -3, -29 },
  { 2644, 25, 27, 30, 3, -32 },
  { 2729, 25, 15, 30, 3, -26 },
  { 2776, 25, 27, 30, 3, -32 },
  { 2861, 21, 39, 23, 4, -38 },
  { 2964, 42, 42, 44, 2, -37 },
  { 3185, 31, 37, 31, -3, -37 },
  { 3329, 29, 37, 32, 2, -37 },
  { 3464, 31, 39, 31, 3, -38 },
  { 3616, 31, 37, 35, 2, -37 },
  { 3760, 28, 37, 28, 2, -37 },
  { 3890, 27, 37, 27, 2, -37 },
  { 4015, 32, 39, 36, 3, -38 },
  { 4171, 34, 37, 36, 2, -37 },
  { 4329, 23, 37, 19, -1, -37 },
  { 4436, 25, 48, 16, -8, -37 },
  { 4586, 34, 37, 31, 2, -37 },
  { 4744, 21, 37, 26, 2, -37 },
  { 4842, 43, 37, 45, 2, -37 },
  { 5041, 37, 37, 38, 2, -37 },
  { 5213, 33, 39, 38, 3, -38 },
  { 5374, 29, 37, 31, 2, -37 },
  { 5509, 33, 47, 38, 3, -38 },
  { 5703, 28, 37, 31, 2, -37 },
  { 5833, 27, 39, 27, 1, -38 },
  { 5965, 27, 37, 27, 4, -37 },
  { 6090, 32, 38, 36, 4, -37 },
  { 6242, 30, 37, 30, 5, -37 },
  { 6381, 45, 37, 46, 5, -37 },
  { 6590, 37, 37, 30, -3, -37 },
  { 6762, 28, 37, 28, 5, -37 },
  { 6892, 31, 37, 28, -1, -37 },
  { 7036, 21, 45, 16, -1, -37 },
  { 7155, 11, 37, 21, 6, -37 },
  { 7206, 21, 45, 16, -4, -37 },
  { 7325, 27, 24, 29, 1, -37 },
  { 7406, 22, 3, 21, -5, 5 },
  { 7415, 10, 8, 16, 8, -40 },
  { 7425, 27, 30, 30, 2, -29 },
  { 7527, 27, 41, 31, 1, -40 },
  { 7666, 23, 30, 25, 2, -29 },
  { 7753, 30, 41, 31, 2, -40 },
  { 7907, 24, 30, 28, 2, -29 },
  { 7997, 30, 52, 18, -6, -40 },
  { 8192, 29, 41, 31, 1, -29 },
  { 8341, 27, 40, 31, 1, -40 },
  { 8476, 15, 39, 15, 1, -39 },
  { 8550, 23, 51, 15, -7, -39 },
  { 8697, 29, 40, 28, 1, -40 },
  { 8842, 15, 40, 15, 1, -40 },
  { 8917, 43, 29, 46, 1, -29 },
  { 9073, 27, 29, 31, 1, -29 },
  { 9171, 26, 29, 30, 2, -29 },
  { 9266, 30, 41, 31, -2, -29 },
  { 9420, 27, 41, 31, 2, -29 },
  { 9559, 22, 29, 21, 1, -29 },
  { 9639, 23, 30, 24, 0, -29 },
  { 9726, 19, 35, 20, 2, -34 },
  { 9810, 27, 29, 31, 3, -28 },
  { 9908, 26, 28, 26, 3, -28 },
  { 9999, 39, 28, 40, 3, -28 },
  { 10136, 31, 28, 27, -2, -28 },
  { 10245, 33, 40, 26, -4, -28 },
  { 10410, 25, 28, 24, -1, -28 },
  { 10498, 21, 45, 18, 0, -37 },
  { 10617, 5, 51, 29, 12, -39 },
  { 10649, 20, 45, 18, -2, -37 },
  { 10762, 25, 8, 30, 3, -22 },
};

const GFXfont NotoSans_SemiBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMIBOLDITALIC52PT7B_H_
