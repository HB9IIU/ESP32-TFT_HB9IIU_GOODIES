#ifndef _NOTOSANS_SEMIBOLDITALIC42PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x20, 0x00,
  0x3E, 0x3E, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F, 0x1E,
  0x1E, 0x3C, 0x3C, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x78, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xCE, 0x30,
  0x3E, 0x30, 0x00, 0xF9, 0xC0, 0x03, 0xE7, 0x00, 0x0F, 0x9C, 0x00, 0x3F,
  0x70, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x73, 0xE0, 0x01, 0xCF, 0xC0,
  0x07, 0x3F, 0x00, 0x18, 0xF8, 0xC0, 0xE3, 0xE3, 0xE3, 0xBF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xF0, 0x7F, 0xC0, 0x07, 0x83, 0xFF, 0x80, 0x3C, 0x0F, 0x9E, 0x01, 0xF0,
  0x7C, 0x7C, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x07, 0x87, 0xC1, 0xE0, 0x3E,
  0x1F, 0x0F, 0x80, 0xF0, 0x78, 0x3C, 0x03, 0xC1, 0xE1, 0xE0, 0x0F, 0x07,
  0x8F, 0x80, 0x3C, 0x3E, 0x7C, 0x00, 0xF0, 0xF1, 0xE7, 0xF3, 0xC7, 0xCF,
  0x3F, 0xEF, 0xBE, 0x7D, 0xFF, 0xFF, 0xF9, 0xE7, 0xDF, 0x7F, 0xCF, 0x3E,
  0x3C, 0xFE, 0x78, 0xF0, 0xF0, 0x03, 0xE7, 0xC3, 0xC0, 0x0F, 0x1E, 0x0F,
  0x00, 0x78, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0x07, 0x87, 0xC0,
  0x78, 0x3E, 0x1E, 0x03, 0xC0, 0xF8, 0x78, 0x1E, 0x01, 0xE3, 0xE0, 0xF8,
  0x07, 0xDF, 0x03, 0xC0, 0x1F, 0xFC, 0x1E, 0x00, 0x3F, 0xE0, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0x1F, 0xFF, 0x07, 0xE7,
  0xF3, 0xE0, 0xF9, 0xF8, 0x7E, 0x3F, 0x3F, 0x07, 0xE7, 0xC7, 0xC0, 0x7F,
  0xF1, 0xF8, 0x0F, 0xFE, 0x3F, 0x00, 0xFF, 0x87, 0xE0, 0x0F, 0xE0, 0x7C,
  0x01, 0xFC, 0x0F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xF3, 0xF0, 0x1F, 0xF8, 0x3F, 0x80, 0x3E, 0x79, 0xF3, 0xE7,
  0xCF, 0x1E, 0x3C, 0x71, 0xE3, 0xC0, 0x00, 0x7E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x40, 0x78, 0x07, 0x07, 0x00, 0xFC, 0x70, 0x0F, 0xF7, 0x00, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x3F, 0x0F, 0xF8, 0x01, 0xF7,
  0x80, 0x3F, 0x3C, 0x07, 0xE3, 0xC0, 0x3C, 0x3E, 0x01, 0x83, 0xE0, 0x08,
  0x1E, 0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0xC7,
  0xE3, 0xE3, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0xFD, 0xFB, 0xFF, 0xEF, 0x8C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD,
  0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1F, 0x01,
  0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE1, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x7F, 0x7C, 0x78, 0xF8, 0xE1, 0xF1,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x0F, 0xE0, 0x38, 0x0F, 0xC0, 0x20, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x78, 0x1F, 0x81, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x80, 0x07, 0xE7, 0x00,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E,
  0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xEF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x80, 0x0F, 0xE3, 0xC0, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0xFE, 0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xF0, 0xFC, 0xFE, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80,
  0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3,
  0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xFC,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xFC, 0x7C,
  0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0x7C, 0x03,
  0xE1, 0xF8, 0x1F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0x87, 0xF3, 0xF0, 0x3F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7,
  0xE0, 0x7F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xBE,
  0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x08, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0,
  0xFC, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xE1, 0xFC,
  0x1F, 0x01, 0x80, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xC1, 0xF9, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0xFC, 0x0F, 0x8F, 0x03,
  0xFF, 0xC3, 0xCF, 0x03, 0xFF, 0xE1, 0xE7, 0x83, 0xFB, 0xE0, 0xF7, 0x83,
  0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0x78, 0x3D, 0xE1, 0xE0, 0x3C, 0x1F, 0xE0,
  0xF0, 0x3C, 0x0F, 0xF0, 0xF8, 0x1E, 0x07, 0xF8, 0x78, 0x0F, 0x07, 0xFC,
  0x3C, 0x0F, 0x83, 0xDE, 0x1E, 0x07, 0x81, 0xEF, 0x0F, 0x07, 0xC1, 0xE7,
  0x87, 0xC3, 0xE1, 0xF3, 0xC3, 0xFF, 0xFF, 0xF1, 0xF0, 0xFF, 0xBF, 0xF0,
  0x78, 0x3F, 0x8F, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x38,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x1F, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xE1, 0xFF, 0x03, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x00,
  0xFC, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8,
  0x3E, 0x0F, 0xE0, 0x04, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x20, 0x7F, 0xC1, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x07, 0xF8, 0x7E, 0x03,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xC1, 0xF0, 0x7F, 0x00, 0x10, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xFD, 0xF0,
  0x0F, 0xFC, 0xF8, 0x0F, 0xFE, 0x7C, 0x07, 0xFF, 0x3E, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x07,
  0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF0, 0x01,
  0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x03,
  0xE0, 0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7C,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xF7, 0xC0, 0x7B, 0xE0, 0x1E, 0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0xF9, 0xE0, 0x3C, 0xF8, 0x0F, 0x9E, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x78,
  0xF8, 0x0F, 0x1E, 0x0F, 0x9F, 0x81, 0xF1, 0xE0, 0xF1, 0xF0, 0x1F, 0x1E,
  0x1F, 0x1F, 0x01, 0xF1, 0xE1, 0xE1, 0xF0, 0x1F, 0x1E, 0x3E, 0x1F, 0x01,
  0xE1, 0xE3, 0xC3, 0xE0, 0x3E, 0x1F, 0x7C, 0x3E, 0x03, 0xE1, 0xF7, 0x83,
  0xE0, 0x3E, 0x1F, 0xF8, 0x3E, 0x03, 0xE0, 0xFF, 0x03, 0xE0, 0x7C, 0x0F,
  0xF0, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x7C, 0x0F, 0xE0, 0x7C, 0x07,
  0xC0, 0xFC, 0x07, 0xC0, 0x78, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x7C, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0xC0, 0x07,
  0xC0, 0xFF, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0xF8, 0x1F, 0xF8, 0x03, 0xE0,
  0x7F, 0xE0, 0x0F, 0x81, 0xFF, 0x80, 0x3E, 0x07, 0x9F, 0x01, 0xF0, 0x1E,
  0x7C, 0x07, 0xC0, 0xF9, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F, 0x8F,
  0x81, 0xF0, 0x3E, 0x3E, 0x0F, 0x80, 0xF0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0,
  0xF8, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x3E, 0x7C,
  0x07, 0x80, 0xF9, 0xF0, 0x3E, 0x01, 0xF7, 0xC0, 0xF8, 0x07, 0xDF, 0x03,
  0xE0, 0x1F, 0x7C, 0x0F, 0x80, 0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0x81, 0xF0,
  0x03, 0xFE, 0x07, 0xC0, 0x07, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x7F, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0x83, 0xF8,
  0x07, 0xE1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8,
  0x7E, 0x01, 0xFC, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE3, 0xFE, 0x03,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xE1, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x1F,
  0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xE1, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xFE, 0x0F, 0x83, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x0F, 0x07, 0xE0,
  0x08, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x80, 0x0F, 0xC7, 0x81, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0xC3, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C,
  0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0xFD, 0xF0, 0x07, 0xF0,
  0x07, 0xCF, 0x80, 0x3F, 0x80, 0x7E, 0x7C, 0x03, 0xFC, 0x03, 0xE3, 0xE0,
  0x1F, 0xE0, 0x1F, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0xF8, 0x0F, 0x78, 0x0F,
  0x87, 0xC0, 0x7B, 0xC0, 0xFC, 0x3E, 0x07, 0xDE, 0x07, 0xC1, 0xF0, 0x3C,
  0xF0, 0x7E, 0x0F, 0x83, 0xE7, 0x83, 0xE0, 0x3C, 0x1E, 0x3C, 0x1F, 0x01,
  0xE1, 0xF1, 0xE1, 0xF0, 0x0F, 0x0F, 0x0F, 0x0F, 0x80, 0x78, 0xF8, 0x78,
  0xF8, 0x03, 0xC7, 0xC3, 0xC7, 0xC0, 0x1E, 0x7C, 0x1E, 0x3E, 0x00, 0xF3,
  0xE0, 0xF3, 0xE0, 0x07, 0x9E, 0x07, 0x9F, 0x00, 0x3D, 0xF0, 0x3D, 0xF0,
  0x01, 0xEF, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFB, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0xFC,
  0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00,
  0x7C, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0,
  0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0,
  0x7C, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xBE, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x1E, 0x01, 0xE0,
  0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87,
  0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F, 0x07,
  0x01, 0xFC, 0x3C, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0x83, 0xFF, 0xFE, 0x1F,
  0xC7, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01,
  0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xF0,
  0x7F, 0x0F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xF7, 0xC0, 0xFF, 0x9E,
  0x01, 0xFC, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0xFD, 0xFF, 0x03, 0xEF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xC7, 0xE0, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x3E,
  0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x7E, 0x01,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC3,
  0xEF, 0xFE, 0x0F, 0xBF, 0xF0, 0x3C, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xC1, 0x8F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x61, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x01, 0xFC, 0x7C, 0x03, 0xFE, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x01, 0xF0,
  0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0,
  0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0,
  0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xF7, 0xC0, 0x3F, 0xE7, 0x80, 0x1F, 0xC7, 0x80,
  0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xF8, 0x3E,
  0x7E, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x07, 0xEF, 0x87, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0C, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x10, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x04, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1E, 0x03, 0xFE,
  0x7C, 0x1F, 0xFE, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F,
  0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF1,
  0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8,
  0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xF8, 0x03, 0xF1,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x04, 0x00, 0xFC, 0x0F, 0x07, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0xFD, 0xFF,
  0x03, 0xEF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC7,
  0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C,
  0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x01, 0xF8, 0x00, 0x40,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x00, 0x01,
  0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x27, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0,
  0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3E, 0x01,
  0xF0, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0x87, 0xE0, 0x3F, 0x03, 0xE7, 0xFC,
  0x3F, 0xE0, 0xFB, 0xFF, 0x1F, 0xFC, 0x3F, 0xFF, 0xEF, 0xFF, 0x0F, 0xF1,
  0xFF, 0x8F, 0xC3, 0xF8, 0x3F, 0xC1, 0xF1, 0xFC, 0x0F, 0xE0, 0x7C, 0x7E,
  0x03, 0xF0, 0x1F, 0x1F, 0x80, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x80, 0xFC, 0xFC, 0x07, 0xE0, 0x3E, 0x3E, 0x01, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC0,
  0x7E, 0x7E, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0xFC, 0x07, 0xE0, 0x3F, 0x3F, 0x01,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0x87, 0xE0, 0x3E, 0x7F,
  0xC0, 0xFB, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xF1,
  0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F,
  0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F,
  0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF3,
  0xF0, 0x3F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0xC0, 0xFC, 0x7E, 0x1F, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xE1, 0xF0,
  0x03, 0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xDF, 0xFE, 0x03, 0xFC, 0x7E,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC,
  0x1F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0xFF, 0xE0,
  0x3E, 0x7F, 0xC0, 0x3E, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x3C, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0x83, 0xFF, 0xFE, 0x1F,
  0xC7, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01,
  0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xF7, 0xC0, 0xFF, 0xBE,
  0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x07, 0x87, 0xC3, 0xE7, 0xE0,
  0xFB, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x81, 0x87, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x20, 0x07, 0xCC, 0x03, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x10,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0x80, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03,
  0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7,
  0xE0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xF7, 0xC0, 0xFF, 0x9F, 0x01, 0xFC, 0x78, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xC7, 0xC0,
  0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xC7, 0xC0, 0x1E, 0x3E,
  0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x07, 0xE0, 0x3F, 0x78, 0x07, 0xE0, 0x3E, 0x78, 0x0F, 0xE0,
  0x3E, 0x78, 0x0F, 0xE0, 0x7C, 0x7C, 0x1F, 0xE0, 0x7C, 0x7C, 0x1F, 0xE0,
  0xFC, 0x7C, 0x3D, 0xE0, 0xF8, 0x7C, 0x3D, 0xE1, 0xF8, 0x7C, 0x7D, 0xE1,
  0xF0, 0x7C, 0x79, 0xE3, 0xF0, 0x7C, 0x79, 0xE3, 0xE0, 0x7C, 0xF1, 0xE3,
  0xE0, 0x7C, 0xF1, 0xE7, 0xC0, 0x7D, 0xF1, 0xE7, 0xC0, 0x7D, 0xE1, 0xEF,
  0x80, 0x7F, 0xE1, 0xEF, 0x80, 0x7F, 0xC1, 0xEF, 0x00, 0x7B, 0xC1, 0xFF,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0x81, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xE3, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x1F, 0x80, 0x07, 0xC7, 0xC0,
  0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x8F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x40, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 31, 12, 1, -30 },
  { 48, 15, 11, 18, 4, -30 },
  { 69, 26, 30, 27, 1, -30 },
  { 167, 22, 34, 23, 1, -32 },
  { 261, 30, 30, 35, 3, -30 },
  { 374, 27, 30, 29, 1, -30 },
  { 476, 7, 11, 10, 4, -30 },
  { 486, 15, 37, 13, 2, -30 },
  { 556, 15, 37, 14, -3, -30 },
  { 626, 20, 20, 23, 4, -32 },
  { 676, 21, 20, 24, 2, -25 },
  { 729, 9, 10, 12, -2, -5 },
  { 741, 11, 5, 13, 1, -14 },
  { 748, 7, 7, 12, 0, -6 },
  { 755, 22, 30, 17, -2, -30 },
  { 838, 21, 30, 23, 2, -30 },
  { 917, 15, 30, 23, 5, -30 },
  { 974, 23, 30, 23, -1, -30 },
  { 1061, 21, 30, 23, 1, -30 },
  { 1140, 22, 30, 23, 0, -30 },
  { 1223, 22, 30, 23, 1, -30 },
  { 1306, 21, 30, 23, 2, -30 },
  { 1385, 22, 30, 23, 2, -30 },
  { 1468, 22, 30, 23, 1, -30 },
  { 1551, 20, 30, 23, 2, -30 },
  { 1626, 11, 24, 12, 0, -23 },
  { 1659, 13, 28, 12, -2, -23 },
  { 1705, 21, 22, 24, 2, -26 },
  { 1763, 20, 12, 24, 3, -21 },
  { 1793, 21, 22, 24, 2, -26 },
  { 1851, 17, 31, 19, 3, -30 },
  { 1917, 33, 34, 36, 2, -30 },
  { 2058, 25, 30, 25, -2, -30 },
  { 2152, 24, 30, 26, 1, -30 },
  { 2242, 24, 30, 25, 3, -30 },
  { 2332, 26, 30, 28, 1, -30 },
  { 2430, 23, 30, 22, 1, -30 },
  { 2517, 23, 30, 22, 1, -30 },
  { 2604, 25, 30, 29, 3, -30 },
  { 2698, 28, 30, 29, 1, -30 },
  { 2803, 19, 30, 15, -1, -30 },
  { 2875, 20, 39, 13, -7, -30 },
  { 2973, 28, 30, 25, 1, -30 },
  { 3078, 17, 30, 21, 1, -30 },
  { 3142, 36, 30, 36, 1, -30 },
  { 3277, 30, 30, 31, 1, -30 },
  { 3390, 26, 30, 31, 3, -30 },
  { 3488, 24, 30, 25, 1, -30 },
  { 3578, 26, 37, 31, 3, -30 },
  { 3699, 24, 30, 25, 1, -30 },
  { 3789, 21, 30, 22, 1, -30 },
  { 3868, 21, 30, 22, 4, -30 },
  { 3947, 26, 30, 29, 3, -30 },
  { 4045, 24, 30, 24, 4, -30 },
  { 4135, 37, 30, 37, 4, -30 },
  { 4274, 30, 30, 24, -2, -30 },
  { 4387, 23, 30, 23, 4, -30 },
  { 4474, 25, 30, 22, -1, -30 },
  { 4568, 17, 37, 13, -1, -30 },
  { 4647, 9, 30, 17, 5, -30 },
  { 4681, 17, 37, 13, -3, -30 },
  { 4760, 21, 19, 23, 1, -30 },
  { 4810, 18, 3, 17, -4, 4 },
  { 4817, 8, 7, 13, 6, -32 },
  { 4824, 22, 23, 24, 2, -23 },
  { 4888, 22, 32, 25, 1, -32 },
  { 4976, 18, 23, 20, 2, -23 },
  { 5028, 24, 32, 25, 2, -32 },
  { 5124, 19, 23, 22, 2, -23 },
  { 5179, 25, 42, 15, -5, -32 },
  { 5311, 23, 33, 25, 1, -23 },
  { 5406, 22, 32, 25, 1, -32 },
  { 5494, 12, 32, 12, 1, -32 },
  { 5542, 18, 42, 12, -5, -32 },
  { 5637, 23, 32, 23, 1, -32 },
  { 5729, 12, 32, 12, 1, -32 },
  { 5777, 34, 23, 38, 1, -23 },
  { 5875, 22, 23, 25, 1, -23 },
  { 5939, 20, 23, 24, 2, -23 },
  { 5997, 24, 33, 25, -1, -23 },
  { 6096, 22, 33, 25, 2, -23 },
  { 6187, 18, 23, 17, 1, -23 },
  { 6239, 18, 23, 19, 0, -23 },
  { 6291, 15, 28, 16, 2, -28 },
  { 6344, 22, 23, 25, 2, -23 },
  { 6408, 21, 23, 21, 2, -23 },
  { 6469, 32, 23, 32, 2, -23 },
  { 6561, 25, 23, 22, -2, -23 },
  { 6633, 26, 33, 21, -3, -23 },
  { 6741, 20, 23, 19, -1, -23 },
  { 6799, 17, 37, 15, 0, -30 },
  { 6878, 4, 42, 23, 10, -32 },
  { 6899, 17, 37, 15, -2, -30 },
  { 6978, 21, 6, 24, 2, -18 },
};

const GFXfont NotoSans_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMIBOLDITALIC42PT7B_H_
