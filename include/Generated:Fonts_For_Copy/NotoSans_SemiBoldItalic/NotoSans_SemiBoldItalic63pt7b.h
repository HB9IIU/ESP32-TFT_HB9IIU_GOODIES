#ifndef _NOTOSANS_SEMIBOLDITALIC63PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC3, 0xFC,
  0xFF, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x78,
  0x3C, 0x07, 0xF8, 0x78, 0x08, 0x07, 0xF8, 0x78, 0x00, 0x07, 0xF0, 0x78,
  0x00, 0x07, 0xF0, 0xF8, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0xF8, 0xF0,
  0x00, 0x07, 0xFC, 0xF0, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xCF,
  0xF8, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x07, 0x87,
  0xF8, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x0F, 0x87, 0xF8, 0x80, 0x0F, 0x0F,
  0xF0, 0xF0, 0x0F, 0x1F, 0xF0, 0xFE, 0x0F, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFC, 0x01,
  0xFE, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF0, 0x3F, 0x81, 0xF8, 0x7E, 0x1F, 0xF0, 0xFE, 0x0F, 0xE3, 0xF1,
  0xFF, 0xF3, 0xF8, 0x7F, 0x1F, 0xCF, 0xFF, 0xEF, 0xE3, 0xFC, 0x7E, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE3, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0x1F, 0xCF, 0xF1,
  0xFC, 0xFF, 0xFC, 0xFE, 0x3F, 0x87, 0xF1, 0xFF, 0xE3, 0xF1, 0xFC, 0x0F,
  0xC3, 0xFE, 0x1F, 0x87, 0xF0, 0x3F, 0x03, 0x80, 0xFE, 0x1F, 0x80, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x1F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x00,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00,
  0x1F, 0xCF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0x7F,
  0xC0, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0xDF, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0x80, 0x07,
  0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x74, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0x7E,
  0x00, 0x0E, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFE, 0x1F, 0x00,
  0x0F, 0xFE, 0x7C, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0xFE,
  0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFE, 0x1F,
  0x80, 0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3E, 0x07, 0xF0,
  0x00, 0x70, 0x0F, 0xE0, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x1F, 0x0F, 0xE7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x03,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F,
  0xC3, 0xFE, 0x3F, 0x87, 0xF8, 0xFF, 0x07, 0xC1, 0xFE, 0x06, 0x03, 0xFC,
  0x08, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x07, 0xF8, 0x00,
  0x60, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x78,
  0x01, 0xFF, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x84, 0x00, 0x00,
  0x7F, 0xC3, 0x80, 0x00, 0xFF, 0xC1, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x08, 0x00, 0x01, 0xFF, 0x07,
  0x80, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xD0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x3F, 0xC7, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0xC0, 0x3F, 0x9F, 0xFF,
  0xE0, 0x7F, 0xBF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x7F,
  0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x07,
  0xF8, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xEF,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC,
  0xFF, 0x00, 0x7F, 0xF3, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7F, 0x81, 0xFF,
  0xF9, 0xFE, 0x03, 0xFF, 0xC7, 0xF0, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x30, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xB8, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0x03, 0xFF, 0x1C, 0x00, 0xFF, 0x88, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFF, 0xFD, 0x07, 0xE0, 0xFC, 0x00, 0xFF, 0xFF,
  0x81, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x7E, 0x1F, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0xE0, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xE0,
  0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF8,
  0x03, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF7, 0xE0, 0x7F,
  0x00, 0x7E, 0x01, 0xFD, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0xBF, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xEF, 0xC0,
  0xFC, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xCF,
  0xC0, 0xFC, 0x03, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8,
  0xFC, 0x0F, 0xE0, 0x7F, 0xC1, 0xFC, 0x3F, 0x81, 0xFE, 0xFF, 0xFB, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF,
  0x80, 0x7E, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x03, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFF, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x03,
  0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xFF, 0xF3, 0xFE, 0x00, 0x7F, 0xFF, 0x8F,
  0xF0, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x08, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0xEF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFF, 0xF8,
  0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x00,
  0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x1F, 0xE0, 0x0F, 0xF1, 0xF8, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0x87, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFC, 0x07, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC1,
  0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x7E, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF8,
  0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x01, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC3,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC0,
  0x03, 0xFD, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xC1, 0xFC, 0x01, 0xFF, 0x00, 0x1C, 0x01, 0xFF, 0x00,
  0x02, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x06, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x01, 0xFF,
  0x81, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x03, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xBF, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0x03, 0xF8,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0xFF, 0x00,
  0x07, 0xF1, 0xFC, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x07, 0xE3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x1F,
  0xC0, 0x1F, 0xFF, 0x0F, 0xC0, 0x1F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xF7,
  0xF0, 0x1F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xF8, 0x7F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0x00,
  0x7F, 0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF, 0x8F, 0xE0,
  0x01, 0xFF, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x03,
  0xFC, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0x00,
  0x7F, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xFC, 0x07, 0xF7,
  0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFC, 0x01, 0xF8, 0x7F, 0xFC, 0x01, 0xFC,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x0C, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x02, 0x07, 0xFE, 0x03, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x07, 0xFF, 0xC7, 0xF0, 0x00, 0xFF,
  0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0xC0, 0x03, 0xFF, 0xF8, 0xFC,
  0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFC, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x07, 0xF8,
  0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x07, 0xFE, 0x00, 0xF0,
  0x3F, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x5C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xEF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0xCF, 0xE0,
  0x0F, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFD, 0xFC, 0x00, 0x7F, 0xFF,
  0x3F, 0x80, 0x0F, 0xFF, 0xCF, 0xF0, 0x00, 0xFF, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x18, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x10, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x03,
  0xFC, 0x7F, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0x80,
  0x7F, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x06, 0x3F, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xF9, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x03, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0x0F, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0xE0,
  0x1F, 0x9F, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x80, 0x3F,
  0xC1, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x07,
  0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0xF0, 0x00, 0x3F, 0x8F, 0xFF, 0x80, 0x03, 0xF1, 0xFF, 0xFC, 0x00, 0x3F,
  0x3F, 0xFF, 0xC0, 0x03, 0xF7, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0xF0, 0x00, 0xFE, 0x3F, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF,
  0x0F, 0xC0, 0x1F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF,
  0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8,
  0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF8,
  0x3F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0xBF,
  0x80, 0x3F, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x38, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x07,
  0xF1, 0xFF, 0x80, 0xFE, 0x7F, 0xF0, 0x1F, 0xCF, 0xFC, 0x03, 0xFB, 0xFF,
  0x80, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0x07, 0xE0, 0x7F, 0x80, 0x1C, 0x1F, 0xF0, 0x00, 0x83, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x40, 0x00,
  0xFF, 0x0E, 0x00, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x40, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x0D, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFC,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0x80, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x3F, 0x80,
  0x7F, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0x0F, 0xC0, 0x07, 0xFE, 0x07, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF7, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0xFD, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFB, 0xF0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xCF, 0xC0,
  0xFF, 0x07, 0xF0, 0x1F, 0x9F, 0x81, 0xFE, 0x0F, 0xE0, 0x7E, 0x3F, 0x07,
  0xF8, 0x1F, 0xC0, 0xFC, 0x7E, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0xFC, 0x3F,
  0xC0, 0x7F, 0x07, 0xE1, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC3, 0xF1, 0xFE,
  0x00, 0xFC, 0x3F, 0x07, 0xE3, 0xFC, 0x01, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0,
  0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xE0, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x80,
  0x0F, 0xCF, 0xE0, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x00,
  0x3F, 0x7F, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x87, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0xFF,
  0xE2, 0x00, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 46, 17, 1, -45 },
  { 105, 22, 16, 27, 6, -45 },
  { 149, 39, 45, 41, 2, -45 },
  { 369, 32, 52, 35, 2, -48 },
  { 577, 46, 47, 53, 4, -46 },
  { 848, 41, 47, 44, 2, -46 },
  { 1089, 10, 16, 15, 6, -45 },
  { 1109, 23, 55, 20, 2, -45 },
  { 1268, 23, 55, 20, -5, -45 },
  { 1427, 30, 30, 35, 6, -48 },
  { 1540, 30, 31, 36, 4, -38 },
  { 1657, 14, 15, 17, -3, -7 },
  { 1684, 17, 7, 20, 1, -20 },
  { 1699, 10, 10, 17, 1, -9 },
  { 1712, 33, 45, 25, -3, -45 },
  { 1898, 31, 47, 35, 3, -46 },
  { 2081, 23, 45, 35, 7, -45 },
  { 2211, 35, 46, 35, -1, -46 },
  { 2413, 33, 47, 35, 1, -46 },
  { 2607, 34, 45, 35, 0, -45 },
  { 2799, 33, 46, 35, 1, -45 },
  { 2989, 32, 47, 35, 3, -46 },
  { 3177, 34, 45, 35, 3, -45 },
  { 3369, 32, 47, 35, 2, -46 },
  { 3557, 30, 47, 35, 3, -46 },
  { 3734, 15, 36, 17, 1, -35 },
  { 3802, 19, 43, 17, -3, -35 },
  { 3905, 30, 32, 36, 4, -39 },
  { 4025, 30, 18, 36, 4, -31 },
  { 4093, 30, 32, 36, 4, -39 },
  { 4213, 25, 47, 28, 5, -46 },
  { 4360, 50, 51, 54, 3, -45 },
  { 4679, 38, 45, 38, -4, -45 },
  { 4893, 36, 45, 39, 2, -45 },
  { 5096, 37, 47, 38, 4, -46 },
  { 5314, 38, 45, 42, 2, -45 },
  { 5528, 34, 45, 34, 2, -45 },
  { 5720, 34, 45, 32, 2, -45 },
  { 5912, 38, 47, 43, 4, -46 },
  { 6136, 42, 45, 44, 2, -45 },
  { 6373, 28, 45, 23, -2, -45 },
  { 6531, 30, 58, 20, -10, -45 },
  { 6749, 41, 45, 37, 2, -45 },
  { 6980, 26, 45, 32, 2, -45 },
  { 7127, 53, 45, 55, 2, -45 },
  { 7426, 45, 45, 47, 2, -45 },
  { 7680, 40, 47, 46, 4, -46 },
  { 7915, 36, 45, 37, 2, -45 },
  { 8118, 40, 57, 46, 4, -46 },
  { 8403, 35, 45, 38, 2, -45 },
  { 8600, 33, 47, 33, 1, -46 },
  { 8794, 33, 45, 33, 5, -45 },
  { 8980, 39, 46, 43, 5, -45 },
  { 9205, 36, 45, 36, 6, -45 },
  { 9408, 55, 45, 55, 6, -45 },
  { 9718, 44, 45, 36, -3, -45 },
  { 9966, 34, 45, 34, 6, -45 },
  { 10158, 38, 45, 34, -1, -45 },
  { 10372, 25, 55, 20, -1, -45 },
  { 10544, 14, 45, 25, 7, -45 },
  { 10623, 25, 55, 20, -4, -45 },
  { 10795, 31, 29, 35, 2, -45 },
  { 10908, 26, 4, 25, -6, 6 },
  { 10921, 12, 10, 19, 9, -48 },
  { 10936, 33, 36, 37, 3, -35 },
  { 11085, 33, 49, 37, 1, -48 },
  { 11288, 27, 36, 30, 3, -35 },
  { 11410, 36, 49, 37, 3, -48 },
  { 11631, 29, 36, 34, 3, -35 },
  { 11762, 37, 63, 22, -7, -48 },
  { 12054, 35, 50, 37, 1, -35 },
  { 12273, 33, 48, 37, 1, -48 },
  { 12471, 18, 47, 18, 1, -47 },
  { 12577, 27, 62, 18, -8, -47 },
  { 12787, 36, 48, 34, 1, -48 },
  { 13003, 18, 48, 18, 1, -48 },
  { 13111, 52, 35, 56, 1, -35 },
  { 13339, 33, 35, 37, 1, -35 },
  { 13484, 31, 36, 36, 3, -35 },
  { 13624, 36, 50, 37, -2, -35 },
  { 13849, 33, 50, 37, 3, -35 },
  { 14056, 27, 35, 26, 1, -35 },
  { 14175, 27, 36, 29, 1, -35 },
  { 14297, 22, 43, 24, 3, -42 },
  { 14416, 33, 35, 37, 3, -34 },
  { 14561, 32, 34, 31, 3, -34 },
  { 14697, 47, 34, 48, 4, -34 },
  { 14897, 38, 34, 32, -3, -34 },
  { 15059, 40, 49, 31, -5, -34 },
  { 15304, 30, 34, 29, -1, -34 },
  { 15432, 26, 55, 22, 0, -45 },
  { 15611, 6, 63, 35, 15, -48 },
  { 15659, 25, 55, 22, -3, -45 },
  { 15831, 30, 10, 36, 4, -27 },
};

const GFXfont NotoSans_SemiBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMIBOLDITALIC63PT7B_H_
