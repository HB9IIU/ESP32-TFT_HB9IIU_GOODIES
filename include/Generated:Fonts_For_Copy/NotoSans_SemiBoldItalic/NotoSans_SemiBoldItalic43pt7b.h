#ifndef _NOTOSANS_SEMIBOLDITALIC43PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x02,
  0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xF3, 0xC3, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x03, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xEE, 0x78, 0x3E, 0x38, 0x20, 0xF8,
  0xE0, 0x03, 0xE3, 0x00, 0x0F, 0x9C, 0x00, 0x3F, 0x70, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xCF, 0xC0, 0x07, 0x1F, 0x00, 0x1C,
  0x7C, 0x00, 0x71, 0xF3, 0x01, 0x8F, 0xCF, 0x8E, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x78, 0x1F, 0xF0, 0x01, 0xE0, 0x7F, 0xE0, 0x07, 0x81, 0xFF, 0xE0,
  0x1F, 0x03, 0xC7, 0xC0, 0x3C, 0x0F, 0x87, 0x80, 0xF0, 0x1E, 0x0F, 0x03,
  0xC0, 0x7C, 0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x78,
  0x03, 0xC1, 0xF1, 0xE0, 0x07, 0x83, 0xC7, 0xC0, 0x0F, 0x0F, 0x8F, 0x1F,
  0x1E, 0x1F, 0x3C, 0xFF, 0x3C, 0x7C, 0xFB, 0xFF, 0x7F, 0xFB, 0xEF, 0xFF,
  0x7F, 0xE7, 0x9F, 0x3E, 0xFF, 0x9E, 0x7C, 0x3C, 0x7C, 0x7C, 0xF8, 0x78,
  0x01, 0xF1, 0xE0, 0xF0, 0x03, 0xC7, 0xC1, 0xE0, 0x0F, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x0F, 0x80, 0xF8, 0x3C, 0x1F, 0x01, 0xE0, 0x78, 0x3C, 0x07,
  0x80, 0xF0, 0xF8, 0x1F, 0x01, 0xF1, 0xE0, 0x7C, 0x03, 0xE7, 0xC0, 0xF0,
  0x03, 0xFF, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0x0F, 0xFF, 0x03, 0xF1, 0xFF,
  0xF0, 0x3E, 0x3F, 0x1F, 0x87, 0xE7, 0xE0, 0xFC, 0x7C, 0x7E, 0x0F, 0xCF,
  0x87, 0xC0, 0x7F, 0xF8, 0xFC, 0x03, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xF1, 0xF8, 0x0F, 0xFC, 0x1F, 0xC0,
  0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC0, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x40, 0x78, 0x07, 0x07,
  0x80, 0x7C, 0x78, 0x0F, 0xF7, 0x00, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x30, 0xFB, 0x80, 0x1F, 0x3C, 0x03,
  0xF3, 0xC0, 0x7E, 0x3E, 0x01, 0xC1, 0xE0, 0x08, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x00, 0x7F, 0xF7,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x7B, 0xFF, 0xFF, 0xFF, 0xE6, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0x7F, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x1F, 0x3F,
  0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3,
  0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x1F, 0x8F,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFF, 0x7F, 0xBE, 0x7C, 0xFC, 0xF1, 0xF0, 0x83, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xFD, 0xFE, 0x01, 0xE0, 0x7F, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xE3, 0xFC, 0x0C, 0x03,
  0xF0, 0x20, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE2, 0x00, 0x1F, 0x8F, 0x01, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x04, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE2, 0x00, 0x3F, 0x8F, 0x03, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFE, 0x18, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x83, 0x00, 0x3E, 0x7F, 0x81, 0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0x7C, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3F, 0x00, 0xF8,
  0xFC, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0xFE, 0x1F, 0x83, 0xF0, 0x1F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC,
  0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xC7,
  0xF3, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xEF, 0x83, 0xFE, 0xF8, 0x0F, 0xC7,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x20, 0x3F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x83, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0x60, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3E, 0x3F, 0x8C, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x07, 0x87, 0xC0, 0x7F, 0xE1, 0xF3, 0xE0, 0x7F, 0xFC, 0x3C, 0xF0, 0x3F,
  0xFE, 0x0F, 0x7C, 0x1F, 0x87, 0x83, 0xDE, 0x0F, 0x81, 0xE0, 0xF7, 0x83,
  0xC0, 0xF0, 0x3D, 0xE1, 0xF0, 0x3C, 0x0F, 0xF8, 0x78, 0x0F, 0x03, 0xFC,
  0x1E, 0x07, 0xC1, 0xFF, 0x0F, 0x81, 0xE0, 0x7B, 0xC3, 0xC0, 0x78, 0x1E,
  0xF0, 0xF0, 0x3E, 0x0F, 0xBC, 0x3E, 0x0F, 0x87, 0xCF, 0x0F, 0x87, 0xE3,
  0xE3, 0xE1, 0xFF, 0xBF, 0xF8, 0xF8, 0x7F, 0xCF, 0xFC, 0x1E, 0x0F, 0xE1,
  0xFC, 0x07, 0xC0, 0x60, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xF0, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7E, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x1F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xC0, 0x3F,
  0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x80, 0x30, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x10, 0x1F,
  0xF0, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xC0, 0xFF, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF8,
  0x3E, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0xC0, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0xF3, 0xF0, 0x1F, 0xFC, 0xFC, 0x07, 0xFF, 0x3F, 0x01, 0xFF, 0xCF, 0x80,
  0xFF, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFE, 0x00, 0x7C, 0x1F, 0xC0, 0x1F,
  0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03,
  0xE0, 0x3F, 0x80, 0x3E, 0x07, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xF0,
  0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xBE, 0x07, 0xDE, 0x00, 0xFB,
  0xE0, 0x7D, 0xE0, 0x0F, 0x7C, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xF9, 0xE0,
  0x1E, 0x7C, 0x0F, 0x9E, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x3C, 0x7C, 0x0F,
  0x9E, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x78, 0xF8, 0x1F, 0x1E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0xF0, 0xF8, 0x1F, 0x1F, 0x1F, 0x1F, 0x81, 0xF1, 0xF1,
  0xE1, 0xF0, 0x1F, 0x0F, 0x3E, 0x1F, 0x03, 0xE0, 0xF3, 0xC1, 0xF0, 0x3E,
  0x0F, 0x7C, 0x1F, 0x03, 0xE0, 0xF7, 0x83, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E,
  0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07, 0xC0, 0xFE,
  0x03, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xF8,
  0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C,
  0x0F, 0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xE0, 0x3F, 0xC0, 0x07, 0xC0,
  0x7F, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0x1F, 0x03, 0xFF, 0x00, 0x7C, 0x07,
  0xDF, 0x00, 0xF8, 0x0F, 0xBE, 0x01, 0xF0, 0x1F, 0x7E, 0x03, 0xE0, 0x7C,
  0x7C, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x01, 0xF1, 0xF8, 0x3E, 0x03, 0xE1,
  0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x07, 0xE3, 0xF0, 0x3E, 0x07,
  0xC7, 0xC0, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0x1F, 0x9F, 0x01, 0xF0, 0x1F,
  0x3E, 0x07, 0xC0, 0x3E, 0x7C, 0x0F, 0x80, 0x7F, 0xF0, 0x1F, 0x00, 0x7F,
  0xE0, 0x3E, 0x00, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0x81, 0xF0, 0x01, 0xFE,
  0x03, 0xE0, 0x03, 0xFC, 0x07, 0xC0, 0x07, 0xF8, 0x0F, 0x80, 0x07, 0xF0,
  0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x03, 0xF8, 0x0F, 0x80, 0x7C,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3E, 0x03,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0x87,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0xC0,
  0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0x80, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC2, 0x00, 0x3F, 0x0F, 0x03, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xCF, 0xC0,
  0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0x1E, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x80,
  0x1F, 0xBE, 0x00, 0x7F, 0x00, 0x7C, 0xF8, 0x03, 0xFC, 0x03, 0xF3, 0xE0,
  0x0F, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0xC0, 0x3E, 0x3E, 0x01, 0xFF, 0x01,
  0xF8, 0xF8, 0x07, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0xF0, 0x3F, 0x0F, 0x80,
  0xF7, 0xC0, 0xF8, 0x1F, 0x07, 0xDF, 0x07, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F,
  0x01, 0xF0, 0xF9, 0xF0, 0x7C, 0x07, 0xC3, 0xE7, 0xC3, 0xE0, 0x1F, 0x1F,
  0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x3C, 0x7E, 0x01, 0xF1, 0xE0, 0xF1, 0xF0,
  0x07, 0xCF, 0x83, 0xCF, 0xC0, 0x1F, 0x3C, 0x0F, 0x3E, 0x00, 0x7D, 0xF0,
  0x3C, 0xF8, 0x01, 0xF7, 0x80, 0xF7, 0xC0, 0x07, 0xFE, 0x03, 0xDF, 0x00,
  0x1E, 0xF8, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0,
  0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7,
  0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E,
  0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x08, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x00, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1,
  0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF8, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x01, 0xE7, 0x80,
  0x07, 0xBE, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xF8,
  0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xDF, 0x1F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xC0,
  0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E,
  0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F,
  0x8F, 0xF0, 0x7F, 0xFB, 0xC1, 0xFF, 0xDF, 0x03, 0xFE, 0x7C, 0x07, 0xF1,
  0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x7C, 0xFF, 0x03, 0xF7, 0xFE, 0x0F, 0xBF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x1F, 0xC0, 0x7C,
  0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC,
  0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x07,
  0xE7, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F, 0x8F, 0xE1, 0xFF, 0xFF, 0x8F,
  0xBF, 0xFC, 0x3E, 0x7F, 0xE0, 0xF0, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x81, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x04, 0x3F, 0x03, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x78, 0x7C, 0x01,
  0xFE, 0x7C, 0x07, 0xFF, 0x7C, 0x0F, 0xFF, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x3F, 0xC0, 0x7F, 0xFB, 0xC0, 0x7F,
  0xFB, 0xC0, 0x3F, 0xF7, 0xC0, 0x1F, 0xC7, 0xC0, 0x00, 0x3C, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE7, 0xF1, 0xF8, 0x3F, 0x3F,
  0x01, 0xF3, 0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x87, 0xE0, 0x38, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x30,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x3F, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFE, 0x3C, 0x0F, 0xFE, 0xF8, 0x3F, 0xFD, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0,
  0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0xC3, 0xF8, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0x7C, 0x07, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x08, 0x01, 0xF8, 0x1C, 0x07,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x7C, 0xFF, 0x03, 0xF7, 0xFE, 0x0F, 0xBF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x0F, 0xC3, 0xF8, 0x1F, 0x1F, 0xC0, 0x7C,
  0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC,
  0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x01, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x27, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x01, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0x83,
  0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x3F,
  0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x01, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0xF1, 0xFE, 0x0F, 0xF0, 0x3E, 0x7F, 0xE3,
  0xFF, 0x07, 0xDF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xFE, 0x1F, 0xE1,
  0xFF, 0x0F, 0xC3, 0xF8, 0x3F, 0xC0, 0xF8, 0xFE, 0x07, 0xF0, 0x1F, 0x1F,
  0x80, 0xFE, 0x03, 0xE3, 0xF0, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF0, 0x1F,
  0x8F, 0x80, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF0,
  0x0F, 0x8F, 0x80, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0x80, 0x7E, 0x3E, 0x01,
  0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0xC0, 0x3E, 0x3E,
  0x01, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC0, 0x3E,
  0x3F, 0x01, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xC0,
  0x1E, 0x3F, 0xC0, 0xF9, 0xFF, 0x83, 0xEF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xC3, 0xF0, 0xFE, 0x07, 0xC7, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0,
  0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E,
  0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x3F,
  0x7E, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7,
  0xE0, 0x3F, 0x3F, 0x03, 0xF8, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE3, 0xFC,
  0x03, 0xE7, 0xFE, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0x3F,
  0x03, 0xF0, 0x1F, 0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0xFC,
  0x1F, 0xC0, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3E, 0x7F, 0xE0, 0x3E, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xF8, 0xF0, 0x7F, 0xF3, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3,
  0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xDF,
  0x03, 0xFE, 0x7C, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC1, 0xE3, 0xF0, 0xF9, 0xFC, 0x3E, 0xFF, 0x0F, 0xFF, 0x83, 0xFE, 0x20,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFC, 0x7C, 0x3F, 0x01, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF2, 0x00,
  0x7E, 0x70, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x08, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00,
  0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0xC3, 0xF0, 0xFF,
  0x83, 0xFF, 0xDE, 0x07, 0xFF, 0x3C, 0x07, 0xFC, 0x78, 0x07, 0xF0, 0xF0,
  0x00, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x1F, 0x00, 0xFC,
  0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x7E,
  0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0xF8, 0x0F, 0xC0,
  0x7E, 0xF8, 0x1F, 0xC0, 0x7E, 0xF8, 0x1F, 0xC0, 0x7C, 0xF8, 0x3D, 0xC0,
  0xFC, 0xF8, 0x3D, 0xC0, 0xF8, 0xF8, 0x7D, 0xE1, 0xF8, 0xF8, 0x79, 0xE1,
  0xF0, 0xF8, 0x7B, 0xE3, 0xF0, 0xF8, 0xFB, 0xE3, 0xE0, 0xF8, 0xF3, 0xE7,
  0xE0, 0xF9, 0xF3, 0xE7, 0xC0, 0xF9, 0xE1, 0xE7, 0xC0, 0xFB, 0xE1, 0xEF,
  0x80, 0xFB, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xEF, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x07,
  0xC1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7E,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 32, 12, 1, -31 },
  { 49, 15, 11, 18, 4, -31 },
  { 70, 27, 31, 28, 1, -31 },
  { 175, 22, 36, 24, 1, -33 },
  { 274, 31, 31, 36, 3, -31 },
  { 395, 28, 31, 30, 1, -31 },
  { 504, 7, 11, 10, 4, -31 },
  { 514, 15, 38, 14, 2, -31 },
  { 586, 15, 38, 14, -3, -31 },
  { 658, 20, 21, 24, 4, -33 },
  { 711, 20, 21, 25, 3, -26 },
  { 764, 10, 11, 12, -2, -5 },
  { 778, 12, 5, 14, 1, -14 },
  { 786, 6, 7, 12, 1, -6 },
  { 792, 22, 31, 17, -2, -31 },
  { 878, 21, 31, 24, 2, -31 },
  { 960, 15, 31, 24, 5, -31 },
  { 1019, 24, 31, 24, -1, -31 },
  { 1112, 22, 31, 24, 1, -31 },
  { 1198, 23, 31, 24, 0, -31 },
  { 1288, 22, 31, 24, 1, -31 },
  { 1374, 22, 31, 24, 2, -31 },
  { 1460, 23, 31, 24, 2, -31 },
  { 1550, 23, 31, 24, 1, -31 },
  { 1640, 21, 31, 24, 2, -31 },
  { 1722, 10, 25, 12, 1, -24 },
  { 1754, 13, 30, 12, -2, -24 },
  { 1803, 20, 22, 25, 3, -27 },
  { 1858, 20, 12, 25, 3, -21 },
  { 1888, 20, 22, 25, 3, -27 },
  { 1943, 18, 32, 19, 3, -31 },
  { 2015, 34, 35, 37, 2, -31 },
  { 2164, 27, 31, 26, -3, -31 },
  { 2269, 25, 31, 26, 1, -31 },
  { 2366, 25, 31, 26, 3, -31 },
  { 2463, 27, 31, 29, 1, -31 },
  { 2568, 23, 31, 23, 1, -31 },
  { 2658, 23, 31, 22, 1, -31 },
  { 2748, 26, 31, 30, 3, -31 },
  { 2849, 29, 31, 30, 1, -31 },
  { 2962, 19, 31, 16, -1, -31 },
  { 3036, 21, 40, 13, -7, -31 },
  { 3141, 28, 31, 26, 1, -31 },
  { 3250, 18, 31, 22, 1, -31 },
  { 3320, 36, 31, 37, 1, -31 },
  { 3460, 31, 31, 32, 1, -31 },
  { 3581, 27, 31, 31, 3, -31 },
  { 3686, 25, 31, 26, 1, -31 },
  { 3783, 27, 38, 31, 3, -31 },
  { 3912, 24, 31, 26, 1, -31 },
  { 4005, 22, 31, 22, 1, -31 },
  { 4091, 22, 31, 22, 4, -31 },
  { 4177, 27, 31, 30, 3, -31 },
  { 4282, 25, 31, 25, 4, -31 },
  { 4379, 38, 31, 38, 4, -31 },
  { 4527, 30, 31, 25, -2, -31 },
  { 4644, 23, 31, 23, 4, -31 },
  { 4734, 26, 31, 23, -1, -31 },
  { 4835, 18, 38, 14, -1, -31 },
  { 4921, 9, 31, 17, 5, -31 },
  { 4956, 17, 38, 14, -3, -31 },
  { 5037, 22, 20, 24, 1, -31 },
  { 5092, 18, 3, 17, -4, 4 },
  { 5099, 9, 7, 13, 6, -33 },
  { 5107, 22, 24, 25, 2, -24 },
  { 5173, 22, 33, 25, 1, -33 },
  { 5264, 19, 24, 20, 2, -24 },
  { 5321, 24, 33, 25, 2, -33 },
  { 5420, 20, 24, 23, 2, -24 },
  { 5480, 25, 43, 15, -5, -33 },
  { 5615, 23, 34, 25, 1, -24 },
  { 5713, 22, 33, 26, 1, -33 },
  { 5804, 12, 32, 12, 1, -32 },
  { 5852, 18, 42, 12, -5, -32 },
  { 5947, 24, 33, 23, 1, -33 },
  { 6046, 12, 33, 12, 1, -33 },
  { 6096, 35, 24, 38, 1, -24 },
  { 6201, 22, 24, 26, 1, -24 },
  { 6267, 21, 24, 25, 2, -24 },
  { 6330, 24, 34, 25, -1, -24 },
  { 6432, 22, 34, 25, 2, -24 },
  { 6526, 18, 24, 18, 1, -24 },
  { 6580, 19, 24, 20, 0, -24 },
  { 6637, 15, 28, 16, 2, -28 },
  { 6690, 23, 23, 26, 2, -23 },
  { 6757, 22, 23, 21, 2, -23 },
  { 6821, 32, 23, 33, 3, -23 },
  { 6913, 26, 23, 22, -2, -23 },
  { 6988, 27, 33, 21, -3, -23 },
  { 7100, 21, 23, 20, -1, -23 },
  { 7161, 18, 38, 15, 0, -31 },
  { 7247, 4, 43, 24, 10, -33 },
  { 7269, 17, 38, 15, -2, -31 },
  { 7350, 20, 6, 25, 3, -18 },
};

const GFXfont NotoSans_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMIBOLDITALIC43PT7B_H_
