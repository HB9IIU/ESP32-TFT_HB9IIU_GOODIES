#ifndef _NOTOSANS_SEMIBOLDITALIC16PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x31, 0x80, 0x07, 0x38, 0xDE, 0xE5, 0x20, 0x0C,
  0x83, 0x60, 0x99, 0xFF, 0x19, 0x04, 0xC7, 0xFF, 0xFE, 0x36, 0x09, 0x86,
  0x40, 0x06, 0x07, 0xCF, 0xC6, 0x83, 0x41, 0xE0, 0x78, 0x1E, 0x0B, 0x6F,
  0xBF, 0x82, 0x01, 0x00, 0x10, 0x27, 0x84, 0x48, 0x8C, 0x98, 0xDB, 0x0D,
  0xAE, 0xF7, 0xB6, 0xD3, 0x19, 0x31, 0x32, 0x33, 0x66, 0x1C, 0x0C, 0x0F,
  0x83, 0x30, 0xCC, 0x36, 0x0F, 0x07, 0x8F, 0x36, 0xCF, 0xB1, 0xCF, 0xF3,
  0xEE, 0xFA, 0x19, 0x98, 0xCC, 0x63, 0x10, 0x84, 0x31, 0x8C, 0x20, 0x10,
  0x61, 0x82, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x0C, 0x61, 0x8C, 0x00, 0x0C,
  0x48, 0xE8, 0x3F, 0x38, 0x6C, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18,
  0x18, 0x18, 0x36, 0x6C, 0x7F, 0x80, 0xFC, 0x03, 0x81, 0x81, 0x81, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x38, 0x00, 0x08, 0x3E, 0x66, 0x63,
  0xC3, 0xC3, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x3D, 0xED, 0xA6, 0x30,
  0xC3, 0x0C, 0x31, 0x86, 0x00, 0x0C, 0x1F, 0x8C, 0xC0, 0x70, 0x30, 0x18,
  0x18, 0x38, 0x38, 0x38, 0x3F, 0x9F, 0xC0, 0x0C, 0x1F, 0x88, 0xE0, 0x70,
  0x30, 0xF0, 0x78, 0x0E, 0x03, 0x01, 0xBF, 0x9F, 0x80, 0x03, 0x83, 0x83,
  0xC3, 0x63, 0x23, 0x31, 0x99, 0xFE, 0xFF, 0x06, 0x03, 0x00, 0x1F, 0x88,
  0x0C, 0x06, 0x03, 0xE3, 0x78, 0x0C, 0x06, 0x07, 0x7F, 0x3F, 0x00, 0x06,
  0x1F, 0x30, 0x60, 0x60, 0xFE, 0xE6, 0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0x7F,
  0x03, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60, 0xC0, 0x0C, 0x3E,
  0x63, 0x63, 0x66, 0x3C, 0x7C, 0xCE, 0xC6, 0xC6, 0xCE, 0x7C, 0x18, 0xFD,
  0x9E, 0x3C, 0x78, 0xFF, 0xBB, 0x06, 0x1B, 0xE7, 0x80, 0x33, 0x20, 0x00,
  0x0E, 0xE0, 0x18, 0xC4, 0x00, 0x00, 0x06, 0x63, 0x30, 0x01, 0x07, 0x1C,
  0x70, 0xC0, 0x78, 0x0E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x1C, 0xF0, 0xC0, 0x19, 0xF9, 0x38, 0x30, 0xC3, 0x0C,
  0x30, 0x00, 0x03, 0x87, 0x00, 0x0F, 0xE3, 0x03, 0x60, 0x34, 0xF9, 0xC9,
  0x99, 0x99, 0x91, 0x19, 0x33, 0xDF, 0xEC, 0x00, 0x60, 0x83, 0xF8, 0x03,
  0x81, 0xE0, 0x58, 0x36, 0x09, 0x86, 0x63, 0xF8, 0xFE, 0x60, 0x98, 0x3C,
  0x0C, 0x3F, 0x19, 0xD8, 0x6C, 0x67, 0xE3, 0xF3, 0x0D, 0x86, 0xC7, 0x7F,
  0x3F, 0x00, 0x06, 0x0F, 0xCE, 0x2C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x1F, 0x87, 0xC0, 0x1F, 0x86, 0x73, 0x0C, 0xC3, 0x30, 0xCC, 0x36,
  0x0D, 0x87, 0x63, 0x9F, 0xCF, 0xC0, 0x1F, 0x8C, 0x0C, 0x06, 0x03, 0xF1,
  0xF9, 0x80, 0xC0, 0x60, 0x3F, 0x3F, 0x80, 0x1F, 0x8C, 0x0C, 0x06, 0x03,
  0x01, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x00, 0x07, 0x07, 0xF3, 0x89,
  0xC0, 0x60, 0x30, 0x0C, 0x7B, 0x06, 0xC1, 0xB8, 0xC7, 0xF0, 0xFC, 0x30,
  0xCC, 0x36, 0x0D, 0x86, 0x7F, 0x9F, 0xEE, 0x1B, 0x0C, 0xC3, 0x30, 0xCC,
  0x30, 0x3E, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xE3, 0xC0, 0x03,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0xF8,
  0xF0, 0x31, 0xCC, 0xC6, 0x61, 0xB0, 0x7C, 0x1E, 0x0E, 0xC3, 0x30, 0xCE,
  0x31, 0x8C, 0x70, 0x30, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0xFF, 0xC0,
  0x1C, 0x1C, 0x70, 0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0xD8, 0x93, 0x66, 0x59,
  0x19, 0x6C, 0x67, 0x31, 0x9C, 0xCC, 0x63, 0x00, 0x1C, 0x31, 0xC2, 0x3C,
  0x63, 0x66, 0x36, 0x63, 0x66, 0x63, 0x46, 0x3C, 0x63, 0xC6, 0x1C, 0xC1,
  0xC0, 0x06, 0x07, 0xE3, 0x1D, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xB8, 0xE7, 0xF0, 0xF8, 0x3F, 0x19, 0x98, 0xEC, 0x66, 0x33, 0xF3, 0xF1,
  0x80, 0xC0, 0x60, 0x30, 0x00, 0x06, 0x07, 0xE3, 0x1D, 0x83, 0x60, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xB8, 0xE7, 0xF0, 0xF8, 0x06, 0x01, 0xC0, 0x30,
  0x1F, 0x8C, 0xCC, 0x66, 0x33, 0x39, 0xF9, 0x98, 0xCC, 0x63, 0x31, 0xB8,
  0xE0, 0x06, 0x0F, 0xCC, 0x46, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x3F, 0x9F, 0x80, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x00, 0x30, 0xD8, 0x36, 0x1D, 0x86, 0x61, 0x98, 0x6C,
  0x1B, 0x0C, 0xC3, 0x3F, 0xC7, 0xC0, 0xC1, 0xD8, 0x66, 0x31, 0x8C, 0x66,
  0x19, 0x86, 0xC1, 0xB0, 0x78, 0x1E, 0x07, 0x00, 0x86, 0x1F, 0x1C, 0x6C,
  0xF3, 0x33, 0xCC, 0xDB, 0x63, 0x6D, 0x8F, 0x34, 0x3C, 0xF0, 0xE3, 0xC3,
  0x8E, 0x0C, 0x38, 0x00, 0x18, 0x71, 0x8C, 0x0D, 0x80, 0xF0, 0x0F, 0x00,
  0xE0, 0x1F, 0x01, 0xB0, 0x33, 0x06, 0x18, 0xE1, 0x80, 0xE3, 0xB1, 0x99,
  0x8D, 0x83, 0xC1, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x3F, 0x81,
  0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x7F, 0x3F, 0x80, 0x1C,
  0xC3, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xF3, 0x80, 0xDB, 0x6C,
  0x9B, 0x6D, 0x80, 0x1C, 0x30, 0xC2, 0x08, 0x61, 0x86, 0x10, 0xC3, 0x0C,
  0xF3, 0x80, 0x0C, 0x0C, 0x16, 0x32, 0x23, 0x63, 0xC1, 0xFF, 0xF0, 0xEC,
  0x3B, 0x7F, 0x67, 0xC6, 0xC6, 0xC6, 0xCE, 0xFE, 0xF4, 0x18, 0x0C, 0x0C,
  0x06, 0xC3, 0xF1, 0x8C, 0xC6, 0xC3, 0x63, 0x31, 0x9D, 0x9B, 0xC0, 0x1E,
  0xF9, 0x86, 0x0C, 0x18, 0x30, 0x74, 0x78, 0x01, 0x81, 0x80, 0xC7, 0x67,
  0xF3, 0x3B, 0x19, 0x8C, 0xC6, 0x67, 0x3F, 0x8E, 0x80, 0x1C, 0xFD, 0x9E,
  0x3F, 0xD8, 0x30, 0x76, 0x7C, 0x03, 0xC1, 0xA0, 0x60, 0x3C, 0x1F, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x0F, 0x03,
  0x80, 0x1D, 0x9F, 0xCC, 0xEC, 0x66, 0x33, 0x19, 0x9C, 0xFE, 0x7E, 0x03,
  0x01, 0x9F, 0x87, 0x80, 0x18, 0x0C, 0x0C, 0x06, 0xE3, 0xF9, 0x8C, 0xC6,
  0xC6, 0x63, 0x31, 0x98, 0xD8, 0xE0, 0x18, 0xC0, 0x63, 0x18, 0xCC, 0x63,
  0x19, 0x80, 0x06, 0x0C, 0x00, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x61,
  0x83, 0x06, 0x3C, 0x70, 0x18, 0x0C, 0x0C, 0x06, 0x33, 0x31, 0xB0, 0xB0,
  0xF8, 0x7C, 0x37, 0x19, 0x98, 0xE0, 0x18, 0xCC, 0x63, 0x18, 0xCC, 0x63,
  0x19, 0x80, 0x37, 0x39, 0xFB, 0xCC, 0xE6, 0x67, 0x36, 0x31, 0xB1, 0x8D,
  0x8C, 0x6C, 0x63, 0xC6, 0x30, 0x37, 0x1F, 0xCC, 0x6E, 0x36, 0x33, 0x19,
  0x8C, 0xC6, 0xC7, 0x00, 0x1C, 0x7E, 0xE6, 0xC7, 0xC6, 0xC6, 0xC6, 0xFC,
  0x78, 0x36, 0x1F, 0x8C, 0x66, 0x36, 0x1B, 0x19, 0x8C, 0xEC, 0xDE, 0x60,
  0x30, 0x18, 0x0C, 0x00, 0x3B, 0x7F, 0x67, 0xC6, 0xC6, 0xC6, 0xCE, 0xFE,
  0x7C, 0x0C, 0x0C, 0x0C, 0x18, 0x36, 0x7C, 0xE1, 0x86, 0x0C, 0x18, 0x30,
  0xC0, 0x1C, 0xFD, 0x83, 0x83, 0x83, 0x83, 0x6E, 0xF8, 0x31, 0x1F, 0xF6,
  0x33, 0x18, 0xC6, 0xBC, 0x63, 0x63, 0x63, 0xC2, 0xC6, 0xC6, 0xCE, 0xFE,
  0xF4, 0xC3, 0xC6, 0xC6, 0xCC, 0xDC, 0xD8, 0x50, 0x70, 0x60, 0xC6, 0x3C,
  0xE6, 0xCA, 0x6D, 0xAC, 0xDA, 0xCF, 0x2C, 0xF3, 0x8E, 0x38, 0xE3, 0x00,
  0x31, 0xC6, 0x61, 0xB0, 0x38, 0x0C, 0x07, 0x83, 0x60, 0xDC, 0xE3, 0x00,
  0x30, 0xCC, 0x63, 0x18, 0xCC, 0x33, 0x05, 0x81, 0x40, 0x70, 0x18, 0x06,
  0x03, 0x03, 0xC0, 0xC0, 0x00, 0x3E, 0xFC, 0x38, 0xE1, 0x86, 0x18, 0x7E,
  0xFC, 0x0E, 0x30, 0x60, 0x83, 0x06, 0x30, 0x30, 0x20, 0xC1, 0x83, 0x07,
  0x02, 0x00, 0xFF, 0xFF, 0x18, 0x18, 0x30, 0x41, 0x83, 0x03, 0x8E, 0x30,
  0x60, 0xC1, 0x8E, 0x10, 0x00, 0x71, 0xFF, 0x84,
};

const GFXglyph NotoSans_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 5, 4, 7, 2, -11 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 9, 13, 9, 0, -12 },
  { 40, 12, 12, 13, 1, -12 },
  { 58, 10, 12, 11, 1, -12 },
  { 73, 2, 4, 4, 2, -11 },
  { 74, 5, 14, 5, 1, -11 },
  { 83, 6, 15, 5, -1, -12 },
  { 95, 8, 7, 9, 1, -12 },
  { 102, 8, 8, 9, 1, -10 },
  { 110, 4, 4, 4, -1, -2 },
  { 112, 5, 2, 5, 0, -5 },
  { 114, 3, 2, 4, 0, -2 },
  { 115, 9, 11, 6, -1, -11 },
  { 128, 8, 12, 9, 1, -12 },
  { 140, 6, 11, 9, 2, -11 },
  { 149, 9, 12, 9, 0, -12 },
  { 163, 9, 12, 9, 0, -12 },
  { 177, 9, 11, 9, 0, -11 },
  { 190, 9, 11, 9, 0, -11 },
  { 203, 8, 12, 9, 1, -12 },
  { 215, 8, 11, 9, 1, -11 },
  { 226, 8, 12, 9, 1, -12 },
  { 238, 7, 12, 9, 1, -12 },
  { 249, 4, 9, 4, 0, -9 },
  { 254, 5, 11, 4, -1, -9 },
  { 261, 8, 8, 9, 1, -10 },
  { 269, 8, 5, 9, 1, -8 },
  { 274, 8, 8, 9, 1, -10 },
  { 282, 7, 12, 7, 1, -12 },
  { 293, 12, 12, 14, 1, -11 },
  { 311, 10, 11, 10, -1, -11 },
  { 325, 9, 11, 10, 1, -11 },
  { 338, 9, 12, 10, 1, -12 },
  { 352, 10, 11, 11, 0, -11 },
  { 366, 9, 11, 9, 0, -11 },
  { 379, 9, 11, 8, 0, -11 },
  { 392, 10, 12, 11, 1, -12 },
  { 407, 10, 11, 11, 1, -11 },
  { 421, 7, 11, 6, 0, -11 },
  { 431, 8, 14, 5, -3, -11 },
  { 445, 10, 11, 10, 1, -11 },
  { 459, 6, 11, 8, 1, -11 },
  { 468, 14, 11, 14, 0, -11 },
  { 488, 12, 11, 12, 0, -11 },
  { 505, 10, 12, 12, 1, -12 },
  { 520, 9, 11, 10, 1, -11 },
  { 533, 10, 15, 12, 1, -12 },
  { 552, 9, 11, 10, 0, -11 },
  { 565, 9, 12, 8, 0, -12 },
  { 579, 9, 11, 8, 1, -11 },
  { 592, 10, 11, 11, 1, -11 },
  { 606, 10, 11, 9, 1, -11 },
  { 620, 14, 11, 14, 2, -11 },
  { 640, 12, 11, 9, -1, -11 },
  { 657, 9, 11, 9, 1, -11 },
  { 670, 9, 11, 9, 0, -11 },
  { 683, 6, 14, 5, 0, -11 },
  { 694, 3, 11, 6, 2, -11 },
  { 699, 6, 14, 5, -1, -11 },
  { 710, 8, 7, 9, 0, -11 },
  { 717, 6, 2, 6, -1, 1 },
  { 719, 3, 2, 5, 2, -12 },
  { 720, 8, 9, 9, 1, -9 },
  { 729, 9, 12, 9, 0, -12 },
  { 743, 7, 9, 8, 1, -9 },
  { 751, 9, 12, 9, 1, -12 },
  { 765, 7, 9, 9, 1, -9 },
  { 773, 10, 16, 6, -2, -12 },
  { 793, 9, 13, 9, 0, -9 },
  { 808, 9, 12, 10, 0, -12 },
  { 822, 5, 12, 5, 0, -12 },
  { 830, 7, 16, 5, -2, -12 },
  { 844, 9, 12, 9, 0, -12 },
  { 858, 5, 12, 5, 0, -12 },
  { 866, 13, 9, 14, 0, -9 },
  { 881, 9, 9, 10, 0, -9 },
  { 892, 8, 9, 9, 1, -9 },
  { 901, 9, 13, 9, 0, -9 },
  { 916, 8, 13, 9, 1, -9 },
  { 929, 7, 9, 7, 0, -9 },
  { 937, 7, 9, 7, 0, -9 },
  { 945, 5, 11, 6, 1, -11 },
  { 952, 8, 9, 10, 1, -9 },
  { 961, 8, 9, 8, 1, -9 },
  { 970, 12, 9, 12, 1, -9 },
  { 984, 10, 9, 8, -1, -9 },
  { 996, 10, 13, 8, -1, -9 },
  { 1013, 7, 9, 7, 0, -9 },
  { 1021, 7, 14, 6, 0, -11 },
  { 1034, 1, 16, 9, 4, -12 },
  { 1036, 7, 14, 6, -1, -11 },
  { 1049, 8, 3, 9, 1, -7 },
};

const GFXfont NotoSans_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMIBOLDITALIC16PT7B_H_
