#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC6PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x80, 0x7B, 0xE0, 0x4D, 0x2C, 0xFF, 0x37, 0x6B, 0xF0, 0x80,
  0x6A, 0x80, 0xF8, 0xB8, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A, 0x40, 0x76,
  0xE0, 0xF0, 0xE5, 0x60, 0x69, 0x60, 0x6B, 0xA0, 0x78, 0xE0, 0x7A, 0xE0,
  0x69, 0x40, 0xEA, 0xE0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F,
  0x00, 0x5A, 0x7F, 0xF8, 0x60, 0x5F, 0x7E, 0xE0, 0x72, 0x70, 0x76, 0xE0,
  0x6A, 0x60, 0x7A, 0x40, 0x72, 0xF0, 0x7E, 0xD0, 0x5A, 0x29, 0x2C, 0x6B,
  0x50, 0x6B, 0x55, 0xFD, 0x5E, 0xAA, 0x76, 0xF0, 0x77, 0x40, 0x76, 0xD6,
  0x77, 0x50, 0xE9, 0x60, 0xE9, 0x40, 0x76, 0xF0, 0xEA, 0xDE, 0xEC, 0x69,
  0x60, 0xEA, 0x6A, 0x60, 0x6A, 0x80, 0xF0, 0x56, 0x80, 0x54, 0xE0, 0x80,
  0xF7, 0x00, 0x4A, 0xDC, 0xEC, 0x2E, 0xDC, 0xFC, 0x25, 0x25, 0x80, 0xF7,
  0x60, 0x4A, 0xDC, 0x6A, 0x29, 0x2C, 0x4F, 0x6C, 0x5A, 0x80, 0xFB, 0xD0,
  0xF7, 0x00, 0xF7, 0x00, 0xF7, 0x40, 0xF7, 0x20, 0xE8, 0xDC, 0x6A, 0xB7,
  0x00, 0xBA, 0x00, 0xDE, 0xA0, 0xEB, 0x00, 0x56, 0x4C, 0xEC, 0x5A, 0x80,
  0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_MediumItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 2, 3, 3, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 3, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 1, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 1, 3, 1, 0, -3 },
  { 43, 1, 4, 1, 0, -3 },
  { 44, 3, 3, 3, 0, -4 },
  { 46, 3, 2, 3, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 4, 5, 4, 0, -4 },
  { 53, 2, 4, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 2, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 2, 4, 2, 0, -4 },
  { 69, 3, 5, 1, -1, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 3, 5, 3, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 2, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 2, 4, 3, 1, -4 },
  { 93, 4, 4, 4, 1, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 2, 4, 3, 1, -4 },
  { 98, 3, 4, 2, 0, -4 },
  { 100, 2, 5, 2, 0, -4 },
  { 102, 1, 4, 2, 1, -4 },
  { 103, 2, 5, 2, 0, -4 },
  { 105, 3, 2, 3, 0, -4 },
  { 106, 3, 1, 2, -1, 0 },
  { 107, 1, 1, 2, 1, -5 },
  { 108, 3, 3, 3, 0, -3 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 2, 3, 2, 0, -3 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 2, 3, 3, 0, -3 },
  { 116, 3, 6, 2, -1, -5 },
  { 119, 3, 4, 3, 0, -3 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 2, 4, 1, 0, -4 },
  { 124, 3, 5, 1, -1, -4 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 2, 5, 1, 0, -5 },
  { 130, 4, 3, 4, 0, -3 },
  { 132, 3, 3, 3, 0, -3 },
  { 134, 3, 3, 3, 0, -3 },
  { 136, 3, 4, 3, 0, -3 },
  { 138, 3, 4, 3, 0, -3 },
  { 140, 2, 3, 2, 0, -3 },
  { 141, 2, 3, 2, 0, -3 },
  { 142, 2, 4, 2, 0, -4 },
  { 143, 3, 3, 3, 0, -3 },
  { 145, 3, 3, 2, 0, -3 },
  { 147, 4, 3, 4, 0, -3 },
  { 149, 3, 3, 2, 0, -3 },
  { 151, 4, 4, 2, -1, -3 },
  { 153, 2, 3, 2, 0, -3 },
  { 154, 2, 5, 2, 0, -4 },
  { 156, 1, 6, 3, 1, -5 },
  { 157, 2, 5, 2, 0, -4 },
  { 159, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_MediumItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC6PT7B_H_
