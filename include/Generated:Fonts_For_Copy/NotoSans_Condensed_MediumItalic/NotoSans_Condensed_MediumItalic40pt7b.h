#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x78,
  0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC3, 0x80, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x03, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7B, 0x38, 0x3C, 0xC2, 0x0F, 0x30, 0x03,
  0x8C, 0x00, 0xE3, 0x00, 0x3D, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0D, 0xE0, 0x03, 0x38,
  0x00, 0x8F, 0x00, 0x63, 0xC0, 0x18, 0xE1, 0x06, 0x78, 0x71, 0xBE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x80, 0x1C, 0x0F, 0xC0, 0x3C, 0x1F, 0xE0, 0x38,
  0x1C, 0xE0, 0x70, 0x38, 0xE0, 0x70, 0x38, 0xE0, 0xE0, 0x70, 0xE1, 0xE0,
  0x70, 0xE1, 0xC0, 0x70, 0xE3, 0x80, 0x70, 0xE3, 0x80, 0xE1, 0xE7, 0x00,
  0xE1, 0xC7, 0x08, 0xE1, 0xCE, 0x7E, 0xE3, 0x9C, 0xFF, 0xF3, 0x9C, 0xE7,
  0x7F, 0x39, 0xC7, 0x7E, 0x39, 0xC7, 0x3C, 0x73, 0x87, 0x00, 0xF3, 0x87,
  0x00, 0xE3, 0x87, 0x01, 0xC3, 0x87, 0x01, 0xC7, 0x0F, 0x03, 0x87, 0x0E,
  0x07, 0x87, 0x0E, 0x07, 0x07, 0x1E, 0x0E, 0x07, 0x1C, 0x0E, 0x07, 0xBC,
  0x1C, 0x03, 0xF8, 0x3C, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x38, 0x38, 0x03, 0x87, 0x80,
  0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x0F, 0x1E, 0xF0,
  0xF3, 0xC7, 0x8E, 0x78, 0x79, 0xE7, 0x83, 0xDE, 0x78, 0x3F, 0xCF, 0x03,
  0xF8, 0xF0, 0x1F, 0x8F, 0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x87, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0x7C, 0x1F, 0xC3, 0xC0, 0x3D, 0xE7, 0x9E, 0x79, 0xC7,
  0x1C, 0xF3, 0x8E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x02, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x43, 0x83, 0xCE, 0x0F, 0xFB, 0xDF, 0xFF,
  0x07, 0xFC, 0x3E, 0x01, 0xFC, 0x0F, 0x70, 0x79, 0xE1, 0xC3, 0x83, 0x0F,
  0x00, 0x30, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78,
  0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3B, 0xDF, 0xF7, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0,
  0x78, 0x3C, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0xE3, 0xFE, 0xFD, 0xE7, 0x9C, 0x63, 0xC2,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x38, 0x3E, 0x04, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0x7E,
  0x06, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x80, 0x3C, 0x30,
  0x3F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0x78, 0x01, 0xDC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x0E, 0x3C,
  0x07, 0x0E, 0x01, 0xC7, 0x80, 0xE1, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E,
  0x0F, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x80, 0x3C, 0x30,
  0x3F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xE6, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF3, 0xE0,
  0x3B, 0xFC, 0x1F, 0xFF, 0x87, 0xF3, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x1E,
  0x03, 0x8F, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0xF0, 0x78, 0x7C, 0x1E, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0x1F, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC1, 0xE0, 0x78, 0xF8, 0x1E, 0x7C, 0x03, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0x3C, 0x0F, 0x87, 0x87, 0xC1, 0xE1,
  0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF8,
  0x1E, 0x1E, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFB, 0xE1, 0xF0, 0xF0, 0xF0, 0x78,
  0xF0, 0x1C, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF1, 0xE0, 0xF8, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xEE, 0x0F,
  0xEF, 0x00, 0x87, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x41, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0,
  0x00, 0x03, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0x80, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x7F, 0xE3,
  0xFF, 0xC7, 0xBF, 0x10, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C,
  0x01, 0xE0, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x0E, 0x07, 0xE1, 0x87, 0x07, 0xFC, 0x71, 0xC3, 0xFE, 0x1C, 0xE1,
  0xE3, 0x87, 0x38, 0x70, 0xE1, 0x8C, 0x38, 0x78, 0x67, 0x0E, 0x1C, 0x39,
  0xC7, 0x07, 0x0E, 0x71, 0xC1, 0xC3, 0x98, 0x70, 0xF0, 0xCE, 0x1C, 0x38,
  0x73, 0x87, 0x0E, 0x1C, 0xE1, 0xC7, 0x8E, 0x38, 0x73, 0x67, 0x8E, 0x1F,
  0xDF, 0xC3, 0x83, 0xE7, 0xE0, 0xE0, 0x60, 0x40, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x07, 0xC1, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xBC, 0x01,
  0xEF, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0x81, 0xF0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0,
  0x70, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0x80,
  0xF8, 0x78, 0x0F, 0x07, 0x87, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0x7C, 0x08, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0xC3, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3C, 0x3F,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x7C,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07,
  0x81, 0xF0, 0x78, 0x3F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x02, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x7F, 0x9E, 0x07, 0xF8, 0xF0, 0x3F, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1F, 0x00,
  0xF0, 0x78, 0x0F, 0x03, 0xF0, 0x78, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x70,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F,
  0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F,
  0x80, 0x78, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x03,
  0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x8F,
  0x00, 0x1C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x79,
  0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F,
  0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1D, 0xC0, 0xEE, 0x01,
  0xFE, 0x07, 0x70, 0x0E, 0xF0, 0x3B, 0x80, 0xF7, 0x83, 0xDC, 0x07, 0xB8,
  0x1E, 0xE0, 0x3B, 0xC0, 0xF7, 0x03, 0xDE, 0x07, 0x3C, 0x1C, 0xF0, 0x79,
  0xE1, 0xE7, 0x83, 0xCF, 0x0E, 0x38, 0x1E, 0x78, 0xF3, 0xC0, 0xF3, 0xC7,
  0x1E, 0x07, 0x1E, 0x78, 0xF0, 0x78, 0x73, 0x87, 0x03, 0xC3, 0xBC, 0x78,
  0x1E, 0x1D, 0xC3, 0xC0, 0xE0, 0xFE, 0x1E, 0x07, 0x07, 0xE0, 0xF0, 0x78,
  0x3F, 0x07, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xE0, 0x78,
  0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F,
  0x03, 0xE0, 0x0F, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x0E, 0x07, 0xF0, 0x1E,
  0x07, 0xF0, 0x1E, 0x07, 0x78, 0x1E, 0x07, 0x78, 0x1E, 0x07, 0x78, 0x1C,
  0x0F, 0x38, 0x3C, 0x0F, 0x38, 0x3C, 0x0F, 0x3C, 0x3C, 0x0E, 0x3C, 0x38,
  0x1E, 0x1C, 0x78, 0x1E, 0x1C, 0x78, 0x1E, 0x1E, 0x78, 0x1E, 0x1E, 0x78,
  0x1C, 0x1E, 0x70, 0x3C, 0x0E, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C, 0x0F, 0xF0,
  0x38, 0x0F, 0xF0, 0x38, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x78, 0x07, 0xE0,
  0x78, 0x07, 0xE0, 0x70, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x81, 0xE0, 0xF0, 0x1F,
  0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x07,
  0xC3, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3C, 0x3E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x87, 0x87, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x81, 0xE0, 0xF0, 0x1F, 0x1F, 0x00,
  0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF,
  0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x07, 0xC3, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3C,
  0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x1F, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x81, 0x83, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x80, 0x7C, 0x3C, 0x7F, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xE3, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x7B, 0x80, 0x3C, 0x03, 0xDC, 0x03, 0xE0, 0x1E,
  0xE0, 0x1F, 0x01, 0xE7, 0x00, 0xF8, 0x0F, 0x38, 0x0F, 0xC0, 0xF1, 0xC0,
  0x7E, 0x07, 0x8E, 0x07, 0xF0, 0x3C, 0x70, 0x3B, 0x83, 0xC3, 0x81, 0xDC,
  0x1E, 0x1C, 0x1D, 0xE1, 0xE0, 0xE0, 0xEF, 0x0F, 0x07, 0x0F, 0x78, 0x70,
  0x38, 0x73, 0xC7, 0x81, 0xC7, 0x9E, 0x3C, 0x0E, 0x38, 0xF3, 0xC0, 0x71,
  0xC7, 0x9E, 0x03, 0x9E, 0x3C, 0xE0, 0x1C, 0xE1, 0xEF, 0x00, 0xEF, 0x0F,
  0x78, 0x07, 0x70, 0x7F, 0x80, 0x3B, 0x83, 0xFC, 0x01, 0xFC, 0x1D, 0xC0,
  0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1E,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0,
  0x78, 0x70, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xE0, 0x7B, 0xC0, 0x7B,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x20, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x00, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78,
  0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87,
  0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x78, 0x0F, 0x1C, 0x07,
  0x0E, 0x07, 0x87, 0x83, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x79, 0xC0, 0x1D,
  0xE0, 0x0E, 0xE0, 0x07, 0x80, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3,
  0xC7, 0x9E, 0x38, 0x71, 0xC0, 0x01, 0xE1, 0xC0, 0xFE, 0xF0, 0xFF, 0xB8,
  0x3E, 0x7E, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x8F, 0xC1,
  0xFF, 0xF0, 0x7F, 0xBC, 0x0F, 0xCE, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x9E, 0x01, 0xCF, 0xC0, 0xF7, 0xF8, 0x3F, 0x9F, 0x0F, 0x83,
  0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1,
  0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x3C, 0x7C, 0x0F, 0x1F, 0x07, 0x87, 0xE3, 0xE1, 0xDF, 0xF0, 0x77, 0xF8,
  0x38, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0xE1, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE3, 0xC0, 0x3F, 0xBC, 0x0F, 0xFB,
  0x80, 0xF9, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x83, 0xC0,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0,
  0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0xC0, 0xF8, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xBC, 0x03, 0xF3, 0x80,
  0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x7C, 0xF1, 0xE0, 0xE7, 0x81, 0xCF,
  0x03, 0x9C, 0x0F, 0x78, 0x3E, 0xF3, 0xF9, 0xFF, 0xE7, 0xFF, 0x0F, 0xC0,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x43,
  0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0xE0, 0x3F, 0xBC, 0x1F,
  0xF7, 0x03, 0xE7, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0x81, 0xF0, 0xF0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x07,
  0xC1, 0xF1, 0xF8, 0x1F, 0xFF, 0x03, 0xFD, 0xE0, 0x3F, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x40, 0x7C,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x9E, 0x01, 0xDF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xBE, 0x0F, 0x87, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x70, 0x1C, 0x3C, 0x0F, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0xE0, 0xF8, 0x3C,
  0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1C, 0x78, 0x03, 0x9F, 0x00, 0xF3,
  0xC0, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7D, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x7C, 0x00, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x1E, 0x0F, 0x80, 0xEF, 0xE3, 0xF8,
  0x3F, 0xFE, 0xFF, 0x87, 0xF7, 0xF9, 0xF0, 0xF8, 0x7E, 0x1E, 0x1E, 0x0F,
  0x83, 0xC3, 0xC1, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xC3,
  0xC0, 0xE0, 0x78, 0x70, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xE3, 0xC0, 0xF0,
  0x3C, 0x78, 0x1E, 0x07, 0x0F, 0x03, 0x81, 0xE1, 0xC0, 0xF0, 0x3C, 0x78,
  0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xE1, 0xE0, 0x78, 0x3C, 0x3C, 0x0E, 0x07,
  0x87, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x00, 0x07, 0x1E, 0x01, 0xDF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xBE, 0x0F, 0x87, 0xC3, 0xE0, 0xF1, 0xF0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x0F, 0x00, 0x01, 0xF8,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x9F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x78,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xC7, 0x80, 0x1C, 0xFE, 0x03,
  0xDF, 0xE0, 0x3F, 0x9F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x1F, 0x03,
  0xC1, 0xF0, 0x78, 0x1F, 0x8F, 0x81, 0xDF, 0xF0, 0x1D, 0xFE, 0x03, 0xCF,
  0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF1, 0xC0, 0xFE, 0xF0, 0x7F, 0xB8, 0x3E, 0x7E, 0x1F, 0x0F, 0x87,
  0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8,
  0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x7F, 0xBC, 0x0F,
  0xCE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x07, 0x1E, 0x0E, 0xF8, 0x3D, 0xF0, 0x7F, 0xE0, 0xFC, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0,
  0xF8, 0xE1, 0xE0, 0x47, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE3, 0x07, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0xF3, 0xFE, 0x7F, 0xE7, 0xFE,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x0E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0x80, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81,
  0xE1, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x8F, 0xC1, 0xFF, 0xF0,
  0x7F, 0xB8, 0x0F, 0xCE, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x70,
  0xE0, 0x71, 0xE0, 0x71, 0xE0, 0x73, 0xC0, 0x73, 0xC0, 0x77, 0x80, 0x77,
  0x80, 0x77, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0x07, 0xBC, 0x1F, 0x83, 0xDE, 0x0F,
  0xC3, 0xCF, 0x07, 0xE1, 0xE7, 0x87, 0xF0, 0xE3, 0xC3, 0xF0, 0xF1, 0xE3,
  0xF8, 0x78, 0xF1, 0xDC, 0x78, 0x78, 0xEE, 0x3C, 0x3C, 0xE7, 0x1C, 0x1E,
  0x73, 0x9E, 0x0F, 0x79, 0xCE, 0x07, 0xB8, 0xE7, 0x03, 0xDC, 0x77, 0x81,
  0xFC, 0x3B, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x81,
  0xF0, 0x78, 0x1E, 0x03, 0x83, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C,
  0xF0, 0x01, 0xCE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xB8, 0x00,
  0x7B, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x1C, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x81, 0xE0, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1C, 0x1E,
  0x00, 0x70, 0x78, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0xFE,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0x7F, 0x81,
  0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0xFE, 0x80, 0x18,
};

const GFXglyph NotoSans_Condensed_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 29, 10, 0, -29 },
  { 41, 12, 11, 15, 4, -29 },
  { 58, 21, 29, 20, 0, -29 },
  { 135, 18, 32, 18, 0, -30 },
  { 207, 24, 29, 28, 2, -29 },
  { 294, 20, 29, 21, 0, -29 },
  { 367, 6, 11, 8, 4, -29 },
  { 376, 13, 35, 11, 1, -29 },
  { 433, 13, 35, 11, -3, -29 },
  { 490, 14, 16, 17, 4, -31 },
  { 518, 16, 19, 19, 2, -24 },
  { 556, 8, 10, 9, -2, -5 },
  { 566, 9, 4, 11, 1, -13 },
  { 571, 5, 5, 9, 0, -5 },
  { 575, 19, 29, 14, -2, -29 },
  { 644, 17, 29, 18, 1, -29 },
  { 706, 12, 29, 18, 4, -29 },
  { 750, 19, 29, 18, -1, -29 },
  { 819, 18, 29, 18, 0, -29 },
  { 885, 18, 29, 18, 0, -29 },
  { 951, 18, 29, 18, 0, -29 },
  { 1017, 18, 29, 18, 1, -29 },
  { 1083, 17, 29, 18, 2, -29 },
  { 1145, 18, 29, 18, 0, -29 },
  { 1211, 17, 29, 18, 1, -29 },
  { 1273, 9, 22, 9, 0, -22 },
  { 1298, 11, 27, 9, -2, -22 },
  { 1336, 16, 19, 19, 2, -24 },
  { 1374, 16, 12, 19, 2, -20 },
  { 1398, 16, 19, 19, 2, -24 },
  { 1436, 14, 29, 14, 1, -29 },
  { 1487, 26, 32, 27, 1, -29 },
  { 1591, 18, 29, 19, -2, -29 },
  { 1657, 20, 29, 20, 0, -29 },
  { 1730, 19, 29, 18, 2, -29 },
  { 1799, 21, 29, 21, 0, -29 },
  { 1876, 19, 29, 17, 0, -29 },
  { 1945, 19, 29, 16, 0, -29 },
  { 2014, 21, 29, 22, 2, -29 },
  { 2091, 23, 29, 22, 0, -29 },
  { 2175, 17, 29, 12, -2, -29 },
  { 2237, 17, 37, 10, -6, -29 },
  { 2316, 22, 29, 19, 0, -29 },
  { 2396, 13, 29, 16, 0, -29 },
  { 2444, 29, 29, 29, 0, -29 },
  { 2550, 24, 29, 23, 0, -29 },
  { 2637, 20, 29, 23, 2, -29 },
  { 2710, 19, 29, 19, 0, -29 },
  { 2779, 20, 36, 23, 2, -29 },
  { 2869, 19, 29, 19, 0, -29 },
  { 2938, 18, 29, 17, 0, -29 },
  { 3004, 16, 29, 16, 3, -29 },
  { 3062, 21, 29, 22, 2, -29 },
  { 3139, 18, 29, 19, 4, -29 },
  { 3205, 29, 29, 29, 3, -29 },
  { 3311, 23, 29, 18, -2, -29 },
  { 3395, 16, 29, 17, 4, -29 },
  { 3453, 20, 29, 16, -1, -29 },
  { 3526, 15, 35, 12, -1, -29 },
  { 3592, 7, 29, 14, 4, -29 },
  { 3618, 16, 35, 12, -3, -29 },
  { 3688, 17, 17, 18, 1, -29 },
  { 3725, 14, 3, 13, -4, 3 },
  { 3731, 6, 7, 11, 6, -31 },
  { 3737, 18, 22, 19, 1, -22 },
  { 3787, 18, 30, 19, 0, -30 },
  { 3855, 15, 22, 15, 1, -22 },
  { 3897, 20, 30, 19, 1, -30 },
  { 3972, 15, 22, 17, 1, -22 },
  { 4014, 21, 41, 11, -5, -31 },
  { 4122, 19, 32, 19, 0, -22 },
  { 4198, 18, 30, 19, 0, -30 },
  { 4266, 10, 30, 9, 0, -30 },
  { 4304, 15, 40, 9, -5, -30 },
  { 4379, 19, 30, 17, 0, -30 },
  { 4451, 11, 30, 9, 0, -30 },
  { 4493, 27, 22, 28, 0, -22 },
  { 4568, 18, 22, 19, 0, -22 },
  { 4618, 16, 22, 19, 1, -22 },
  { 4662, 20, 31, 19, -2, -22 },
  { 4740, 18, 32, 19, 1, -22 },
  { 4812, 15, 22, 13, 0, -22 },
  { 4854, 15, 22, 15, 0, -22 },
  { 4896, 12, 26, 11, 1, -26 },
  { 4935, 18, 22, 19, 1, -22 },
  { 4985, 16, 22, 16, 2, -22 },
  { 5029, 25, 22, 25, 2, -22 },
  { 5098, 20, 22, 16, -2, -22 },
  { 5153, 22, 32, 16, -4, -22 },
  { 5241, 16, 22, 14, -1, -22 },
  { 5285, 15, 35, 13, 1, -29 },
  { 5351, 3, 40, 17, 7, -31 },
  { 5366, 15, 35, 13, -2, -29 },
  { 5432, 16, 6, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC40PT7B_H_
