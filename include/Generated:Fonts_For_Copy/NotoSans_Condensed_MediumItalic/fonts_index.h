#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_Condensed_MediumItalic6pt7b, 6, "NotoSans_Condensed_MediumItalic6pt7b" },
  { &NotoSans_Condensed_MediumItalic7pt7b, 7, "NotoSans_Condensed_MediumItalic7pt7b" },
  { &NotoSans_Condensed_MediumItalic8pt7b, 8, "NotoSans_Condensed_MediumItalic8pt7b" },
  { &NotoSans_Condensed_MediumItalic9pt7b, 9, "NotoSans_Condensed_MediumItalic9pt7b" },
  { &NotoSans_Condensed_MediumItalic10pt7b, 10, "NotoSans_Condensed_MediumItalic10pt7b" },
  { &NotoSans_Condensed_MediumItalic11pt7b, 11, "NotoSans_Condensed_MediumItalic11pt7b" },
  { &NotoSans_Condensed_MediumItalic12pt7b, 12, "NotoSans_Condensed_MediumItalic12pt7b" },
  { &NotoSans_Condensed_MediumItalic13pt7b, 13, "NotoSans_Condensed_MediumItalic13pt7b" },
  { &NotoSans_Condensed_MediumItalic14pt7b, 14, "NotoSans_Condensed_MediumItalic14pt7b" },
  { &NotoSans_Condensed_MediumItalic15pt7b, 15, "NotoSans_Condensed_MediumItalic15pt7b" },
  { &NotoSans_Condensed_MediumItalic16pt7b, 16, "NotoSans_Condensed_MediumItalic16pt7b" },
  { &NotoSans_Condensed_MediumItalic17pt7b, 17, "NotoSans_Condensed_MediumItalic17pt7b" },
  { &NotoSans_Condensed_MediumItalic18pt7b, 18, "NotoSans_Condensed_MediumItalic18pt7b" },
  { &NotoSans_Condensed_MediumItalic19pt7b, 19, "NotoSans_Condensed_MediumItalic19pt7b" },
  { &NotoSans_Condensed_MediumItalic20pt7b, 20, "NotoSans_Condensed_MediumItalic20pt7b" },
  { &NotoSans_Condensed_MediumItalic21pt7b, 21, "NotoSans_Condensed_MediumItalic21pt7b" },
  { &NotoSans_Condensed_MediumItalic22pt7b, 22, "NotoSans_Condensed_MediumItalic22pt7b" },
  { &NotoSans_Condensed_MediumItalic23pt7b, 23, "NotoSans_Condensed_MediumItalic23pt7b" },
  { &NotoSans_Condensed_MediumItalic24pt7b, 24, "NotoSans_Condensed_MediumItalic24pt7b" },
  { &NotoSans_Condensed_MediumItalic25pt7b, 25, "NotoSans_Condensed_MediumItalic25pt7b" },
  { &NotoSans_Condensed_MediumItalic26pt7b, 26, "NotoSans_Condensed_MediumItalic26pt7b" },
  { &NotoSans_Condensed_MediumItalic27pt7b, 27, "NotoSans_Condensed_MediumItalic27pt7b" },
  { &NotoSans_Condensed_MediumItalic28pt7b, 28, "NotoSans_Condensed_MediumItalic28pt7b" },
  { &NotoSans_Condensed_MediumItalic29pt7b, 29, "NotoSans_Condensed_MediumItalic29pt7b" },
  { &NotoSans_Condensed_MediumItalic30pt7b, 30, "NotoSans_Condensed_MediumItalic30pt7b" },
  { &NotoSans_Condensed_MediumItalic31pt7b, 31, "NotoSans_Condensed_MediumItalic31pt7b" },
  { &NotoSans_Condensed_MediumItalic32pt7b, 32, "NotoSans_Condensed_MediumItalic32pt7b" },
  { &NotoSans_Condensed_MediumItalic33pt7b, 33, "NotoSans_Condensed_MediumItalic33pt7b" },
  { &NotoSans_Condensed_MediumItalic34pt7b, 34, "NotoSans_Condensed_MediumItalic34pt7b" },
  { &NotoSans_Condensed_MediumItalic35pt7b, 35, "NotoSans_Condensed_MediumItalic35pt7b" },
  { &NotoSans_Condensed_MediumItalic36pt7b, 36, "NotoSans_Condensed_MediumItalic36pt7b" },
  { &NotoSans_Condensed_MediumItalic37pt7b, 37, "NotoSans_Condensed_MediumItalic37pt7b" },
  { &NotoSans_Condensed_MediumItalic38pt7b, 38, "NotoSans_Condensed_MediumItalic38pt7b" },
  { &NotoSans_Condensed_MediumItalic39pt7b, 39, "NotoSans_Condensed_MediumItalic39pt7b" },
  { &NotoSans_Condensed_MediumItalic40pt7b, 40, "NotoSans_Condensed_MediumItalic40pt7b" },
  { &NotoSans_Condensed_MediumItalic41pt7b, 41, "NotoSans_Condensed_MediumItalic41pt7b" },
  { &NotoSans_Condensed_MediumItalic42pt7b, 42, "NotoSans_Condensed_MediumItalic42pt7b" },
  { &NotoSans_Condensed_MediumItalic43pt7b, 43, "NotoSans_Condensed_MediumItalic43pt7b" },
  { &NotoSans_Condensed_MediumItalic44pt7b, 44, "NotoSans_Condensed_MediumItalic44pt7b" },
  { &NotoSans_Condensed_MediumItalic45pt7b, 45, "NotoSans_Condensed_MediumItalic45pt7b" },
  { &NotoSans_Condensed_MediumItalic46pt7b, 46, "NotoSans_Condensed_MediumItalic46pt7b" },
  { &NotoSans_Condensed_MediumItalic47pt7b, 47, "NotoSans_Condensed_MediumItalic47pt7b" },
  { &NotoSans_Condensed_MediumItalic48pt7b, 48, "NotoSans_Condensed_MediumItalic48pt7b" },
  { &NotoSans_Condensed_MediumItalic49pt7b, 49, "NotoSans_Condensed_MediumItalic49pt7b" },
  { &NotoSans_Condensed_MediumItalic50pt7b, 50, "NotoSans_Condensed_MediumItalic50pt7b" },
  { &NotoSans_Condensed_MediumItalic51pt7b, 51, "NotoSans_Condensed_MediumItalic51pt7b" },
  { &NotoSans_Condensed_MediumItalic52pt7b, 52, "NotoSans_Condensed_MediumItalic52pt7b" },
  { &NotoSans_Condensed_MediumItalic53pt7b, 53, "NotoSans_Condensed_MediumItalic53pt7b" },
  { &NotoSans_Condensed_MediumItalic54pt7b, 54, "NotoSans_Condensed_MediumItalic54pt7b" },
  { &NotoSans_Condensed_MediumItalic55pt7b, 55, "NotoSans_Condensed_MediumItalic55pt7b" },
  { &NotoSans_Condensed_MediumItalic56pt7b, 56, "NotoSans_Condensed_MediumItalic56pt7b" },
  { &NotoSans_Condensed_MediumItalic57pt7b, 57, "NotoSans_Condensed_MediumItalic57pt7b" },
  { &NotoSans_Condensed_MediumItalic58pt7b, 58, "NotoSans_Condensed_MediumItalic58pt7b" },
  { &NotoSans_Condensed_MediumItalic59pt7b, 59, "NotoSans_Condensed_MediumItalic59pt7b" },
  { &NotoSans_Condensed_MediumItalic60pt7b, 60, "NotoSans_Condensed_MediumItalic60pt7b" },
  { &NotoSans_Condensed_MediumItalic61pt7b, 61, "NotoSans_Condensed_MediumItalic61pt7b" },
  { &NotoSans_Condensed_MediumItalic62pt7b, 62, "NotoSans_Condensed_MediumItalic62pt7b" },
  { &NotoSans_Condensed_MediumItalic63pt7b, 63, "NotoSans_Condensed_MediumItalic63pt7b" },
  { &NotoSans_Condensed_MediumItalic64pt7b, 64, "NotoSans_Condensed_MediumItalic64pt7b" },
  { &NotoSans_Condensed_MediumItalic65pt7b, 65, "NotoSans_Condensed_MediumItalic65pt7b" },
  { &NotoSans_Condensed_MediumItalic66pt7b, 66, "NotoSans_Condensed_MediumItalic66pt7b" },
  { &NotoSans_Condensed_MediumItalic67pt7b, 67, "NotoSans_Condensed_MediumItalic67pt7b" },
  { &NotoSans_Condensed_MediumItalic68pt7b, 68, "NotoSans_Condensed_MediumItalic68pt7b" },
  { &NotoSans_Condensed_MediumItalic69pt7b, 69, "NotoSans_Condensed_MediumItalic69pt7b" },
  { &NotoSans_Condensed_MediumItalic70pt7b, 70, "NotoSans_Condensed_MediumItalic70pt7b" },
  { &NotoSans_Condensed_MediumItalic71pt7b, 71, "NotoSans_Condensed_MediumItalic71pt7b" },
  { &NotoSans_Condensed_MediumItalic72pt7b, 72, "NotoSans_Condensed_MediumItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
