#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC64PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x1F,
  0x87, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xCE, 0x3C, 0x03, 0xF0, 0xE0, 0xC0, 0x3F, 0x1C, 0x00, 0x07,
  0xE1, 0xC0, 0x00, 0x7E, 0x1C, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x1C,
  0x00, 0x07, 0xE3, 0x80, 0x00, 0x7F, 0x38, 0x00, 0x07, 0xF3, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0xFE, 0x00, 0x00,
  0xE7, 0xF0, 0x00, 0x1C, 0x3F, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0x1C, 0x3F,
  0x00, 0x01, 0xC3, 0xF0, 0x00, 0x3C, 0x3F, 0x00, 0x03, 0x87, 0xE0, 0xC0,
  0x38, 0x7E, 0x0F, 0x03, 0x8F, 0xE0, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x0F,
  0x8F, 0x80, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0x0F, 0x81, 0xE0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x7C,
  0x00, 0x78, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x7C, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x3E, 0x00, 0x0F, 0x01, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F,
  0x8F, 0x87, 0xFC, 0xF0, 0x3E, 0x3E, 0x3F, 0xFB, 0xC1, 0xF1, 0xF1, 0xFF,
  0xEF, 0x87, 0xC7, 0xCF, 0xEF, 0xFE, 0x3E, 0x3E, 0x3E, 0x1F, 0xFF, 0xF9,
  0xF1, 0xF0, 0x7D, 0xFF, 0xC7, 0xC7, 0xC1, 0xF7, 0xFE, 0x3E, 0x3E, 0x07,
  0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0x3E,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xE0,
  0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x7C, 0x00, 0x7F, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x03,
  0xFF, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0x03, 0xFF, 0xE0, 0x3F, 0x03, 0xFB, 0xF8, 0x1F, 0x83,
  0xF9, 0xFC, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xE1,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x07, 0xF3, 0xF0, 0xFE, 0x01, 0xFB, 0xF0,
  0x7E, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0xF8, 0x1F, 0x80, 0x1F, 0xF8,
  0x1F, 0xC0, 0x0F, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xFC,
  0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x08, 0x07, 0xC0, 0x0C, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7F, 0x3C, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x9E, 0x00, 0x7E, 0x3E, 0x03, 0xFC,
  0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xC0, 0xFC, 0x03, 0x01, 0xF8, 0x02, 0x01,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3E, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xCF, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F,
  0xF7, 0xEF, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x0E, 0x1F, 0xC2, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xE0,
  0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0x0F, 0xF8, 0x01, 0xC0, 0x1F, 0xC0, 0x08, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x10, 0x00, 0x3F, 0xC0, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x7C, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x07,
  0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x70, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x82, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x3F,
  0xC0, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFE, 0x02,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x9F, 0xF8, 0x03, 0xF3, 0xFF,
  0xC0, 0x3F, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x07,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7F,
  0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0,
  0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xF0,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x1F, 0xF0, 0x7F, 0x07, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7E, 0x01, 0xFF, 0xCF,
  0xC0, 0x1F, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3E, 0x0F, 0xF0, 0x60, 0x0F, 0xC1, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x38, 0x00, 0xF0, 0x3E, 0x00, 0xFF, 0xE0, 0x78, 0x1F, 0x00, 0xFF, 0xF8,
  0x3C, 0x1F, 0x00, 0xFF, 0xFC, 0x1F, 0x0F, 0x80, 0xFE, 0x7C, 0x0F, 0x8F,
  0x80, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0x03, 0xC3, 0xC0, 0xF8,
  0x0F, 0x81, 0xE3, 0xE0, 0x7C, 0x07, 0x80, 0xF1, 0xF0, 0x7C, 0x07, 0xC0,
  0x78, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x1E, 0x01, 0xF0, 0x3E, 0x7C,
  0x1F, 0x00, 0xF0, 0x1F, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x1E, 0x07, 0xC0,
  0x7C, 0x07, 0x8F, 0x03, 0xC0, 0x3E, 0x07, 0xCF, 0x83, 0xE0, 0x3E, 0x03,
  0xC7, 0xC1, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x0F, 0x81, 0xF1, 0xF0,
  0x7C, 0x0F, 0xC0, 0xF0, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0xF0, 0xF8, 0x3E, 0x07, 0xC7, 0x7C, 0xF8, 0x1F, 0x03, 0xFF, 0xBF, 0xFC,
  0x0F, 0x81, 0xFF, 0x8F, 0xFC, 0x07, 0xC0, 0x7F, 0x87, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x3E,
  0x00, 0x3F, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x87, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0xC0, 0x7E, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xC7, 0xE0, 0x0F, 0xF8, 0x03,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x02, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xFC, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xF8, 0x03, 0xFE,
  0x00, 0x38, 0x03, 0xFE, 0x00, 0x04, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF8,
  0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x3F, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x04, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F,
  0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xFC,
  0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x07, 0xDF, 0x80,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x00, 0xF9, 0xF8, 0x03,
  0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x80, 0x7E,
  0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE3,
  0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x3E,
  0x01, 0xF1, 0xF8, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xE0,
  0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x07,
  0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0x87, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x1F, 0x03,
  0xF0, 0x07, 0xE0, 0xFC, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF3, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xDF, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x7C, 0x07, 0xE0,
  0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0x07, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x01,
  0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0x03, 0xF3, 0xF0, 0x0F,
  0xC0, 0x0F, 0x87, 0xC0, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x7E,
  0x00, 0x7E, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x07, 0xC3, 0xF0,
  0x03, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xE0, 0x0F, 0x9F, 0x80,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x01,
  0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xC0, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F, 0x80,
  0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x07, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F,
  0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0x00, 0x3F, 0x80, 0x04, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x04, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0x7F, 0x80, 0x7E, 0x0F, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x7C,
  0x0F, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xFF, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFB,
  0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xE3, 0xE0,
  0x3F, 0x00, 0xFC, 0x0F, 0x8F, 0x81, 0xFC, 0x03, 0xF0, 0x7E, 0x3E, 0x07,
  0xE0, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC,
  0x00, 0xFC, 0x3E, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x3E, 0x1F, 0xC0,
  0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xE0, 0x3E, 0x3F, 0x00, 0x0F,
  0x8F, 0x80, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x00, 0xF9,
  0xF0, 0x0F, 0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xBF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0xC1, 0xF0,
  0x07, 0xFE, 0x1F, 0x00, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xBF, 0x03, 0xFF,
  0xFB, 0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xC0,
  0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0x0F, 0xF0, 0xF8, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xF8,
  0x01, 0xF9, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x01, 0xFE, 0x01, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE,
  0x01, 0xF3, 0xFF, 0xE0, 0x0F, 0x8F, 0xFE, 0x00, 0xF8, 0x3F, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x87, 0x01, 0xFC, 0x02,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x04, 0x0F, 0xE0, 0x30, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0xF1, 0xF8, 0x00, 0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC,
  0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xDF, 0x80, 0x0F, 0xFF,
  0x3E, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x0F,
  0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x7E, 0x03, 0xFC, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x10, 0x7F, 0x00, 0x60, 0x7F, 0xE3, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x20, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x1F, 0xF8, 0x7C, 0x00, 0x7F,
  0xF9, 0xF8, 0x01, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0xF7, 0xC0, 0x1F, 0xF1,
  0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0xFE,
  0x03, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xBF, 0x00, 0x0F, 0xFE,
  0x7E, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x06, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xFC,
  0x01, 0xF9, 0xFF, 0xE0, 0x1F, 0xBF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFC, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x87,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0x7E, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x00,
  0x3E, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xC7, 0xFF, 0x0F, 0xFF, 0x00, 0xF9,
  0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0x1F,
  0xFE, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xFC, 0x01, 0xF1,
  0xFF, 0xE0, 0x1F, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF,
  0x03, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87,
  0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x1F, 0xF8, 0x00,
  0x3E, 0x3F, 0xFC, 0x00, 0x3E, 0x7F, 0xFC, 0x00, 0x3E, 0xFF, 0xFE, 0x00,
  0x3F, 0xF0, 0xFE, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x03,
  0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0x80, 0x0F,
  0xDF, 0xFF, 0x00, 0x0F, 0xCF, 0xFE, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x1F,
  0x80, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC1, 0xF0, 0x07, 0xFE, 0x1F, 0x00, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF,
  0xBF, 0x03, 0xFF, 0xFB, 0xE0, 0x3F, 0xC7, 0xFE, 0x07, 0xF0, 0x3F, 0xE0,
  0xFE, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xEF, 0xC0, 0x3F, 0xFD, 0xF8, 0x03, 0xFF, 0x9F, 0x80, 0x1F, 0xF1,
  0xF8, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x03, 0xE1, 0xFC,
  0x07, 0xC7, 0xF8, 0x0F, 0x9F, 0xF0, 0x1F, 0x7F, 0xC0, 0x3E, 0xFF, 0x80,
  0xFF, 0xE1, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFE, 0x07, 0x83, 0xF8, 0x02, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x08, 0x00, 0xFE, 0x1C, 0x03,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x81, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xFE, 0x07,
  0xFC, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xEF, 0x80,
  0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xE0, 0xF8, 0x00, 0x38,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0x7D, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0,
  0x03, 0xF7, 0xE0, 0x1F, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0xC0, 0x1F, 0x9F,
  0x80, 0x7F, 0x80, 0x7E, 0x3F, 0x01, 0xFF, 0x00, 0xFC, 0x7E, 0x03, 0xFE,
  0x01, 0xF8, 0xFC, 0x0F, 0xBC, 0x07, 0xE1, 0xF8, 0x1F, 0x78, 0x0F, 0xC3,
  0xF0, 0x3E, 0xF0, 0x3F, 0x07, 0xE0, 0xFB, 0xE0, 0x7E, 0x0F, 0xC1, 0xF7,
  0xC0, 0xF8, 0x1F, 0x87, 0xCF, 0x83, 0xF0, 0x3F, 0x0F, 0x9F, 0x07, 0xE0,
  0x7E, 0x1F, 0x3E, 0x1F, 0x80, 0xFC, 0x7C, 0x7C, 0x3F, 0x01, 0xF8, 0xF8,
  0xF8, 0x7C, 0x03, 0xF3, 0xE1, 0xF1, 0xF8, 0x07, 0xC7, 0xC3, 0xE3, 0xF0,
  0x0F, 0x8F, 0x87, 0xCF, 0xC0, 0x1F, 0x3E, 0x0F, 0x9F, 0x80, 0x3E, 0x7C,
  0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFA, 0x00, 0x0F, 0xFC, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 47, 16, 1, -46 },
  { 95, 20, 17, 24, 6, -46 },
  { 138, 32, 46, 32, 1, -46 },
  { 322, 28, 53, 29, 1, -49 },
  { 508, 38, 47, 44, 4, -46 },
  { 732, 33, 47, 33, 0, -46 },
  { 926, 9, 17, 14, 7, -46 },
  { 946, 21, 56, 18, 1, -46 },
  { 1093, 21, 56, 18, -5, -46 },
  { 1240, 23, 25, 27, 6, -49 },
  { 1312, 26, 31, 31, 3, -38 },
  { 1413, 13, 15, 15, -3, -7 },
  { 1438, 16, 6, 18, 1, -20 },
  { 1450, 8, 9, 15, 1, -8 },
  { 1459, 31, 46, 23, -3, -46 },
  { 1638, 26, 47, 29, 2, -46 },
  { 1791, 18, 46, 29, 7, -46 },
  { 1895, 30, 46, 29, -2, -46 },
  { 2068, 29, 47, 29, 0, -46 },
  { 2239, 30, 46, 29, -1, -46 },
  { 2412, 29, 47, 29, 0, -46 },
  { 2583, 28, 47, 29, 2, -46 },
  { 2748, 28, 46, 29, 3, -46 },
  { 2909, 28, 47, 29, 1, -46 },
  { 3074, 27, 47, 29, 1, -46 },
  { 3233, 14, 36, 15, 0, -35 },
  { 3296, 17, 43, 15, -3, -35 },
  { 3388, 26, 30, 31, 3, -38 },
  { 3486, 26, 19, 31, 3, -32 },
  { 3548, 26, 30, 31, 3, -38 },
  { 3646, 22, 47, 22, 2, -46 },
  { 3776, 41, 51, 43, 2, -46 },
  { 4038, 30, 46, 30, -4, -46 },
  { 4211, 31, 46, 31, 1, -46 },
  { 4390, 30, 47, 29, 3, -46 },
  { 4567, 32, 46, 34, 1, -46 },
  { 4751, 29, 46, 27, 1, -46 },
  { 4918, 29, 46, 25, 1, -46 },
  { 5085, 33, 47, 36, 3, -46 },
  { 5279, 36, 46, 35, 1, -46 },
  { 5486, 26, 46, 19, -3, -46 },
  { 5636, 27, 59, 15, -10, -46 },
  { 5836, 34, 46, 30, 1, -46 },
  { 6032, 20, 46, 25, 1, -46 },
  { 6147, 46, 46, 46, 1, -46 },
  { 6412, 38, 46, 38, 1, -46 },
  { 6631, 33, 47, 37, 3, -46 },
  { 6825, 30, 46, 30, 1, -46 },
  { 6998, 33, 57, 37, 3, -46 },
  { 7234, 30, 46, 31, 1, -46 },
  { 7407, 30, 47, 27, -1, -46 },
  { 7584, 26, 46, 26, 5, -46 },
  { 7734, 33, 47, 35, 3, -46 },
  { 7928, 29, 46, 30, 6, -46 },
  { 8095, 46, 46, 47, 6, -46 },
  { 8360, 37, 46, 28, -4, -46 },
  { 8573, 27, 46, 27, 6, -46 },
  { 8729, 32, 46, 26, -2, -46 },
  { 8913, 25, 56, 18, -2, -46 },
  { 9088, 11, 46, 23, 7, -46 },
  { 9152, 24, 56, 18, -4, -46 },
  { 9320, 27, 27, 29, 1, -46 },
  { 9412, 23, 5, 21, -6, 5 },
  { 9427, 10, 10, 17, 9, -49 },
  { 9440, 28, 36, 31, 2, -35 },
  { 9566, 29, 50, 30, 0, -49 },
  { 9748, 23, 36, 24, 2, -35 },
  { 9852, 31, 50, 31, 2, -49 },
  { 10046, 24, 36, 28, 2, -35 },
  { 10154, 33, 64, 17, -8, -49 },
  { 10418, 31, 50, 31, -1, -35 },
  { 10612, 28, 49, 30, 0, -49 },
  { 10784, 16, 48, 14, 0, -48 },
  { 10880, 24, 63, 14, -8, -48 },
  { 11069, 30, 49, 27, 0, -49 },
  { 11253, 17, 49, 14, 0, -49 },
  { 11358, 43, 35, 45, 0, -35 },
  { 11547, 28, 35, 30, 0, -35 },
  { 11670, 26, 36, 30, 2, -35 },
  { 11787, 32, 50, 30, -3, -35 },
  { 11987, 28, 50, 31, 2, -35 },
  { 12162, 23, 35, 21, 0, -35 },
  { 12263, 23, 36, 23, 0, -35 },
  { 12367, 18, 43, 18, 2, -42 },
  { 12464, 28, 36, 30, 2, -35 },
  { 12590, 24, 35, 25, 4, -35 },
  { 12695, 39, 35, 39, 4, -35 },
  { 12866, 31, 35, 26, -3, -35 },
  { 13002, 35, 50, 25, -6, -35 },
  { 13221, 25, 35, 22, -2, -35 },
  { 13331, 25, 56, 22, 1, -46 },
  { 13506, 5, 64, 27, 11, -49 },
  { 13546, 23, 56, 22, -3, -46 },
  { 13707, 26, 9, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_MediumItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC64PT7B_H_
