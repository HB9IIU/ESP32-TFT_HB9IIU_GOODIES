#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0x78, 0x00, 0x7C, 0x7D, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF9,
  0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC3, 0x8E, 0x1E, 0x38, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x70,
  0x00, 0x70, 0x70, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0,
  0x01, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x03, 0x87, 0x80,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xCC, 0x20, 0x3C, 0x60, 0x01, 0xE3, 0x00, 0x1E, 0x38, 0x00, 0xF9,
  0x80, 0x07, 0xCC, 0x00, 0x1F, 0x60, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x37,
  0xE0, 0x01, 0x9F, 0x00, 0x0C, 0xF8, 0x00, 0x63, 0xC0, 0x07, 0x1E, 0x00,
  0x31, 0xF0, 0x81, 0x8F, 0x07, 0x0D, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x07, 0x81, 0xFC,
  0x01, 0xE0, 0x7F, 0xC0, 0x38, 0x1E, 0x78, 0x0F, 0x03, 0x87, 0x01, 0xC0,
  0xF0, 0xE0, 0x78, 0x1C, 0x1C, 0x1E, 0x03, 0x83, 0x83, 0x80, 0xF0, 0x70,
  0xF0, 0x1E, 0x1E, 0x1C, 0x03, 0x83, 0xC7, 0x80, 0x70, 0x78, 0xE0, 0x0E,
  0x0E, 0x3C, 0x01, 0xC3, 0xCF, 0x1F, 0x38, 0x79, 0xC7, 0xF7, 0x1E, 0x79,
  0xFF, 0xE3, 0xCE, 0x79, 0xFF, 0xF3, 0xCE, 0x1D, 0xFC, 0xF3, 0xC3, 0xBF,
  0x1C, 0x70, 0x70, 0x07, 0x9E, 0x0E, 0x00, 0xE3, 0xC3, 0xC0, 0x3C, 0x78,
  0x78, 0x0F, 0x0E, 0x0F, 0x01, 0xC1, 0xC1, 0xC0, 0x78, 0x38, 0x38, 0x0E,
  0x0F, 0x0F, 0x03, 0xC1, 0xE1, 0xC0, 0xF0, 0x3C, 0x78, 0x1E, 0x03, 0x8E,
  0x07, 0x80, 0x7F, 0xC0, 0xE0, 0x0F, 0xF0, 0x3C, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0x8F, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xE1,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF8, 0x3C, 0x7F, 0xF0, 0xF8, 0xF1, 0xF1, 0xE3, 0xE3, 0xE3, 0xCF,
  0x83, 0xEF, 0x9E, 0x07, 0xDE, 0x3C, 0x07, 0xF8, 0xF8, 0x0F, 0xF1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0xC1, 0xFE, 0x0F, 0xCF,
  0xFC, 0x1F, 0xFF, 0x7C, 0x1F, 0xFC, 0xF8, 0x1F, 0xE0, 0xF8, 0x7D, 0xF7,
  0xDE, 0x79, 0xE7, 0x3C, 0xF3, 0xCE, 0x38, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x06, 0x0E, 0x03, 0xC7, 0x01, 0xFB, 0x8F, 0xFF,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01, 0xFE, 0x01, 0xE7, 0x01,
  0xF3, 0xC1, 0xF1, 0xE0, 0x30, 0x78, 0x08, 0x38, 0x00, 0x10, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x39,
  0xF7, 0xDF, 0xFD, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3E, 0x3E, 0x0F,
  0x83, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C, 0x78,
  0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80,
  0x7D, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x03,
  0xE3, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x87, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF9, 0xFB, 0xDF, 0xBE, 0x79, 0xF3, 0x0F, 0x08, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x1C,
  0x0F, 0x80, 0xC0, 0x7C, 0x04, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x38, 0x1F, 0x01, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x08, 0x03, 0xF0, 0x7C, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0x9E,
  0x00, 0x1C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x1C, 0x3E, 0x00,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x7F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x0C, 0x03, 0xF0, 0x7E, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0xFB,
  0xFC, 0x1E, 0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x1F, 0x9F, 0x81, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x1F, 0x0F, 0x87,
  0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x20, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x0F, 0x83,
  0xE0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07,
  0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0x3E, 0x7E, 0x01, 0xF7, 0xE0, 0x07,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xE7, 0xC0,
  0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x87,
  0xC0, 0xF8, 0x3F, 0x0F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8,
  0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0,
  0x3C, 0xF8, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x01,
  0xF9, 0xF0, 0x7E, 0x3E, 0x1F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFB,
  0xE0, 0x7C, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0xCF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x81, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x18, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x07, 0xF0, 0xE0, 0xE0, 0x7F,
  0xE3, 0xC7, 0x83, 0xFF, 0x0F, 0x1C, 0x1E, 0x1C, 0x3C, 0xF0, 0xF0, 0xF0,
  0xF3, 0x83, 0x83, 0xC3, 0x8E, 0x1E, 0x0E, 0x0E, 0x78, 0x70, 0x38, 0x39,
  0xE1, 0xC1, 0xE0, 0xE7, 0x0F, 0x07, 0x87, 0x9C, 0x3C, 0x1C, 0x1C, 0x70,
  0xE0, 0xF0, 0x71, 0xC3, 0x83, 0xC3, 0xC7, 0x0E, 0x0F, 0x0E, 0x3C, 0x38,
  0x7C, 0x78, 0xF0, 0xF3, 0xF3, 0xC3, 0xC3, 0xFD, 0xFE, 0x07, 0x07, 0xE3,
  0xF0, 0x1C, 0x0F, 0x07, 0x80, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x10, 0x00,
  0x7E, 0x03, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1D, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0xDE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x1E,
  0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0x7C,
  0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3E,
  0x0F, 0x80, 0x78, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x0F, 0x80,
  0xF0, 0x3E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF0, 0x10, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x02, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE1, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3C, 0x03,
  0xE0, 0x3C, 0x07, 0xE0, 0x7C, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xF8, 0x0E, 0x07, 0xE0, 0x02, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xFC, 0x78, 0x07, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x01,
  0xE0, 0x7E, 0x01, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x03,
  0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xE0,
  0x07, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x7C,
  0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00,
  0x78, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3C, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0x83, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xF3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x78, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xEF, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x3D, 0xF0,
  0x1E, 0xF0, 0x0F, 0x7C, 0x07, 0xBC, 0x07, 0xDE, 0x01, 0xEF, 0x01, 0xE7,
  0x80, 0xF9, 0xC0, 0x79, 0xE0, 0x3C, 0x70, 0x3C, 0xF8, 0x0F, 0x1C, 0x0F,
  0x3C, 0x03, 0xC7, 0x87, 0x8F, 0x00, 0xF1, 0xE1, 0xE3, 0xC0, 0x7C, 0x78,
  0xF1, 0xF0, 0x1E, 0x1E, 0x3C, 0x7C, 0x07, 0x87, 0x9E, 0x1E, 0x01, 0xE1,
  0xE7, 0x87, 0x80, 0xF8, 0x7B, 0xC1, 0xE0, 0x3C, 0x1E, 0xF0, 0xF8, 0x0F,
  0x07, 0xF8, 0x3E, 0x03, 0xC1, 0xFE, 0x0F, 0x00, 0xF0, 0x7F, 0x03, 0xC0,
  0x7C, 0x1F, 0xC0, 0xF0, 0x1E, 0x07, 0xE0, 0x7C, 0x07, 0x81, 0xF8, 0x1E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x80, 0x1E,
  0x03, 0xFC, 0x01, 0xE0, 0x3F, 0xC0, 0x3E, 0x03, 0xFC, 0x03, 0xC0, 0x3F,
  0xC0, 0x3C, 0x03, 0xFC, 0x03, 0xC0, 0x7D, 0xE0, 0x3C, 0x07, 0x9E, 0x07,
  0xC0, 0x79, 0xE0, 0x78, 0x07, 0x9E, 0x07, 0x80, 0x79, 0xF0, 0x78, 0x0F,
  0x8F, 0x0F, 0x80, 0xF0, 0xF0, 0xF8, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0xF0, 0x0F, 0x07, 0x8F, 0x01, 0xF0, 0x79, 0xF0, 0x1E, 0x07, 0x9F, 0x01,
  0xE0, 0x79, 0xE0, 0x1E, 0x07, 0xDE, 0x03, 0xE0, 0x3D, 0xE0, 0x3E, 0x03,
  0xDE, 0x03, 0xC0, 0x3F, 0xC0, 0x3C, 0x03, 0xFC, 0x03, 0xC0, 0x1F, 0xC0,
  0x7C, 0x01, 0xFC, 0x07, 0x80, 0x1F, 0xC0, 0x78, 0x01, 0xF8, 0x07, 0x80,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE1, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0xFC, 0x0F, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xE1, 0xF8, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xE1, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x83,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xE0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0xF0, 0xF8,
  0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7E, 0x07, 0x03, 0xE0, 0x10, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE1, 0x00, 0x3E, 0x0E, 0x03, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x3E,
  0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C,
  0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x3E,
  0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x0F,
  0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00,
  0xF8, 0x03, 0xDF, 0x00, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x01, 0xE7, 0xC0,
  0x7F, 0x00, 0xF3, 0xE0, 0x3F, 0x80, 0xF9, 0xF0, 0x1F, 0xC0, 0x78, 0xF8,
  0x1F, 0xE0, 0x7C, 0x78, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0x78, 0x1E, 0x1E,
  0x07, 0xBC, 0x1F, 0x0F, 0x03, 0x9E, 0x0F, 0x07, 0x83, 0xCF, 0x0F, 0x83,
  0xC1, 0xE7, 0x87, 0x81, 0xE1, 0xE3, 0xC3, 0xC0, 0xF0, 0xF1, 0xE3, 0xE0,
  0x78, 0x70, 0xF1, 0xE0, 0x3C, 0x78, 0x79, 0xF0, 0x1E, 0x3C, 0x3C, 0xF0,
  0x0F, 0x3C, 0x1E, 0x78, 0x07, 0x9E, 0x0F, 0x7C, 0x03, 0xCE, 0x07, 0x3C,
  0x01, 0xEF, 0x03, 0xBE, 0x00, 0xF7, 0x81, 0xDE, 0x00, 0x7F, 0x80, 0xEF,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x81, 0xF0,
  0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7C, 0xF0,
  0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0xF8, 0xF0,
  0x1E, 0x1E, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x07, 0x8F, 0x80, 0xF1,
  0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0xF1, 0xE0, 0x1E, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF9, 0xF1, 0xE3, 0xE3, 0xC3, 0xC3,
  0x80, 0x00, 0xFC, 0x78, 0x1F, 0xF3, 0x81, 0xFF, 0xBC, 0x0F, 0xFF, 0xE0,
  0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3C,
  0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x07, 0x83, 0xF0, 0x3F, 0x7F, 0x81, 0xFF,
  0xBC, 0x07, 0xF9, 0xE0, 0x1F, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF3, 0xF0,
  0x0F, 0xBF, 0xC0, 0x7B, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xC1, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE1,
  0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3F,
  0x03, 0xE1, 0xF8, 0x3E, 0x0F, 0xE3, 0xF0, 0x7F, 0xFF, 0x03, 0x9F, 0xF0,
  0x3C, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xF8, 0x10, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x83,
  0xF3, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0xF7, 0x80, 0x7F, 0xEF, 0x00, 0xFF,
  0xFE, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x03,
  0xE0, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x1E,
  0x0F, 0xC0, 0x3E, 0x3F, 0x80, 0x7F, 0xEF, 0x00, 0x7F, 0x9E, 0x00, 0x7E,
  0x3C, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0x1F, 0x0F,
  0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x1F, 0x3C, 0x07, 0x8F, 0x03,
  0xE7, 0xC7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x02, 0x1F, 0x87, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x3C, 0x07, 0xFC, 0xE0, 0x3F, 0xF7, 0x80, 0xFF, 0xFE, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE0,
  0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x3C, 0x1F, 0x80, 0xFD, 0xFE,
  0x03, 0xFF, 0x78, 0x07, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x08, 0x03,
  0xE0, 0x30, 0x1F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xCF, 0xC0, 0x7D, 0xFE, 0x07, 0xBF, 0xF0,
  0x7F, 0xFF, 0x07, 0xE1, 0xF0, 0xFC, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0x78, 0x1E, 0x03, 0xC1, 0xF0, 0x1E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x0F, 0x01, 0xF0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xE0,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x8F, 0xC1, 0xF8, 0x0F, 0x3F, 0xC7,
  0xF8, 0x1E, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7E, 0x1F, 0xC3,
  0xE1, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x1F,
  0x0F, 0x01, 0xF0, 0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x7C, 0x07, 0x80, 0xF0,
  0xF8, 0x1F, 0x01, 0xE1, 0xE0, 0x3E, 0x07, 0xC3, 0xC0, 0x78, 0x0F, 0x0F,
  0x80, 0xF0, 0x1E, 0x1F, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0xC0, 0xF8, 0x78,
  0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x07, 0x87, 0xC0,
  0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x3E, 0x1E, 0x03, 0xC0, 0x7C, 0x3C, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x01, 0xE0, 0x07, 0x8F, 0xC0, 0x79, 0xFE, 0x07,
  0xBF, 0xF0, 0x7F, 0xFF, 0x07, 0xE1, 0xF0, 0xFC, 0x0F, 0x0F, 0xC0, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x03,
  0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0xC7,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0xBE,
  0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x3C, 0x0F, 0x87, 0xC1, 0xF0, 0xFC,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xE3, 0xF0,
  0x03, 0xCF, 0xF0, 0x07, 0xBF, 0xF0, 0x0F, 0xF7, 0xE0, 0x1F, 0x87, 0xC0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0,
  0x0F, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xFD, 0xFC,
  0x07, 0xBF, 0xF0, 0x0F, 0x7F, 0xC0, 0x3E, 0x7E, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x78, 0x1F, 0xF3, 0x81, 0xFF,
  0xBC, 0x0F, 0xFF, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8,
  0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x07, 0x83, 0xF0,
  0x3F, 0x3F, 0x81, 0xFF, 0xBC, 0x07, 0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x8F, 0x83, 0xCF, 0xC1, 0xEF, 0xC0, 0xFF,
  0xE0, 0x7F, 0x10, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFB, 0xE1, 0xF0, 0x20, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x88, 0x07, 0xC7, 0x9F, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x01,
  0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xF1, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF9, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0,
  0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xCF, 0x80,
  0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x3E, 0x03,
  0xC7, 0xC0, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0xF8, 0x78, 0x1F,
  0x0F, 0x07, 0xE1, 0xF3, 0xFC, 0x3F, 0xF7, 0x87, 0xFC, 0xE0, 0x7F, 0x1C,
  0x00, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7,
  0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3E,
  0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xE7, 0x80, 0xF3,
  0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xFF, 0x01,
  0xF0, 0x1E, 0xF0, 0x3F, 0x03, 0xEF, 0x03, 0xF0, 0x3C, 0xF0, 0x7F, 0x07,
  0xCF, 0x07, 0xF0, 0x78, 0xF0, 0x7F, 0x07, 0x8F, 0x0F, 0xF0, 0xF0, 0xF0,
  0xEF, 0x0F, 0x0F, 0x1E, 0xF1, 0xF0, 0xF1, 0xEF, 0x1E, 0x0F, 0x1C, 0xF1,
  0xE0, 0xF3, 0xCF, 0x3C, 0x0F, 0x38, 0xF3, 0xC0, 0xF7, 0x8F, 0x7C, 0x0F,
  0x78, 0xF7, 0x80, 0xF7, 0x0F, 0x78, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x7C, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x1F, 0x78,
  0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x3C, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xE0,
  0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x3E,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x2F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0xFD, 0x00,
  0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 33, 11, 0, -33 },
  { 51, 14, 12, 17, 5, -33 },
  { 72, 24, 33, 23, 0, -33 },
  { 171, 21, 38, 21, 0, -35 },
  { 271, 27, 33, 32, 3, -33 },
  { 383, 23, 33, 24, 0, -33 },
  { 478, 6, 12, 10, 5, -33 },
  { 487, 15, 40, 13, 1, -33 },
  { 562, 14, 40, 13, -3, -33 },
  { 632, 17, 18, 20, 4, -35 },
  { 671, 19, 22, 22, 2, -27 },
  { 724, 9, 11, 10, -2, -5 },
  { 737, 11, 4, 13, 1, -14 },
  { 743, 6, 6, 10, 0, -6 },
  { 748, 22, 33, 16, -2, -33 },
  { 839, 19, 33, 21, 1, -33 },
  { 918, 13, 33, 21, 5, -33 },
  { 972, 21, 33, 21, -1, -33 },
  { 1059, 21, 33, 21, 0, -33 },
  { 1146, 22, 33, 21, -1, -33 },
  { 1237, 21, 33, 21, 0, -33 },
  { 1324, 19, 33, 21, 2, -33 },
  { 1403, 20, 33, 21, 2, -33 },
  { 1486, 21, 33, 21, 0, -33 },
  { 1573, 19, 33, 21, 1, -33 },
  { 1652, 10, 25, 11, 0, -25 },
  { 1684, 12, 31, 11, -2, -25 },
  { 1731, 19, 21, 22, 2, -27 },
  { 1781, 19, 13, 22, 2, -23 },
  { 1812, 19, 21, 22, 2, -27 },
  { 1862, 16, 33, 16, 2, -33 },
  { 1928, 30, 37, 31, 1, -33 },
  { 2067, 22, 33, 22, -3, -33 },
  { 2158, 23, 33, 23, 0, -33 },
  { 2253, 22, 33, 21, 2, -33 },
  { 2344, 24, 33, 25, 0, -33 },
  { 2443, 21, 33, 19, 0, -33 },
  { 2530, 21, 33, 18, 0, -33 },
  { 2617, 24, 33, 26, 2, -33 },
  { 2716, 26, 33, 25, 0, -33 },
  { 2824, 19, 33, 14, -2, -33 },
  { 2903, 19, 42, 11, -7, -33 },
  { 3003, 25, 33, 22, 0, -33 },
  { 3107, 15, 33, 18, 0, -33 },
  { 3169, 34, 33, 33, 0, -33 },
  { 3310, 28, 33, 27, 0, -33 },
  { 3426, 24, 33, 26, 2, -33 },
  { 3525, 22, 33, 22, 0, -33 },
  { 3616, 24, 41, 26, 2, -33 },
  { 3739, 22, 33, 22, 0, -33 },
  { 3830, 21, 33, 20, 0, -33 },
  { 3917, 18, 33, 19, 4, -33 },
  { 3992, 24, 33, 25, 2, -33 },
  { 4091, 21, 33, 21, 4, -33 },
  { 4178, 33, 33, 33, 4, -33 },
  { 4315, 27, 33, 20, -3, -33 },
  { 4427, 19, 33, 19, 4, -33 },
  { 4506, 23, 33, 19, -2, -33 },
  { 4601, 18, 40, 13, -1, -33 },
  { 4691, 8, 33, 16, 5, -33 },
  { 4724, 18, 40, 13, -3, -33 },
  { 4814, 19, 19, 21, 1, -33 },
  { 4860, 16, 3, 15, -4, 4 },
  { 4866, 7, 7, 13, 7, -35 },
  { 4873, 21, 25, 22, 1, -25 },
  { 4939, 21, 35, 22, 0, -35 },
  { 5031, 17, 25, 17, 1, -25 },
  { 5085, 23, 35, 22, 1, -35 },
  { 5186, 18, 25, 20, 1, -25 },
  { 5243, 23, 46, 12, -5, -35 },
  { 5376, 22, 36, 22, 0, -25 },
  { 5475, 20, 35, 22, 0, -35 },
  { 5563, 12, 34, 10, 0, -34 },
  { 5614, 18, 45, 10, -6, -34 },
  { 5716, 21, 35, 19, 0, -35 },
  { 5808, 12, 35, 10, 0, -35 },
  { 5861, 31, 25, 32, 0, -25 },
  { 5958, 20, 25, 22, 0, -25 },
  { 6021, 19, 25, 21, 1, -25 },
  { 6081, 23, 36, 22, -2, -25 },
  { 6185, 21, 36, 22, 1, -25 },
  { 6280, 17, 25, 15, 0, -25 },
  { 6334, 17, 25, 17, 0, -25 },
  { 6388, 12, 30, 13, 2, -30 },
  { 6433, 19, 25, 22, 2, -25 },
  { 6493, 17, 25, 18, 3, -25 },
  { 6547, 28, 25, 28, 3, -25 },
  { 6635, 22, 25, 19, -2, -25 },
  { 6704, 25, 36, 18, -4, -25 },
  { 6817, 18, 25, 16, -1, -25 },
  { 6874, 17, 40, 16, 1, -33 },
  { 6959, 4, 46, 19, 8, -35 },
  { 6982, 17, 40, 16, -2, -33 },
  { 7067, 19, 6, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_MediumItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC46PT7B_H_
