#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC50PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x01,
  0x00, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xE1, 0xE7, 0xC3, 0xCF,
  0x8F, 0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x83,
  0x8F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x70, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x21, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xF7, 0x78, 0x0F, 0x8C, 0x10, 0x1F, 0x18, 0x00, 0x3C, 0x30, 0x00, 0x78,
  0xE0, 0x00, 0xF1, 0x80, 0x01, 0xF3, 0x00, 0x03, 0xE6, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1B, 0xF0, 0x00, 0x33, 0xE0,
  0x00, 0x63, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x06, 0x1E, 0x08,
  0x0C, 0x7C, 0x1C, 0x39, 0xF8, 0x3F, 0x7F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0,
  0x01, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0xFF, 0x80, 0x3C, 0x07, 0x9E, 0x01,
  0xE0, 0x3C, 0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x3C, 0x03, 0x83, 0xC0, 0xF0,
  0x1E, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x3C, 0x01, 0xC0, 0xE0, 0xF0, 0x0F,
  0x07, 0x87, 0x80, 0x3C, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0xF0, 0x03, 0xC1,
  0xE3, 0x80, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF1, 0xFC, 0xF0, 0xE3,
  0xCF, 0xFB, 0xC7, 0x9E, 0x7F, 0xEF, 0x3C, 0x71, 0xE3, 0xFF, 0xF3, 0xCF,
  0x0F, 0x7F, 0x9E, 0x3C, 0x3C, 0xFC, 0x79, 0xE0, 0xF0, 0x03, 0xC7, 0x83,
  0xC0, 0x0F, 0x1E, 0x0F, 0x00, 0x78, 0x70, 0x38, 0x03, 0xC3, 0xC1, 0xE0,
  0x0F, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x70, 0x0F,
  0x03, 0xC3, 0xC0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x00,
  0xF3, 0xE0, 0x3C, 0x03, 0xFF, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x7C,
  0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xF1, 0xFB, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0xF8, 0x7C, 0x7C, 0xF8, 0x1F, 0x3C, 0x7C, 0x0F, 0xBE, 0x3E,
  0x03, 0xFE, 0x3E, 0x01, 0xFF, 0x1F, 0x00, 0x7F, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x7E, 0x0F, 0xFF, 0x1F, 0x01, 0xFE, 0x0F, 0xC0, 0x10, 0x00,
  0x00, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x40, 0xF0, 0x1C, 0x38, 0x0F, 0xCE,
  0x03, 0xFF, 0xBF, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xDE, 0x03, 0xE7, 0x81, 0xF1, 0xF0, 0x38, 0x3C, 0x06,
  0x0F, 0x80, 0x03, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x7B, 0xFF, 0xFF, 0xFB, 0xE2, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0x1F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F,
  0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x87, 0x80, 0xF8, 0x3C, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x87, 0xFF, 0x1F, 0xBC, 0xFE, 0xF8, 0xF1, 0xF0, 0xC3, 0xE1, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0x0F,
  0xE0, 0x3C, 0x0F, 0xC0, 0x20, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xE1, 0xFC, 0x06, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x08, 0x00, 0xFC, 0x30, 0x0F, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x03,
  0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1,
  0xF0, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC8, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x10, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x20, 0x03,
  0xF0, 0x70, 0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x81, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0xF3, 0xFC, 0x0F, 0xBF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFE, 0xFE, 0x1F, 0xC1, 0xF1, 0xFC, 0x0F, 0x8F,
  0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x87, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFC,
  0x03, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x3F,
  0x07, 0xE0, 0xF8, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF8, 0x3F, 0x87, 0xE3,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xDE, 0x07, 0xFD, 0xF0, 0x0F, 0x8F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x10, 0x1F, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x87, 0xF0, 0xFC, 0x1F,
  0x81, 0xE0, 0x10, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xE1,
  0xF8, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFE, 0x3F,
  0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x07, 0xF8, 0x38, 0xF0, 0x3F, 0xF8, 0x71, 0xE0, 0xFF, 0xE0, 0xE7,
  0x83, 0xE3, 0xC1, 0xCF, 0x07, 0x87, 0x83, 0x9C, 0x1E, 0x0F, 0x07, 0x78,
  0x78, 0x1C, 0x1E, 0xF0, 0xF0, 0x78, 0x3D, 0xC1, 0xC0, 0xF0, 0x7F, 0x87,
  0x81, 0xE0, 0xEF, 0x0F, 0x03, 0x81, 0xDE, 0x1E, 0x0F, 0x07, 0xB8, 0x38,
  0x1E, 0x0E, 0x70, 0x70, 0x3C, 0x1C, 0xE0, 0xE0, 0xF8, 0x79, 0xC1, 0xC1,
  0xE1, 0xE3, 0x83, 0xC7, 0xE3, 0x87, 0x07, 0xFD, 0xFF, 0x0E, 0x0F, 0xF3,
  0xFC, 0x1C, 0x0F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x80, 0x01, 0xF8, 0x0F, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xBC, 0x00,
  0x0F, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x1F, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x03,
  0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0xFF, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFE, 0x1E, 0x03, 0xF8, 0x04, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x01,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0xE0,
  0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E,
  0x01, 0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7F, 0x01, 0xF1, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x40, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0x80, 0xFE, 0x00,
  0x60, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0xFF, 0xC7, 0xC0, 0x3F, 0xF1, 0xF0, 0x1F, 0xF8, 0xFC, 0x07,
  0xFE, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x78, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0xFE, 0x03,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0xF8,
  0x07, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3E,
  0x01, 0xF8, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0x78, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x3D, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xF7, 0x80, 0x1E, 0xF8,
  0x07, 0xBC, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xEF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x3C, 0xF8, 0x07,
  0x9F, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x1E, 0x7C, 0x03, 0xE3, 0xC1, 0xE3,
  0xE0, 0x1F, 0x1E, 0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0xF0, 0xF8, 0x07, 0x87,
  0x87, 0x87, 0x80, 0x7C, 0x3C, 0x7C, 0x7C, 0x03, 0xE1, 0xE3, 0xC3, 0xE0,
  0x1F, 0x0F, 0x3E, 0x1F, 0x00, 0xF0, 0x79, 0xE0, 0xF8, 0x0F, 0x83, 0xDF,
  0x07, 0x80, 0x7C, 0x1E, 0xF0, 0x7C, 0x03, 0xE0, 0xFF, 0x83, 0xE0, 0x1E,
  0x07, 0xF8, 0x1F, 0x00, 0xF0, 0x3F, 0xC0, 0xF0, 0x0F, 0x81, 0xFC, 0x0F,
  0x80, 0x7C, 0x0F, 0xE0, 0x7C, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3C,
  0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0x00, 0x1F, 0x01,
  0xFE, 0x00, 0x78, 0x07, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x7F,
  0x80, 0x3E, 0x03, 0xFE, 0x00, 0xF8, 0x0F, 0x7C, 0x03, 0xC0, 0x3D, 0xF0,
  0x1F, 0x00, 0xF3, 0xC0, 0x7C, 0x07, 0xCF, 0x01, 0xF0, 0x1F, 0x3E, 0x07,
  0x80, 0x7C, 0xF8, 0x1E, 0x01, 0xE1, 0xE0, 0xF8, 0x07, 0x87, 0x83, 0xE0,
  0x3E, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x3C, 0x03, 0xE1, 0xF1, 0xF0, 0x0F,
  0x03, 0xC7, 0xC0, 0x3C, 0x0F, 0x1F, 0x01, 0xF0, 0x3E, 0x7C, 0x07, 0xC0,
  0xF9, 0xE0, 0x1F, 0x01, 0xE7, 0x80, 0x78, 0x07, 0xBE, 0x03, 0xE0, 0x1F,
  0xF8, 0x0F, 0x80, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFC,
  0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0xFE, 0x01,
  0xF0, 0x01, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFC, 0x7F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xCF, 0xC0,
  0x01, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x7E,
  0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E,
  0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x01, 0xFC, 0x7F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xCF,
  0xC0, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x1F, 0xC0, 0xF8, 0x1F, 0x81,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0,
  0x7C, 0x0F, 0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFE, 0x7C, 0x03, 0xF0, 0x0C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x40, 0x07, 0xE0, 0x78, 0x1F, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0x78, 0x00, 0x7C, 0x78, 0x00, 0xFC,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xFB, 0xC0, 0x07, 0xC0, 0x0F, 0x9E, 0x00, 0x7E, 0x00, 0x7C, 0xF0,
  0x03, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x80, 0x3E, 0x3C, 0x01, 0xFC, 0x03,
  0xE1, 0xE0, 0x0F, 0xE0, 0x1F, 0x0F, 0x00, 0xFF, 0x00, 0xF8, 0x78, 0x07,
  0xF8, 0x0F, 0x83, 0xC0, 0x3F, 0xC0, 0x7C, 0x1E, 0x03, 0xDE, 0x07, 0xC1,
  0xF0, 0x1E, 0xF0, 0x3E, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0x7C, 0x0F, 0x3C,
  0x1F, 0x03, 0xE0, 0xF9, 0xE0, 0xF8, 0x1F, 0x07, 0x8F, 0x0F, 0x80, 0xF8,
  0x3C, 0x78, 0x7C, 0x07, 0xC3, 0xC3, 0xC3, 0xC0, 0x3E, 0x1E, 0x1E, 0x3E,
  0x01, 0xF1, 0xF0, 0xF1, 0xF0, 0x0F, 0x8F, 0x0F, 0x9F, 0x00, 0x7C, 0x78,
  0x78, 0xF8, 0x03, 0xE7, 0x83, 0xC7, 0x80, 0x1F, 0x3C, 0x1E, 0x7C, 0x00,
  0xFB, 0xE0, 0xF3, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x3E, 0xF0, 0x3D,
  0xF0, 0x01, 0xFF, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFD, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF9, 0xF0, 0x01, 0xEF, 0x80,
  0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x01,
  0xE7, 0x80, 0x1F, 0x3E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3E,
  0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x00, 0xF1, 0xE0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x7C, 0x7C, 0x3E, 0x1E,
  0x1F, 0x0F, 0x07, 0x00, 0xFE, 0x3E, 0x03, 0xFE, 0x78, 0x0F, 0xFE, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F,
  0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xF7, 0x80, 0x7F, 0xCF, 0x00, 0x7F, 0x1E, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF9, 0xFC, 0x03, 0xCF, 0xF8,
  0x1F, 0x7F, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x07, 0xE0, 0x7C, 0x1F,
  0x81, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xFC, 0x1F, 0x07, 0xFF, 0xFC,
  0x1E, 0xFF, 0xE0, 0x79, 0xFF, 0x03, 0xC3, 0xF8, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xC1, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0xC7, 0x80, 0x1F, 0xF3, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x80,
  0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x3F,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0xF0, 0x03, 0xFE, 0x78, 0x00, 0xFE,
  0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0x7E, 0x07, 0xC1, 0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC7, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x03, 0x03, 0xFB, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x04,
  0x7E, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0xFF, 0x9E, 0x01, 0xFF,
  0xDE, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x0F, 0xE0, 0x3E, 0x1F,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFB, 0xC0, 0x1F, 0xF7, 0xC0, 0x0F, 0xE7,
  0xC0, 0x01, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x80, 0x3F, 0x00, 0xE0, 0x7E,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF9, 0xFC, 0x03, 0xCF,
  0xF8, 0x1F, 0x7F, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0x7C,
  0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E,
  0x03, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x09, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x1F,
  0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0xC0, 0x03,
  0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00,
  0x03, 0xC7, 0xF0, 0x7F, 0x00, 0xF3, 0xFC, 0x7F, 0xE0, 0x7D, 0xFF, 0xBF,
  0xF8, 0x1E, 0xFF, 0xEF, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0x1E, 0x0F, 0x80,
  0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x3C,
  0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0x1F,
  0x0F, 0x80, 0x78, 0x07, 0x83, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80,
  0xF8, 0x3C, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0x0F, 0x87, 0xC0, 0x7C,
  0x03, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1E, 0x01,
  0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x03, 0xC7, 0xF0, 0x0F, 0x3F,
  0xE0, 0x7D, 0xFF, 0x81, 0xEF, 0xFF, 0x07, 0xF0, 0xFC, 0x1F, 0x81, 0xF0,
  0x7E, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xE0, 0xF8,
  0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0,
  0x3E, 0x3E, 0x01, 0xE3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0xFC,
  0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xFC, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0xF1, 0xFC, 0x00,
  0xF3, 0xFE, 0x00, 0xF7, 0xFE, 0x01, 0xEF, 0xFF, 0x01, 0xFC, 0x1F, 0x01,
  0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x1F,
  0x80, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F, 0xFF, 0xF0, 0x1E, 0xFF, 0xE0, 0x1E,
  0x7F, 0xC0, 0x3E, 0x3F, 0x80, 0x3E, 0x08, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x3E, 0x03, 0xFE, 0x78, 0x0F,
  0xFE, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87,
  0xC0, 0x3E, 0x07, 0x80, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xF7, 0x80, 0x7F, 0xDF, 0x00, 0x7F, 0x3E, 0x00, 0x10,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC7,
  0xC0, 0xF3, 0xF0, 0x7D, 0xFC, 0x1E, 0xFE, 0x07, 0xBF, 0x81, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0x81, 0x87, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x20, 0x0F,
  0x8C, 0x07, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x01, 0xFF, 0xDF, 0xFE, 0x7F, 0xFB, 0xFF, 0xE1, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0x20, 0x00, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0xC3,
  0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xEF, 0x03, 0xFE, 0x78, 0x0F, 0xE3,
  0xC0, 0x08, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xF1,
  0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x81, 0xFC, 0x0F, 0xBE, 0x07, 0xF0, 0x3E,
  0xF8, 0x1F, 0xC0, 0xF3, 0xE0, 0xFF, 0x07, 0xCF, 0x83, 0xFC, 0x1F, 0x3E,
  0x1E, 0xF0, 0xF8, 0xF8, 0x7B, 0xC3, 0xE3, 0xE1, 0xCF, 0x0F, 0x0F, 0x8F,
  0x3C, 0x7C, 0x3E, 0x3C, 0xF1, 0xE0, 0xF1, 0xE3, 0xCF, 0x83, 0xC7, 0x8F,
  0x3E, 0x0F, 0x1C, 0x3C, 0xF0, 0x3C, 0xF0, 0xE7, 0xC0, 0xF3, 0xC3, 0x9E,
  0x03, 0xDE, 0x0E, 0xF8, 0x0F, 0x78, 0x3B, 0xC0, 0x3D, 0xC0, 0xEF, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0x81, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF1, 0xF0,
  0x00, 0xF3, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xCF, 0x00,
  0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x07, 0x80,
  0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1F,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x7C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x08, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80,
  0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFA, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 37, 12, 0, -36 },
  { 62, 15, 13, 19, 5, -36 },
  { 87, 26, 36, 25, 0, -36 },
  { 204, 23, 41, 22, 0, -38 },
  { 322, 30, 37, 35, 3, -36 },
  { 461, 25, 37, 26, 0, -36 },
  { 577, 7, 13, 11, 5, -36 },
  { 589, 16, 44, 14, 1, -36 },
  { 677, 16, 44, 14, -4, -36 },
  { 765, 18, 19, 21, 5, -38 },
  { 808, 21, 24, 24, 2, -30 },
  { 871, 9, 13, 11, -2, -6 },
  { 886, 12, 5, 14, 1, -16 },
  { 894, 6, 7, 11, 1, -6 },
  { 900, 24, 36, 18, -2, -36 },
  { 1008, 21, 37, 22, 1, -36 },
  { 1106, 15, 36, 22, 5, -36 },
  { 1174, 23, 36, 22, -1, -36 },
  { 1278, 22, 37, 22, 0, -36 },
  { 1380, 23, 36, 22, -1, -36 },
  { 1484, 23, 37, 22, 0, -36 },
  { 1591, 21, 37, 22, 2, -36 },
  { 1689, 22, 36, 22, 2, -36 },
  { 1788, 23, 37, 22, 0, -36 },
  { 1895, 21, 37, 22, 1, -36 },
  { 1993, 11, 28, 12, 0, -27 },
  { 2032, 14, 34, 12, -3, -27 },
  { 2092, 21, 24, 24, 2, -30 },
  { 2155, 21, 15, 24, 2, -25 },
  { 2195, 21, 24, 24, 2, -30 },
  { 2258, 17, 37, 17, 2, -36 },
  { 2337, 31, 40, 34, 2, -36 },
  { 2492, 24, 36, 24, -3, -36 },
  { 2600, 25, 36, 25, 0, -36 },
  { 2713, 24, 37, 23, 2, -36 },
  { 2824, 26, 36, 27, 0, -36 },
  { 2941, 23, 36, 21, 0, -36 },
  { 3045, 23, 36, 20, 0, -36 },
  { 3149, 26, 37, 28, 2, -36 },
  { 3270, 28, 36, 28, 1, -36 },
  { 3396, 20, 36, 15, -2, -36 },
  { 3486, 21, 46, 12, -8, -36 },
  { 3607, 27, 36, 23, 1, -36 },
  { 3729, 16, 36, 20, 0, -36 },
  { 3801, 37, 36, 36, 0, -36 },
  { 3968, 30, 36, 29, 0, -36 },
  { 4103, 26, 37, 29, 2, -36 },
  { 4224, 24, 36, 23, 0, -36 },
  { 4332, 26, 45, 29, 2, -36 },
  { 4479, 23, 36, 24, 1, -36 },
  { 4583, 24, 37, 21, -1, -36 },
  { 4694, 20, 36, 20, 4, -36 },
  { 4784, 26, 37, 27, 2, -36 },
  { 4905, 24, 36, 23, 4, -36 },
  { 5013, 37, 36, 36, 4, -36 },
  { 5180, 29, 36, 22, -3, -36 },
  { 5311, 22, 36, 21, 4, -36 },
  { 5410, 25, 36, 20, -2, -36 },
  { 5523, 19, 44, 14, -1, -36 },
  { 5628, 9, 36, 18, 5, -36 },
  { 5669, 19, 44, 14, -3, -36 },
  { 5774, 21, 21, 23, 1, -36 },
  { 5830, 18, 4, 17, -5, 4 },
  { 5839, 8, 8, 14, 7, -38 },
  { 5847, 23, 28, 24, 1, -27 },
  { 5928, 22, 39, 24, 0, -38 },
  { 6036, 18, 28, 19, 2, -27 },
  { 6099, 25, 39, 24, 1, -38 },
  { 6221, 20, 28, 22, 1, -27 },
  { 6291, 25, 50, 14, -6, -38 },
  { 6448, 24, 39, 24, 0, -27 },
  { 6565, 22, 38, 24, 0, -38 },
  { 6670, 13, 37, 11, 0, -37 },
  { 6731, 19, 49, 11, -6, -37 },
  { 6848, 23, 38, 21, 0, -38 },
  { 6958, 13, 38, 11, 0, -38 },
  { 7020, 34, 27, 35, 0, -27 },
  { 7135, 22, 27, 24, 0, -27 },
  { 7210, 20, 28, 23, 2, -27 },
  { 7280, 24, 39, 24, -2, -27 },
  { 7397, 23, 39, 24, 1, -27 },
  { 7510, 18, 27, 16, 0, -27 },
  { 7571, 18, 28, 18, 0, -27 },
  { 7634, 14, 34, 14, 2, -33 },
  { 7694, 21, 28, 24, 2, -27 },
  { 7768, 19, 27, 20, 3, -27 },
  { 7833, 30, 27, 31, 3, -27 },
  { 7935, 24, 27, 20, -2, -27 },
  { 8016, 26, 39, 20, -4, -27 },
  { 8143, 20, 27, 17, -2, -27 },
  { 8211, 19, 44, 17, 1, -36 },
  { 8316, 4, 50, 21, 9, -38 },
  { 8341, 19, 44, 17, -3, -36 },
  { 8446, 21, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC50PT7B_H_
