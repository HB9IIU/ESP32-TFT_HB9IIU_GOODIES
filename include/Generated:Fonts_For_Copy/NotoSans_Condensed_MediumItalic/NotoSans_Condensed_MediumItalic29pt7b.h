#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xE0, 0x73, 0xB9,
  0x98, 0xCC, 0xEE, 0x77, 0x33, 0x19, 0x8C, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x30, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x0F, 0xFF, 0x9F, 0xFF, 0x06, 0x30,
  0x1C, 0xE0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x1F, 0xFF, 0x3F, 0xFE, 0x0C,
  0x60, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x98, 0x06, 0x30, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x78, 0x0F, 0xF0, 0xFF, 0x8E, 0xC8, 0x66, 0x03, 0x20,
  0x1D, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x01, 0x70, 0x0B, 0x80,
  0xCC, 0x06, 0xE6, 0x27, 0x3F, 0xF1, 0xFF, 0x01, 0xE0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x1C, 0x07, 0x1F, 0x03, 0x1D, 0xC3, 0x0C, 0xE3, 0x8E, 0x71,
  0x86, 0x39, 0x83, 0x18, 0xC1, 0x8C, 0xC0, 0xC6, 0xE6, 0x66, 0x67, 0xB3,
  0x76, 0xFF, 0x37, 0x37, 0x33, 0x18, 0x39, 0x8C, 0x19, 0xC6, 0x1C, 0xC7,
  0x0C, 0x63, 0x0C, 0x31, 0x8E, 0x19, 0x86, 0x0F, 0xC7, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x9C,
  0x07, 0x70, 0x0F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x73, 0xB9, 0xCE,
  0x3B, 0x98, 0x7E, 0x70, 0x7C, 0xE0, 0xF1, 0xC1, 0xE3, 0xCF, 0xC3, 0xFF,
  0xC3, 0xE3, 0x80, 0x77, 0x66, 0xEE, 0xCC, 0x03, 0x83, 0x81, 0x81, 0xC1,
  0xC0, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38,
  0x00, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x00, 0x0E, 0x03, 0x88, 0xE3, 0xB0,
  0xFF, 0xC7, 0xF1, 0xE0, 0xD8, 0xF7, 0x18, 0xC2, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0xDC, 0xE6, 0x73, 0x00, 0x7F,
  0x7E, 0xFE, 0x27, 0xFE, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xE1, 0xC7, 0x38,
  0x73, 0x87, 0x70, 0x77, 0x07, 0x70, 0x76, 0x07, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x38, 0xE7, 0x07, 0xF0, 0x7E,
  0x00, 0x03, 0x83, 0x87, 0xC7, 0xE7, 0x77, 0x31, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07,
  0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFE, 0x1F, 0xF8,
  0xFF, 0xE0, 0x07, 0xE0, 0xFF, 0x83, 0xFE, 0x10, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x30, 0xF1, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0D,
  0xC0, 0xCC, 0x0E, 0xE0, 0xE7, 0x06, 0x38, 0x61, 0xC7, 0x0C, 0x30, 0xE3,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x1F, 0x81, 0xFE, 0x07, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x30, 0xF1, 0xFF, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x81, 0xE4, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x77, 0x83, 0xFE, 0x1E, 0x79, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C,
  0x1C, 0xE1, 0xC7, 0x0E, 0x3C, 0xE0, 0xFF, 0x03, 0xE0, 0x00, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0x83, 0xDE, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8E, 0x0E, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0x83, 0x8E, 0x38, 0x71, 0x81, 0x9C, 0x0C, 0xE0,
  0x67, 0x07, 0x1C, 0x78, 0xFF, 0x83, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0x83,
  0xFC, 0x38, 0x61, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3,
  0x8E, 0x3C, 0x7F, 0xE1, 0xF7, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x21, 0xE1, 0xFE, 0x0F, 0xC0, 0x00, 0x0C, 0x71, 0xC7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x23, 0xCF, 0x38, 0x06, 0x1C, 0x38, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x38, 0x71, 0xC3, 0x06,
  0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x70, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x0F, 0x00, 0xC0, 0x00, 0x1F, 0x1F, 0xE3, 0xBC, 0x87, 0x01, 0xC0,
  0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xC0, 0x78, 0x38, 0x38, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x33, 0x0F, 0xCC,
  0xC7, 0xF3, 0x63, 0x98, 0xD8, 0xC6, 0x36, 0x61, 0x8F, 0x18, 0xE3, 0xC6,
  0x31, 0xF1, 0x8C, 0x6C, 0x67, 0x1B, 0x19, 0xCC, 0xC7, 0xDE, 0x30, 0xC7,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x3C, 0x01, 0xFF, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xD8, 0x07, 0x60, 0x19,
  0x80, 0xE6, 0x03, 0x98, 0x1C, 0x60, 0x71, 0x81, 0x87, 0x0F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0xF0,
  0x1C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x71,
  0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x7F, 0xC1, 0xFE, 0x0E, 0x3C, 0x38, 0x70,
  0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x3E, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xF0, 0xFF, 0x83, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x8C, 0x0F,
  0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x70, 0xE0, 0xE1,
  0xE1, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x39,
  0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x38, 0x1C, 0x70, 0x78, 0xE1,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0x07,
  0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xF8,
  0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x78,
  0x11, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC3, 0xF7, 0x87, 0xEE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0x70,
  0x38, 0xE0, 0x61, 0xF1, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0x03, 0x87,
  0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x60, 0x38, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0x03, 0x83, 0x81,
  0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0xE0, 0x30, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x0E, 0x07, 0x0E, 0x07, 0x00, 0x0F, 0xF0, 0xFE, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0xFC, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0x07, 0x0E, 0x0E, 0x0E,
  0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0C, 0x70, 0x1C, 0xE0, 0x1D, 0xE0, 0x1D,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3D, 0xC0, 0x39, 0xC0, 0x39,
  0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x60, 0xE0, 0xE0,
  0x70, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0xFD, 0xFE, 0xFF, 0x80, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xD8, 0x7E, 0x0F, 0xC3, 0xB0,
  0x6E, 0x1D, 0x87, 0x70, 0xCC, 0x33, 0x06, 0x63, 0xB8, 0x73, 0x19, 0xC3,
  0x99, 0xCE, 0x1C, 0xCC, 0x70, 0xC6, 0x63, 0x0E, 0x37, 0x38, 0x71, 0xB1,
  0xC3, 0x8F, 0x8E, 0x18, 0x78, 0x70, 0xC3, 0xC3, 0x0E, 0x1C, 0x38, 0x00,
  0x07, 0x01, 0xC3, 0xC0, 0x60, 0xF0, 0x38, 0x3E, 0x0E, 0x0F, 0x83, 0x83,
  0xE0, 0xC1, 0xD8, 0x30, 0x77, 0x1C, 0x1D, 0xC7, 0x06, 0x71, 0xC1, 0x8C,
  0x60, 0xE3, 0x38, 0x38, 0xEE, 0x0E, 0x3B, 0x83, 0x06, 0xE1, 0xC1, 0xB0,
  0x70, 0x7C, 0x1C, 0x1F, 0x06, 0x07, 0xC1, 0x80, 0xE0, 0xE0, 0x38, 0x00,
  0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x01, 0xCE,
  0x03, 0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x7E, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1C, 0xF0, 0x38, 0xE0, 0xE1, 0xE7, 0x81,
  0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0x83, 0x8F, 0x0E,
  0x1C, 0x30, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0x8F, 0x0F,
  0xF8, 0x3F, 0xC0, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0,
  0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3B, 0x80, 0x7E, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1C, 0xF0,
  0x38, 0xE0, 0xE1, 0xE7, 0x81, 0xFF, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0x83,
  0x8F, 0x0E, 0x1C, 0x30, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x71, 0xE1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x30, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x18, 0x38, 0xE0, 0x70, 0x03, 0xF0, 0x7F, 0xC3, 0xFE,
  0x38, 0x21, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE4, 0x0E,
  0x39, 0xF1, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x00, 0x1C, 0x06, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x31, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC1,
  0xEF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0xC0, 0x3E, 0x03, 0xB0, 0x1D, 0x81,
  0xEC, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x39, 0xC1,
  0xCE, 0x0E, 0x60, 0x77, 0x03, 0xB0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0xC0, 0x60, 0x7C, 0x0E, 0x07, 0xC0, 0xE0,
  0x7C, 0x1E, 0x0E, 0xC1, 0xE0, 0xEC, 0x1E, 0x0C, 0xC3, 0xE1, 0xCC, 0x36,
  0x1C, 0xC7, 0x63, 0x8C, 0x66, 0x38, 0xC6, 0x63, 0x0C, 0xE6, 0x70, 0xCC,
  0x67, 0x0D, 0xC6, 0xE0, 0xD8, 0x6E, 0x0D, 0x86, 0xC0, 0xF8, 0x7C, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x00, 0x07, 0x03,
  0x83, 0x83, 0x80, 0xC3, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0xE0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x39, 0x80, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x0E, 0x1C, 0x0E, 0x06, 0x0F, 0x03, 0x80, 0xC0, 0x7E, 0x0E, 0xE1, 0xEE,
  0x1C, 0xE3, 0x8E, 0x38, 0x67, 0x06, 0x70, 0x6E, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xFE,
  0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xE0, 0xFC, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xF0, 0x7C, 0x1F, 0x80, 0xE7, 0x39, 0xC6, 0x31, 0x8C, 0x73, 0x9C, 0xE3,
  0x18, 0xC7, 0x39, 0xCE, 0x31, 0x80, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x0F,
  0x80, 0x6C, 0x07, 0x70, 0x31, 0x83, 0x8C, 0x18, 0x71, 0xC1, 0x9C, 0x0D,
  0xC0, 0x70, 0x7F, 0xFF, 0xF8, 0xF3, 0x8C, 0x70, 0x07, 0x38, 0xFD, 0x8F,
  0xFC, 0x71, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x9C, 0x1C, 0xE0, 0xE7, 0x07,
  0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0xFF, 0x0F, 0xB0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x73, 0x83, 0xBE, 0x1F,
  0x78, 0xF1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xC0, 0xE6, 0x0E,
  0x70, 0x73, 0x83, 0x9C, 0x38, 0xF3, 0xCF, 0xFC, 0x77, 0xC0, 0x07, 0xC7,
  0xF1, 0xFC, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x47, 0xF0, 0xFC, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x73, 0x87, 0xEC, 0x3F, 0xF0, 0xE3, 0xC7,
  0x07, 0x1C, 0x1C, 0x70, 0x63, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3,
  0x87, 0x0E, 0x1C, 0x38, 0xF0, 0xFF, 0xC1, 0xF6, 0x00, 0x07, 0x81, 0xF8,
  0x77, 0x9C, 0x77, 0x0E, 0xE1, 0xD8, 0xF7, 0xFC, 0xFE, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xE1, 0x1F, 0xE1, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x0E,
  0x40, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0x9C,
  0x3F, 0x61, 0xFF, 0x87, 0x1E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x1C, 0x1C,
  0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x71, 0xE1, 0xCF, 0x87, 0xFE,
  0x0F, 0xB0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x20, 0xE0, 0xEF, 0x83, 0xFC,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x73, 0x83, 0xFE, 0x1F, 0xF8, 0xF1, 0xC7, 0x0E, 0x70, 0x73, 0x83,
  0x1C, 0x38, 0xE1, 0xC6, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x38, 0xC1, 0xCE,
  0x0E, 0x70, 0x60, 0x02, 0x1C, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x1C, 0x38,
  0x61, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x00, 0x00,
  0x20, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x82, 0xF0,
  0x7C, 0x0F, 0x00, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xE7, 0x06, 0x70, 0x77, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x07, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0x70, 0xC3, 0x8E,
  0x1C, 0x70, 0xF0, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0xE0,
  0xE0, 0x1C, 0xE1, 0xC3, 0xFE, 0xFC, 0x6F, 0xFF, 0x8E, 0x1C, 0x31, 0xC3,
  0x86, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE6, 0x0C,
  0x19, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x1C, 0xC1, 0xC3, 0xB8, 0x30,
  0x67, 0x0E, 0x1C, 0x1C, 0xE0, 0xFF, 0x86, 0xFE, 0x3C, 0x71, 0xC3, 0x9C,
  0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0x83, 0x9C, 0x18, 0xE1, 0xC7, 0x0E,
  0x38, 0x73, 0x83, 0x9C, 0x38, 0x07, 0x81, 0xFC, 0x3F, 0xE3, 0x8E, 0x70,
  0x77, 0x07, 0x60, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1,
  0xCE, 0x38, 0x7F, 0x83, 0xE0, 0x0E, 0x70, 0x3B, 0xE0, 0xDB, 0xC3, 0xC7,
  0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x1C, 0x60, 0xE3, 0x83,
  0x8E, 0x0E, 0x38, 0x70, 0xF3, 0xC3, 0x7E, 0x1D, 0xF0, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x38,
  0xFD, 0x87, 0xFC, 0x71, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0xFF, 0x0F, 0xB0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0xE3, 0xF8, 0x6F, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x0F, 0x83,
  0xFC, 0xF7, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x39, 0x0E, 0x3F, 0xC7, 0xF0, 0x0C, 0x0C, 0x1C, 0x3F,
  0x7F, 0xFF, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF8, 0x78, 0x38, 0x33, 0x87, 0x38, 0x73, 0x07, 0x30, 0x77, 0x06,
  0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0xCE, 0x7C,
  0xFF, 0x87, 0xD8, 0xC0, 0xF8, 0x3B, 0x07, 0x60, 0xCC, 0x39, 0x86, 0x31,
  0xC7, 0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xC1, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xD8, 0x78, 0xEC, 0x6C, 0x76,
  0x36, 0x73, 0x3B, 0x39, 0x99, 0x98, 0xCC, 0xDC, 0x6E, 0x6C, 0x36, 0x3E,
  0x1F, 0x1F, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0x1C,
  0x1C, 0x70, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0x60, 0x39, 0xC1, 0xC7, 0x07,
  0x1C, 0x38, 0x38, 0x06, 0x07, 0x07, 0x06, 0x07, 0x0E, 0x07, 0x0E, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x30, 0x1E, 0x03, 0xE0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x06, 0x00, 0xF0, 0x1F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC1, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x07, 0xE0, 0xF8, 0x10, 0x00,
  0x7C, 0x1F, 0xFF, 0xC7, 0xF8, 0x1C,
};

const GFXglyph NotoSans_Condensed_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 8, 11, 3, -21 },
  { 31, 15, 21, 15, 0, -21 },
  { 71, 13, 24, 13, 0, -22 },
  { 110, 17, 21, 20, 2, -21 },
  { 155, 15, 21, 15, 0, -21 },
  { 195, 4, 8, 6, 3, -21 },
  { 199, 9, 26, 8, 1, -21 },
  { 229, 9, 26, 8, -2, -21 },
  { 259, 10, 11, 12, 3, -22 },
  { 273, 12, 14, 14, 1, -17 },
  { 294, 5, 7, 7, -1, -3 },
  { 299, 8, 3, 8, 0, -9 },
  { 302, 4, 4, 7, 0, -4 },
  { 304, 14, 21, 10, -1, -21 },
  { 341, 12, 21, 13, 1, -21 },
  { 373, 9, 21, 13, 3, -21 },
  { 397, 14, 21, 13, -1, -21 },
  { 434, 13, 21, 13, 0, -21 },
  { 469, 13, 21, 13, 0, -21 },
  { 504, 13, 21, 13, 0, -21 },
  { 539, 13, 21, 13, 1, -21 },
  { 574, 13, 21, 13, 1, -21 },
  { 609, 13, 21, 13, 0, -21 },
  { 644, 13, 21, 13, 0, -21 },
  { 679, 6, 16, 7, 0, -16 },
  { 691, 7, 20, 7, -1, -16 },
  { 709, 12, 13, 14, 1, -17 },
  { 729, 12, 8, 14, 1, -14 },
  { 741, 12, 13, 14, 1, -17 },
  { 761, 10, 21, 10, 1, -21 },
  { 788, 18, 23, 20, 1, -21 },
  { 840, 14, 21, 14, -2, -21 },
  { 877, 14, 21, 14, 0, -21 },
  { 914, 14, 21, 13, 1, -21 },
  { 951, 15, 21, 16, 0, -21 },
  { 991, 13, 21, 12, 0, -21 },
  { 1026, 13, 21, 12, 0, -21 },
  { 1061, 15, 21, 16, 1, -21 },
  { 1101, 17, 21, 16, 0, -21 },
  { 1146, 12, 21, 9, -1, -21 },
  { 1178, 12, 27, 7, -4, -21 },
  { 1219, 16, 21, 14, 0, -21 },
  { 1261, 10, 21, 11, 0, -21 },
  { 1288, 21, 21, 21, 0, -21 },
  { 1344, 18, 21, 17, 0, -21 },
  { 1392, 15, 21, 17, 1, -21 },
  { 1432, 14, 21, 14, 0, -21 },
  { 1469, 15, 26, 17, 1, -21 },
  { 1518, 14, 21, 14, 0, -21 },
  { 1555, 13, 21, 12, 0, -21 },
  { 1590, 12, 21, 12, 2, -21 },
  { 1622, 15, 21, 16, 1, -21 },
  { 1662, 13, 21, 13, 3, -21 },
  { 1697, 20, 21, 21, 3, -21 },
  { 1750, 17, 21, 13, -2, -21 },
  { 1795, 12, 21, 12, 3, -21 },
  { 1827, 14, 21, 12, -1, -21 },
  { 1864, 11, 26, 8, -1, -21 },
  { 1900, 5, 21, 10, 3, -21 },
  { 1914, 11, 26, 8, -2, -21 },
  { 1950, 13, 12, 13, 0, -21 },
  { 1970, 11, 2, 10, -3, 2 },
  { 1973, 5, 4, 8, 4, -22 },
  { 1976, 13, 16, 14, 1, -16 },
  { 2002, 13, 22, 14, 0, -22 },
  { 2038, 10, 16, 11, 1, -16 },
  { 2058, 14, 22, 14, 1, -22 },
  { 2097, 11, 16, 12, 1, -16 },
  { 2119, 14, 29, 8, -3, -22 },
  { 2170, 14, 23, 14, 0, -16 },
  { 2211, 13, 22, 14, 0, -22 },
  { 2247, 7, 22, 6, 0, -22 },
  { 2267, 11, 29, 7, -4, -22 },
  { 2307, 13, 22, 12, 0, -22 },
  { 2343, 8, 22, 6, 0, -22 },
  { 2365, 19, 16, 20, 0, -16 },
  { 2403, 13, 16, 14, 0, -16 },
  { 2429, 12, 16, 13, 1, -16 },
  { 2453, 14, 23, 14, -1, -16 },
  { 2494, 13, 23, 14, 1, -16 },
  { 2532, 11, 16, 9, 0, -16 },
  { 2554, 11, 16, 11, 0, -16 },
  { 2576, 8, 19, 8, 1, -19 },
  { 2595, 12, 16, 14, 1, -16 },
  { 2619, 11, 16, 11, 2, -16 },
  { 2641, 17, 16, 18, 2, -16 },
  { 2675, 14, 16, 12, -1, -16 },
  { 2703, 16, 23, 11, -3, -16 },
  { 2749, 12, 16, 10, -1, -16 },
  { 2773, 12, 26, 10, 0, -21 },
  { 2812, 2, 29, 12, 5, -22 },
  { 2820, 11, 26, 10, -2, -21 },
  { 2856, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC29PT7B_H_
