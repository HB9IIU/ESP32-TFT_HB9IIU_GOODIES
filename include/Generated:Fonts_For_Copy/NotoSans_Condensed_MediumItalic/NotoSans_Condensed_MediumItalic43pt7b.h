#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x78, 0x00,
  0x3C, 0x7C, 0xF1, 0xE3, 0xC7, 0x9E, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0xF0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1,
  0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x3C,
  0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x0F, 0x0E,
  0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xBE, 0x07, 0x98, 0x40, 0xF1, 0x80, 0x0F,
  0x18, 0x00, 0xF3, 0x80, 0x0F, 0x30, 0x00, 0xFB, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0C, 0xF8, 0x00, 0xC7, 0x80, 0x0C, 0x78, 0x00, 0xC7,
  0x88, 0x0C, 0xF0, 0x61, 0x9F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x07, 0x03, 0xF8, 0x03, 0x80, 0xFF,
  0x01, 0xE0, 0x71, 0xC0, 0x70, 0x3C, 0x70, 0x3C, 0x0E, 0x1C, 0x0E, 0x03,
  0x87, 0x07, 0x01, 0xE1, 0xC3, 0xC0, 0x70, 0x70, 0xE0, 0x1C, 0x1C, 0x78,
  0x07, 0x0F, 0x1C, 0x01, 0xC3, 0x8E, 0x00, 0xF0, 0xE7, 0x8F, 0x3C, 0x79,
  0xC7, 0xEF, 0x1C, 0xF3, 0xFD, 0xCF, 0x39, 0xEF, 0x7F, 0x9C, 0xF1, 0xDF,
  0xCF, 0x38, 0x73, 0xE3, 0x8E, 0x1C, 0x01, 0xE7, 0x87, 0x00, 0x71, 0xC1,
  0xC0, 0x38, 0x70, 0xF0, 0x1E, 0x1C, 0x3C, 0x07, 0x0F, 0x0E, 0x03, 0xC3,
  0xC3, 0x80, 0xE0, 0xE1, 0xE0, 0x78, 0x3C, 0x70, 0x1C, 0x0F, 0x3C, 0x0E,
  0x01, 0xFE, 0x07, 0x80, 0x7F, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E,
  0x00, 0x3C, 0xF8, 0x00, 0xF7, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x3C, 0x7D, 0xE1, 0xE3, 0xE7,
  0xC7, 0x8F, 0x0F, 0x3C, 0x78, 0x3E, 0xF1, 0xE0, 0x7F, 0x8F, 0x81, 0xFE,
  0x3C, 0x03, 0xF0, 0xF0, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xFC, 0x1F,
  0x1F, 0xF0, 0x7F, 0xFB, 0xE0, 0xFF, 0xCF, 0x81, 0xFE, 0x1F, 0x00, 0x3C,
  0xF3, 0xCF, 0x79, 0xE7, 0x9E, 0x71, 0xCF, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x61, 0xC0, 0x79, 0xC0, 0xFF, 0xCF,
  0x7F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xC0, 0x1E, 0xE0, 0x3C, 0xE0,
  0x7C, 0xF0, 0x38, 0x78, 0x10, 0x78, 0x00, 0x60, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C,
  0x78, 0x78, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xFF,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xC7, 0xC3, 0xE0,
  0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3E, 0x0F, 0x07, 0x87, 0x81,
  0xF3, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x1F,
  0x03, 0xF0, 0xFE, 0x1F, 0xE3, 0xFE, 0x7D, 0xEF, 0xBE, 0x73, 0xC4, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xC1, 0xF0, 0x10, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x30, 0x3E, 0x04, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE2, 0x00, 0xF8, 0x78, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xDE, 0x00,
  0x73, 0x80, 0x1E, 0xF0, 0x03, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x0F,
  0x1E, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x03, 0x83, 0xE0, 0xF0,
  0x78, 0x3C, 0x0F, 0x07, 0x01, 0xE1, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE2, 0x00, 0xF8, 0x78, 0x7F,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x08,
  0x03, 0xCF, 0xE0, 0x7B, 0xFC, 0x0F, 0xFF, 0xC3, 0xF8, 0xF8, 0x7E, 0x0F,
  0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1E,
  0x3E, 0x03, 0xC7, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0xF8,
  0x3E, 0x3E, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x3E, 0x7E, 0x07, 0xC1,
  0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0x7C, 0x7C, 0x03, 0xCF, 0x80, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFB, 0xE0, 0x3E, 0x1F, 0x03,
  0xC0, 0xF0, 0x78, 0x0F, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x78,
  0xF8, 0x07, 0x8F, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0xC3, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF,
  0x03, 0xE3, 0xC0, 0xF8, 0xF8, 0x7E, 0x3F, 0xFF, 0x87, 0xFD, 0xE0, 0xFE,
  0xF0, 0x1E, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x82, 0x0F, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x0F, 0x8F, 0xC7, 0xC1, 0xE0, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0xFB, 0xF1, 0x81, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x0F, 0x00, 0x80, 0xE0, 0xE0, 0x7F, 0x8F, 0x1C, 0x1F, 0xF8,
  0x71, 0xC1, 0xC7, 0x87, 0x3C, 0x38, 0x70, 0x73, 0x87, 0x87, 0x0E, 0x38,
  0x70, 0x70, 0xE7, 0x8F, 0x0F, 0x0E, 0x70, 0xE0, 0xE0, 0xE7, 0x0E, 0x0E,
  0x0E, 0x71, 0xE0, 0xE1, 0xC7, 0x1E, 0x1E, 0x1C, 0xF1, 0xC1, 0xC1, 0xCF,
  0x1C, 0x3C, 0x38, 0xE1, 0xE3, 0xC7, 0x8E, 0x0F, 0xEF, 0xF0, 0xF0, 0xFE,
  0xFE, 0x07, 0x07, 0x87, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x01, 0xF0,
  0x1C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1C,
  0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E,
  0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3C,
  0x78, 0x01, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3C, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xF0, 0x3E, 0x07, 0x80,
  0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x20, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x02, 0x07, 0xF3, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xC1, 0xF8, 0x0F, 0x03, 0xF0, 0x3C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0,
  0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF0, 0x18, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xFF, 0x3E, 0x03,
  0xFC, 0xF8, 0x1F, 0xF3, 0xE0, 0x7F, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0xF8,
  0x03, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0xE3, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0xF0,
  0x07, 0x80, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x1E,
  0x00, 0xF8, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x0F, 0x80, 0x3C, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F,
  0x01, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x01,
  0xF0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x3E, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x01, 0x1F, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xE0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0xF8, 0x03, 0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x87,
  0xC0, 0x07, 0x8F, 0x80, 0x07, 0x9F, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3E,
  0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xB8,
  0x03, 0xBC, 0x07, 0xB8, 0x07, 0xBC, 0x07, 0xB8, 0x07, 0x7C, 0x07, 0xB8,
  0x0F, 0x78, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x38, 0x1E, 0x78, 0x0F, 0x38,
  0x1E, 0x78, 0x0F, 0x3C, 0x3C, 0xF0, 0x1E, 0x3C, 0x3C, 0xF0, 0x1E, 0x3C,
  0x78, 0xF0, 0x1E, 0x3C, 0x78, 0xF0, 0x1E, 0x3C, 0xF0, 0xF0, 0x1E, 0x3C,
  0xF1, 0xE0, 0x3C, 0x3C, 0xE1, 0xE0, 0x3C, 0x3D, 0xE1, 0xE0, 0x3C, 0x3D,
  0xC1, 0xE0, 0x3C, 0x3F, 0xC3, 0xE0, 0x3C, 0x1F, 0x83, 0xC0, 0x78, 0x1F,
  0x83, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E,
  0x07, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00,
  0xF0, 0x3F, 0x00, 0x3C, 0x0F, 0xC0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE,
  0x01, 0xE0, 0x3F, 0x80, 0x78, 0x1E, 0xE0, 0x3C, 0x07, 0xBC, 0x0F, 0x01,
  0xEF, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x1C, 0xF0, 0x3C, 0x0F, 0x1C, 0x1E,
  0x03, 0xC7, 0x87, 0x80, 0xF1, 0xE1, 0xE0, 0x3C, 0x78, 0x78, 0x1E, 0x0E,
  0x1E, 0x07, 0x83, 0xCF, 0x01, 0xE0, 0xF3, 0xC0, 0x78, 0x3C, 0xF0, 0x1E,
  0x0F, 0x3C, 0x0F, 0x01, 0xEF, 0x03, 0xC0, 0x7F, 0x80, 0xF0, 0x1F, 0xE0,
  0x3C, 0x07, 0xF8, 0x0F, 0x00, 0xFE, 0x07, 0x80, 0x3F, 0x01, 0xE0, 0x0F,
  0xC0, 0x78, 0x03, 0xF0, 0x1E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0,
  0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0xF8, 0x1F, 0xDF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80,
  0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0xF8, 0x1F, 0x07,
  0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xE3, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0,
  0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0xF8, 0x1F, 0xDF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x3F, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x7C,
  0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1F, 0x07, 0x80, 0xF8,
  0x3C, 0x03, 0xC3, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0xC0,
  0x3E, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x83, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78,
  0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78,
  0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x87,
  0x80, 0x3E, 0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00,
  0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF0,
  0x1F, 0x9F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07,
  0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0,
  0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00, 0x77, 0xC0, 0x07, 0x78, 0x00,
  0x77, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F,
  0x00, 0x7B, 0xC0, 0x1E, 0x00, 0xF7, 0x80, 0x7C, 0x03, 0xEF, 0x00, 0xF8,
  0x07, 0x9E, 0x03, 0xF0, 0x1F, 0x3C, 0x07, 0xE0, 0x3C, 0x78, 0x1F, 0xC0,
  0x78, 0xF0, 0x3F, 0x81, 0xE1, 0xE0, 0x77, 0x03, 0xC3, 0xC1, 0xEE, 0x0F,
  0x87, 0x83, 0x9C, 0x1E, 0x0F, 0x0F, 0x38, 0x3C, 0x1E, 0x1E, 0x70, 0xF0,
  0x3C, 0x38, 0xE1, 0xE0, 0x78, 0xF1, 0xC7, 0xC0, 0xF1, 0xC3, 0x8F, 0x01,
  0xE7, 0x87, 0x1E, 0x03, 0xCF, 0x0E, 0x78, 0x07, 0x9C, 0x1C, 0xF0, 0x0F,
  0x78, 0x39, 0xE0, 0x1E, 0xE0, 0x77, 0x80, 0x3F, 0xC0, 0xEF, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xEE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0,
  0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF,
  0x00, 0x07, 0x8F, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0x0F, 0x80, 0x1E, 0x07,
  0x80, 0x3E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0,
  0x3C, 0xF8, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0x78,
  0x1E, 0x3E, 0x07, 0x8F, 0x00, 0xE7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x21, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xC0,
  0x0E, 0x78, 0x07, 0x9E, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x07, 0x0F, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x0E, 0x70, 0x03, 0xFC, 0x00,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0xF8, 0xF1, 0xF1, 0xE1, 0xC3, 0xC3, 0x80,
  0x00, 0x60, 0x00, 0x3F, 0x1C, 0x1F, 0xF7, 0x83, 0xFE, 0xF0, 0xF8, 0xFE,
  0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF1,
  0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x3E, 0x03, 0xC7,
  0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x07,
  0xCF, 0xE0, 0xFF, 0xFC, 0x0F, 0xF7, 0x81, 0xF8, 0xF0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x40, 0x1E, 0x7E, 0x03,
  0xDF, 0xE0, 0x7F, 0xFE, 0x1F, 0xC7, 0xC3, 0xF0, 0x78, 0x7C, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x07, 0xCF, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0,
  0x1E, 0x3E, 0x07, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x1D, 0xFF, 0x83, 0xBF,
  0xE0, 0xF3, 0xF8, 0x00, 0x00, 0x30, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0x82, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x08, 0x7C, 0x30, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x03, 0x0F, 0x00, 0x7E, 0x78, 0x0F, 0xFB, 0xC0,
  0x7F, 0xFE, 0x07, 0xC7, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x3E, 0x3F, 0x01, 0xFF,
  0xF8, 0x07, 0xFB, 0xC0, 0x3F, 0x1C, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x78, 0x0E,
  0x3C, 0x0F, 0x3E, 0x0F, 0x9E, 0x3F, 0x8F, 0xFF, 0x87, 0xFF, 0x07, 0xFC,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC1, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x27, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0xC7, 0x03, 0xFE, 0xF0, 0x3F, 0xFF, 0x07, 0xC7, 0xF0, 0xF8, 0x3E,
  0x0F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x3E, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0,
  0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC3, 0xF0, 0x3E,
  0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0xEF, 0x01, 0xF9, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x08, 0x07, 0xC0,
  0xE1, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x40, 0x1E, 0x7E,
  0x03, 0xDF, 0xE0, 0x77, 0xFE, 0x1F, 0xC7, 0xC3, 0xF0, 0x78, 0x7C, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x8F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0xF8, 0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x02, 0x7E, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x78,
  0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F,
  0x3C, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0xC0,
  0x3C, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x38, 0xFC, 0x3F, 0x81,
  0xDF, 0xF3, 0xFC, 0x0E, 0xFF, 0xBF, 0xF0, 0xFE, 0x3F, 0x8F, 0x87, 0xE1,
  0xF8, 0x3C, 0x3E, 0x0F, 0x81, 0xE1, 0xE0, 0x7C, 0x0F, 0x0F, 0x03, 0xC0,
  0xF8, 0xF8, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x0F, 0x81, 0xE1,
  0xE0, 0x78, 0x0F, 0x1F, 0x03, 0xC0, 0xF0, 0xF0, 0x1E, 0x07, 0x87, 0x80,
  0xF0, 0x3C, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x0F, 0x1F, 0x03, 0xC0,
  0xF0, 0xF0, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x0F, 0x01, 0xE1,
  0xE0, 0x78, 0x0F, 0x1E, 0x03, 0xC0, 0xF0, 0x00, 0x06, 0x00, 0xE3, 0xF0,
  0x1C, 0xFF, 0x03, 0xBF, 0xF0, 0xFE, 0x3E, 0x1F, 0x83, 0xC3, 0xE0, 0x78,
  0x78, 0x0F, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87,
  0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x07, 0xC7, 0xC0, 0xF0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0xFE, 0x0F, 0x8F, 0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07,
  0xDF, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF,
  0x80, 0x7B, 0xE0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x81, 0xE1, 0xE0,
  0xF8, 0x7C, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0x80, 0x0E, 0x3F, 0x00, 0x73, 0xFC, 0x03, 0xBF, 0xF0, 0x3F, 0x8F, 0x81,
  0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x03,
  0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0xF8,
  0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xFF, 0xC0, 0x7B, 0xFC, 0x07, 0x8F,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x1C, 0x1F, 0xF7, 0x83,
  0xFF, 0xF0, 0xF8, 0xFC, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3C,
  0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0xFC, 0x7C, 0x1F, 0x07, 0xCF, 0xE0, 0xFF, 0xBC, 0x1F, 0xF7, 0x81, 0xF9,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x06, 0x07, 0x1F, 0x07, 0x3E, 0x07, 0x7E, 0x0F, 0xFE, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x00, 0x60, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x06, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x80, 0xF8, 0xE1, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x13, 0xFE, 0xFF, 0xEF,
  0xFE, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF1, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xF1,
  0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x1F,
  0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x7F, 0x07, 0xFD, 0xE0, 0xFF, 0xB8, 0x0F,
  0xC7, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81,
  0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xEF, 0x07, 0xE0,
  0xF3, 0xC1, 0xF8, 0x3C, 0xF0, 0xFE, 0x0F, 0x3C, 0x3B, 0x87, 0x8E, 0x0F,
  0xE1, 0xE3, 0x87, 0x78, 0xF0, 0xE1, 0xDE, 0x3C, 0x38, 0xF7, 0x8E, 0x0E,
  0x39, 0xE7, 0x83, 0x9E, 0x79, 0xE0, 0xE7, 0x1E, 0xF0, 0x39, 0xC7, 0xBC,
  0x0E, 0xF1, 0xEE, 0x03, 0xB8, 0x7F, 0x80, 0xEE, 0x1D, 0xE0, 0x3F, 0x07,
  0x70, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x1E, 0x0F, 0x80,
  0xF0, 0x78, 0x07, 0x87, 0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBC,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBE, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1,
  0xF0, 0x3E, 0x07, 0x83, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x3B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x11, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01,
  0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0x80, 0xFF,
  0xA0, 0x07, 0x80,
};

const GFXglyph NotoSans_Condensed_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 31, 11, 0, -31 },
  { 48, 14, 11, 16, 4, -31 },
  { 68, 22, 31, 22, 0, -31 },
  { 154, 20, 36, 19, 0, -33 },
  { 244, 26, 31, 30, 2, -31 },
  { 345, 22, 31, 22, 0, -31 },
  { 431, 6, 11, 9, 4, -31 },
  { 440, 14, 38, 12, 1, -31 },
  { 507, 14, 38, 12, -3, -31 },
  { 574, 16, 17, 18, 4, -33 },
  { 608, 18, 20, 21, 2, -25 },
  { 653, 8, 11, 10, -2, -5 },
  { 664, 10, 4, 12, 1, -14 },
  { 669, 6, 5, 10, 0, -5 },
  { 673, 21, 31, 15, -2, -31 },
  { 755, 18, 31, 19, 1, -31 },
  { 825, 12, 31, 19, 5, -31 },
  { 872, 20, 31, 19, -1, -31 },
  { 950, 19, 31, 19, 0, -31 },
  { 1024, 19, 31, 19, 0, -31 },
  { 1098, 19, 31, 19, 0, -31 },
  { 1172, 19, 31, 19, 1, -31 },
  { 1246, 19, 31, 19, 2, -31 },
  { 1320, 20, 31, 19, 0, -31 },
  { 1398, 18, 31, 19, 1, -31 },
  { 1468, 9, 23, 10, 0, -23 },
  { 1494, 12, 29, 10, -2, -23 },
  { 1538, 18, 20, 21, 2, -25 },
  { 1583, 18, 12, 21, 2, -21 },
  { 1610, 18, 20, 21, 2, -25 },
  { 1655, 15, 31, 15, 1, -31 },
  { 1714, 28, 35, 29, 1, -31 },
  { 1837, 21, 31, 20, -3, -31 },
  { 1919, 21, 31, 21, 0, -31 },
  { 2001, 20, 31, 20, 2, -31 },
  { 2079, 22, 31, 23, 0, -31 },
  { 2165, 20, 31, 18, 0, -31 },
  { 2243, 20, 31, 17, 0, -31 },
  { 2321, 22, 31, 24, 2, -31 },
  { 2407, 25, 31, 24, 0, -31 },
  { 2504, 18, 31, 13, -2, -31 },
  { 2574, 18, 39, 10, -7, -31 },
  { 2662, 24, 31, 20, 0, -31 },
  { 2755, 14, 31, 17, 0, -31 },
  { 2810, 32, 31, 31, 0, -31 },
  { 2934, 26, 31, 25, 0, -31 },
  { 3035, 22, 31, 25, 2, -31 },
  { 3121, 21, 31, 20, 0, -31 },
  { 3203, 22, 38, 25, 2, -31 },
  { 3308, 21, 31, 21, 0, -31 },
  { 3390, 20, 31, 18, 0, -31 },
  { 3468, 18, 31, 17, 3, -31 },
  { 3538, 22, 31, 23, 2, -31 },
  { 3624, 20, 31, 20, 4, -31 },
  { 3702, 31, 31, 31, 4, -31 },
  { 3823, 24, 31, 19, -2, -31 },
  { 3916, 18, 31, 18, 4, -31 },
  { 3986, 21, 31, 17, -1, -31 },
  { 4068, 16, 38, 12, -1, -31 },
  { 4144, 8, 31, 15, 4, -31 },
  { 4175, 17, 38, 12, -3, -31 },
  { 4256, 18, 18, 20, 1, -31 },
  { 4297, 15, 2, 14, -4, 4 },
  { 4301, 7, 7, 12, 6, -33 },
  { 4308, 19, 24, 21, 1, -24 },
  { 4365, 19, 33, 20, 0, -33 },
  { 4444, 16, 24, 16, 1, -24 },
  { 4492, 21, 33, 21, 1, -33 },
  { 4579, 17, 24, 18, 1, -24 },
  { 4630, 22, 43, 12, -5, -33 },
  { 4749, 20, 34, 21, 0, -24 },
  { 4834, 19, 33, 20, 0, -33 },
  { 4913, 11, 32, 10, 0, -32 },
  { 4957, 17, 42, 10, -6, -32 },
  { 5047, 20, 33, 18, 0, -33 },
  { 5130, 11, 33, 10, 0, -33 },
  { 5176, 29, 24, 30, 0, -24 },
  { 5263, 19, 24, 20, 0, -24 },
  { 5320, 18, 24, 20, 1, -24 },
  { 5374, 21, 34, 20, -2, -24 },
  { 5464, 19, 34, 21, 1, -24 },
  { 5545, 16, 24, 14, 0, -24 },
  { 5593, 16, 24, 16, 0, -24 },
  { 5641, 12, 28, 12, 2, -28 },
  { 5683, 19, 23, 20, 1, -23 },
  { 5738, 17, 23, 17, 2, -23 },
  { 5787, 26, 23, 27, 3, -23 },
  { 5862, 21, 23, 17, -2, -23 },
  { 5923, 23, 33, 17, -4, -23 },
  { 6018, 17, 23, 15, -1, -23 },
  { 6067, 16, 38, 14, 1, -31 },
  { 6143, 4, 43, 18, 7, -33 },
  { 6165, 16, 38, 14, -2, -31 },
  { 6241, 18, 6, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC43PT7B_H_
