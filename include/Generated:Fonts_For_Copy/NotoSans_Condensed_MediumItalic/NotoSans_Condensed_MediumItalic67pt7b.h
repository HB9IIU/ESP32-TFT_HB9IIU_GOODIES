#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC67PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x87,
  0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xF0,
  0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0xE7,
  0xE0, 0x3F, 0x8F, 0x06, 0x01, 0xF8, 0x70, 0x10, 0x0F, 0xC3, 0x80, 0x00,
  0x7E, 0x1C, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x3F, 0x0F, 0x00, 0x01, 0xF8,
  0x70, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0x3F, 0x9C, 0x00, 0x01, 0xFE, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xEF,
  0xF0, 0x00, 0x0E, 0x3F, 0x80, 0x00, 0x71, 0xFC, 0x00, 0x03, 0x87, 0xE0,
  0x00, 0x1C, 0x3F, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x0E, 0x0F, 0xC0, 0x00,
  0x70, 0xFE, 0x10, 0x03, 0x87, 0xE0, 0xE0, 0x3C, 0x7F, 0x07, 0xC1, 0xE7,
  0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x07, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0x83, 0xF8, 0xF8, 0x1F,
  0x1F, 0x0F, 0xFC, 0xF8, 0x3F, 0x1F, 0x1F, 0xFE, 0xF8, 0x3E, 0x3E, 0x3F,
  0xFE, 0xF8, 0x7E, 0x7E, 0x3F, 0x3F, 0xFC, 0xFC, 0x7C, 0x7E, 0x3F, 0xFF,
  0xF8, 0xFC, 0x7C, 0x1F, 0x7F, 0xF0, 0xF8, 0xF8, 0x1F, 0x3F, 0xE1, 0xF0,
  0xF8, 0x1F, 0x1F, 0xC1, 0xF1, 0xF0, 0x1F, 0x02, 0x03, 0xE1, 0xF0, 0x1F,
  0x00, 0x07, 0xE1, 0xF0, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x3F, 0x00, 0x0F,
  0x83, 0xE0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x07, 0xC1, 0xF8,
  0x03, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x03, 0xE3, 0xF0, 0x07, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFC, 0x1F, 0xEF, 0xC0, 0x7E, 0x0F, 0xF3,
  0xF8, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE,
  0x07, 0xF1, 0xFC, 0x3F, 0x00, 0xFE, 0x7E, 0x1F, 0xC0, 0x3F, 0xBF, 0x87,
  0xF0, 0x07, 0xFF, 0xC1, 0xF8, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0xF8,
  0x3F, 0x80, 0x0F, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0xF8, 0x07, 0xF0, 0x0F,
  0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0x07, 0xF0, 0x07,
  0xFF, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xE3,
  0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0x00, 0xF8, 0x00, 0xE0, 0x7C, 0x00,
  0x78, 0x3E, 0x00, 0x7F, 0x1E, 0x00, 0x3F, 0xEF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFD,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x03, 0xF9,
  0xF0, 0x03, 0xF8, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3C,
  0x0F, 0xC0, 0x0C, 0x07, 0xF0, 0x04, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x08, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xF0,
  0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0x9F, 0x8F, 0xF1, 0xF8, 0x7E, 0x1F, 0x83, 0xC3, 0xF8,
  0x10, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x1C, 0x00,
  0xFF, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x1E, 0x00, 0xFF, 0x00,
  0x60, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x02, 0x00, 0x03, 0xFC, 0x0C, 0x00, 0x1F, 0xE0, 0x3E, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x03, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0,
  0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x18, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x80, 0x00, 0xFF, 0x03, 0x80, 0x07, 0xF8, 0x0F, 0x80, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x01,
  0xF9, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xEF,
  0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0x83, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF,
  0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC,
  0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xF1,
  0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xC0, 0x3F, 0xFC, 0xFC,
  0x01, 0xFF, 0x1F, 0xC0, 0x01, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x0C, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x10,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x01, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xC1, 0xFE, 0x07, 0x00, 0xFE, 0x04, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0xF8, 0x07, 0x81, 0xF8, 0x07, 0xFF, 0xE0, 0xF0, 0x3E, 0x01,
  0xFF, 0xF8, 0x1F, 0x0F, 0x80, 0x7F, 0xFF, 0x03, 0xE1, 0xF0, 0x1F, 0x83,
  0xE0, 0x7C, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0x1F, 0x01,
  0xE1, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x8F,
  0x81, 0xF0, 0x1F, 0x81, 0xF1, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x3C, 0x0F,
  0x80, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0x0F, 0x80, 0xF9, 0xF0, 0x3E, 0x03,
  0xF0, 0x1E, 0x3E, 0x0F, 0x80, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0x0F, 0x80,
  0xF8, 0xF0, 0x3E, 0x01, 0xF0, 0x1E, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xC7,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x1F, 0x03,
  0xE0, 0x7E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xC1, 0xF0, 0x7C, 0x0F, 0xC7,
  0xF8, 0x7C, 0x0F, 0x81, 0xFF, 0xEF, 0xFF, 0x81, 0xF0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x3E, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x00,
  0x7C, 0x00, 0x40, 0x04, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0xFE,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0xFC, 0x00, 0xFF, 0xC0, 0x1C, 0x00, 0xFF, 0x00, 0x08, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x04, 0x00, 0x3F, 0xF0, 0x7C, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xF0,
  0x03, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03,
  0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xC0,
  0x1F, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xC1,
  0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xFF, 0x0F, 0xE0, 0x07, 0xFF,
  0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x03, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0x80,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xE0, 0x00, 0xFD,
  0xFC, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF3,
  0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3,
  0xF0, 0x07, 0xF3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE3,
  0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF0, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0xFC, 0x1F,
  0xC0, 0x1F, 0x81, 0xF8, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xF9, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xF9, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFB, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xFB, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFF, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xF8, 0x01, 0xFB, 0xF0, 0x01,
  0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF8, 0x01,
  0xF9, 0xF8, 0x03, 0xF0, 0x01, 0xF9, 0xF8, 0x03, 0xF0, 0x03, 0xF1, 0xF8,
  0x03, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x03, 0xF1, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x1F, 0xBF,
  0x00, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE,
  0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0x81, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x80, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x38, 0x00, 0xFF, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x60, 0x00, 0x7F, 0x80, 0x78, 0x01, 0xFF, 0x00, 0x7F,
  0xDF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xE0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF3, 0xE0,
  0x1F, 0xC0, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF3, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE3, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC3, 0xE0,
  0x7F, 0x00, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x83, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x03, 0xE1,
  0xFC, 0x00, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3E, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x7C, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xF8, 0x07, 0xEF,
  0xE0, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x07, 0xEF,
  0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFB, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7D, 0xF8, 0x00,
  0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x07, 0xC1, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x07,
  0xFF, 0x8F, 0x80, 0x3F, 0xFE, 0x7E, 0x01, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF,
  0xF7, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0x7E, 0x01, 0xFF, 0xFD, 0xF8, 0x03, 0xFF,
  0xE7, 0xE0, 0x07, 0xFF, 0x1F, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x3F,
  0x0F, 0xF0, 0x00, 0xFC, 0xFF, 0xE0, 0x07, 0xF7, 0xFF, 0xC0, 0x1F, 0xBF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xFC, 0x07,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xBF,
  0xFF, 0x80, 0x7C, 0xFF, 0xFC, 0x01, 0xF1, 0xFF, 0xE0, 0x0F, 0xC3, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFC, 0x04, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x40, 0x7F, 0x81, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x07,
  0xF0, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x7F, 0xF9, 0xF8, 0x00, 0x7F, 0xFC,
  0xFC, 0x00, 0x7F, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x1F,
  0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0x7C, 0x00, 0x0F, 0xFE, 0x3E,
  0x00, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xF1, 0xFC,
  0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x01, 0x01, 0xFE, 0x01, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x40, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0xC7, 0xC0,
  0x03, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xFD, 0xF8,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x0F,
  0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0xF0, 0x00,
  0x7F, 0xF3, 0xF0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x01, 0xC1, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x1F, 0x8F, 0xFC,
  0x00, 0xFC, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0x80, 0x7E, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0x80, 0xFF, 0x81, 0xFC, 0x0F, 0xF8,
  0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0x80,
  0x01, 0xFF, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0xC3, 0xFE, 0x03, 0xFE, 0x00, 0x3E, 0x3F, 0xF8, 0x3F, 0xF8, 0x03,
  0xF3, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xC3, 0xFF, 0x00, 0x3E, 0x3F, 0xFC, 0x03, 0xF3,
  0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x0F,
  0xE0, 0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0,
  0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFC, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x83, 0xFC, 0x00, 0x07, 0xC7, 0xFF, 0x80,
  0x03, 0xE7, 0xFF, 0xC0, 0x03, 0xF7, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F,
  0xDF, 0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0xE0, 0x03, 0xF3, 0xFF, 0xE0, 0x01,
  0xF9, 0xFF, 0xE0, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x07, 0xFF,
  0x8F, 0x80, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF7,
  0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x80, 0x7F, 0xFF, 0x7E, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xEF,
  0xC0, 0x07, 0xFF, 0x3F, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x7C, 0x3F, 0x80, 0x3E, 0x3F, 0xC0, 0x3F, 0x3F, 0xE0, 0x1F, 0xBF,
  0xF0, 0x0F, 0xDF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xC0, 0x38, 0x1F, 0xC0, 0x08, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x82, 0x00, 0x3F, 0xC1, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x82,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x38, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xEF, 0x80, 0x7F,
  0xFE, 0x7C, 0x03, 0xFF, 0xF3, 0xE0, 0x0F, 0xFE, 0x1F, 0x00, 0x3F, 0xE1,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFF, 0x00, 0xFE, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0xFC, 0x03, 0xFF,
  0x01, 0xFC, 0xFC, 0x03, 0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xDF, 0x01, 0xF8,
  0xFC, 0x07, 0xDF, 0x03, 0xF0, 0xFC, 0x0F, 0xBF, 0x03, 0xF0, 0xFC, 0x0F,
  0xBF, 0x07, 0xF0, 0xFC, 0x1F, 0xBF, 0x07, 0xE0, 0xFC, 0x1F, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3E, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x3E, 0x1F, 0x80, 0xFC, 0x7C, 0x3E,
  0x1F, 0x80, 0xFC, 0x7C, 0x3E, 0x3F, 0x00, 0xFC, 0xFC, 0x3E, 0x3F, 0x00,
  0xFC, 0xF8, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x3E, 0x7E, 0x00, 0xFD, 0xF0,
  0x3E, 0x7E, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x3E, 0xFC,
  0x00, 0xFF, 0xE0, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x02, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xEC, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 17, 49, 17, 1, -48 },
  { 106, 20, 17, 25, 7, -48 },
  { 149, 34, 48, 34, 1, -48 },
  { 353, 29, 55, 30, 1, -51 },
  { 553, 40, 50, 46, 4, -49 },
  { 803, 34, 50, 35, 0, -49 },
  { 1016, 9, 17, 14, 7, -48 },
  { 1036, 21, 59, 18, 2, -48 },
  { 1191, 21, 59, 18, -5, -48 },
  { 1346, 25, 26, 29, 6, -51 },
  { 1428, 28, 32, 32, 3, -40 },
  { 1540, 13, 17, 15, -3, -8 },
  { 1568, 16, 6, 19, 1, -21 },
  { 1580, 8, 10, 15, 1, -9 },
  { 1590, 32, 48, 24, -3, -48 },
  { 1782, 28, 50, 30, 2, -49 },
  { 1957, 20, 48, 30, 7, -48 },
  { 2077, 32, 49, 30, -2, -49 },
  { 2273, 30, 50, 30, 0, -49 },
  { 2461, 31, 48, 30, -1, -48 },
  { 2647, 30, 49, 30, 0, -48 },
  { 2831, 29, 50, 30, 2, -49 },
  { 3013, 30, 48, 30, 3, -48 },
  { 3193, 29, 50, 30, 1, -49 },
  { 3375, 28, 50, 30, 1, -49 },
  { 3550, 15, 38, 15, 0, -37 },
  { 3622, 18, 46, 15, -3, -37 },
  { 3726, 28, 32, 32, 3, -40 },
  { 3838, 27, 19, 32, 3, -33 },
  { 3903, 28, 32, 32, 3, -40 },
  { 4015, 24, 50, 23, 2, -49 },
  { 4165, 43, 54, 45, 2, -48 },
  { 4456, 31, 48, 32, -4, -48 },
  { 4642, 32, 48, 33, 1, -48 },
  { 4834, 32, 50, 31, 3, -49 },
  { 5034, 34, 48, 36, 1, -48 },
  { 5238, 30, 48, 28, 1, -48 },
  { 5418, 30, 48, 27, 1, -48 },
  { 5598, 35, 50, 37, 3, -49 },
  { 5817, 37, 48, 37, 1, -48 },
  { 6039, 27, 48, 20, -3, -48 },
  { 6201, 28, 61, 16, -10, -48 },
  { 6415, 36, 48, 31, 1, -48 },
  { 6631, 21, 48, 26, 1, -48 },
  { 6757, 48, 48, 48, 1, -48 },
  { 7045, 40, 48, 39, 1, -48 },
  { 7285, 34, 50, 38, 3, -49 },
  { 7498, 32, 48, 31, 1, -48 },
  { 7690, 34, 60, 38, 3, -49 },
  { 7945, 31, 48, 32, 1, -48 },
  { 8131, 32, 50, 28, -1, -49 },
  { 8331, 27, 48, 27, 5, -48 },
  { 8493, 35, 49, 36, 3, -48 },
  { 8708, 31, 48, 31, 6, -48 },
  { 8894, 48, 48, 49, 6, -48 },
  { 9182, 38, 48, 29, -4, -48 },
  { 9410, 28, 48, 28, 6, -48 },
  { 9578, 33, 48, 27, -2, -48 },
  { 9776, 26, 59, 19, -2, -48 },
  { 9968, 12, 48, 24, 7, -48 },
  { 10040, 26, 59, 19, -5, -48 },
  { 10232, 29, 28, 31, 1, -48 },
  { 10334, 23, 4, 22, -6, 6 },
  { 10346, 10, 10, 18, 10, -51 },
  { 10359, 30, 38, 32, 2, -37 },
  { 10502, 30, 52, 32, 0, -51 },
  { 10697, 24, 38, 25, 2, -37 },
  { 10811, 33, 52, 32, 2, -51 },
  { 11026, 26, 38, 29, 2, -37 },
  { 11150, 34, 67, 18, -8, -51 },
  { 11435, 33, 53, 32, -1, -37 },
  { 11654, 29, 51, 32, 0, -51 },
  { 11839, 17, 50, 15, 0, -50 },
  { 11946, 26, 66, 15, -9, -50 },
  { 12161, 31, 51, 28, 0, -51 },
  { 12359, 18, 51, 15, 0, -51 },
  { 12474, 45, 37, 47, 0, -37 },
  { 12683, 29, 37, 32, 0, -37 },
  { 12818, 27, 38, 31, 2, -37 },
  { 12947, 33, 53, 32, -3, -37 },
  { 13166, 30, 53, 32, 2, -37 },
  { 13365, 25, 37, 22, 0, -37 },
  { 13481, 25, 38, 24, 0, -37 },
  { 13600, 19, 45, 19, 2, -44 },
  { 13707, 29, 37, 32, 2, -36 },
  { 13842, 26, 36, 26, 4, -36 },
  { 13959, 40, 36, 41, 4, -36 },
  { 14139, 33, 36, 27, -3, -36 },
  { 14288, 36, 52, 27, -6, -36 },
  { 14522, 27, 36, 23, -2, -36 },
  { 14644, 26, 59, 23, 1, -48 },
  { 14836, 5, 67, 28, 12, -51 },
  { 14878, 25, 59, 23, -4, -48 },
  { 15063, 28, 9, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_MediumItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC67PT7B_H_
