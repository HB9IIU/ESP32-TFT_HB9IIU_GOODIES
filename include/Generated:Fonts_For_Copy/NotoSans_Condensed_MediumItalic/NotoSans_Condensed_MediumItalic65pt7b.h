#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC65PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x1F,
  0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0, 0xFC,
  0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xBB, 0xF8, 0x07, 0xF1, 0xC1, 0x80, 0x3F, 0x0E, 0x04,
  0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x87, 0x00, 0x00, 0xFC, 0x38, 0x00, 0x07,
  0xE1, 0xC0, 0x00, 0x3F, 0x0E, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x0F, 0xE7,
  0x00, 0x00, 0x3F, 0xB8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0x7F, 0x80, 0x00, 0x39, 0xFC, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x1E, 0x3F,
  0x00, 0x00, 0xE1, 0xF8, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x38, 0x7E, 0x00,
  0x01, 0xC3, 0xF0, 0x40, 0x1E, 0x1F, 0x83, 0x00, 0xE1, 0xF8, 0x1E, 0x07,
  0x1F, 0xC0, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0xFD, 0xF8,
  0x00, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x87, 0xC0,
  0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0xF8, 0x3F, 0x8F, 0x83, 0xE3, 0xF1, 0xFF, 0x9F, 0x07, 0xC7, 0xC7,
  0xFF, 0xBE, 0x1F, 0x1F, 0x1F, 0xFF, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0xFF,
  0xF8, 0xF8, 0xF8, 0x7D, 0xFF, 0xF3, 0xF1, 0xF0, 0x7D, 0xFF, 0xC7, 0xC7,
  0xC0, 0xF9, 0xFF, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0x3E, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x07, 0xC1,
  0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x7C,
  0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x07, 0x83, 0xF0, 0x07, 0xC0,
  0x0F, 0x87, 0xC0, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0xFE,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xF8, 0x1F, 0xC1, 0xFD, 0xFC, 0x0F, 0xC1,
  0xFC, 0x7E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0,
  0xFE, 0x07, 0xF3, 0xF8, 0x7E, 0x01, 0xF9, 0xF8, 0x7F, 0x00, 0xFF, 0xFC,
  0x3F, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFE,
  0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFE,
  0x3F, 0x80, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xC0,
  0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x30, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7F,
  0xBE, 0x07, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xEF, 0x80, 0x1F, 0xCF, 0x80, 0x3F, 0x8F, 0xC0, 0x7F, 0x87, 0xC0, 0x3F,
  0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x04, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xE0,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xCF, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xDF, 0x8F, 0xF3, 0xF3, 0xFC, 0xFE, 0x3F, 0x1F, 0x83, 0x83, 0xF0, 0x60,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1E, 0x00,
  0xFF, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xE0, 0x1F, 0xE0, 0x0C,
  0x00, 0x7F, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x1F, 0xC0, 0xC0, 0x01,
  0xFE, 0x07, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0,
  0x7F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0x80, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x20, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x82, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x3F,
  0xC0, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xDE,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x08, 0x00, 0x1F, 0x8F, 0xF8, 0x01, 0xF9, 0xFF,
  0xC0, 0x3F, 0x3F, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x87, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x01,
  0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0,
  0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF9, 0xFF, 0xC1, 0xFF, 0xFD, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xC0, 0x3F, 0xF1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x10, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xE0, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0xFF, 0x81, 0xC0, 0x7F,
  0x82, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0xC0, 0x7C, 0x1F, 0x00,
  0x7F, 0xFC, 0x1E, 0x0F, 0x80, 0xFF, 0xFC, 0x0F, 0x0F, 0x80, 0xFF, 0xFE,
  0x07, 0x87, 0xC0, 0xFC, 0x1F, 0x03, 0xC7, 0xC0, 0x7C, 0x0F, 0x81, 0xE3,
  0xE0, 0x7C, 0x0F, 0x80, 0xF1, 0xE0, 0x7E, 0x07, 0xC0, 0xF9, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0xF8, 0x1E, 0x01, 0xF0, 0x3E, 0x78, 0x1F, 0x01, 0xF0,
  0x1F, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x3E, 0x0F, 0x80, 0x7C, 0x07, 0x9F,
  0x07, 0xC0, 0x3E, 0x07, 0xCF, 0x03, 0xE0, 0x3E, 0x03, 0xE7, 0x81, 0xF0,
  0x1F, 0x01, 0xE7, 0xC0, 0xF0, 0x0F, 0x81, 0xF3, 0xE0, 0x78, 0x0F, 0xC0,
  0xF9, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x7C,
  0x0F, 0x03, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xF8, 0x3C, 0x1F, 0x03, 0xF3,
  0xFE, 0x7E, 0x0F, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xC0, 0x7F, 0xC7, 0xFE,
  0x03, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x38, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xC0, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0x7F,
  0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0,
  0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0E, 0x00,
  0x7F, 0x80, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x04, 0x00, 0x7F,
  0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x7F, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xE1,
  0xFC, 0x00, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0xFC, 0x3F, 0x80, 0x1F, 0xFF,
  0x0F, 0xE0, 0x07, 0xFF, 0xC3, 0xF8, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x04, 0x1F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x7E, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0x01, 0xFB, 0xF8,
  0x03, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0xF8, 0xFE, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x3E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x3F, 0x07, 0xF0, 0x07, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0xF8, 0x1F, 0x80, 0x3F, 0x01,
  0xF3, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xE7, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xDF, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xFF,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xF8, 0x00, 0x7E, 0x00,
  0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0x01, 0xF3, 0xF0, 0x03, 0xF0, 0x07,
  0xCF, 0xC0, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x80, 0x7E,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x80, 0x3F, 0x7E, 0x00, 0xFC, 0x00,
  0x7D, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0x80,
  0x3F, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01,
  0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0,
  0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0x3F, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x00,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xE0,
  0x1F, 0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x3E, 0x00, 0x7F, 0x80, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0x7F, 0x80, 0x70, 0x01, 0xFE,
  0x00, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFB, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xC3, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFD,
  0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE7,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x1F,
  0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x7C,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xC1, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x07, 0xC3,
  0xF0, 0x01, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x1F, 0x1F,
  0xC0, 0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0xF9, 0xF8, 0x00, 0x3F, 0x3E, 0x01, 0xF3, 0xF0,
  0x00, 0x7E, 0xFC, 0x03, 0xEF, 0xE0, 0x00, 0xFD, 0xF0, 0x07, 0xDF, 0x80,
  0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00,
  0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xE7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF,
  0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x1F,
  0xFC, 0x7C, 0x01, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xBF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xE0, 0xFF, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xF8, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xEF, 0x80, 0x7F,
  0xFE, 0xFC, 0x01, 0xFF, 0xE7, 0xE0, 0x0F, 0xFE, 0x3F, 0x00, 0x1F, 0xE1,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x03, 0xF1, 0xFE,
  0x00, 0x3F, 0x9F, 0xFC, 0x01, 0xF9, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0x81, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0x7F, 0xFE, 0x01, 0xF3, 0xFF, 0xE0, 0x0F, 0x8F, 0xFE, 0x00,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xF8, 0x0C, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x40, 0x7F, 0x81, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x3F, 0xE3, 0xF8, 0x00,
  0x7F, 0xF3, 0xF0, 0x00, 0xFF, 0xFB, 0xF0, 0x01, 0xFF, 0xFB, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x7C, 0x00, 0x7F,
  0xFE, 0x7C, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x0F,
  0xF0, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xF3, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x03, 0xF9, 0xFC, 0x07, 0xF8, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x81, 0xFC, 0x01, 0xC0, 0xFF, 0xCF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x0F, 0xFE, 0x3E,
  0x00, 0x1F, 0xFF, 0x3E, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0,
  0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xDF, 0x80,
  0x07, 0xFF, 0x9F, 0x80, 0x07, 0xFF, 0x3F, 0x80, 0x03, 0xFE, 0x3F, 0x00,
  0x00, 0x70, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x03, 0xFC, 0x00,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x03, 0xF1, 0xFF, 0x00, 0x3F,
  0x9F, 0xFC, 0x01, 0xFB, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xFC,
  0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0F,
  0x87, 0xF8, 0x0F, 0xF8, 0x01, 0xF9, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0x3F,
  0xFE, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xE7, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x81, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x81, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x7E, 0x3F, 0xF8, 0x03, 0xE7,
  0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0x00, 0xFB, 0xFF, 0xF8, 0x07, 0xFE, 0x1F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0x80,
  0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x07,
  0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x1F, 0x1F, 0xFC, 0x00,
  0x3F, 0x3F, 0xFC, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0x3E, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x03,
  0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07,
  0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0x80, 0x0F,
  0xDF, 0xFF, 0x00, 0x0F, 0xCF, 0xFE, 0x00, 0x0F, 0xC7, 0xFC, 0x00, 0x1F,
  0x81, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xFC, 0x7C, 0x01, 0xFF,
  0xF3, 0xE0, 0x1F, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFC, 0x01, 0xFF,
  0xE7, 0xE0, 0x0F, 0xFE, 0x7F, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x38, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0xF8, 0x7F, 0x01, 0xF9, 0xFE, 0x01, 0xF1, 0xFE, 0x01, 0xF3, 0xFE, 0x01,
  0xF7, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xF0, 0x1C, 0x0F, 0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x80,
  0x0F, 0xE0, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x0C, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC1,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xC0, 0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0x8F,
  0x80, 0x1F, 0xF0, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7,
  0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC7,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0xC0, 0x3F, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x7E, 0x03, 0xFF, 0x01,
  0xF8, 0xFC, 0x07, 0xBE, 0x03, 0xF1, 0xF8, 0x1F, 0x7C, 0x0F, 0xC3, 0xF0,
  0x3E, 0xF8, 0x1F, 0x87, 0xE0, 0xF9, 0xF0, 0x7E, 0x0F, 0xC1, 0xF3, 0xE0,
  0xFC, 0x1F, 0x83, 0xE7, 0xC1, 0xF0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x7E,
  0x1F, 0x1F, 0x0F, 0xC0, 0xFC, 0x7C, 0x3E, 0x3F, 0x01, 0xF8, 0xF8, 0x7C,
  0x7E, 0x03, 0xF3, 0xF0, 0xF8, 0xF8, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x0F,
  0xCF, 0x83, 0xE7, 0xE0, 0x1F, 0xBE, 0x07, 0xDF, 0x80, 0x3E, 0x7C, 0x0F,
  0xBF, 0x00, 0x7D, 0xF8, 0x1E, 0x7C, 0x00, 0xFB, 0xE0, 0x3D, 0xF8, 0x01,
  0xF7, 0xC0, 0xFB, 0xE0, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0xFE, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0xFE, 0x00, 0x05, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x80, 0x01, 0xFF, 0x10, 0x00, 0x02, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 47, 16, 1, -46 },
  { 95, 20, 16, 24, 6, -46 },
  { 135, 33, 46, 33, 1, -46 },
  { 325, 29, 53, 29, 1, -49 },
  { 518, 39, 48, 45, 4, -47 },
  { 752, 33, 48, 34, 0, -47 },
  { 950, 9, 16, 14, 7, -46 },
  { 968, 21, 57, 18, 1, -47 },
  { 1118, 21, 57, 18, -5, -47 },
  { 1268, 24, 26, 28, 6, -50 },
  { 1346, 27, 30, 31, 3, -38 },
  { 1448, 13, 17, 15, -3, -8 },
  { 1476, 16, 5, 18, 1, -20 },
  { 1486, 8, 9, 15, 1, -8 },
  { 1495, 31, 47, 23, -3, -47 },
  { 1678, 27, 48, 29, 2, -47 },
  { 1840, 19, 46, 29, 7, -46 },
  { 1950, 31, 47, 29, -2, -47 },
  { 2133, 29, 48, 29, 0, -47 },
  { 2307, 30, 47, 29, -1, -47 },
  { 2484, 29, 47, 29, 0, -46 },
  { 2655, 28, 48, 29, 2, -47 },
  { 2823, 29, 46, 29, 3, -46 },
  { 2990, 29, 48, 29, 1, -47 },
  { 3164, 27, 48, 29, 1, -47 },
  { 3326, 14, 36, 15, 0, -35 },
  { 3389, 17, 44, 15, -3, -35 },
  { 3483, 27, 30, 31, 3, -38 },
  { 3585, 27, 18, 31, 3, -32 },
  { 3646, 27, 30, 31, 3, -38 },
  { 3748, 23, 48, 22, 2, -47 },
  { 3886, 41, 53, 44, 2, -47 },
  { 4158, 31, 47, 31, -4, -47 },
  { 4341, 31, 46, 32, 1, -46 },
  { 4520, 31, 48, 30, 3, -47 },
  { 4706, 33, 46, 35, 1, -46 },
  { 4896, 29, 46, 27, 1, -46 },
  { 5063, 29, 46, 26, 1, -46 },
  { 5230, 34, 48, 36, 3, -47 },
  { 5434, 36, 46, 36, 1, -46 },
  { 5641, 27, 46, 19, -3, -46 },
  { 5797, 27, 59, 15, -10, -46 },
  { 5997, 35, 46, 30, 1, -46 },
  { 6199, 20, 46, 26, 1, -46 },
  { 6314, 47, 46, 47, 1, -46 },
  { 6585, 38, 46, 38, 1, -46 },
  { 6804, 33, 48, 37, 3, -47 },
  { 7002, 31, 46, 30, 1, -46 },
  { 7181, 33, 58, 37, 3, -47 },
  { 7421, 30, 46, 31, 1, -46 },
  { 7594, 31, 48, 28, -1, -47 },
  { 7780, 26, 46, 26, 5, -46 },
  { 7930, 34, 47, 35, 3, -46 },
  { 8130, 30, 46, 30, 6, -46 },
  { 8303, 47, 46, 47, 6, -46 },
  { 8574, 37, 46, 29, -4, -46 },
  { 8787, 27, 46, 27, 6, -46 },
  { 8943, 32, 46, 26, -2, -46 },
  { 9127, 25, 57, 19, -2, -47 },
  { 9306, 12, 47, 23, 7, -47 },
  { 9377, 25, 57, 19, -4, -47 },
  { 9556, 28, 26, 30, 1, -46 },
  { 9647, 23, 4, 22, -6, 6 },
  { 9659, 11, 11, 18, 9, -50 },
  { 9675, 29, 37, 31, 2, -36 },
  { 9810, 29, 50, 31, 0, -49 },
  { 9992, 24, 37, 24, 2, -36 },
  { 10103, 32, 50, 31, 2, -49 },
  { 10303, 25, 37, 28, 2, -36 },
  { 10419, 33, 66, 18, -8, -50 },
  { 10692, 32, 52, 31, -1, -36 },
  { 10900, 29, 49, 31, 0, -49 },
  { 11078, 17, 48, 15, 0, -48 },
  { 11180, 25, 64, 15, -8, -48 },
  { 11380, 30, 49, 27, 0, -49 },
  { 11564, 17, 49, 14, 0, -49 },
  { 11669, 44, 36, 46, 0, -36 },
  { 11867, 29, 36, 31, 0, -36 },
  { 11998, 26, 37, 30, 2, -36 },
  { 12119, 32, 51, 31, -3, -36 },
  { 12323, 29, 52, 31, 2, -36 },
  { 12512, 24, 36, 21, 0, -36 },
  { 12620, 24, 37, 24, 0, -36 },
  { 12731, 18, 44, 18, 2, -43 },
  { 12830, 28, 36, 31, 2, -35 },
  { 12956, 25, 35, 25, 4, -35 },
  { 13066, 39, 35, 40, 4, -35 },
  { 13237, 32, 35, 26, -3, -35 },
  { 13377, 35, 51, 26, -6, -35 },
  { 13601, 26, 35, 22, -2, -35 },
  { 13715, 25, 56, 22, 1, -46 },
  { 13890, 6, 65, 28, 11, -50 },
  { 13939, 25, 56, 22, -4, -46 },
  { 14114, 27, 10, 31, 3, -28 },
};

const GFXfont NotoSans_Condensed_MediumItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC65PT7B_H_
