#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC49PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x3E,
  0x78, 0x7D, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C,
  0x3C, 0x70, 0x79, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x3C, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1E,
  0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0xC1, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xE6, 0x38, 0x1F, 0x18, 0x20, 0x78, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x8C, 0x00, 0x1E, 0x30, 0x00, 0x7C, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0x7E, 0x00, 0x0C, 0xF8, 0x00,
  0x73, 0xE0, 0x01, 0xC7, 0x80, 0x06, 0x1E, 0x00, 0x18, 0xF8, 0x40, 0x63,
  0xE1, 0x83, 0x9F, 0x07, 0xCF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x7F,
  0x80, 0x1E, 0x07, 0xFE, 0x01, 0xE0, 0x3C, 0xF0, 0x0F, 0x03, 0xC3, 0x80,
  0xF0, 0x1C, 0x1C, 0x07, 0x01, 0xE0, 0xE0, 0x78, 0x0F, 0x0F, 0x07, 0x80,
  0x70, 0x78, 0x3C, 0x07, 0x83, 0xC3, 0xC0, 0x3C, 0x1E, 0x1C, 0x01, 0xE0,
  0xF1, 0xE0, 0x0F, 0x07, 0x1E, 0x00, 0x78, 0x78, 0xF0, 0x03, 0x83, 0xCF,
  0x1F, 0x9C, 0x1C, 0x71, 0xFE, 0xF1, 0xE7, 0x9F, 0xFF, 0x9E, 0x79, 0xF3,
  0xFF, 0xF3, 0xCF, 0x1E, 0xFF, 0x3C, 0xF0, 0xF3, 0xF1, 0xE7, 0x87, 0x80,
  0x1E, 0x38, 0x3C, 0x01, 0xE3, 0xC1, 0xE0, 0x0F, 0x1E, 0x0F, 0x00, 0xF0,
  0xF0, 0x78, 0x07, 0x87, 0x83, 0x80, 0x78, 0x38, 0x3C, 0x03, 0x81, 0xC1,
  0xE0, 0x3C, 0x0E, 0x0F, 0x03, 0xC0, 0x70, 0xF0, 0x1E, 0x03, 0x87, 0x81,
  0xE0, 0x1E, 0x78, 0x0E, 0x00, 0xFF, 0x80, 0xF0, 0x07, 0xFC, 0x0F, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x83, 0xE1, 0xF7, 0xC1, 0xE1, 0xF3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF0,
  0x7C, 0xF8, 0xF8, 0x1F, 0x7C, 0x7C, 0x0F, 0xFC, 0x3C, 0x03, 0xFC, 0x3E,
  0x01, 0xFE, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x81,
  0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xF8, 0x1F, 0xFE, 0x7E,
  0x07, 0xFC, 0x1F, 0x80, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x79,
  0xE3, 0xC7, 0x8F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x06, 0x1E, 0x07, 0xCF, 0x03, 0xFF, 0x87, 0xFF,
  0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x01,
  0xF3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF8, 0x38, 0x3C, 0x08, 0x1C, 0x00, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x87, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x1E,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x7B, 0xFF, 0xFF, 0xFB, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0x78, 0x1F, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E,
  0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xDE, 0x3F, 0x7C, 0xFC, 0xF8, 0xF1, 0xE0, 0x83, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1E, 0x07, 0xC0, 0x38, 0x0F,
  0xC0, 0x20, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xC0, 0xFC, 0x04, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC2, 0x00, 0x3F, 0x0C, 0x03,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0x80,
  0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xF8, 0x03,
  0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x80, 0x78, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE4, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1C, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC2, 0x00, 0x3F, 0x0C, 0x03, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x3F, 0x01, 0xF7, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0x7E, 0x3F, 0x81, 0xF1, 0xF8, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07,
  0xC7, 0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0x7F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xC1,
  0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF3, 0xE0, 0x1F,
  0x87, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01,
  0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF1, 0xF0,
  0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x3E, 0x07, 0xF3,
  0xF0, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFB, 0xE0, 0x7E, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x78,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE1, 0x81, 0xF8, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x1E, 0x01, 0xE0, 0x38, 0x78, 0x0F,
  0xF8, 0x70, 0xF0, 0x7F, 0xF0, 0xF3, 0xC1, 0xF1, 0xE1, 0xE7, 0x83, 0xC3,
  0xC3, 0xCE, 0x0F, 0x07, 0x07, 0x3C, 0x3C, 0x1E, 0x0E, 0x70, 0x78, 0x3C,
  0x1C, 0xE0, 0xE0, 0x78, 0x3B, 0xC3, 0xC0, 0xE0, 0xF7, 0x87, 0x83, 0xC1,
  0xEF, 0x0E, 0x07, 0x83, 0x9C, 0x1C, 0x0F, 0x0F, 0x38, 0x78, 0x3C, 0x1E,
  0x70, 0xF0, 0x78, 0x38, 0xE1, 0xE1, 0xF0, 0xF1, 0xC3, 0xC3, 0xE3, 0xC3,
  0x83, 0xFF, 0xFF, 0x07, 0x07, 0xF9, 0xFC, 0x0E, 0x07, 0xE3, 0xF0, 0x1C,
  0x02, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x40, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x7F, 0x01,
  0xF0, 0x3F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC1, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3C,
  0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFC, 0x0C, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x01, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x1F, 0xF0, 0x0F, 0x81, 0xF8,
  0x07, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x3F, 0x81, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x01,
  0xC0, 0x3F, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0xFC, 0x07,
  0xFE, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03,
  0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3D,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x0F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFE, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x07, 0xBC, 0x03,
  0xDE, 0x00, 0xF7, 0xC0, 0x7D, 0xE0, 0x0F, 0x7C, 0x07, 0xDE, 0x01, 0xE7,
  0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xEF, 0x80, 0x79, 0xE0,
  0x3C, 0xF8, 0x0F, 0x9E, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x78, 0xF0, 0x0F,
  0x1E, 0x0F, 0x8F, 0x00, 0xF1, 0xF0, 0xF1, 0xF0, 0x0F, 0x1F, 0x1F, 0x1F,
  0x01, 0xF0, 0xF1, 0xE1, 0xF0, 0x1F, 0x0F, 0x3E, 0x1E, 0x01, 0xE0, 0xF3,
  0xC1, 0xE0, 0x1E, 0x0F, 0x3C, 0x3E, 0x03, 0xE0, 0xF7, 0x83, 0xE0, 0x3E,
  0x0F, 0x78, 0x3E, 0x03, 0xE0, 0xFF, 0x03, 0xC0, 0x3C, 0x0F, 0xF0, 0x7C,
  0x03, 0xC0, 0xFE, 0x07, 0xC0, 0x7C, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0xFC,
  0x07, 0x80, 0x7C, 0x0F, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xE0,
  0x1F, 0xC0, 0x07, 0x80, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0xF8, 0x07,
  0xF8, 0x03, 0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xDE,
  0x01, 0xF0, 0x0F, 0x7C, 0x07, 0xC0, 0x3D, 0xF0, 0x1E, 0x01, 0xF3, 0xC0,
  0x78, 0x07, 0xCF, 0x03, 0xE0, 0x1F, 0x3C, 0x0F, 0x80, 0x78, 0xF8, 0x3E,
  0x01, 0xE3, 0xE0, 0xF0, 0x0F, 0x87, 0x83, 0xC0, 0x3E, 0x1E, 0x1F, 0x00,
  0xF8, 0x7C, 0x7C, 0x03, 0xC1, 0xF1, 0xF0, 0x0F, 0x03, 0xC7, 0x80, 0x7C,
  0x0F, 0x1E, 0x01, 0xF0, 0x3C, 0xF8, 0x07, 0x80, 0xFB, 0xE0, 0x1E, 0x01,
  0xEF, 0x00, 0xF8, 0x07, 0xBC, 0x03, 0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0x7F,
  0xC0, 0x3C, 0x01, 0xFF, 0x00, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xE0,
  0x1F, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0xFE, 0x01, 0xE0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x1F,
  0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7,
  0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7D,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01,
  0xFB, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xF0,
  0x1F, 0x81, 0xFC, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0xFE, 0x01, 0xF0, 0x3E,
  0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7E, 0x07, 0x80, 0xFC, 0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x1F,
  0x81, 0xFC, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE1, 0xFC, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x83,
  0xC0, 0x7E, 0x1F, 0x0F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x8F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x38, 0x1F, 0x80, 0x20,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC2, 0x00, 0x7E, 0x0F, 0x03, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x3E, 0x1E,
  0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x07,
  0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x01, 0xF0, 0x03,
  0xEF, 0x80, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x07, 0xCF, 0x80, 0x3F,
  0x00, 0x78, 0xF8, 0x07, 0xF0, 0x0F, 0x8F, 0x80, 0x7F, 0x00, 0xF8, 0xF8,
  0x0F, 0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0xF8, 0x0F, 0xF0, 0x1E,
  0x0F, 0x81, 0xEF, 0x03, 0xE0, 0xF8, 0x1E, 0xF0, 0x3E, 0x0F, 0x83, 0xCF,
  0x07, 0xC0, 0xF8, 0x3C, 0xF0, 0x7C, 0x0F, 0x83, 0xCF, 0x07, 0x80, 0xF8,
  0x78, 0xF0, 0xF8, 0x0F, 0x87, 0x8F, 0x0F, 0x80, 0xF8, 0xF0, 0xF1, 0xF0,
  0x0F, 0x8F, 0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0xF1, 0xE0, 0x0F, 0x9E, 0x0F,
  0x3E, 0x00, 0xF9, 0xE0, 0xF3, 0xC0, 0x0F, 0xBC, 0x0F, 0x7C, 0x00, 0xFB,
  0xC0, 0xF7, 0xC0, 0x0F, 0xFC, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3C,
  0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9F, 0x00, 0xFC,
  0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x78, 0x3E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC1,
  0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0xF0, 0x03,
  0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xF3, 0xE0,
  0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xC0, 0xFC, 0x7C, 0x7C, 0x3E, 0x1E, 0x1E, 0x0F, 0x00, 0x7C, 0x00,
  0x07, 0xF8, 0xF0, 0x3F, 0xF3, 0xC1, 0xFF, 0xFF, 0x07, 0xE3, 0xF8, 0x3F,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0x87,
  0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x7F, 0x07, 0xC1, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xF7, 0x80, 0xFF, 0x9E, 0x01, 0xFC, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0xF3, 0xFC, 0x07, 0xDF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0x8F, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x3F,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x81, 0xF8, 0x7F, 0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xBF, 0xF8,
  0x1E, 0xFF, 0xC0, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFC, 0x30, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x21, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x7C,
  0x7C, 0x01, 0xFE, 0x7C, 0x03, 0xFF, 0x7C, 0x07, 0xFF, 0xF8, 0x07, 0xE3,
  0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03,
  0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xF7,
  0x80, 0x3F, 0xE7, 0x80, 0x1F, 0xC7, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7C, 0x3E, 0x1F, 0x03, 0xC7, 0xC0, 0x78,
  0xF8, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF0, 0x1F, 0x3E, 0x1F, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x83, 0xFC, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x02, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x09, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFE, 0x3C, 0x07, 0xFE, 0x78, 0x1F, 0xFF, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x07, 0xC1,
  0xFC, 0x0F, 0x87, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xEF,
  0x80, 0x3F, 0x9F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0x00, 0x7C, 0x03,
  0xC3, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0xF3, 0xFC,
  0x07, 0xDF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x9F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x7C, 0x3F, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xF0,
  0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x4F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x08, 0x1E, 0x03,
  0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xC1, 0xF0,
  0x07, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0xF7, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE1,
  0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xE7, 0xF8, 0x7F, 0x81, 0xE7,
  0xFC, 0xFF, 0xC0, 0xF7, 0xFF, 0x7F, 0xF0, 0x7F, 0x9F, 0xF9, 0xF8, 0x3F,
  0x07, 0xF0, 0x7C, 0x1F, 0x03, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0x0F,
  0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0x83, 0xE0, 0x3E, 0x03, 0xC1,
  0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07,
  0x83, 0xC0, 0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x3F, 0xC0,
  0x79, 0xFF, 0x81, 0xEF, 0xFE, 0x07, 0xF9, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xC3, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3C, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x7C, 0x3E, 0x07, 0xCF,
  0xC0, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1E, 0xF0,
  0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xF0,
  0x3E, 0x3E, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF3, 0xFC, 0x00, 0xE7, 0xFE, 0x01,
  0xEF, 0xFE, 0x01, 0xFE, 0x3F, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x03,
  0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x07,
  0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1E, 0xFF, 0xE0, 0x1E, 0x7F, 0xC0, 0x3E, 0x3F, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF8, 0xF0, 0x3F, 0xF3, 0xC1, 0xFF, 0xFE, 0x07, 0xE3,
  0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F,
  0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x7F, 0x07,
  0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xF7, 0x80, 0xFF, 0xBE, 0x01, 0xFC,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0xF3, 0xF0, 0x79, 0xF8, 0x1E, 0xFE, 0x07, 0xBF, 0x81, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0x83, 0x87,
  0xC0, 0x21, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x88, 0x07, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFC, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x07,
  0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x07, 0xE1, 0xE0, 0x3F, 0x0F, 0x83, 0xF0,
  0x7C, 0x3F, 0x83, 0xFF, 0xBC, 0x1F, 0xFD, 0xE0, 0x7F, 0xCE, 0x01, 0xF8,
  0xF0, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0xCF,
  0x00, 0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E,
  0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7E, 0x03, 0xEF,
  0x01, 0xF8, 0x0F, 0x3C, 0x0F, 0xE0, 0x7C, 0xF0, 0x3F, 0x81, 0xE3, 0xC0,
  0xEE, 0x0F, 0x8F, 0x07, 0xF8, 0x3E, 0x3C, 0x1F, 0xE0, 0xF0, 0xF0, 0xF7,
  0x87, 0xC3, 0xC3, 0xDE, 0x1E, 0x0F, 0x0E, 0x78, 0xF8, 0x3C, 0x79, 0xE3,
  0xE0, 0xF1, 0xE7, 0x8F, 0x03, 0xCF, 0x1E, 0x7C, 0x0F, 0x3C, 0x79, 0xE0,
  0x3C, 0xE1, 0xEF, 0x80, 0xF7, 0x87, 0xBC, 0x03, 0xDE, 0x1E, 0xF0, 0x0F,
  0x70, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x7C, 0x01, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0,
  0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xDF, 0x00,
  0x07, 0xCF, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x3E, 0x07, 0x80, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x27,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x13, 0xFC, 0x01, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 35, 12, 0, -35 },
  { 58, 15, 13, 18, 5, -35 },
  { 83, 26, 35, 25, 0, -35 },
  { 197, 22, 40, 22, 0, -37 },
  { 307, 29, 35, 34, 3, -35 },
  { 434, 25, 35, 26, 0, -35 },
  { 544, 7, 13, 10, 5, -35 },
  { 556, 16, 43, 13, 1, -35 },
  { 642, 16, 43, 13, -4, -35 },
  { 728, 17, 19, 21, 5, -37 },
  { 769, 20, 23, 24, 2, -29 },
  { 827, 9, 12, 11, -2, -6 },
  { 841, 12, 4, 14, 1, -15 },
  { 847, 6, 6, 11, 1, -6 },
  { 852, 23, 35, 17, -2, -35 },
  { 953, 21, 35, 22, 1, -35 },
  { 1045, 15, 35, 22, 5, -35 },
  { 1111, 23, 35, 22, -1, -35 },
  { 1212, 22, 35, 22, 0, -35 },
  { 1309, 23, 35, 22, -1, -35 },
  { 1410, 22, 35, 22, 0, -35 },
  { 1507, 21, 35, 22, 2, -35 },
  { 1599, 22, 35, 22, 2, -35 },
  { 1696, 22, 35, 22, 0, -35 },
  { 1793, 20, 35, 22, 1, -35 },
  { 1881, 11, 27, 11, 0, -27 },
  { 1919, 14, 33, 11, -3, -27 },
  { 1977, 20, 23, 24, 2, -29 },
  { 2035, 20, 14, 24, 2, -24 },
  { 2070, 20, 23, 24, 2, -29 },
  { 2128, 17, 35, 17, 2, -35 },
  { 2203, 31, 39, 33, 2, -35 },
  { 2355, 23, 35, 23, -3, -35 },
  { 2456, 24, 35, 24, 0, -35 },
  { 2561, 24, 36, 22, 2, -36 },
  { 2669, 25, 35, 26, 0, -35 },
  { 2779, 23, 35, 21, 0, -35 },
  { 2880, 23, 35, 19, 0, -35 },
  { 2981, 26, 36, 27, 2, -36 },
  { 3098, 27, 35, 27, 1, -35 },
  { 3217, 20, 35, 15, -2, -35 },
  { 3305, 20, 45, 12, -7, -35 },
  { 3418, 26, 35, 23, 1, -35 },
  { 3532, 16, 35, 19, 0, -35 },
  { 3602, 36, 35, 35, 0, -35 },
  { 3760, 30, 35, 29, 0, -35 },
  { 3892, 25, 35, 28, 2, -35 },
  { 4002, 24, 35, 23, 0, -35 },
  { 4107, 25, 43, 28, 2, -35 },
  { 4242, 22, 35, 23, 1, -35 },
  { 4339, 22, 35, 21, 0, -35 },
  { 4436, 20, 35, 20, 4, -35 },
  { 4524, 26, 35, 27, 2, -35 },
  { 4638, 23, 35, 23, 4, -35 },
  { 4739, 36, 35, 36, 4, -35 },
  { 4897, 28, 35, 22, -3, -35 },
  { 5020, 21, 35, 21, 4, -35 },
  { 5112, 25, 35, 20, -2, -35 },
  { 5222, 19, 43, 14, -1, -35 },
  { 5325, 9, 35, 18, 5, -35 },
  { 5365, 18, 43, 14, -3, -35 },
  { 5462, 21, 20, 22, 1, -35 },
  { 5515, 17, 3, 16, -4, 4 },
  { 5522, 8, 7, 13, 7, -37 },
  { 5529, 22, 27, 23, 1, -27 },
  { 5604, 22, 37, 23, 0, -37 },
  { 5706, 17, 27, 18, 2, -27 },
  { 5764, 24, 37, 23, 1, -37 },
  { 5875, 19, 27, 21, 1, -27 },
  { 5940, 25, 49, 13, -6, -37 },
  { 6094, 23, 39, 23, 0, -27 },
  { 6207, 22, 37, 23, 0, -37 },
  { 6309, 13, 36, 11, 0, -36 },
  { 6368, 19, 48, 11, -6, -36 },
  { 6482, 23, 37, 21, 0, -37 },
  { 6589, 13, 37, 11, 0, -37 },
  { 6650, 33, 27, 35, 0, -27 },
  { 6762, 22, 27, 23, 0, -27 },
  { 6837, 19, 27, 23, 2, -27 },
  { 6902, 24, 39, 23, -2, -27 },
  { 7019, 22, 39, 23, 1, -27 },
  { 7127, 18, 27, 16, 0, -27 },
  { 7188, 18, 27, 18, 0, -27 },
  { 7249, 13, 32, 14, 2, -32 },
  { 7301, 21, 26, 23, 2, -26 },
  { 7370, 19, 26, 19, 3, -26 },
  { 7432, 30, 26, 30, 3, -26 },
  { 7530, 24, 26, 20, -2, -26 },
  { 7608, 26, 38, 19, -4, -26 },
  { 7732, 20, 26, 17, -2, -26 },
  { 7797, 19, 43, 17, 1, -35 },
  { 7900, 4, 49, 21, 8, -37 },
  { 7925, 19, 43, 17, -3, -35 },
  { 8028, 20, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC49PT7B_H_
