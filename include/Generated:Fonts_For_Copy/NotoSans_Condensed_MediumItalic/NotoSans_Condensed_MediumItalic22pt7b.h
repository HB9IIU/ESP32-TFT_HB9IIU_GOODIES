#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC2, 0x10, 0x01, 0x8E,
  0x38, 0x66, 0xCD, 0xB2, 0x6C, 0xD9, 0x80, 0x06, 0x60, 0xCC, 0x11, 0x02,
  0x60, 0xCC, 0x7F, 0xC2, 0x60, 0xCC, 0x19, 0x02, 0x63, 0xFF, 0x19, 0x02,
  0x20, 0xCC, 0x19, 0x82, 0x60, 0x01, 0x00, 0x80, 0xF8, 0x7F, 0x3A, 0x8D,
  0x83, 0x40, 0xF0, 0x1E, 0x03, 0xC0, 0xB0, 0x2E, 0x0B, 0xA2, 0xCF, 0xF1,
  0xF0, 0x10, 0x04, 0x00, 0x18, 0x31, 0xE1, 0x99, 0x18, 0xC8, 0x84, 0x4C,
  0x66, 0x43, 0x36, 0xD9, 0x6F, 0xFA, 0xCB, 0xB6, 0x41, 0x22, 0x19, 0x31,
  0x99, 0x8C, 0xCC, 0xC6, 0xCC, 0x1C, 0x07, 0x01, 0xF0, 0x66, 0x0C, 0xC1,
  0x98, 0x37, 0x07, 0xC0, 0x70, 0x3E, 0x6E, 0xCD, 0x9B, 0x61, 0xEC, 0x39,
  0x87, 0x3F, 0xE3, 0xEE, 0x6D, 0xAD, 0x80, 0x07, 0x06, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0xC1, 0x87, 0x0C, 0x30, 0x63, 0x80, 0x0C, 0x08, 0x48, 0xFB, 0x3F,
  0x38, 0x6C, 0x6E, 0x04, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20,
  0x10, 0x08, 0x04, 0x00, 0x33, 0x66, 0x4C, 0x7F, 0xE0, 0x7F, 0x80, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x0E, 0x0F, 0x8C,
  0xE6, 0x36, 0x1B, 0x0F, 0x8F, 0x86, 0xC3, 0x61, 0xB0, 0xD8, 0xCC, 0x66,
  0x73, 0xF0, 0xF0, 0x06, 0x38, 0xF7, 0xE4, 0xC1, 0x86, 0x0C, 0x18, 0x30,
  0xE1, 0x83, 0x06, 0x0C, 0x38, 0x07, 0x83, 0xF8, 0x23, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60,
  0x1F, 0xE7, 0xFC, 0x0F, 0x0F, 0xE1, 0x1C, 0x03, 0x00, 0xC0, 0x60, 0x38,
  0x78, 0x1E, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x21, 0xCF, 0xE3, 0xF0, 0x01,
  0xC0, 0x70, 0x38, 0x1E, 0x05, 0x83, 0x61, 0xB0, 0xCC, 0x33, 0x18, 0xCC,
  0x33, 0xFE, 0xFF, 0x81, 0x80, 0x60, 0x38, 0x0F, 0xC7, 0xF1, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0xE0, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x21,
  0xCF, 0xE3, 0xF0, 0x07, 0x87, 0xC6, 0x06, 0x07, 0x03, 0x01, 0xB9, 0xBE,
  0xE3, 0x61, 0xB0, 0xD8, 0x6C, 0x76, 0x33, 0xF8, 0xF8, 0x7F, 0xDF, 0xE0,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0x07, 0x07, 0xF1, 0x8C, 0xC3, 0x30, 0xCE,
  0x61, 0xB8, 0x38, 0x3E, 0x1C, 0xC6, 0x3B, 0x06, 0xC1, 0xB8, 0xC7, 0xF0,
  0xF8, 0x0F, 0x07, 0xE3, 0x98, 0xC7, 0x30, 0xDC, 0x77, 0x19, 0xC6, 0x3F,
  0x8F, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x8F, 0xC3, 0xE0, 0x19, 0xCC, 0x00,
  0x00, 0x00, 0x03, 0x39, 0xC0, 0x0C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC3, 0x18, 0x63, 0x0C, 0x00, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x1C, 0x3C, 0x78, 0xF0, 0x60, 0x00,
  0x3C, 0xFD, 0x18, 0x30, 0x60, 0xC3, 0x0C, 0x30, 0xC1, 0x80, 0x00, 0x18,
  0x38, 0x60, 0x01, 0xE0, 0x3F, 0xC1, 0x81, 0x8C, 0x02, 0x21, 0x8D, 0x9F,
  0x34, 0x4C, 0xF3, 0x32, 0xC8, 0x8A, 0x62, 0x69, 0x99, 0xA6, 0x64, 0x9E,
  0xE2, 0x11, 0x0C, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x01, 0x80,
  0xE0, 0x38, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x73, 0x18, 0xC7, 0xF3, 0xFC,
  0xC3, 0x60, 0xD8, 0x3E, 0x0F, 0x03, 0x0F, 0x83, 0xF8, 0x63, 0x8C, 0x31,
  0x86, 0x71, 0x8C, 0x71, 0xFC, 0x3F, 0x86, 0x31, 0xC7, 0x30, 0xE6, 0x18,
  0xC7, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8, 0x71, 0x1C, 0x07, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x1F,
  0x81, 0xF0, 0x0F, 0x03, 0xF8, 0x63, 0x8C, 0x31, 0x86, 0x70, 0xCC, 0x19,
  0x83, 0x30, 0x66, 0x0D, 0xC3, 0xB0, 0x66, 0x1C, 0xC7, 0x1F, 0xC7, 0xE0,
  0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xFC, 0x3F, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF1, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xFC, 0x3F, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0x07, 0xC0, 0xFF, 0x1C, 0x23, 0x80, 0x70, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC3, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xE1, 0x8E,
  0x18, 0x7F, 0x83, 0xF8, 0x0C, 0x38, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83,
  0x1C, 0x38, 0xC1, 0x87, 0xFC, 0x3F, 0xE1, 0x87, 0x1C, 0x30, 0xC1, 0x86,
  0x0C, 0x30, 0x61, 0x87, 0x1C, 0x30, 0x1F, 0x8F, 0xC1, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xE1, 0xF8,
  0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x3E, 0x1E, 0x00, 0x0C,
  0x31, 0x86, 0x18, 0xE1, 0x9C, 0x19, 0x83, 0xB0, 0x36, 0x03, 0xE0, 0x3E,
  0x03, 0x60, 0x77, 0x06, 0x30, 0x63, 0x06, 0x30, 0x63, 0x8C, 0x18, 0x0C,
  0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x1F,
  0xFF, 0x0C, 0x07, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x36,
  0x1E, 0x36, 0x36, 0x36, 0x36, 0x36, 0x6C, 0x36, 0x6C, 0x66, 0xCC, 0x66,
  0xCC, 0x67, 0x8C, 0x67, 0x98, 0x67, 0x18, 0xC3, 0x18, 0x0C, 0x18, 0xE0,
  0xC7, 0x06, 0x3C, 0x31, 0xE3, 0x1B, 0x18, 0xD8, 0xC6, 0x66, 0x33, 0x31,
  0x9B, 0x18, 0xD8, 0xC3, 0xC6, 0x1E, 0x30, 0xF1, 0x87, 0x18, 0x38, 0x07,
  0x83, 0xF8, 0x63, 0x98, 0x37, 0x06, 0xC0, 0xD8, 0x1F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0x60, 0x6C, 0x1D, 0xC7, 0x1F, 0xC1, 0xF0, 0x0F, 0x03, 0xF8,
  0x63, 0x0C, 0x71, 0x8E, 0x71, 0xCC, 0x31, 0x8E, 0x3F, 0x87, 0xE1, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x07, 0x83, 0xF8, 0x63, 0x98,
  0x37, 0x06, 0xC0, 0xD8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0x60, 0x6C,
  0x1D, 0xC7, 0x1F, 0xC1, 0xF0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x0F,
  0x03, 0xF8, 0x63, 0x0C, 0x71, 0x8E, 0x71, 0x8C, 0x31, 0x8E, 0x3F, 0x07,
  0xC1, 0xDC, 0x31, 0x86, 0x30, 0xC6, 0x18, 0xE6, 0x0C, 0x0F, 0x87, 0xF3,
  0x88, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x21, 0xCF, 0xE3, 0xF0, 0xFF, 0xFF, 0x86, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0x38,
  0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0xE1, 0x98, 0x33, 0x06, 0x60, 0xDC,
  0x3B, 0x06, 0x60, 0xCC, 0x19, 0x86, 0x3F, 0xC3, 0xF0, 0xC0, 0xF0, 0x7C,
  0x1B, 0x0E, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xCC, 0x33, 0x0D, 0x83, 0x60,
  0xD8, 0x3C, 0x0F, 0x03, 0x80, 0xC1, 0x83, 0xC3, 0x86, 0xC3, 0x86, 0xC3,
  0x8C, 0xC7, 0x8C, 0xC7, 0x8C, 0xCD, 0x98, 0xCD, 0x98, 0xC9, 0xB0, 0xD9,
  0xB0, 0xD9, 0xB0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0xE1,
  0xC0, 0x1C, 0x30, 0xC7, 0x0C, 0x60, 0xCC, 0x0D, 0xC0, 0xF8, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x1B, 0x01, 0xB0, 0x33, 0x07, 0x38, 0x61, 0x8C,
  0x18, 0xC1, 0xE1, 0xF0, 0xDC, 0xC6, 0x63, 0x61, 0xF0, 0xF0, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0x0F, 0xE3, 0xFC, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0x87, 0xC3, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x1E, 0x1F, 0x00, 0xCC, 0x46, 0x66, 0x66, 0x66, 0x33, 0x33, 0x33,
  0x07, 0x87, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x1E, 0x1F, 0x00, 0x06,
  0x01, 0x80, 0xF0, 0x3C, 0x1B, 0x04, 0x63, 0x19, 0x86, 0xE0, 0xC0, 0xFF,
  0xE6, 0x63, 0x1D, 0x9F, 0xDC, 0xEC, 0x7E, 0x36, 0x1B, 0x0D, 0x86, 0xC7,
  0x63, 0x3F, 0x8E, 0xC0, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0xE3,
  0x7C, 0xE3, 0x30, 0xCC, 0x37, 0x0D, 0x86, 0x61, 0x98, 0x66, 0x33, 0xFC,
  0xDE, 0x00, 0x1F, 0x3E, 0x70, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFC, 0x7C, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x87, 0x63, 0xF9, 0xCE,
  0x63, 0xB8, 0xCC, 0x33, 0x0C, 0xC3, 0x31, 0xCC, 0x63, 0xF8, 0x76, 0x00,
  0x1E, 0x3F, 0x63, 0x63, 0xC7, 0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C,
  0x00, 0xF0, 0x1E, 0x01, 0x80, 0x30, 0x03, 0x00, 0x7C, 0x0F, 0xC0, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0xF8, 0x0F, 0x00, 0x0E, 0x47, 0xF3,
  0x9C, 0xC7, 0x71, 0x98, 0x66, 0x19, 0x86, 0x63, 0x98, 0xC7, 0xF1, 0xEC,
  0x03, 0x01, 0xC0, 0x63, 0xF8, 0xFC, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x07, 0xE3, 0x7C, 0xE7, 0x31, 0xCC, 0x63, 0x19, 0x86, 0x61, 0x98,
  0xE6, 0x33, 0x8C, 0xC3, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xC3, 0x0C, 0x31,
  0xC6, 0x18, 0x61, 0x8E, 0x30, 0x03, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18,
  0x0C, 0x06, 0x1E, 0x0F, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x33, 0x18, 0xCC, 0x36, 0x0F, 0x82, 0xC1, 0xF0, 0x76, 0x19, 0x86, 0x63,
  0x9C, 0xC3, 0x00, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x18,
  0x61, 0x86, 0x38, 0xC0, 0x17, 0x9C, 0x7F, 0x7C, 0xE7, 0x19, 0x8E, 0x33,
  0x18, 0xC6, 0x31, 0x98, 0x63, 0x31, 0xC6, 0x63, 0x0C, 0xC6, 0x33, 0x8C,
  0x66, 0x18, 0xC0, 0x17, 0x8F, 0xF3, 0x9C, 0xC7, 0x31, 0x9C, 0x66, 0x19,
  0x86, 0x63, 0x98, 0xCE, 0x33, 0x0C, 0x1E, 0x1F, 0x9C, 0xCC, 0x7C, 0x3E,
  0x1B, 0x0D, 0x86, 0xC7, 0x63, 0x3F, 0x8F, 0x00, 0x09, 0xC3, 0x7C, 0x71,
  0x8C, 0x31, 0x86, 0x30, 0xCC, 0x39, 0x86, 0x30, 0xC6, 0x31, 0xFE, 0x37,
  0x86, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x00, 0x1C, 0x9F, 0xDC, 0xEC,
  0x7E, 0x36, 0x1B, 0x0D, 0x86, 0xC7, 0x63, 0x3F, 0x9E, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x0C, 0x00, 0x17, 0x37, 0x38, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0xE0, 0xC0, 0x1F, 0x3F, 0x70, 0x60, 0x70, 0x38, 0x1C, 0x0E,
  0x0E, 0x0E, 0xFC, 0xF8, 0x10, 0x43, 0x1F, 0xFD, 0x86, 0x18, 0x63, 0x0C,
  0x30, 0xC3, 0xCF, 0x00, 0x31, 0xB0, 0xD8, 0x6C, 0x66, 0x37, 0x1B, 0x0D,
  0x86, 0xC6, 0x63, 0x3F, 0x9E, 0xC0, 0xC3, 0xE1, 0xB0, 0xD8, 0xCC, 0x66,
  0x61, 0x30, 0xB0, 0x58, 0x38, 0x1C, 0x0C, 0x00, 0xC3, 0x1F, 0x1C, 0x6C,
  0x71, 0xB3, 0xCC, 0xCF, 0x33, 0x2D, 0x8D, 0xB6, 0x36, 0xD8, 0xF3, 0xC3,
  0xCF, 0x0E, 0x38, 0x38, 0xE0, 0x18, 0xE3, 0x38, 0x66, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x3E, 0x06, 0x61, 0x8C, 0x71, 0x80, 0x18, 0x71,
  0x86, 0x18, 0x60, 0xCC, 0x0C, 0xC0, 0xD8, 0x0D, 0x80, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x0F, 0x00, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x1F,
  0x9F, 0xC0, 0x01, 0x83, 0xC3, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x38,
  0x38, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x1E, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x07, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x70,
  0xE0, 0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_Condensed_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 5, 0, -16 },
  { 13, 7, 6, 8, 2, -16 },
  { 19, 11, 16, 11, 0, -16 },
  { 41, 10, 18, 10, 0, -17 },
  { 64, 13, 16, 15, 1, -16 },
  { 90, 11, 16, 12, 0, -16 },
  { 112, 3, 6, 5, 2, -16 },
  { 115, 8, 19, 6, 0, -16 },
  { 134, 7, 19, 6, -2, -16 },
  { 151, 8, 9, 9, 2, -17 },
  { 160, 9, 10, 11, 1, -13 },
  { 172, 4, 6, 5, -1, -3 },
  { 175, 6, 2, 6, 0, -7 },
  { 177, 3, 3, 5, 0, -3 },
  { 179, 11, 16, 8, -1, -16 },
  { 201, 9, 16, 10, 1, -16 },
  { 219, 7, 16, 10, 2, -16 },
  { 233, 11, 16, 10, -1, -16 },
  { 255, 10, 16, 10, 0, -16 },
  { 275, 10, 16, 10, 0, -16 },
  { 295, 10, 16, 10, 0, -16 },
  { 315, 9, 16, 10, 1, -16 },
  { 333, 10, 16, 10, 1, -16 },
  { 353, 10, 16, 10, 0, -16 },
  { 373, 10, 16, 10, 0, -16 },
  { 393, 5, 12, 5, 0, -12 },
  { 401, 6, 15, 5, -1, -12 },
  { 413, 9, 10, 11, 1, -13 },
  { 425, 9, 6, 11, 1, -11 },
  { 432, 9, 10, 11, 1, -13 },
  { 444, 7, 16, 8, 1, -16 },
  { 458, 14, 18, 15, 1, -16 },
  { 490, 10, 16, 10, -1, -16 },
  { 510, 11, 16, 11, 0, -16 },
  { 532, 11, 16, 10, 1, -16 },
  { 554, 11, 16, 12, 0, -16 },
  { 576, 10, 16, 9, 0, -16 },
  { 596, 10, 16, 9, 0, -16 },
  { 616, 12, 16, 12, 1, -16 },
  { 640, 13, 16, 12, 0, -16 },
  { 666, 9, 16, 7, -1, -16 },
  { 684, 9, 20, 5, -3, -16 },
  { 707, 12, 16, 10, 0, -16 },
  { 731, 7, 16, 9, 0, -16 },
  { 745, 16, 16, 16, 0, -16 },
  { 777, 13, 16, 13, 0, -16 },
  { 803, 11, 16, 13, 1, -16 },
  { 825, 11, 16, 10, 0, -16 },
  { 847, 11, 20, 13, 1, -16 },
  { 875, 11, 16, 11, 0, -16 },
  { 897, 10, 16, 9, 0, -16 },
  { 917, 9, 16, 9, 2, -16 },
  { 935, 11, 16, 12, 1, -16 },
  { 957, 10, 16, 10, 2, -16 },
  { 977, 16, 16, 16, 2, -16 },
  { 1009, 12, 16, 10, -1, -16 },
  { 1033, 9, 16, 9, 2, -16 },
  { 1051, 11, 16, 9, -1, -16 },
  { 1073, 9, 20, 6, -1, -16 },
  { 1096, 4, 16, 8, 2, -16 },
  { 1104, 9, 20, 6, -2, -16 },
  { 1127, 10, 9, 10, 0, -16 },
  { 1139, 8, 1, 7, -2, 2 },
  { 1140, 4, 4, 6, 3, -17 },
  { 1142, 9, 12, 11, 1, -12 },
  { 1156, 10, 17, 10, 0, -17 },
  { 1178, 8, 12, 8, 1, -12 },
  { 1190, 10, 17, 11, 1, -17 },
  { 1212, 8, 12, 9, 1, -12 },
  { 1224, 12, 22, 6, -3, -17 },
  { 1257, 10, 17, 11, 0, -12 },
  { 1279, 10, 17, 10, 0, -17 },
  { 1301, 6, 16, 5, 0, -16 },
  { 1313, 9, 21, 5, -3, -16 },
  { 1337, 10, 17, 9, 0, -17 },
  { 1359, 6, 17, 5, 0, -17 },
  { 1372, 15, 12, 16, 0, -12 },
  { 1395, 10, 12, 10, 0, -12 },
  { 1410, 9, 12, 10, 1, -12 },
  { 1424, 11, 17, 10, -1, -12 },
  { 1448, 9, 17, 11, 1, -12 },
  { 1468, 8, 12, 7, 0, -12 },
  { 1480, 8, 12, 8, 0, -12 },
  { 1492, 6, 15, 6, 1, -15 },
  { 1504, 9, 12, 10, 1, -12 },
  { 1518, 9, 12, 9, 1, -12 },
  { 1532, 14, 12, 14, 1, -12 },
  { 1553, 11, 12, 9, -1, -12 },
  { 1570, 12, 17, 9, -2, -12 },
  { 1596, 9, 12, 8, -1, -12 },
  { 1610, 9, 19, 7, 0, -16 },
  { 1632, 2, 22, 9, 4, -17 },
  { 1638, 8, 19, 7, -1, -16 },
  { 1657, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC22PT7B_H_
