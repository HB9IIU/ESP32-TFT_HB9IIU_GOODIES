#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC58PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x3F, 0x0F, 0xCF, 0x87,
  0xE3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x47, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFC, 0xE1, 0x80, 0xFC, 0x70,
  0x40, 0x7C, 0x30, 0x00, 0x3E, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x0F, 0x8E,
  0x00, 0x07, 0xC7, 0x00, 0x03, 0xF3, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0xFE, 0x00,
  0x03, 0x3F, 0x00, 0x03, 0x8F, 0x80, 0x01, 0xC7, 0xE0, 0x00, 0xE3, 0xF0,
  0x00, 0x61, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0x38, 0x7C, 0x20, 0x1C, 0x7E,
  0x1E, 0x0E, 0x7E, 0x0F, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x1F,
  0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xC0,
  0x3E, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x01, 0xF0, 0x78, 0x0F,
  0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x7C, 0x01, 0xF0, 0x3C,
  0x0F, 0x00, 0x3E, 0x07, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0xF8, 0x00, 0xF0,
  0x3E, 0x1E, 0x00, 0x1E, 0x07, 0x87, 0xC0, 0x07, 0xC0, 0xF0, 0xF0, 0x00,
  0xF8, 0x3E, 0x3E, 0x00, 0x1F, 0x07, 0x87, 0x87, 0xF3, 0xE0, 0xF1, 0xE1,
  0xFF, 0x7C, 0x3E, 0x7C, 0x7F, 0xEF, 0x87, 0x8F, 0x1F, 0xFE, 0xF1, 0xF3,
  0xE7, 0xC7, 0xDF, 0xFC, 0x78, 0xF0, 0x7B, 0xFF, 0x1F, 0x3E, 0x0F, 0x3F,
  0xC7, 0xC7, 0x81, 0xE3, 0xF0, 0xF0, 0xF0, 0x3C, 0x00, 0x3E, 0x3E, 0x0F,
  0x80, 0x07, 0x87, 0x81, 0xF0, 0x01, 0xF0, 0xF0, 0x3E, 0x00, 0x7C, 0x1E,
  0x07, 0x80, 0x0F, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x1E, 0x00, 0x78,
  0x1E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x78, 0x1E, 0x00,
  0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x3E, 0x3E,
  0x01, 0xF0, 0x07, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x0F,
  0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x7E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x10, 0x3F, 0xF8,
  0x0F, 0x81, 0xFB, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1, 0xF0, 0x7E, 0x1F, 0x87,
  0xC3, 0xF0, 0x7E, 0x3F, 0x0F, 0x80, 0xFC, 0xF8, 0x7E, 0x03, 0xF7, 0xE1,
  0xF8, 0x0F, 0xFF, 0x07, 0xC0, 0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0xFC,
  0x00, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00,
  0x7F, 0xC0, 0x7E, 0x03, 0xFF, 0x01, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xFD,
  0xF8, 0x0F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0x3F,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x20, 0x3C, 0x00, 0xC0, 0xF0, 0x07, 0xC3, 0xC0,
  0x1F, 0xCF, 0x00, 0x7F, 0xF9, 0xFB, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFC, 0x3C, 0x0F, 0xF0, 0x00, 0x7D, 0xE0, 0x03, 0xF7,
  0x80, 0x1F, 0x9F, 0x00, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x03, 0x83, 0xF0,
  0x04, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBE, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x7F, 0x7F, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0x7C, 0x7F, 0x3E, 0x7F, 0x3F,
  0x1F, 0x1F, 0x87, 0x0F, 0xC1, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x78, 0x07, 0xE0, 0x03, 0x00, 0x7F, 0x00,
  0x20, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0xE0, 0x0C, 0x01, 0xFC, 0x02, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x82, 0x00, 0x0F, 0xE0, 0xC0, 0x07, 0xF0, 0x3F, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x3C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78,
  0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xB8, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x3F, 0x83, 0x80, 0x1F,
  0xC0, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x03, 0xF8, 0x08, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x1F, 0xC0, 0x1F, 0xBF, 0xF0, 0x0F, 0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0x7F, 0x83, 0xFC, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x1F, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE1, 0xF8, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00,
  0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x1F, 0x80, 0xFF, 0x1F, 0x80,
  0xFE, 0x1F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0x7E, 0x03, 0xFE, 0x7C, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0xE1, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x80, 0xFE,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF0, 0x7F, 0x0C, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x07, 0xFE, 0x0F, 0x07, 0xC0, 0x7F, 0xF8, 0x78, 0x3C, 0x07, 0xFF,
  0xC3, 0xE3, 0xE0, 0x7C, 0x3C, 0x1F, 0x1E, 0x07, 0xC1, 0xE0, 0xF9, 0xF0,
  0x7C, 0x1F, 0x07, 0x8F, 0x03, 0xC0, 0xF8, 0x3C, 0x78, 0x3E, 0x07, 0x81,
  0xE7, 0xC1, 0xE0, 0x3C, 0x0F, 0x3C, 0x1F, 0x03, 0xE0, 0x79, 0xE0, 0xF0,
  0x1F, 0x03, 0xCF, 0x07, 0x80, 0xF0, 0x3C, 0xF8, 0x3C, 0x07, 0x81, 0xE7,
  0x83, 0xE0, 0x7C, 0x0F, 0x3C, 0x1F, 0x03, 0xE0, 0xF1, 0xE0, 0xF0, 0x1E,
  0x07, 0x8F, 0x07, 0x81, 0xF0, 0x3C, 0x78, 0x3C, 0x0F, 0x83, 0xC3, 0xC1,
  0xF0, 0xFC, 0x3E, 0x1E, 0x0F, 0x8E, 0xF3, 0xE0, 0xF0, 0x3F, 0xF7, 0xFE,
  0x07, 0x81, 0xFF, 0x3F, 0xE0, 0x3C, 0x07, 0xF0, 0xFE, 0x01, 0xE0, 0x04,
  0x00, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x83,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xF8, 0x7F, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07,
  0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFE, 0x07, 0x00, 0x7F, 0x00, 0x20, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x06, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0,
  0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0xFE, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0x03, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0x8F, 0xC0, 0x1F, 0xFE, 0x3F, 0x00,
  0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F,
  0x80, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC,
  0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x01, 0xFF,
  0xC0, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x1F, 0x3E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7E, 0xF8,
  0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x07, 0xCF, 0xC0,
  0x3E, 0x3E, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x7C, 0x3E, 0x01, 0xF8, 0x78, 0x1F, 0x1F, 0x80, 0x7E, 0x1E, 0x0F,
  0x87, 0xE0, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x07, 0xC1, 0xF1, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x3E, 0x0F, 0xC0, 0x3F,
  0x07, 0xCF, 0x83, 0xF0, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x03, 0xE0, 0x7D,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xFE, 0x07,
  0xE0, 0x1F, 0x81, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x7C, 0x01,
  0xF0, 0x1F, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0x3E, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x1F, 0xF0,
  0x01, 0xF8, 0x07, 0xFE, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0xFB,
  0xE0, 0x07, 0xC0, 0x3E, 0xF8, 0x03, 0xF0, 0x0F, 0xBF, 0x00, 0xFC, 0x03,
  0xE7, 0xC0, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0x80, 0x7C, 0x7C, 0x07, 0xE0,
  0x1F, 0x1F, 0x01, 0xF8, 0x07, 0xC7, 0xE0, 0x7E, 0x01, 0xF0, 0xF8, 0x1F,
  0x00, 0xFC, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0,
  0xFC, 0x03, 0xE0, 0x7C, 0x3E, 0x01, 0xF8, 0x1F, 0x0F, 0x80, 0x7E, 0x07,
  0xC3, 0xE0, 0x1F, 0x01, 0xF1, 0xF8, 0x07, 0xC0, 0x7E, 0x7E, 0x01, 0xF0,
  0x0F, 0x9F, 0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x0F,
  0x80, 0x3F, 0x7C, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xFE,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x0F,
  0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x8F, 0xFC,
  0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x3F, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7C,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x1F, 0x80, 0x7F,
  0x00, 0x60, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x20, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xEF, 0xC0, 0x07,
  0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0xF0, 0x07, 0xE3,
  0xF0, 0x07, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x3F, 0x00,
  0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x7C,
  0x07, 0xE0, 0xFC, 0x07, 0xDF, 0x01, 0xF8, 0x3F, 0x01, 0xF7, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF9, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0x80, 0xFC,
  0x0F, 0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x0F, 0xC1, 0xF1,
  0xE0, 0x7C, 0x03, 0xF0, 0xF8, 0x78, 0x3F, 0x00, 0xFC, 0x3E, 0x1E, 0x0F,
  0x80, 0x3F, 0x0F, 0x07, 0x87, 0xE0, 0x0F, 0xC7, 0xC1, 0xE1, 0xF8, 0x03,
  0xF1, 0xF0, 0x78, 0x7C, 0x00, 0xF8, 0xF8, 0x1E, 0x3F, 0x00, 0x3E, 0x3E,
  0x07, 0x8F, 0x80, 0x0F, 0x9F, 0x01, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x79,
  0xF8, 0x00, 0xF9, 0xF0, 0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x07, 0xBF, 0x00,
  0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x03, 0xEF, 0x00, 0x7B, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07,
  0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xC7, 0xC0, 0x7F, 0xF3, 0xE0, 0x7F, 0xFD, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xFC, 0x1F, 0xC7, 0xBE, 0x07,
  0xFF, 0xDF, 0x03, 0xFF, 0xDF, 0x00, 0xFF, 0xCF, 0x80, 0x3F, 0x87, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x7C,
  0x7F, 0x80, 0x1F, 0x3F, 0xF0, 0x0F, 0xDF, 0xFE, 0x03, 0xEF, 0xFF, 0x80,
  0xFF, 0x87, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xF8, 0x1F, 0xC1, 0xFF,
  0x0F, 0xE0, 0x7D, 0xFF, 0xF0, 0x1F, 0x7F, 0xF8, 0x07, 0x8F, 0xFC, 0x03,
  0xE1, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF8, 0x30, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x40, 0xFE, 0x3E, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0xF8, 0xF8, 0x01,
  0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0x0F,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC,
  0x0F, 0xF0, 0x0F, 0xE3, 0xFF, 0x00, 0x7F, 0xFD, 0xE0, 0x07, 0xFF, 0x9E,
  0x00, 0x3F, 0xF3, 0xE0, 0x01, 0xFE, 0x3E, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80,
  0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x7E, 0x03, 0xF1,
  0xF0, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x08, 0x1F, 0xC0, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0x30, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0x1F, 0x00, 0x3F, 0xF9, 0xF0, 0x07, 0xFF, 0xDF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x7F, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x81, 0xFE, 0x01, 0xFC, 0x7F, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xC0, 0x07, 0xFE, 0x7C, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x0C, 0x00, 0x7E, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0x80, 0x0F, 0x8F, 0xF0, 0x07, 0xDF,
  0xFC, 0x07, 0xEF, 0xFF, 0x03, 0xEF, 0xFF, 0x81, 0xFF, 0x0F, 0xC0, 0xFF,
  0x07, 0xE0, 0x7F, 0x01, 0xF0, 0x7F, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x02, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x3E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFB, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC3, 0xFC, 0x1F, 0xF0, 0x07, 0x9F, 0xFC, 0x7F,
  0xF0, 0x1F, 0x7F, 0xF9, 0xFF, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC7, 0xFF, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xF0,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x3F, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC1,
  0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x7C, 0x01, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x0F,
  0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0xFF, 0x00, 0x79, 0xFF, 0xC0, 0x7D, 0xFF, 0xF0, 0x3E,
  0xFF, 0xF8, 0x1F, 0xF0, 0xFC, 0x0F, 0xF0, 0x7E, 0x07, 0xF0, 0x1F, 0x07,
  0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7E,
  0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x07,
  0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xF9, 0xF0, 0x01,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0x80, 0x0F, 0xDF, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x0F, 0x1F, 0xF8,
  0x00, 0xF9, 0xFF, 0xE0, 0x07, 0xDF, 0xFF, 0x00, 0x3F, 0xE1, 0xFC, 0x01,
  0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xF1, 0xFE, 0x00, 0xFB, 0xFF, 0xE0, 0x07, 0xDF,
  0xFE, 0x00, 0x3E, 0x7F, 0xE0, 0x03, 0xF1, 0xFE, 0x00, 0x1F, 0x83, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x7F, 0xF3, 0xE0, 0x7F, 0xFD,
  0xF0, 0x7F, 0xFE, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80,
  0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xFC,
  0x1F, 0xC7, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0x00, 0xFF, 0xCF,
  0x80, 0x3F, 0x8F, 0xC0, 0x02, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x0F, 0xC0, 0x79, 0xFE, 0x07, 0xCF, 0xF0, 0x3E,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xF0, 0x38, 0x3F, 0x00, 0x41, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x20, 0x07, 0xE1, 0xE0,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x20, 0xFF,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0E, 0x00, 0x07, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0,
  0xFC, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3F, 0x8F, 0xF8, 0x1F, 0xFF, 0x7C,
  0x07, 0xFF, 0xBE, 0x03, 0xFF, 0x9F, 0x00, 0xFF, 0x0F, 0x00, 0x06, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x03, 0xF0,
  0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07,
  0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C,
  0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFF,
  0x00, 0xFE, 0x01, 0xFB, 0xE0, 0x1F, 0xC0, 0x3E, 0x7C, 0x07, 0xF8, 0x0F,
  0xCF, 0x80, 0xFF, 0x01, 0xF9, 0xF0, 0x1F, 0xE0, 0x3E, 0x3E, 0x07, 0xBC,
  0x0F, 0xC7, 0xC0, 0xF7, 0x81, 0xF0, 0xF8, 0x3E, 0xF0, 0x7E, 0x1F, 0x07,
  0xBE, 0x0F, 0x83, 0xE1, 0xF7, 0xC1, 0xF0, 0x7C, 0x3E, 0xF8, 0x7E, 0x0F,
  0x87, 0x9F, 0x0F, 0x81, 0xF1, 0xF3, 0xE3, 0xF0, 0x3E, 0x3C, 0x7C, 0x7C,
  0x07, 0xCF, 0x8F, 0x8F, 0x80, 0xF9, 0xF1, 0xF3, 0xE0, 0x1F, 0x3C, 0x3E,
  0x7C, 0x03, 0xEF, 0x87, 0xDF, 0x80, 0x7D, 0xE0, 0xFB, 0xE0, 0x0F, 0x7C,
  0x1F, 0x7C, 0x01, 0xEF, 0x83, 0xFF, 0x00, 0x3D, 0xE0, 0x7F, 0xE0, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x40, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x3F, 0xE0, 0x01,
  0x7F, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFE, 0x80, 0x07, 0xF8, 0x80, 0x00, 0x40,
};

const GFXglyph NotoSans_Condensed_MediumItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 42, 14, 1, -41 },
  { 80, 18, 15, 22, 6, -41 },
  { 114, 29, 41, 29, 1, -41 },
  { 263, 25, 47, 26, 1, -44 },
  { 410, 35, 43, 40, 3, -42 },
  { 599, 30, 43, 30, 0, -42 },
  { 761, 8, 15, 12, 6, -41 },
  { 776, 19, 51, 16, 1, -42 },
  { 898, 18, 51, 16, -4, -42 },
  { 1013, 22, 22, 25, 5, -44 },
  { 1074, 23, 27, 28, 3, -34 },
  { 1152, 12, 15, 13, -3, -7 },
  { 1175, 14, 5, 16, 1, -18 },
  { 1184, 7, 8, 13, 1, -7 },
  { 1191, 28, 42, 21, -3, -42 },
  { 1338, 24, 43, 26, 2, -42 },
  { 1467, 17, 41, 26, 6, -41 },
  { 1555, 28, 42, 26, -2, -42 },
  { 1702, 26, 43, 26, 0, -42 },
  { 1842, 27, 42, 26, -1, -42 },
  { 1984, 26, 42, 26, 0, -41 },
  { 2121, 25, 43, 26, 2, -42 },
  { 2256, 26, 41, 26, 2, -41 },
  { 2390, 26, 43, 26, 0, -42 },
  { 2530, 24, 43, 26, 1, -42 },
  { 2659, 13, 33, 13, 0, -32 },
  { 2713, 16, 40, 13, -3, -32 },
  { 2793, 24, 27, 28, 3, -34 },
  { 2874, 23, 17, 28, 3, -29 },
  { 2923, 24, 27, 28, 3, -34 },
  { 3004, 20, 43, 20, 2, -42 },
  { 3112, 37, 47, 39, 2, -42 },
  { 3330, 28, 42, 27, -4, -42 },
  { 3477, 28, 41, 29, 1, -41 },
  { 3621, 27, 43, 27, 3, -42 },
  { 3767, 29, 41, 31, 1, -41 },
  { 3916, 26, 41, 24, 1, -41 },
  { 4050, 26, 41, 23, 1, -41 },
  { 4184, 30, 43, 32, 3, -42 },
  { 4346, 32, 41, 32, 1, -41 },
  { 4510, 23, 41, 17, -2, -41 },
  { 4628, 24, 52, 14, -9, -41 },
  { 4784, 31, 41, 27, 1, -41 },
  { 4943, 18, 41, 23, 1, -41 },
  { 5036, 42, 41, 42, 1, -41 },
  { 5252, 34, 41, 34, 1, -41 },
  { 5427, 29, 43, 33, 3, -42 },
  { 5583, 27, 41, 27, 1, -41 },
  { 5722, 29, 52, 33, 3, -42 },
  { 5911, 27, 41, 28, 1, -41 },
  { 6050, 27, 43, 25, -1, -42 },
  { 6196, 23, 41, 23, 5, -41 },
  { 6314, 30, 42, 32, 3, -41 },
  { 6472, 27, 41, 27, 5, -41 },
  { 6611, 42, 41, 42, 5, -41 },
  { 6827, 33, 41, 25, -3, -41 },
  { 6997, 25, 41, 24, 5, -41 },
  { 7126, 29, 41, 23, -2, -41 },
  { 7275, 22, 51, 17, -1, -42 },
  { 7416, 11, 42, 21, 6, -42 },
  { 7474, 22, 51, 17, -4, -42 },
  { 7615, 25, 24, 26, 1, -41 },
  { 7690, 20, 4, 19, -5, 5 },
  { 7700, 10, 9, 16, 8, -44 },
  { 7712, 25, 33, 28, 2, -32 },
  { 7816, 26, 45, 28, 0, -44 },
  { 7963, 21, 33, 22, 2, -32 },
  { 8050, 28, 45, 28, 2, -44 },
  { 8208, 22, 33, 25, 2, -32 },
  { 8299, 30, 58, 16, -7, -44 },
  { 8517, 28, 46, 28, -1, -32 },
  { 8678, 25, 44, 27, 0, -44 },
  { 8816, 15, 43, 13, 0, -43 },
  { 8897, 22, 57, 13, -7, -43 },
  { 9054, 27, 44, 24, 0, -44 },
  { 9203, 15, 44, 13, 0, -44 },
  { 9286, 39, 32, 41, 0, -32 },
  { 9442, 25, 32, 27, 0, -32 },
  { 9542, 23, 33, 27, 2, -32 },
  { 9637, 29, 46, 28, -3, -32 },
  { 9804, 25, 46, 28, 2, -32 },
  { 9948, 21, 32, 19, 0, -32 },
  { 10032, 21, 33, 21, 0, -32 },
  { 10119, 16, 39, 16, 2, -38 },
  { 10197, 25, 32, 27, 2, -31 },
  { 10297, 23, 31, 23, 3, -31 },
  { 10387, 35, 31, 36, 4, -31 },
  { 10523, 29, 31, 23, -3, -31 },
  { 10636, 31, 45, 23, -5, -31 },
  { 10811, 23, 31, 20, -2, -31 },
  { 10901, 22, 50, 20, 1, -41 },
  { 11039, 5, 58, 25, 10, -44 },
  { 11076, 22, 50, 20, -3, -41 },
  { 11214, 24, 9, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_MediumItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC58PT7B_H_
