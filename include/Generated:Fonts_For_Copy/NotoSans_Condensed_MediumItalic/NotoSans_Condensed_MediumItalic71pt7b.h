#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC71PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x1F, 0xC1,
  0xFC, 0x7F, 0x0F, 0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF1, 0xFC,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F,
  0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xE3, 0x87, 0x80, 0x3F, 0x8F, 0x03, 0x00,
  0xFE, 0x1E, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x07,
  0xE0, 0xE0, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3F,
  0x8E, 0x00, 0x00, 0x7F, 0x1C, 0x00, 0x00, 0xFF, 0x38, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0x7F, 0x80, 0x00, 0x1C, 0x7F, 0x00, 0x00, 0x38, 0x7F,
  0x00, 0x00, 0x70, 0xFE, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x03, 0x83, 0xF8,
  0x00, 0x07, 0x07, 0xE0, 0x00, 0x0E, 0x0F, 0xC1, 0x00, 0x3C, 0x3F, 0x83,
  0x00, 0x78, 0x7F, 0x07, 0x80, 0xE3, 0xFC, 0x0F, 0xF1, 0xDF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0,
  0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0x80, 0xFC, 0x7E, 0x0F, 0xE1, 0xF0, 0x1F, 0x0F, 0x83, 0xFE,
  0x3E, 0x07, 0xE3, 0xF0, 0xFF, 0xE7, 0xC0, 0xF8, 0x7C, 0x3F, 0xFE, 0xF8,
  0x3F, 0x1F, 0x8F, 0xFF, 0xDF, 0x87, 0xC7, 0xE3, 0xF1, 0xFB, 0xFF, 0xF8,
  0xF8, 0x7C, 0x1F, 0x3F, 0xFE, 0x3F, 0x1F, 0x83, 0xF7, 0xFF, 0x87, 0xC3,
  0xE0, 0x7E, 0x7F, 0xE1, 0xF8, 0xFC, 0x0F, 0xC7, 0xF8, 0x3E, 0x1F, 0x01,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0x03, 0xE0,
  0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0x07, 0xF9, 0xFC, 0x07, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x0F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xC3, 0xF8,
  0x07, 0xF3, 0xF8, 0x3F, 0x00, 0x7F, 0xBF, 0x87, 0xF0, 0x03, 0xFF, 0xF0,
  0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x7E, 0x00, 0x1F,
  0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0x00, 0xFF,
  0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F,
  0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x06, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x3F,
  0xE7, 0xC0, 0x2F, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x9F, 0x00, 0x3F,
  0xC7, 0xE0, 0x1F, 0xE1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0,
  0x0E, 0x03, 0xF8, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xF8,
  0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0xFC, 0x7F,
  0xDF, 0xCF, 0xF9, 0xFC, 0xFF, 0x1F, 0xC7, 0xE1, 0xF8, 0x38, 0x3F, 0x83,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x04, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x20, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x7F, 0x80, 0xE0, 0x01, 0xFF,
  0x80, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x0F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xF9, 0xFF, 0xE0, 0x01, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x00, 0xFF, 0x80, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x7F,
  0xF0, 0x03, 0xFB, 0xFF, 0xF0, 0x07, 0xEF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0x83, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xC0,
  0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xDF, 0xC0, 0x1F, 0xFC, 0x7F, 0x00, 0x3F, 0xE1, 0xF8,
  0x00, 0x08, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x03, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1E,
  0x01, 0xFE, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xFC, 0x03, 0xE0,
  0x7C, 0x00, 0xFF, 0xFC, 0x1F, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0xF8, 0x3E,
  0x01, 0xFF, 0xFE, 0x07, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x3E, 0x1F, 0x00,
  0xFC, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x8F, 0x80, 0xFC,
  0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF9, 0xF0, 0x3F, 0x00, 0xF8,
  0x0F, 0x8F, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0xFC, 0x0F, 0x80, 0x7E, 0x03,
  0xE7, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF9,
  0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0x7C,
  0x0F, 0x80, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x3F, 0x03,
  0xE0, 0x3F, 0x01, 0xF1, 0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x0F, 0x80, 0xF8,
  0x1F, 0xC1, 0xF8, 0x7C, 0x07, 0xE1, 0xFE, 0x1F, 0x83, 0xE0, 0x3F, 0xBE,
  0xF9, 0xF8, 0x1F, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F,
  0xDF, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xC1,
  0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xF0, 0x01, 0xFF,
  0x00, 0x08, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x3F,
  0xF0, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x1C,
  0x00, 0xFF, 0x80, 0x00, 0x20, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC3, 0xF8, 0x00, 0xFF, 0xFC, 0x1F,
  0xC0, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xFF, 0x07, 0xF0, 0x01, 0xFF,
  0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x06, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF8, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0,
  0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x01, 0xF9,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x0F,
  0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xF1, 0xF8,
  0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87,
  0xE0, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xE1, 0xFC, 0x1F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E,
  0x00, 0x7F, 0x03, 0xF1, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x3F, 0x03,
  0xF8, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xEF,
  0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0x7F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xF0,
  0x03, 0xF7, 0xE0, 0x01, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xE0, 0x07, 0xF7, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x03,
  0xF8, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x03, 0xF8,
  0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0x07, 0xF3, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE0, 0x03, 0xFB, 0xF0, 0x03, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x80,
  0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0xFC, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xC1, 0xF8, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0xFF, 0x00, 0x02, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x10, 0x00, 0x0F, 0xF0, 0x0E, 0x00, 0x0F, 0xF8, 0x07,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF7, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xDF, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x1F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E,
  0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0x81, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7E, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0xFC,
  0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x00, 0xFD,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x00,
  0xFD, 0xF0, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x01, 0x00, 0x1F, 0xF8, 0x3E, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F,
  0xFE, 0x7E, 0x00, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x80, 0x7F, 0x87,
  0xFF, 0x80, 0x7F, 0xFF, 0xBF, 0x00, 0x3F, 0xFF, 0x3F, 0x00, 0x3F, 0xFF,
  0x3F, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFE, 0x3F, 0xF0, 0x00, 0xFE,
  0x7F, 0xF8, 0x00, 0xFE, 0xFF, 0xFC, 0x00, 0xFD, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xC1, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xF8, 0x7F, 0xC0, 0x7E, 0xFF, 0xFF, 0x80, 0x7E, 0xFF,
  0xFF, 0x00, 0x7E, 0x7F, 0xFE, 0x00, 0x7C, 0x3F, 0xFC, 0x00, 0xFC, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xE0, 0x70, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x30, 0x1F, 0xF8, 0x7C, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x07, 0xFF, 0x9F, 0xC0, 0x01,
  0xFF, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0x87,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0xFC, 0x00, 0x1F,
  0xFF, 0x9F, 0x80, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x1F, 0xF0, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x3F,
  0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0C, 0x0F, 0xF8, 0x07, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x7F, 0xE0,
  0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0x00, 0x07, 0xFF, 0xE7, 0xE0, 0x01, 0xFF,
  0xFC, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xDF,
  0x80, 0x07, 0xFF, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0xFE, 0x00, 0x07, 0xFF,
  0x1F, 0xC0, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x04, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFE, 0x3F, 0xF0, 0x01, 0xFC, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xF0, 0x07,
  0xEF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xC0, 0x7F,
  0xE0, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x0F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x1F, 0x9F, 0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x07, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xC0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFC,
  0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x01, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0xE0, 0x03, 0xF1, 0xFF, 0xE0, 0x07, 0xE7,
  0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01,
  0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x0F, 0xCF, 0xFF,
  0xC0, 0x01, 0xFB, 0xFF, 0xFC, 0x00, 0x3E, 0xFF, 0xFF, 0x80, 0x0F, 0xDE,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xF7, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0xFC,
  0x00, 0x1F, 0x8F, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0x80, 0x00, 0xFE, 0x03,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x7C, 0x00, 0xFF, 0xF1, 0xF8,
  0x03, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0x87, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xF7, 0xF0, 0x03,
  0xFF, 0x8F, 0xE0, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0xE0, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xF0, 0x0F, 0xC7, 0xFC, 0x03,
  0xF3, 0xFE, 0x00, 0xFD, 0xFF, 0x80, 0x7E, 0xFF, 0xE0, 0x1F, 0xBF, 0xF0,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x70, 0x1F, 0xC0, 0x04, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x82, 0x00, 0x0F, 0xE0, 0xC0, 0x07, 0xF8, 0x3E, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC1, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x38, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xFC,
  0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0,
  0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0x7E, 0x01,
  0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xC3, 0xE0, 0x03,
  0xFF, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFB, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xC7, 0xF0,
  0x0F, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xFF, 0x80, 0x7E, 0x1F, 0xC0, 0x7D,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xBE, 0x03, 0xF8, 0x7F, 0x03, 0xF7, 0xC0,
  0x7E, 0x0F, 0xE0, 0x7C, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0x9F, 0x03, 0xF0,
  0x3F, 0x83, 0xE3, 0xE0, 0xFE, 0x07, 0xF0, 0xFC, 0x7C, 0x1F, 0xC0, 0xFE,
  0x1F, 0x8F, 0x83, 0xF0, 0x1F, 0xC3, 0xE1, 0xF0, 0xFE, 0x03, 0xF8, 0xFC,
  0x3E, 0x1F, 0x80, 0x7F, 0x1F, 0x07, 0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0xF8,
  0xFC, 0x01, 0xFC, 0xFC, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x03, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x0F, 0x9F, 0x80, 0x1F,
  0xBF, 0x01, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x00, 0x7E, 0xF8,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x04, 0x7F, 0xF0, 0x00, 0x37, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xB8,
  0x00, 0xFF, 0xFC, 0xC0, 0x00, 0xFF, 0xE2, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 18, 52, 18, 1, -51 },
  { 118, 22, 19, 26, 7, -51 },
  { 171, 36, 51, 36, 1, -51 },
  { 401, 31, 58, 32, 1, -54 },
  { 626, 43, 52, 49, 4, -51 },
  { 906, 36, 52, 37, 0, -51 },
  { 1140, 10, 19, 15, 7, -51 },
  { 1164, 22, 62, 19, 2, -51 },
  { 1335, 22, 62, 20, -5, -51 },
  { 1506, 26, 28, 30, 7, -54 },
  { 1597, 29, 34, 34, 3, -42 },
  { 1721, 14, 17, 16, -3, -8 },
  { 1751, 17, 6, 20, 1, -22 },
  { 1764, 9, 10, 16, 1, -9 },
  { 1776, 34, 51, 25, -3, -51 },
  { 1993, 29, 52, 32, 2, -51 },
  { 2182, 20, 51, 32, 8, -51 },
  { 2310, 33, 51, 32, -2, -51 },
  { 2521, 32, 52, 32, 0, -51 },
  { 2729, 33, 51, 32, -1, -51 },
  { 2940, 32, 52, 32, 0, -51 },
  { 3148, 31, 52, 32, 2, -51 },
  { 3350, 32, 51, 32, 3, -51 },
  { 3554, 31, 52, 32, 1, -51 },
  { 3756, 30, 52, 32, 1, -51 },
  { 3951, 16, 40, 16, 0, -39 },
  { 4031, 20, 48, 16, -4, -39 },
  { 4151, 29, 33, 34, 3, -42 },
  { 4271, 29, 20, 34, 3, -35 },
  { 4344, 30, 33, 34, 3, -42 },
  { 4468, 25, 52, 24, 2, -51 },
  { 4631, 45, 57, 48, 2, -51 },
  { 4952, 33, 51, 33, -4, -51 },
  { 5163, 34, 51, 35, 1, -51 },
  { 5380, 34, 52, 33, 3, -51 },
  { 5601, 36, 51, 38, 1, -51 },
  { 5831, 32, 51, 30, 1, -51 },
  { 6035, 32, 51, 28, 1, -51 },
  { 6239, 37, 52, 39, 3, -51 },
  { 6480, 40, 51, 39, 1, -51 },
  { 6735, 29, 51, 21, -3, -51 },
  { 6920, 30, 65, 17, -11, -51 },
  { 7164, 38, 51, 33, 1, -51 },
  { 7407, 22, 51, 28, 1, -51 },
  { 7548, 51, 51, 51, 1, -51 },
  { 7874, 42, 51, 42, 1, -51 },
  { 8142, 36, 52, 41, 3, -51 },
  { 8376, 33, 51, 33, 1, -51 },
  { 8587, 36, 63, 41, 3, -51 },
  { 8871, 33, 51, 34, 1, -51 },
  { 9082, 33, 52, 30, -1, -51 },
  { 9297, 28, 51, 29, 6, -51 },
  { 9476, 37, 52, 39, 3, -51 },
  { 9717, 33, 51, 33, 6, -51 },
  { 9928, 52, 51, 52, 6, -51 },
  { 10260, 40, 51, 31, -4, -51 },
  { 10515, 30, 51, 30, 6, -51 },
  { 10707, 35, 51, 29, -2, -51 },
  { 10931, 28, 62, 20, -2, -51 },
  { 11148, 13, 51, 25, 7, -51 },
  { 11231, 27, 62, 20, -5, -51 },
  { 11441, 31, 30, 32, 1, -51 },
  { 11558, 24, 5, 24, -6, 6 },
  { 11573, 12, 11, 19, 10, -54 },
  { 11590, 32, 40, 34, 2, -39 },
  { 11750, 32, 55, 34, 0, -54 },
  { 11970, 26, 40, 26, 2, -39 },
  { 12100, 35, 55, 34, 2, -54 },
  { 12341, 27, 40, 31, 2, -39 },
  { 12476, 36, 71, 19, -8, -54 },
  { 12796, 35, 56, 34, -1, -39 },
  { 13041, 31, 54, 34, 0, -54 },
  { 13251, 18, 53, 16, 0, -53 },
  { 13371, 27, 70, 16, -9, -53 },
  { 13608, 33, 54, 30, 0, -54 },
  { 13831, 19, 54, 16, 0, -54 },
  { 13960, 48, 39, 50, 0, -39 },
  { 14194, 31, 39, 34, 0, -39 },
  { 14346, 29, 40, 33, 2, -39 },
  { 14491, 35, 56, 34, -3, -39 },
  { 14736, 31, 56, 34, 2, -39 },
  { 14953, 26, 39, 23, 0, -39 },
  { 15080, 26, 40, 26, 0, -39 },
  { 15210, 19, 48, 20, 3, -47 },
  { 15324, 31, 39, 34, 2, -38 },
  { 15476, 28, 38, 28, 4, -38 },
  { 15609, 43, 38, 44, 4, -38 },
  { 15814, 34, 38, 29, -3, -38 },
  { 15976, 38, 55, 28, -6, -38 },
  { 16238, 28, 38, 25, -2, -38 },
  { 16371, 27, 62, 24, 1, -51 },
  { 16581, 6, 71, 30, 12, -54 },
  { 16635, 27, 62, 24, -4, -51 },
  { 16845, 30, 10, 34, 3, -30 },
};

const GFXfont NotoSans_Condensed_MediumItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC71PT7B_H_
