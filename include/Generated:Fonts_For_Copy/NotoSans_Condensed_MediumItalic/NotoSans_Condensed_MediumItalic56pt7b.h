#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC56PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x20,
  0x00, 0x3E, 0x1F, 0x9F, 0x0F, 0x9F, 0x87, 0xCF, 0xC3, 0xE7, 0xC3, 0xF3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F,
  0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x08, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xE3, 0x0E, 0x07, 0xC7, 0x04, 0x07, 0xC7, 0x00, 0x0F,
  0x87, 0x00, 0x0F, 0x86, 0x00, 0x0F, 0x86, 0x00, 0x0F, 0xCE, 0x00, 0x0F,
  0xCE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3B, 0xF0, 0x00, 0x39, 0xF8, 0x00, 0x31, 0xF8, 0x00,
  0x30, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0x71, 0xF0, 0x80,
  0x61, 0xF0, 0xE0, 0x63, 0xF0, 0xFC, 0xEF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x7F,
  0xC0, 0x03, 0xC0, 0x3F, 0xF8, 0x01, 0xE0, 0x0F, 0xBE, 0x00, 0xF8, 0x07,
  0xC7, 0x80, 0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0x80,
  0x3C, 0x1F, 0x03, 0xC0, 0x0F, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x3E, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x87,
  0x80, 0x0F, 0x83, 0xE1, 0xE0, 0x03, 0xE0, 0xF0, 0xF0, 0x00, 0xF0, 0x3C,
  0x7C, 0x08, 0x3C, 0x0F, 0x1E, 0x1F, 0xCF, 0x07, 0x8F, 0x9F, 0xF3, 0xC1,
  0xE3, 0xC7, 0xFE, 0xF8, 0xF1, 0xE3, 0xEF, 0xBF, 0x7C, 0xF9, 0xF1, 0xF7,
  0xFE, 0x3C, 0x78, 0x7D, 0xFF, 0x1F, 0x3E, 0x1F, 0x3F, 0x87, 0x8F, 0x07,
  0xC1, 0x83, 0xC3, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x7C, 0x00, 0x78, 0x78,
  0x1E, 0x00, 0x3E, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x81, 0xE0, 0x07, 0x83,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x3E, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x7C,
  0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC1, 0xF0, 0x0F, 0x80, 0xF0, 0x78, 0x07,
  0xC0, 0x3E, 0x3E, 0x01, 0xE0, 0x07, 0xDF, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x3C, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFC, 0x1F, 0xFE, 0x07,
  0xC1, 0xF9, 0xF0, 0x7E, 0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC1, 0xF9, 0xF0, 0xFC, 0x0F, 0xCF, 0x87, 0xC0, 0x3F, 0xF8, 0x3E, 0x01,
  0xFF, 0xC1, 0xF0, 0x07, 0xFC, 0x1F, 0x80, 0x3F, 0xE0, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x07, 0xFC, 0x07,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xFE, 0x03, 0xFF,
  0xC3, 0xF0, 0x0F, 0xFC, 0x1F, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x10, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0xCF, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xBF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0xC0,
  0x3F, 0x1E, 0x03, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x38, 0x1F, 0x00, 0x80,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0x3C, 0xFB, 0xFF, 0xFF, 0xDF, 0xBE, 0x10, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3F,
  0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3E,
  0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0xCF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0xFC, 0x00,
  0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xE7, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x7C, 0xFE, 0x7C, 0x78, 0x7C,
  0x30, 0xFC, 0x20, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0x01, 0xFC, 0x03, 0x80, 0x3F,
  0x00, 0x40, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0x00, 0xFE, 0x01, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x20, 0x00,
  0xFC, 0x10, 0x00, 0xFE, 0x0F, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x79, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC3,
  0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7E,
  0x03, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF2, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x20, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x40, 0x01, 0xF8, 0x30, 0x03, 0xFC, 0x1F,
  0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0x82, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0xC0, 0x3E, 0x7F,
  0xE0, 0x3E, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC3, 0xF0, 0x7F, 0x81,
  0xF8, 0x7F, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC7, 0xE0, 0x1F, 0xC1, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xF0,
  0x7F, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x1F, 0x00, 0xFE, 0x1F, 0x00, 0xFE, 0x1F, 0x81, 0xFE, 0x1F, 0xC7, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x7C, 0x07, 0xFE, 0xFC, 0x03, 0xF8, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xC0, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1E, 0x1F, 0xC3, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x3F, 0xE0, 0xF0, 0xF0,
  0x1F, 0xFE, 0x1E, 0x3E, 0x07, 0xFF, 0x83, 0xC7, 0x81, 0xF0, 0xF0, 0x78,
  0xF0, 0x7C, 0x1E, 0x0F, 0x3C, 0x0F, 0x03, 0xC1, 0xE7, 0x83, 0xC0, 0xF0,
  0x3D, 0xF0, 0x78, 0x1E, 0x07, 0xBC, 0x1E, 0x03, 0xC0, 0xF7, 0x83, 0xC0,
  0xF8, 0x1E, 0xF0, 0x78, 0x1E, 0x07, 0xBE, 0x1E, 0x03, 0xC0, 0xF7, 0x83,
  0xC0, 0x78, 0x1E, 0xF0, 0x78, 0x1F, 0x07, 0x9E, 0x0F, 0x03, 0xE0, 0xF3,
  0xC1, 0xE0, 0x78, 0x1E, 0x78, 0x3C, 0x1F, 0x07, 0x8F, 0x07, 0x83, 0xE1,
  0xF1, 0xE0, 0xF0, 0xFC, 0x3C, 0x3C, 0x1F, 0xFB, 0xFF, 0x07, 0x81, 0xFE,
  0x7F, 0xC0, 0xF0, 0x3F, 0x87, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x10,
  0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F,
  0x80, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x0F, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE,
  0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xE0, 0x3F, 0xC0, 0x10, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0x00, 0x7F, 0xCF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0x03, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0xC0, 0x7C, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x08, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xF0, 0x07, 0xF8, 0x03,
  0x80, 0x7F, 0x00, 0x04, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x8F,
  0xC0, 0x1F, 0xFC, 0x7E, 0x00, 0xFF, 0xE3, 0xF0, 0x0F, 0xFE, 0x1F, 0x80,
  0x7F, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xFE, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0,
  0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0,
  0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x01,
  0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x10, 0x7F, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE,
  0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x07, 0xCF, 0x00, 0x3E, 0xFC,
  0x07, 0xCF, 0x00, 0x3E, 0xF8, 0x07, 0xCF, 0x00, 0x7C, 0xF8, 0x07, 0xCF,
  0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0xF9, 0xF8, 0x0F, 0x8F, 0x00, 0xF9,
  0xF8, 0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0x1F, 0x0F, 0x83,
  0xC3, 0xF0, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x1F, 0x0F, 0x87, 0xC3, 0xE0,
  0x1F, 0x0F, 0x8F, 0x83, 0xE0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x3E, 0x0F,
  0x9F, 0x07, 0xC0, 0x3E, 0x0F, 0x9F, 0x07, 0xC0, 0x3E, 0x0F, 0xBE, 0x07,
  0xC0, 0x3E, 0x07, 0xBE, 0x07, 0xC0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x0F, 0xC0,
  0x7F, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x03, 0xE0, 0x1F, 0xE0, 0x01, 0xF0,
  0x0F, 0xF8, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0x7C,
  0x03, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0xFB, 0xE0, 0x1F,
  0x80, 0x7D, 0xF0, 0x0F, 0x80, 0x7C, 0xF8, 0x07, 0xC0, 0x3E, 0x7C, 0x03,
  0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x0F, 0x8F, 0x81, 0xF8, 0x07, 0xC7, 0xC0,
  0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x3E, 0x01, 0xF0, 0x7C,
  0x3F, 0x00, 0xF8, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x0F, 0x80, 0x7C, 0x0F,
  0x87, 0xC0, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x80,
  0xF9, 0xF0, 0x0F, 0xC0, 0x7C, 0xF8, 0x07, 0xC0, 0x3E, 0x7C, 0x03, 0xE0,
  0x0F, 0xBE, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x3F, 0xE0, 0x1F,
  0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0x80, 0x07, 0xF8, 0x07,
  0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F,
  0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0xE0, 0x1F,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3E, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xDF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x05, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0xE0, 0x1F, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC1, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0xE0, 0x0F, 0xC0,
  0x04, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x01, 0x00, 0x0F, 0xE0, 0x38, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07,
  0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03,
  0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xF8,
  0x00, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0xF8, 0x00, 0xFE,
  0x00, 0x7E, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0xF8, 0x01, 0xFE, 0x00, 0xFC,
  0xF8, 0x01, 0xFE, 0x00, 0xF8, 0xF8, 0x03, 0xFE, 0x01, 0xF8, 0xF8, 0x03,
  0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x03,
  0xF0, 0xF8, 0x07, 0xBE, 0x03, 0xE0, 0xF8, 0x0F, 0xBE, 0x07, 0xE0, 0xF8,
  0x0F, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x3E,
  0x0F, 0xC0, 0xF8, 0x1E, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x3E, 0x1F, 0x80,
  0xF8, 0x3C, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x3C, 0x1F, 0x00, 0xF8, 0x7C,
  0x3C, 0x3F, 0x00, 0xF8, 0xF8, 0x3C, 0x3E, 0x00, 0xF8, 0xF8, 0x3C, 0x7E,
  0x00, 0xF8, 0xF0, 0x3C, 0x7C, 0x00, 0xF9, 0xF0, 0x3C, 0x7C, 0x00, 0xF9,
  0xF0, 0x3C, 0xFC, 0x00, 0xFB, 0xE0, 0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x3D,
  0xF8, 0x00, 0xFB, 0xC0, 0x3D, 0xF0, 0x00, 0xFF, 0xC0, 0x3D, 0xF0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x81, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7B, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x03,
  0xE0, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x78, 0x0F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x3C,
  0x1F, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x0F, 0x01, 0xFF, 0x9F,
  0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xDF, 0x0F, 0xE1, 0xFE, 0x0F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x07, 0xF0, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x3F, 0xE0,
  0x7F, 0xFB, 0xE0, 0x7F, 0xF3, 0xE0, 0x3F, 0xE3, 0xC0, 0x1F, 0xC3, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x0F, 0x9F, 0xE0, 0x0F,
  0xDF, 0xF8, 0x07, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xC1,
  0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xFC,
  0x0F, 0xC1, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xE0, 0x3C,
  0xFF, 0xE0, 0x3E, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x04,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x20, 0xFF, 0x0E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xC1,
  0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x7F, 0xE7, 0xC0, 0x1F, 0xFE, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0xFE, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x8F, 0xF8, 0x03, 0xFF, 0xDF, 0x00, 0x7F, 0xF3, 0xE0, 0x07,
  0xFC, 0x78, 0x00, 0x7F, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xF0, 0xFC, 0x3F, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0x3E, 0x1F, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x04, 0x1F, 0x80, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFC, 0x3C, 0x00, 0xFF, 0xCF, 0x80, 0x3F, 0xFD, 0xF0, 0x0F,
  0xFF, 0xBE, 0x03, 0xF8, 0x7F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0,
  0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07,
  0xC0, 0x3F, 0x80, 0xF8, 0x07, 0xF0, 0x1F, 0x01, 0xFC, 0x03, 0xF0, 0x7F,
  0x80, 0x7F, 0x1F, 0xF0, 0x0F, 0xFF, 0xBE, 0x00, 0xFF, 0xEF, 0xC0, 0x0F,
  0xF9, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x02, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x03, 0xF8, 0x07, 0xC1, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x0F, 0x9F, 0xE0, 0x0F, 0xDF,
  0xF8, 0x07, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0x80, 0xFE,
  0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0,
  0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07,
  0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x23, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87,
  0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x8F, 0xF0, 0x3F, 0xC0, 0x3E,
  0x7F, 0xE3, 0xFF, 0x80, 0xFB, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF0, 0xFF, 0xC7, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xC1, 0xFC,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x7E, 0x01,
  0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x07, 0xC1,
  0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF1, 0xFE, 0x00,
  0xF9, 0xFF, 0x80, 0x7D, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE1, 0xF8,
  0x1F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x0F,
  0x81, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3F,
  0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07,
  0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0x1F, 0xE0, 0x03, 0xE7, 0xFE, 0x00, 0x7D, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xC0, 0x7F, 0xC7, 0xF0, 0x0F, 0xBF, 0xFE, 0x01, 0xF7, 0xFF, 0x80,
  0x3E, 0x7F, 0xE0, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0x10, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x0F, 0x01, 0xFF, 0x9F,
  0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xDF, 0x0F, 0xE1, 0xFE, 0x0F, 0xC0, 0xFE,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x07, 0xF0, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x3F, 0xE0,
  0xFF, 0xFB, 0xE0, 0x7F, 0xF7, 0xE0, 0x3F, 0xE7, 0xC0, 0x1F, 0xC7, 0xC0,
  0x02, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x1F, 0x80, 0xF9, 0xFC, 0x07,
  0xDF, 0xE0, 0x3F, 0xFF, 0x01, 0xEF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xE0, 0x30, 0x3E, 0x00, 0x83, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x84, 0x01, 0xFC, 0x3C, 0x1F, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x20, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x04, 0x00, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F, 0xE0, 0xFF,
  0xFB, 0xC0, 0x7F, 0xF3, 0xC0, 0x7F, 0xE3, 0xC0, 0x3F, 0xC7, 0xC0, 0x06,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x01, 0xF0,
  0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x7F,
  0x00, 0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0xFC, 0x0F, 0xF0, 0x1F, 0x3E, 0x03,
  0xFC, 0x07, 0xCF, 0x80, 0xFF, 0x03, 0xE3, 0xE0, 0x7B, 0xC0, 0xF8, 0xF8,
  0x1E, 0xF0, 0x7E, 0x3E, 0x0F, 0xBC, 0x1F, 0x0F, 0x83, 0xCF, 0x07, 0xC3,
  0xE1, 0xF3, 0xC3, 0xE0, 0xF8, 0x78, 0xF0, 0xF8, 0x3E, 0x1E, 0x3C, 0x7C,
  0x0F, 0x8F, 0x8F, 0x1F, 0x03, 0xE3, 0xC3, 0xC7, 0xC0, 0xF9, 0xF0, 0xF3,
  0xE0, 0x3E, 0x78, 0x3C, 0xF8, 0x0F, 0x9E, 0x0F, 0x7C, 0x03, 0xEF, 0x83,
  0xDF, 0x00, 0xFB, 0xC0, 0xF7, 0x80, 0x3E, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x03,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x02, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xA0, 0x07, 0xFE, 0x40, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_MediumItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 41, 14, 1, -40 },
  { 73, 17, 14, 21, 6, -40 },
  { 103, 29, 40, 28, 0, -40 },
  { 248, 24, 46, 25, 1, -43 },
  { 386, 34, 42, 39, 3, -41 },
  { 565, 29, 42, 29, 0, -41 },
  { 718, 8, 14, 12, 6, -40 },
  { 732, 18, 49, 15, 1, -40 },
  { 843, 18, 49, 15, -4, -40 },
  { 954, 21, 22, 24, 5, -43 },
  { 1012, 23, 27, 27, 3, -33 },
  { 1090, 11, 14, 13, -3, -7 },
  { 1110, 14, 5, 16, 1, -18 },
  { 1119, 7, 8, 13, 1, -7 },
  { 1126, 27, 40, 20, -3, -40 },
  { 1261, 23, 42, 25, 2, -41 },
  { 1382, 16, 40, 25, 6, -40 },
  { 1462, 26, 41, 25, -1, -41 },
  { 1596, 25, 42, 25, 0, -41 },
  { 1728, 26, 40, 25, -1, -40 },
  { 1858, 25, 41, 25, 0, -40 },
  { 1987, 24, 42, 25, 2, -41 },
  { 2113, 25, 40, 25, 2, -40 },
  { 2238, 25, 42, 25, 0, -41 },
  { 2370, 24, 42, 25, 1, -41 },
  { 2496, 12, 32, 13, 0, -31 },
  { 2544, 15, 38, 13, -3, -31 },
  { 2616, 23, 26, 27, 3, -33 },
  { 2691, 22, 16, 27, 3, -28 },
  { 2735, 23, 26, 27, 3, -33 },
  { 2810, 19, 42, 19, 2, -41 },
  { 2910, 35, 45, 38, 2, -40 },
  { 3107, 26, 40, 26, -3, -40 },
  { 3237, 27, 40, 28, 1, -40 },
  { 3372, 26, 42, 26, 3, -41 },
  { 3509, 28, 40, 30, 1, -40 },
  { 3649, 25, 40, 24, 1, -40 },
  { 3774, 25, 40, 22, 1, -40 },
  { 3899, 29, 42, 31, 3, -41 },
  { 4052, 31, 40, 31, 1, -40 },
  { 4207, 22, 40, 17, -2, -40 },
  { 4317, 23, 51, 13, -8, -40 },
  { 4464, 30, 40, 26, 1, -40 },
  { 4614, 17, 40, 22, 1, -40 },
  { 4699, 40, 40, 40, 1, -40 },
  { 4899, 33, 40, 33, 1, -40 },
  { 5064, 28, 42, 32, 3, -41 },
  { 5211, 26, 40, 26, 1, -40 },
  { 5341, 28, 51, 32, 3, -41 },
  { 5520, 26, 40, 27, 1, -40 },
  { 5650, 27, 42, 24, -1, -41 },
  { 5792, 22, 40, 23, 5, -40 },
  { 5902, 29, 41, 30, 3, -40 },
  { 6051, 26, 40, 26, 5, -40 },
  { 6181, 40, 40, 41, 5, -40 },
  { 6381, 32, 40, 25, -3, -40 },
  { 6541, 24, 40, 24, 5, -40 },
  { 6661, 28, 40, 23, -2, -40 },
  { 6801, 21, 49, 16, -1, -40 },
  { 6930, 10, 40, 20, 6, -40 },
  { 6980, 22, 49, 16, -4, -40 },
  { 7115, 24, 23, 26, 1, -40 },
  { 7184, 20, 3, 19, -5, 5 },
  { 7192, 9, 9, 15, 8, -43 },
  { 7203, 24, 32, 27, 2, -31 },
  { 7299, 25, 44, 27, 0, -43 },
  { 7437, 20, 32, 21, 2, -31 },
  { 7517, 27, 44, 27, 2, -43 },
  { 7666, 21, 32, 24, 2, -31 },
  { 7750, 29, 56, 15, -7, -43 },
  { 7953, 27, 44, 27, -1, -31 },
  { 8102, 25, 43, 26, 0, -43 },
  { 8237, 14, 42, 12, 0, -42 },
  { 8311, 21, 55, 13, -7, -42 },
  { 8456, 26, 43, 24, 0, -43 },
  { 8596, 15, 43, 12, 0, -43 },
  { 8677, 38, 31, 40, 0, -31 },
  { 8825, 25, 31, 26, 0, -31 },
  { 8922, 22, 32, 26, 2, -31 },
  { 9010, 27, 44, 27, -2, -31 },
  { 9159, 24, 44, 27, 2, -31 },
  { 9291, 21, 31, 18, 0, -31 },
  { 9373, 21, 32, 20, 0, -31 },
  { 9457, 16, 38, 16, 2, -37 },
  { 9533, 24, 31, 26, 2, -30 },
  { 9626, 22, 30, 22, 3, -30 },
  { 9709, 34, 30, 35, 3, -30 },
  { 9837, 28, 30, 23, -3, -30 },
  { 9942, 30, 43, 22, -5, -30 },
  { 10104, 23, 30, 19, -2, -30 },
  { 10191, 21, 49, 19, 1, -40 },
  { 10320, 4, 56, 24, 10, -43 },
  { 10348, 21, 49, 19, -3, -40 },
  { 10477, 23, 8, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_MediumItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC56PT7B_H_
