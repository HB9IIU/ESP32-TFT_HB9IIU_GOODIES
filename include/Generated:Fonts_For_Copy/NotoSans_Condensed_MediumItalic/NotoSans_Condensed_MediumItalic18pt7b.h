#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCC, 0x63, 0x18, 0x8C, 0x60, 0x01, 0x8C, 0x00, 0xDE, 0xF7,
  0x29, 0x00, 0x0D, 0x84, 0x82, 0x43, 0x27, 0xF8, 0x90, 0x48, 0x6C, 0xFF,
  0x12, 0x1B, 0x09, 0x04, 0x80, 0x04, 0x04, 0x1F, 0x35, 0x28, 0x28, 0x38,
  0x1C, 0x0E, 0x16, 0x16, 0xDE, 0xFC, 0x10, 0x20, 0x30, 0xCD, 0x11, 0x24,
  0x65, 0x89, 0xA1, 0x2D, 0xAD, 0x5B, 0x7B, 0x0A, 0x62, 0x4C, 0xC9, 0x11,
  0x66, 0x38, 0x0E, 0x0D, 0x84, 0xC6, 0x41, 0x60, 0xE0, 0xE0, 0xDB, 0x4D,
  0x63, 0xB1, 0x99, 0xE7, 0xB0, 0xFE, 0x80, 0x0C, 0x21, 0x8C, 0x21, 0x86,
  0x10, 0x43, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x18, 0xC2, 0x10, 0x84, 0x21,
  0x18, 0xC4, 0x63, 0x31, 0x10, 0x10, 0x4D, 0x1F, 0x73, 0x65, 0x80, 0x10,
  0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x36, 0x6C, 0x7F, 0x80, 0xF0,
  0x01, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x0C, 0x00, 0x1C, 0x7D, 0x9B, 0x3C, 0x78, 0xF1, 0xC2, 0x8D, 0x1A,
  0x26, 0xCF, 0x00, 0x19, 0xDF, 0xA1, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x00,
  0x1E, 0x3F, 0x23, 0x03, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xFC,
  0xFC, 0x1E, 0x3F, 0x03, 0x03, 0x03, 0x0E, 0x38, 0x0E, 0x06, 0x06, 0x06,
  0x9C, 0xF8, 0x03, 0x07, 0x0F, 0x0A, 0x1E, 0x36, 0x26, 0x44, 0xC5, 0xFE,
  0x0C, 0x0C, 0x08, 0x1F, 0x1F, 0x30, 0x30, 0x20, 0x3C, 0x7E, 0x06, 0x06,
  0x06, 0x06, 0x9C, 0xF8, 0x0E, 0x7C, 0x83, 0x04, 0x1F, 0xBB, 0x62, 0x85,
  0x1A, 0x36, 0xC7, 0x00, 0x7F, 0x7E, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x1E, 0x3B, 0x33, 0x33, 0x33, 0x1E, 0x1C,
  0x66, 0x46, 0xC6, 0xC6, 0xEE, 0x7C, 0x1E, 0x3F, 0x33, 0x63, 0x63, 0x63,
  0x67, 0x3A, 0x06, 0x06, 0x0C, 0x98, 0xF0, 0x33, 0x20, 0x00, 0x00, 0xCC,
  0x18, 0xC4, 0x00, 0x00, 0x00, 0x33, 0x11, 0x80, 0x02, 0x0C, 0x73, 0x8C,
  0x0E, 0x07, 0x03, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x81, 0x81, 0xC0,
  0xE0, 0x63, 0x9C, 0x60, 0x80, 0x79, 0xF0, 0xC3, 0x18, 0xC2, 0x18, 0x40,
  0x00, 0x30, 0xC0, 0x07, 0x83, 0x18, 0xC1, 0xB0, 0x14, 0xF3, 0xB2, 0x64,
  0xCC, 0x93, 0xB2, 0x56, 0xDA, 0x6E, 0x40, 0x0C, 0x00, 0xFC, 0x06, 0x00,
  0x03, 0x07, 0x07, 0x0F, 0x0B, 0x1B, 0x1B, 0x33, 0x3F, 0x63, 0x61, 0x41,
  0xC1, 0x1F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0xB8, 0xF8, 0xC6, 0x63, 0x31,
  0x90, 0xCF, 0xCF, 0xC0, 0x0F, 0x3F, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xE4, 0x7C, 0x1E, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0x8C,
  0x86, 0xC3, 0x61, 0xB1, 0x91, 0xCF, 0xCF, 0x80, 0x1F, 0x1F, 0x30, 0x30,
  0x30, 0x30, 0x3E, 0x60, 0x60, 0x60, 0x40, 0x7C, 0xFC, 0x1F, 0x1F, 0x30,
  0x30, 0x30, 0x30, 0x3E, 0x7E, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x0F, 0x9F,
  0xCC, 0x0C, 0x06, 0x06, 0x03, 0x1D, 0x9E, 0xC3, 0x61, 0xB0, 0x9C, 0xC7,
  0xE0, 0x18, 0xC4, 0x33, 0x0C, 0xC3, 0x30, 0x8F, 0xE3, 0xF9, 0x86, 0x61,
  0x98, 0x46, 0x31, 0x0C, 0xC3, 0x00, 0x1F, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x02, 0x06, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0xF0, 0x40,
  0x18, 0xC4, 0x63, 0x30, 0xD8, 0x36, 0x0F, 0x03, 0xC1, 0xF0, 0x6C, 0x19,
  0x04, 0x61, 0x18, 0xC6, 0x00, 0x18, 0x43, 0x0C, 0x30, 0xC2, 0x18, 0x61,
  0x84, 0x1F, 0xFC, 0x18, 0x18, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0xC5, 0x16,
  0x78, 0xB2, 0xCD, 0xB6, 0x6D, 0x23, 0x79, 0x13, 0x98, 0x9C, 0xCC, 0x46,
  0x00, 0x18, 0x63, 0x0C, 0xE1, 0x1E, 0x23, 0xCC, 0x49, 0x89, 0x33, 0x34,
  0x67, 0x8C, 0xF1, 0x0E, 0x21, 0x8C, 0x30, 0x0F, 0x1F, 0x8C, 0x6C, 0x36,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0x9D, 0xC7, 0xC0, 0x1E, 0x0F,
  0x8C, 0x66, 0x33, 0x19, 0x98, 0x9C, 0xFC, 0x60, 0x30, 0x10, 0x08, 0x0C,
  0x00, 0x0F, 0x1F, 0x8C, 0x6C, 0x34, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x61,
  0xB1, 0x9D, 0xC7, 0xC0, 0xC0, 0x30, 0x1C, 0x1E, 0x0F, 0x8C, 0x66, 0x33,
  0x11, 0x98, 0xF8, 0xF8, 0x6C, 0x32, 0x11, 0x88, 0xCC, 0x60, 0x1F, 0x3F,
  0x30, 0x20, 0x30, 0x30, 0x1C, 0x0C, 0x06, 0x06, 0x04, 0xDC, 0xF8, 0x7F,
  0xFE, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x31, 0x90, 0xD8, 0x6C, 0x26, 0x32, 0x1B, 0x0D, 0x86, 0xC2, 0x63, 0x31,
  0x9D, 0x87, 0x80, 0x83, 0x86, 0x86, 0x84, 0x8C, 0x88, 0x98, 0xD8, 0xF0,
  0xF0, 0xA0, 0xE0, 0xC0, 0x86, 0x1C, 0x31, 0xA3, 0x8D, 0x1C, 0xC8, 0xE6,
  0x4F, 0x22, 0x5B, 0x16, 0xD8, 0xA7, 0x87, 0x3C, 0x39, 0xC1, 0x8E, 0x0C,
  0x70, 0x00, 0x18, 0xC6, 0x21, 0x98, 0x2C, 0x0E, 0x03, 0x80, 0xC0, 0x78,
  0x1E, 0x0D, 0x82, 0x61, 0x88, 0xC3, 0x00, 0x87, 0x8B, 0x36, 0xCD, 0x9E,
  0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x00, 0x1F, 0x8F, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0F, 0xCF, 0xE0, 0x1C, 0x43,
  0x0C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x0E, 0x38, 0x9B, 0x6C,
  0x92, 0x6D, 0xB6, 0x1E, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30,
  0x40, 0x83, 0x06, 0x3C, 0x70, 0x0C, 0x0C, 0x1C, 0x16, 0x36, 0x62, 0x43,
  0xC3, 0xFE, 0xF4, 0x3B, 0x7E, 0x66, 0xC6, 0xC6, 0x84, 0x8C, 0x8C, 0xDC,
  0xEC, 0x18, 0x10, 0x10, 0x30, 0x36, 0x3F, 0x33, 0x63, 0x63, 0x63, 0x62,
  0x66, 0xEE, 0xFC, 0x1D, 0xF6, 0x30, 0xC2, 0x08, 0x20, 0xCB, 0xC0, 0x01,
  0x03, 0x03, 0x03, 0x3A, 0x7E, 0x66, 0xC6, 0xC6, 0x84, 0x8C, 0x8C, 0xDC,
  0xEC, 0x1D, 0xF4, 0x73, 0xFF, 0xC8, 0x20, 0xCB, 0xE0, 0x03, 0x83, 0xC1,
  0x80, 0x80, 0xF0, 0xF0, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x70, 0x00, 0x1D, 0x9F, 0x8C, 0xCC, 0x66, 0x32,
  0x11, 0x18, 0x8C, 0x6E, 0x3B, 0x01, 0x01, 0x88, 0xC7, 0xC0, 0x18, 0x10,
  0x10, 0x30, 0x36, 0x3F, 0x33, 0x63, 0x63, 0x62, 0x66, 0x46, 0xC6, 0xC4,
  0x18, 0x80, 0x63, 0x11, 0x8C, 0x63, 0x11, 0x8C, 0x00, 0x06, 0x08, 0x00,
  0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x30, 0xE0,
  0x18, 0x10, 0x10, 0x30, 0x33, 0x36, 0x26, 0x6C, 0x78, 0x78, 0x6C, 0x4C,
  0xCC, 0xC6, 0x18, 0x84, 0x63, 0x18, 0x8C, 0x63, 0x18, 0x8C, 0x60, 0x36,
  0x62, 0xFF, 0x33, 0x36, 0x33, 0x62, 0x36, 0x63, 0x66, 0x24, 0x66, 0xC6,
  0x6C, 0x46, 0x36, 0x2F, 0x33, 0x63, 0x63, 0x62, 0x66, 0x46, 0xC6, 0xC4,
  0x38, 0xF9, 0x1E, 0x3C, 0x70, 0xE1, 0x46, 0xD9, 0xE0, 0x1B, 0x0B, 0xC6,
  0x66, 0x33, 0x19, 0x8C, 0xC6, 0x66, 0x77, 0x3F, 0x18, 0x0C, 0x04, 0x06,
  0x00, 0x3A, 0xFD, 0x9E, 0x3C, 0x70, 0xA3, 0x46, 0xDD, 0xD8, 0x20, 0xC1,
  0x83, 0x00, 0x36, 0x58, 0xC3, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x80, 0x3E,
  0xF9, 0x83, 0x03, 0x07, 0x06, 0x04, 0x99, 0xE0, 0x21, 0x1F, 0xE4, 0x23,
  0x18, 0xC4, 0x29, 0xC0, 0x62, 0xCD, 0x1E, 0x3C, 0x58, 0xB3, 0x46, 0xDD,
  0xD0, 0xC7, 0x8B, 0x36, 0x4D, 0x9B, 0x3C, 0x78, 0xE1, 0xC0, 0xCC, 0x79,
  0x8B, 0x33, 0x6E, 0x6D, 0x49, 0xEB, 0x39, 0x47, 0x38, 0xE6, 0x18, 0xC0,
  0x31, 0x89, 0x86, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x68, 0x66, 0x63, 0x00,
  0x18, 0xC6, 0x21, 0x98, 0x66, 0x1B, 0x06, 0xC1, 0xE0, 0x38, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x38, 0x00, 0x1F, 0x3E, 0x06, 0x0C, 0x08, 0x18,
  0x30, 0x20, 0x60, 0xFC, 0x06, 0x1C, 0x60, 0xC1, 0x82, 0x0C, 0x30, 0xE0,
  0x60, 0x81, 0x06, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18,
  0x38, 0x30, 0x60, 0xC1, 0x02, 0x07, 0x0E, 0x30, 0x41, 0x83, 0x06, 0x38,
  0x60, 0x63, 0xFE, 0x38,
};

const GFXglyph NotoSans_Condensed_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 4, 0, -13 },
  { 10, 5, 5, 7, 2, -13 },
  { 14, 9, 13, 9, 0, -13 },
  { 29, 8, 15, 8, 0, -14 },
  { 44, 11, 13, 12, 1, -13 },
  { 62, 9, 13, 9, 0, -13 },
  { 77, 2, 5, 4, 2, -13 },
  { 79, 6, 16, 5, 0, -13 },
  { 91, 5, 16, 5, -1, -13 },
  { 101, 6, 7, 8, 2, -14 },
  { 107, 7, 9, 9, 1, -11 },
  { 115, 4, 4, 4, -1, -2 },
  { 117, 5, 2, 5, 0, -6 },
  { 119, 2, 2, 4, 0, -2 },
  { 120, 9, 13, 6, -1, -13 },
  { 135, 7, 13, 8, 1, -13 },
  { 147, 5, 13, 8, 2, -13 },
  { 156, 8, 13, 8, 0, -13 },
  { 169, 8, 13, 8, 0, -13 },
  { 182, 8, 13, 8, 0, -13 },
  { 195, 8, 13, 8, 0, -13 },
  { 208, 7, 13, 8, 1, -13 },
  { 220, 8, 13, 8, 1, -13 },
  { 233, 8, 13, 8, 0, -13 },
  { 246, 8, 13, 8, 0, -13 },
  { 259, 4, 10, 4, 0, -10 },
  { 264, 5, 12, 4, -1, -10 },
  { 272, 7, 9, 9, 1, -11 },
  { 280, 7, 5, 9, 1, -9 },
  { 285, 7, 9, 9, 1, -11 },
  { 293, 6, 13, 6, 1, -13 },
  { 303, 11, 15, 12, 1, -13 },
  { 324, 8, 13, 8, -1, -13 },
  { 337, 9, 13, 9, 0, -13 },
  { 352, 8, 13, 8, 1, -13 },
  { 365, 9, 13, 10, 0, -13 },
  { 380, 8, 13, 8, 0, -13 },
  { 393, 8, 13, 7, 0, -13 },
  { 406, 9, 13, 10, 1, -13 },
  { 421, 10, 13, 10, 0, -13 },
  { 438, 8, 13, 5, -1, -13 },
  { 451, 8, 17, 4, -3, -13 },
  { 468, 10, 13, 8, 0, -13 },
  { 485, 6, 13, 7, 0, -13 },
  { 495, 13, 13, 13, 0, -13 },
  { 517, 11, 13, 11, 0, -13 },
  { 535, 9, 13, 10, 1, -13 },
  { 550, 9, 13, 8, 0, -13 },
  { 565, 9, 16, 10, 1, -13 },
  { 583, 9, 13, 9, 0, -13 },
  { 598, 8, 13, 8, 0, -13 },
  { 611, 8, 13, 7, 1, -13 },
  { 624, 9, 13, 10, 1, -13 },
  { 639, 8, 13, 8, 2, -13 },
  { 652, 13, 13, 13, 2, -13 },
  { 674, 10, 13, 8, -1, -13 },
  { 691, 7, 13, 8, 2, -13 },
  { 703, 9, 13, 7, -1, -13 },
  { 718, 6, 16, 5, 0, -13 },
  { 730, 3, 13, 6, 2, -13 },
  { 735, 7, 16, 5, -1, -13 },
  { 749, 8, 8, 8, 0, -13 },
  { 757, 7, 1, 6, -2, 2 },
  { 758, 2, 3, 5, 3, -14 },
  { 759, 8, 10, 9, 1, -10 },
  { 769, 8, 14, 9, 0, -14 },
  { 783, 6, 10, 7, 1, -10 },
  { 791, 8, 14, 9, 1, -14 },
  { 805, 6, 10, 8, 1, -10 },
  { 813, 9, 18, 5, -2, -14 },
  { 834, 9, 14, 9, 0, -10 },
  { 850, 8, 14, 9, 0, -14 },
  { 864, 5, 13, 4, 0, -13 },
  { 873, 7, 17, 4, -2, -13 },
  { 888, 8, 14, 8, 0, -14 },
  { 902, 5, 14, 4, 0, -14 },
  { 911, 12, 10, 13, 0, -10 },
  { 926, 8, 10, 9, 0, -10 },
  { 936, 7, 10, 8, 1, -10 },
  { 945, 9, 14, 9, -1, -10 },
  { 961, 7, 14, 9, 1, -10 },
  { 974, 7, 10, 6, 0, -10 },
  { 983, 7, 10, 7, 0, -10 },
  { 992, 5, 12, 5, 1, -12 },
  { 1000, 7, 10, 9, 1, -10 },
  { 1009, 7, 10, 7, 1, -10 },
  { 1018, 11, 10, 11, 1, -10 },
  { 1032, 9, 10, 7, -1, -10 },
  { 1044, 10, 14, 7, -2, -10 },
  { 1062, 8, 10, 6, -1, -10 },
  { 1072, 7, 16, 6, 0, -13 },
  { 1086, 2, 18, 8, 3, -14 },
  { 1091, 7, 16, 6, -1, -13 },
  { 1105, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC18PT7B_H_
