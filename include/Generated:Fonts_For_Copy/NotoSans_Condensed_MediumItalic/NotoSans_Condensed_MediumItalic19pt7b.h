#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x63, 0x00, 0x0E, 0x60, 0x6F, 0x2D,
  0xB6, 0x98, 0x04, 0x83, 0x20, 0xD8, 0x24, 0x3F, 0xDF, 0xF1, 0x30, 0x48,
  0x32, 0x3F, 0xE2, 0x41, 0x90, 0x4C, 0x12, 0x00, 0x06, 0x07, 0xCF, 0xC6,
  0x83, 0x41, 0xC0, 0xE0, 0x1C, 0x0E, 0x05, 0x05, 0x9F, 0xCF, 0xC0, 0x80,
  0x80, 0x30, 0x4F, 0x19, 0x22, 0x24, 0xCC, 0x91, 0xB4, 0x27, 0xBF, 0xAD,
  0x6D, 0x21, 0x64, 0x6C, 0x99, 0xB2, 0x34, 0xC3, 0x80, 0x06, 0x07, 0xC1,
  0xB0, 0x4C, 0x13, 0x07, 0x81, 0xC0, 0xF3, 0x6D, 0xB1, 0xEC, 0x73, 0x1C,
  0xEF, 0x1E, 0xE0, 0x6B, 0x6C, 0x06, 0x18, 0x60, 0x83, 0x04, 0x18, 0x30,
  0x60, 0x81, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0x18, 0x20, 0x83, 0x0C,
  0x30, 0xC3, 0x08, 0x61, 0x86, 0x30, 0xC6, 0x10, 0xC0, 0x10, 0x32, 0x47,
  0xF3, 0xEF, 0x32, 0x26, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x36, 0x64, 0xC0, 0x7F, 0xC0, 0xF8, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x0C,
  0x7C, 0xDB, 0x16, 0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x34, 0x6D, 0x9E, 0x00,
  0x0C, 0x67, 0xB6, 0x98, 0x43, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x80, 0x07,
  0x0F, 0xC4, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x06,
  0x07, 0xF7, 0xF8, 0x0E, 0x3F, 0x23, 0x01, 0x03, 0x03, 0x1C, 0x3C, 0x06,
  0x06, 0x06, 0x06, 0xDC, 0xF8, 0x03, 0x81, 0x81, 0xC1, 0xE0, 0xB0, 0x90,
  0xD8, 0x4C, 0x46, 0x7F, 0xBF, 0xC1, 0x80, 0xC0, 0x60, 0x1F, 0x8F, 0x84,
  0x06, 0x03, 0x01, 0x01, 0xF8, 0x0C, 0x03, 0x01, 0x81, 0x80, 0xCD, 0xC7,
  0xC0, 0x07, 0x1F, 0x30, 0x60, 0x60, 0x48, 0xFC, 0xC6, 0xC6, 0xC6, 0x86,
  0xCC, 0xDC, 0x78, 0x7F, 0x7F, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0x0E, 0x0F, 0x8C, 0x66, 0x33, 0x31, 0x98,
  0x78, 0x78, 0x66, 0x61, 0x30, 0xD8, 0xCE, 0x63, 0xE0, 0x0E, 0x1F, 0x33,
  0x23, 0x63, 0x63, 0x63, 0x7F, 0x3B, 0x02, 0x06, 0x0C, 0x9C, 0xF0, 0x33,
  0x00, 0x00, 0x00, 0xEC, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x19, 0x88,
  0x00, 0x03, 0x0F, 0x3C, 0xE0, 0xC0, 0x78, 0x1E, 0x07, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x1C, 0x70, 0xC0, 0x80,
  0x39, 0xF4, 0xC3, 0x0C, 0x63, 0x18, 0x61, 0x00, 0x00, 0xC3, 0x00, 0x03,
  0x80, 0xFC, 0x10, 0x62, 0x02, 0x67, 0xB4, 0xDB, 0xD9, 0x39, 0x12, 0x93,
  0x29, 0x36, 0x97, 0x49, 0x98, 0x80, 0x0C, 0x00, 0x7E, 0x01, 0xC0, 0x03,
  0x03, 0x81, 0xC0, 0xA0, 0xD0, 0x48, 0x66, 0x33, 0x3F, 0x9F, 0xD8, 0x6C,
  0x34, 0x1E, 0x0C, 0x1E, 0x0F, 0xC4, 0x66, 0x33, 0x19, 0x8C, 0xFC, 0x7E,
  0x63, 0x31, 0x98, 0xCC, 0x67, 0xE7, 0xE0, 0x07, 0x0F, 0xCE, 0x2E, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xC3, 0xE0, 0x1E,
  0x07, 0xE1, 0x98, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0x83, 0x61, 0x98, 0x66,
  0x39, 0x9C, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0xC6, 0x06, 0x03, 0x01, 0x80,
  0xF8, 0x7C, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC6,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x7C, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06,
  0x00, 0x07, 0x07, 0xF3, 0x89, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x1E, 0xC1,
  0x30, 0xCC, 0x33, 0x0C, 0x77, 0x1F, 0x80, 0x18, 0x63, 0x0C, 0x61, 0x18,
  0x63, 0x0C, 0x61, 0x8F, 0xF1, 0xFC, 0x61, 0x8C, 0x31, 0x86, 0x30, 0xC4,
  0x31, 0x86, 0x00, 0x1F, 0x1F, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0xF0, 0xE0, 0x18,
  0xE3, 0x18, 0x46, 0x19, 0x83, 0x60, 0x6C, 0x0F, 0x01, 0xE0, 0x7C, 0x0C,
  0xC1, 0x98, 0x33, 0x04, 0x61, 0x86, 0x00, 0x18, 0x61, 0x0C, 0x30, 0xC3,
  0x08, 0x61, 0x86, 0x18, 0x7F, 0xF0, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xCF,
  0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xCD, 0x8B, 0x36, 0x6D, 0xB1, 0x96, 0xC6,
  0x53, 0x11, 0xCC, 0x46, 0x23, 0x19, 0x80, 0x18, 0x31, 0x82, 0x1C, 0x63,
  0xC6, 0x3C, 0x63, 0x44, 0x36, 0xC2, 0x6C, 0x66, 0xC6, 0x2C, 0x62, 0x84,
  0x38, 0x43, 0x8C, 0x38, 0x0E, 0x07, 0xE3, 0x19, 0x82, 0x60, 0xD8, 0x3C,
  0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x33, 0x0C, 0xFE, 0x1F, 0x00, 0x1E, 0x0F,
  0xC6, 0x66, 0x33, 0x19, 0x8C, 0xCE, 0x7E, 0x7C, 0x30, 0x18, 0x0C, 0x04,
  0x06, 0x00, 0x0E, 0x07, 0xE3, 0x19, 0x82, 0x60, 0xD8, 0x3C, 0x1B, 0x06,
  0xC1, 0xB0, 0x6C, 0x33, 0x0C, 0xFE, 0x1F, 0x00, 0xC0, 0x30, 0x0E, 0x00,
  0x1C, 0x0F, 0x84, 0x66, 0x33, 0x19, 0x8C, 0xCC, 0x7C, 0x6C, 0x33, 0x19,
  0x8C, 0xC4, 0x66, 0x18, 0x0F, 0x0F, 0xCC, 0x46, 0x03, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x01, 0x80, 0xCF, 0xC7, 0xC0, 0xFF, 0xFC, 0xC1, 0x83,
  0x04, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x00, 0x30, 0xCC, 0x32,
  0x19, 0x86, 0x61, 0x98, 0x66, 0x13, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x18,
  0xFE, 0x1F, 0x00, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8,
  0xF0, 0xF0, 0xE0, 0xE0, 0xC0, 0xC2, 0x1E, 0x30, 0xF1, 0x87, 0x9C, 0x68,
  0xE3, 0x45, 0x32, 0x69, 0x92, 0x48, 0xB2, 0xC5, 0x96, 0x28, 0xA1, 0xC7,
  0x0C, 0x30, 0x61, 0x80, 0x18, 0x63, 0x18, 0x62, 0x06, 0xC0, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xC8, 0x11, 0x86, 0x31, 0x86, 0x00,
  0xC3, 0xC6, 0xC4, 0xCC, 0xD8, 0xD8, 0x70, 0x70, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0xC0, 0x1F, 0xC7, 0xF0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x7E, 0x3F, 0x80, 0x1E, 0x3C, 0x41, 0x83,
  0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x68, 0xE0, 0xDB,
  0x64, 0x93, 0x6D, 0xB2, 0x40, 0x1E, 0x3C, 0x18, 0x20, 0xC1, 0x83, 0x04,
  0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0xF0, 0x04, 0x0C, 0x0E, 0x1E,
  0x32, 0x23, 0x63, 0xC1, 0xFE, 0xD9, 0x80, 0x3F, 0x67, 0x66, 0xC6, 0xC6,
  0xC6, 0x86, 0x8C, 0xDC, 0xFC, 0x18, 0x0C, 0x04, 0x06, 0x03, 0xF1, 0xD8,
  0xC6, 0xC2, 0x63, 0x31, 0x98, 0xCC, 0xCE, 0x66, 0xE0, 0x3D, 0x9C, 0x30,
  0xC3, 0x08, 0x30, 0xC9, 0xE0, 0x01, 0x80, 0x80, 0xC0, 0x63, 0xF3, 0x39,
  0x19, 0x8C, 0xC6, 0x63, 0x21, 0x91, 0x8D, 0xC7, 0xE0, 0x3C, 0xCF, 0x1E,
  0x6F, 0xD8, 0x20, 0x40, 0xC8, 0xF0, 0x01, 0x01, 0xC1, 0x80, 0xC0, 0x40,
  0xF8, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x38, 0x18, 0x00, 0x1F, 0x99, 0xCC, 0xCC, 0x66, 0x33, 0x19,
  0x0C, 0x8C, 0x6E, 0x3F, 0x01, 0x80, 0x88, 0xC7, 0xC0, 0x80, 0x18, 0x18,
  0x10, 0x30, 0x3F, 0x3B, 0x33, 0x63, 0x63, 0x63, 0x62, 0x46, 0xC6, 0xC6,
  0x18, 0xC0, 0x03, 0x18, 0xCC, 0x63, 0x18, 0x8C, 0x60, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x61,
  0xC2, 0x00, 0x18, 0x0C, 0x04, 0x06, 0x13, 0x31, 0xB0, 0x98, 0xD8, 0x78,
  0x3E, 0x1B, 0x09, 0x8C, 0x46, 0x30, 0x18, 0xC4, 0x63, 0x18, 0xCC, 0x63,
  0x18, 0x8C, 0x60, 0x3F, 0x71, 0xDC, 0xCC, 0xC6, 0xC6, 0x36, 0x31, 0x31,
  0x99, 0x88, 0xC8, 0xC6, 0xC6, 0x26, 0x33, 0x00, 0x3F, 0x3B, 0x33, 0x63,
  0x63, 0x63, 0x62, 0x46, 0xC6, 0xC6, 0x3C, 0xCF, 0x1E, 0x3C, 0x78, 0xE1,
  0xC6, 0xDC, 0xF0, 0x1F, 0x87, 0x61, 0x8C, 0x42, 0x31, 0x8C, 0x63, 0x18,
  0xCC, 0x77, 0x1B, 0x86, 0x01, 0x80, 0x40, 0x30, 0x00, 0x3F, 0x67, 0x46,
  0xC6, 0xC6, 0xC6, 0x86, 0x8C, 0xDC, 0xFC, 0x0C, 0x08, 0x18, 0x18, 0x18,
  0x3E, 0x74, 0xC3, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x80, 0x3E, 0xC5, 0x83,
  0x03, 0x83, 0x03, 0x06, 0x99, 0xF0, 0x31, 0x09, 0xF6, 0x31, 0x18, 0xC6,
  0x31, 0xAE, 0x00, 0x63, 0x62, 0x46, 0xC6, 0xC6, 0xC6, 0xCC, 0x8C, 0xDC,
  0xEC, 0xC7, 0x8F, 0x36, 0x6D, 0x9B, 0x34, 0x78, 0xE0, 0xC0, 0xC6, 0x3C,
  0xE6, 0xCE, 0x4D, 0xEC, 0xD6, 0xCD, 0x68, 0xF7, 0x8E, 0x70, 0xE7, 0x0C,
  0x70, 0x31, 0x8D, 0x86, 0x83, 0xC0, 0xC0, 0xE0, 0x50, 0x6C, 0x66, 0x63,
  0x00, 0x18, 0xE3, 0x18, 0x66, 0x0C, 0xC1, 0xB0, 0x16, 0x02, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x01, 0xE0, 0x10, 0x00, 0x1F, 0x26,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xFC, 0x03, 0x0E, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x30, 0xE0, 0x60, 0x30, 0x30, 0x20, 0x60, 0x60, 0x70,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x38, 0x30, 0x60, 0xC1, 0x82,
  0x06, 0x06, 0x3C, 0x60, 0x83, 0x06, 0x0C, 0x70, 0xE0, 0xF1, 0xFF, 0x84,
};

const GFXglyph NotoSans_Condensed_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 9, 15, 8, 0, -14 },
  { 49, 11, 14, 13, 1, -14 },
  { 69, 10, 14, 10, 0, -14 },
  { 87, 3, 5, 4, 2, -14 },
  { 89, 7, 17, 5, 0, -14 },
  { 104, 6, 17, 5, -1, -14 },
  { 117, 7, 8, 8, 2, -15 },
  { 124, 8, 9, 9, 1, -11 },
  { 133, 4, 5, 4, -1, -2 },
  { 136, 5, 2, 5, 0, -6 },
  { 138, 3, 2, 4, 0, -2 },
  { 139, 9, 14, 7, -1, -14 },
  { 155, 7, 14, 8, 1, -14 },
  { 168, 6, 14, 9, 2, -14 },
  { 179, 9, 14, 8, -1, -14 },
  { 195, 8, 14, 8, 0, -14 },
  { 209, 9, 14, 9, 0, -14 },
  { 225, 9, 14, 8, 0, -14 },
  { 241, 8, 14, 8, 1, -14 },
  { 255, 8, 14, 8, 1, -14 },
  { 269, 9, 14, 8, 0, -14 },
  { 285, 8, 14, 8, 0, -14 },
  { 299, 4, 10, 4, 0, -10 },
  { 304, 5, 13, 4, -1, -10 },
  { 313, 8, 9, 9, 1, -11 },
  { 322, 8, 5, 9, 1, -9 },
  { 327, 8, 9, 9, 1, -11 },
  { 336, 6, 14, 7, 1, -14 },
  { 347, 12, 16, 13, 1, -14 },
  { 371, 9, 14, 9, -1, -14 },
  { 387, 9, 14, 9, 0, -14 },
  { 403, 9, 14, 9, 1, -14 },
  { 419, 10, 14, 10, 0, -14 },
  { 437, 9, 14, 8, 0, -14 },
  { 453, 9, 14, 8, 0, -14 },
  { 469, 10, 14, 11, 1, -14 },
  { 487, 11, 14, 11, 0, -14 },
  { 507, 8, 14, 6, -1, -14 },
  { 521, 8, 18, 5, -3, -14 },
  { 539, 11, 14, 9, 0, -14 },
  { 559, 6, 14, 7, 0, -14 },
  { 570, 14, 14, 14, 0, -14 },
  { 595, 12, 14, 11, 0, -14 },
  { 616, 10, 14, 11, 1, -14 },
  { 634, 9, 14, 9, 0, -14 },
  { 650, 10, 17, 11, 1, -14 },
  { 672, 9, 14, 9, 0, -14 },
  { 688, 9, 14, 8, 0, -14 },
  { 704, 7, 14, 8, 2, -14 },
  { 717, 10, 14, 10, 1, -14 },
  { 735, 8, 14, 9, 2, -14 },
  { 749, 13, 14, 14, 2, -14 },
  { 772, 11, 14, 8, -1, -14 },
  { 792, 8, 14, 8, 2, -14 },
  { 806, 10, 14, 8, -1, -14 },
  { 824, 7, 17, 5, 0, -14 },
  { 839, 3, 14, 7, 2, -14 },
  { 845, 7, 17, 5, -1, -14 },
  { 860, 8, 8, 9, 0, -14 },
  { 868, 7, 1, 6, -2, 2 },
  { 869, 3, 3, 5, 3, -15 },
  { 871, 8, 10, 9, 1, -10 },
  { 881, 9, 14, 9, 0, -14 },
  { 897, 6, 10, 7, 1, -10 },
  { 905, 9, 14, 9, 1, -14 },
  { 921, 7, 10, 8, 1, -10 },
  { 930, 9, 20, 5, -2, -15 },
  { 953, 9, 15, 9, 0, -10 },
  { 970, 8, 14, 9, 0, -14 },
  { 984, 5, 14, 4, 0, -14 },
  { 993, 7, 19, 4, -2, -14 },
  { 1010, 9, 14, 8, 0, -14 },
  { 1026, 5, 14, 4, 0, -14 },
  { 1035, 13, 10, 13, 0, -10 },
  { 1052, 8, 10, 9, 0, -10 },
  { 1062, 7, 10, 9, 1, -10 },
  { 1071, 10, 14, 9, -1, -10 },
  { 1089, 8, 15, 9, 1, -10 },
  { 1104, 7, 10, 6, 0, -10 },
  { 1113, 7, 10, 7, 0, -10 },
  { 1122, 5, 13, 5, 1, -13 },
  { 1131, 8, 10, 9, 1, -10 },
  { 1141, 7, 10, 7, 1, -10 },
  { 1150, 12, 10, 12, 1, -10 },
  { 1165, 9, 10, 8, -1, -10 },
  { 1177, 11, 15, 8, -2, -10 },
  { 1198, 8, 10, 7, -1, -10 },
  { 1208, 8, 17, 6, 0, -14 },
  { 1225, 2, 19, 8, 3, -15 },
  { 1230, 7, 17, 6, -1, -14 },
  { 1245, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC19PT7B_H_
