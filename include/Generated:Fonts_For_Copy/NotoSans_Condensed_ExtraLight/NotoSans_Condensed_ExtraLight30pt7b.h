#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT30PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight30pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x03, 0xC0, 0x8E, 0x38, 0xE2, 0x8A, 0x28,
  0x80, 0x04, 0x20, 0x41, 0x02, 0x08, 0x10, 0x80, 0x84, 0x04, 0x23, 0xFF,
  0xE1, 0x08, 0x18, 0x40, 0x82, 0x04, 0x10, 0x21, 0x01, 0x08, 0x7F, 0xF8,
  0x42, 0x02, 0x10, 0x20, 0x81, 0x04, 0x08, 0x40, 0x42, 0x02, 0x10, 0x00,
  0x04, 0x00, 0x80, 0x7E, 0x1A, 0x64, 0x41, 0x88, 0x21, 0x04, 0x20, 0xC4,
  0x08, 0x80, 0x90, 0x0E, 0x00, 0x70, 0x0B, 0x01, 0x10, 0x21, 0x04, 0x20,
  0x84, 0x10, 0x82, 0x38, 0x4C, 0xFE, 0x01, 0x00, 0x20, 0x04, 0x00, 0x18,
  0x04, 0x12, 0x04, 0x11, 0x82, 0x08, 0x42, 0x04, 0x21, 0x06, 0x10, 0x82,
  0x08, 0x81, 0x04, 0x40, 0x82, 0x40, 0x21, 0x27, 0x90, 0x94, 0x48, 0xD2,
  0x12, 0x49, 0x08, 0xC8, 0x84, 0x04, 0x82, 0x02, 0x41, 0x02, 0x20, 0x81,
  0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x41, 0x10, 0x40, 0x78, 0x0E, 0x00,
  0x64, 0x03, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x04, 0x40,
  0x11, 0x00, 0x38, 0x00, 0xC0, 0x05, 0x00, 0x22, 0x09, 0x0C, 0x2C, 0x10,
  0xA0, 0x24, 0x80, 0xD2, 0x01, 0xCC, 0x02, 0x10, 0x14, 0x60, 0x98, 0xFC,
  0x30, 0xFE, 0x0C, 0x61, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x30, 0xC3,
  0x0C, 0x10, 0x41, 0x04, 0x18, 0x20, 0x81, 0x04, 0x08, 0x10, 0xC1, 0x82,
  0x0C, 0x10, 0x40, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x30, 0xC2, 0x08, 0x20,
  0x86, 0x10, 0x42, 0x08, 0x42, 0x00, 0x04, 0x01, 0x00, 0x41, 0x11, 0xF7,
  0x83, 0x00, 0xA0, 0x48, 0x21, 0x88, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x2D, 0x24, 0xA0, 0xFE, 0xF0, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x00, 0x0E, 0x03, 0x30,
  0x82, 0x10, 0x24, 0x04, 0x80, 0xD0, 0x0A, 0x01, 0x40, 0x28, 0x07, 0x00,
  0xE0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x68, 0x09, 0x81, 0x10,
  0x23, 0x08, 0x3E, 0x00, 0x0C, 0x72, 0x71, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x0E, 0x0E, 0x71, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0xFF, 0xC0, 0x1E, 0x0E, 0x73, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x30, 0x78, 0x03, 0x80, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x28, 0x08, 0xFE, 0x00, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81,
  0x08, 0x30, 0x82, 0x08, 0x40, 0x84, 0x08, 0x80, 0x88, 0x08, 0xFF, 0xF0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x7F, 0x90, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xBE, 0x30, 0xC0, 0x08, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0A, 0x04, 0xFE, 0x00, 0x03, 0x07,
  0x23, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x27, 0xCA, 0x1B,
  0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x05, 0x02, 0x61,
  0x8F, 0xC0, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x0E, 0x07, 0x30, 0x81, 0x20,
  0x24, 0x06, 0x80, 0xD0, 0x1B, 0x02, 0x20, 0xC3, 0x20, 0x38, 0x0D, 0x83,
  0x08, 0xC0, 0x90, 0x1E, 0x01, 0x80, 0x30, 0x07, 0x00, 0xA0, 0x36, 0x0C,
  0x3F, 0x00, 0x0E, 0x07, 0x31, 0x82, 0x20, 0x24, 0x05, 0x80, 0xB0, 0x1C,
  0x01, 0xC0, 0x38, 0x0D, 0x01, 0xB0, 0x53, 0x1A, 0x3C, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x30, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x5A, 0x4B, 0x40, 0x00, 0x30, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0x00,
  0x38, 0xCE, 0x02, 0x03, 0x01, 0x01, 0x03, 0x02, 0x02, 0x04, 0x0C, 0x18,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x30, 0x30, 0x07, 0xF8,
  0x0C, 0x06, 0x0C, 0x00, 0x84, 0x00, 0x64, 0x00, 0x12, 0x00, 0x0F, 0x07,
  0xC3, 0x04, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x31, 0x82, 0x18,
  0xC3, 0x0C, 0x21, 0x86, 0x10, 0xC3, 0x08, 0x62, 0x86, 0xDB, 0x40, 0xC3,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x30, 0xC0, 0x07,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00,
  0x88, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x06, 0x04, 0x08, 0x3F, 0xE0,
  0x80, 0x82, 0x01, 0x08, 0x04, 0x60, 0x11, 0x00, 0x64, 0x00, 0xB0, 0x02,
  0x80, 0x0C, 0xFF, 0x10, 0x12, 0x03, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x04, 0x81, 0x9F, 0xC2, 0x0E, 0x40, 0x68, 0x05, 0x00, 0xA0, 0x14, 0x03,
  0x80, 0x50, 0x0A, 0x03, 0x40, 0xCF, 0xE0, 0x03, 0x80, 0xC7, 0x30, 0x02,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x18, 0x10, 0xFE, 0xFF, 0x08, 0x18, 0x80, 0xC8, 0x04, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0x80, 0x88, 0x38, 0xFE, 0x00,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xD0, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x01, 0xC0, 0x38,
  0xE1, 0x00, 0x88, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x05, 0x00, 0x16, 0x00, 0x4C, 0x01, 0x18, 0x0C, 0x3F, 0xE0,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x3F, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x4F, 0x80, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x43, 0x0B, 0xE0, 0x80, 0xE0, 0x68, 0x12, 0x08, 0x86, 0x21, 0x08, 0x82,
  0x60, 0xB0, 0x2C, 0x0D, 0x83, 0x20, 0x8C, 0x21, 0x08, 0x62, 0x08, 0x81,
  0x20, 0x48, 0x0A, 0x03, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x05, 0xA0,
  0x05, 0xA0, 0x0D, 0xB0, 0x09, 0x90, 0x09, 0x90, 0x19, 0x98, 0x11, 0x88,
  0x11, 0x88, 0x31, 0x8C, 0x21, 0x84, 0x21, 0x84, 0x61, 0x86, 0x41, 0x82,
  0x41, 0x82, 0xC1, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x1C, 0x01,
  0xC0, 0x1A, 0x01, 0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x88, 0x18, 0x41,
  0x84, 0x18, 0x21, 0x82, 0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x98, 0x05,
  0x80, 0x58, 0x03, 0x80, 0x30, 0x07, 0x00, 0x73, 0x83, 0x03, 0x18, 0x04,
  0x40, 0x0B, 0x00, 0x28, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x09, 0x00,
  0x24, 0x01, 0x88, 0x04, 0x30, 0x20, 0x3F, 0x00, 0xFE, 0x20, 0x48, 0x0A,
  0x02, 0x80, 0xA0, 0x38, 0x0E, 0x02, 0x80, 0xA0, 0x68, 0x33, 0xF0, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x03,
  0x80, 0x73, 0x83, 0x03, 0x18, 0x04, 0x40, 0x0B, 0x00, 0x28, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x09, 0x00, 0x24, 0x01, 0x88, 0x04, 0x30, 0x20,
  0x3F, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0xFE,
  0x20, 0x48, 0x0A, 0x02, 0x80, 0xE0, 0x38, 0x0A, 0x02, 0x80, 0xA0, 0x4F,
  0xE2, 0x30, 0x84, 0x21, 0x88, 0x22, 0x0C, 0x81, 0x20, 0x68, 0x0A, 0x03,
  0x80, 0x40, 0x0F, 0x07, 0x39, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x28, 0x09, 0xFE, 0x00, 0xFF, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x60, 0x33, 0x06, 0x1F,
  0xC0, 0x80, 0x0A, 0x00, 0xD0, 0x04, 0x80, 0x26, 0x01, 0x10, 0x18, 0x80,
  0x84, 0x04, 0x30, 0x20, 0x82, 0x04, 0x10, 0x20, 0x80, 0x8C, 0x04, 0x40,
  0x22, 0x01, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0E, 0x00, 0x20, 0x00,
  0xC0, 0x30, 0x0A, 0x01, 0x80, 0x50, 0x0C, 0x02, 0x80, 0xE0, 0x36, 0x05,
  0x81, 0x10, 0x24, 0x08, 0x81, 0x20, 0x44, 0x09, 0x06, 0x30, 0x88, 0x20,
  0x84, 0x21, 0x04, 0x21, 0x08, 0x21, 0x08, 0xC1, 0x18, 0x44, 0x04, 0x83,
  0x20, 0x24, 0x09, 0x01, 0x20, 0x48, 0x09, 0x02, 0xC0, 0x70, 0x14, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x00, 0x60, 0x32, 0x06, 0x20,
  0x41, 0x04, 0x10, 0x80, 0x88, 0x09, 0x00, 0xD0, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x09, 0x00, 0x90, 0x10, 0x81, 0x08, 0x30, 0x42, 0x04, 0x60,
  0x64, 0x02, 0xC0, 0x30, 0xC0, 0x34, 0x02, 0x40, 0x42, 0x04, 0x20, 0xC3,
  0x08, 0x10, 0x81, 0x10, 0x09, 0x00, 0xB0, 0x0E, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xFF, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x00, 0xFF, 0xC0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF0, 0x80,
  0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0xFC,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xF0, 0x06, 0x00, 0x60, 0x09, 0x00,
  0x90, 0x10, 0x83, 0x08, 0x20, 0x46, 0x04, 0x40, 0x2C, 0x02, 0x80, 0x30,
  0xFF, 0xF0, 0xC3, 0x08, 0x20, 0x80, 0x7F, 0x10, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x3F, 0x30, 0xA0, 0x70, 0x30, 0x18, 0x0E, 0x0D, 0x06, 0x7D,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0xF8, 0xA0,
  0x94, 0x0B, 0x01, 0x60, 0x3C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x01, 0xE0, 0x2C, 0x05, 0x41, 0x27, 0xC0, 0x0F, 0x88, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00,
  0xC0, 0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0xF9, 0x30, 0xA4, 0x0D, 0x01, 0xA0, 0x14, 0x02, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x28, 0x05, 0x00, 0xA0, 0x36, 0x06, 0x41, 0x47, 0xC8, 0x1F, 0x06,
  0x10, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x1F, 0xFF, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x10, 0xFE, 0x0F, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x26, 0x14, 0x81, 0xA0,
  0x34, 0x02, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x14,
  0x06, 0xC0, 0xC8, 0x28, 0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x81, 0x8F, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x7C, 0xB1, 0xA8, 0x2C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0xF8, 0x0A, 0xAA, 0xAA,
  0xAA, 0xA0, 0x18, 0xC4, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x2F, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x03, 0x81, 0x41, 0x21, 0x11, 0x88, 0x84,
  0x82, 0xA1, 0x50, 0xC4, 0x42, 0x20, 0x90, 0x48, 0x14, 0x0A, 0x02, 0xFF,
  0xFF, 0xFE, 0x9E, 0x1E, 0x50, 0x91, 0xB0, 0x70, 0x58, 0x10, 0x3C, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x9F, 0x2C, 0x6A, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x1F, 0x86, 0x18, 0x81,
  0x20, 0x14, 0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x02, 0xC0, 0x8C, 0x30, 0xFC, 0x9F, 0x16, 0x12, 0x81, 0x60, 0x2C,
  0x07, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x3C, 0x05,
  0x40, 0xA8, 0x24, 0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x00, 0x1F, 0x26, 0x14, 0x81, 0xA0, 0x34, 0x02, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x14, 0x06, 0xC0, 0xCC, 0x28, 0xF9,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x9F, 0x62,
  0x86, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x3F, 0xA0, 0xB0, 0x10, 0x08, 0x02, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x0E, 0x05, 0xFC, 0x41, 0x04, 0x10, 0xFD, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x82, 0x0F, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xF0, 0x34, 0x14, 0xF9, 0x80, 0x70, 0x14, 0x05, 0x02, 0x40, 0x88,
  0x22, 0x18, 0x84, 0x31, 0x04, 0x41, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xC0,
  0x30, 0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x30, 0x68, 0x28, 0x26, 0x16, 0x11,
  0x09, 0x08, 0x84, 0x84, 0x46, 0x44, 0x22, 0x32, 0x09, 0x09, 0x04, 0x84,
  0x82, 0xC2, 0xC1, 0x41, 0x40, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x80,
  0x90, 0x64, 0x10, 0x8C, 0x22, 0x05, 0x81, 0x40, 0x30, 0x0C, 0x05, 0x03,
  0x20, 0x88, 0x61, 0x10, 0x4C, 0x0A, 0x03, 0x40, 0x68, 0x09, 0x01, 0x30,
  0x22, 0x08, 0x41, 0x08, 0x20, 0x8C, 0x11, 0x02, 0x20, 0x64, 0x05, 0x00,
  0xA0, 0x14, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x3C, 0x00, 0xFF, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0xFF, 0x07, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0xE0, 0x30, 0x10, 0x10, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x0C, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x30, 0xC0, 0x78, 0x18, 0x62, 0x81, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLight30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 6, 7, 10, 2, -21 },
  { 13, 13, 21, 15, 1, -21 },
  { 48, 11, 25, 14, 1, -23 },
  { 83, 17, 22, 20, 1, -22 },
  { 130, 14, 22, 15, 1, -22 },
  { 169, 1, 7, 5, 2, -21 },
  { 170, 6, 26, 8, 1, -21 },
  { 190, 6, 26, 8, 1, -21 },
  { 210, 10, 10, 12, 1, -23 },
  { 223, 12, 14, 14, 1, -18 },
  { 244, 3, 7, 6, 1, -3 },
  { 247, 7, 1, 8, 1, -9 },
  { 248, 2, 2, 6, 2, -2 },
  { 249, 9, 21, 10, 1, -21 },
  { 273, 11, 22, 14, 1, -22 },
  { 304, 6, 21, 14, 2, -21 },
  { 320, 11, 22, 14, 1, -22 },
  { 351, 11, 22, 14, 1, -22 },
  { 382, 12, 22, 14, 1, -22 },
  { 415, 10, 21, 14, 2, -21 },
  { 442, 10, 22, 14, 2, -22 },
  { 470, 11, 21, 14, 1, -21 },
  { 499, 11, 22, 14, 1, -22 },
  { 530, 11, 22, 14, 1, -22 },
  { 561, 2, 16, 6, 2, -16 },
  { 565, 3, 20, 6, 1, -16 },
  { 573, 12, 13, 14, 1, -17 },
  { 593, 12, 7, 14, 1, -14 },
  { 604, 12, 13, 14, 1, -17 },
  { 624, 8, 22, 10, 1, -22 },
  { 646, 17, 24, 21, 2, -21 },
  { 697, 14, 21, 14, 0, -21 },
  { 734, 11, 21, 15, 3, -21 },
  { 763, 12, 22, 14, 2, -22 },
  { 796, 12, 21, 16, 3, -21 },
  { 828, 8, 21, 13, 3, -21 },
  { 849, 9, 21, 12, 3, -21 },
  { 873, 14, 22, 18, 2, -22 },
  { 912, 11, 21, 17, 3, -21 },
  { 941, 5, 21, 8, 1, -21 },
  { 955, 6, 26, 6, -2, -21 },
  { 975, 10, 21, 13, 3, -21 },
  { 1002, 8, 21, 12, 3, -21 },
  { 1023, 16, 21, 22, 3, -21 },
  { 1065, 12, 21, 17, 3, -21 },
  { 1097, 14, 22, 18, 2, -22 },
  { 1136, 10, 21, 14, 3, -21 },
  { 1163, 14, 27, 18, 2, -22 },
  { 1211, 10, 21, 14, 3, -21 },
  { 1238, 11, 22, 13, 1, -22 },
  { 1269, 12, 21, 12, 0, -21 },
  { 1301, 12, 21, 17, 2, -21 },
  { 1333, 13, 21, 13, 0, -21 },
  { 1368, 21, 21, 22, 0, -21 },
  { 1424, 12, 21, 12, 0, -21 },
  { 1456, 12, 21, 12, 0, -21 },
  { 1488, 10, 21, 12, 1, -21 },
  { 1515, 6, 26, 9, 2, -21 },
  { 1535, 9, 21, 10, 1, -21 },
  { 1559, 6, 26, 9, 1, -21 },
  { 1579, 12, 11, 14, 1, -21 },
  { 1596, 12, 1, 12, 0, 3 },
  { 1598, 5, 5, 7, 1, -23 },
  { 1602, 9, 16, 13, 1, -16 },
  { 1620, 11, 23, 14, 2, -23 },
  { 1652, 9, 16, 11, 1, -16 },
  { 1670, 11, 23, 14, 1, -23 },
  { 1702, 11, 16, 13, 1, -16 },
  { 1724, 8, 23, 7, 0, -23 },
  { 1747, 11, 23, 14, 1, -16 },
  { 1779, 10, 23, 14, 2, -23 },
  { 1808, 2, 22, 6, 2, -22 },
  { 1814, 5, 29, 6, -1, -22 },
  { 1833, 9, 23, 11, 2, -23 },
  { 1859, 1, 23, 6, 2, -23 },
  { 1862, 17, 16, 21, 2, -16 },
  { 1896, 10, 16, 14, 2, -16 },
  { 1916, 11, 16, 14, 1, -16 },
  { 1938, 11, 23, 14, 2, -16 },
  { 1970, 11, 23, 14, 1, -16 },
  { 2002, 7, 16, 9, 2, -16 },
  { 2016, 9, 16, 11, 1, -16 },
  { 2034, 6, 20, 8, 1, -20 },
  { 2049, 10, 16, 14, 2, -16 },
  { 2069, 10, 16, 11, 0, -16 },
  { 2089, 17, 16, 17, 0, -16 },
  { 2123, 10, 16, 11, 1, -16 },
  { 2143, 11, 23, 11, 0, -16 },
  { 2175, 8, 16, 10, 1, -16 },
  { 2191, 8, 26, 10, 1, -21 },
  { 2217, 1, 30, 13, 6, -23 },
  { 2221, 8, 26, 10, 1, -21 },
  { 2247, 12, 3, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraLight30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT30PT7B_H_
