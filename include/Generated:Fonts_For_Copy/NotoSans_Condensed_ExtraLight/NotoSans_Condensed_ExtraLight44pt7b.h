#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT44PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight44pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD2, 0x49, 0x24, 0x90, 0x00, 0x0F,
  0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1,
  0x01, 0x81, 0x80, 0x18, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x03,
  0x00, 0x10, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x02, 0x07, 0xFF,
  0xFF, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x40, 0x06, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00,
  0x40, 0xC0, 0xFF, 0xFF, 0xE0, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0xC0, 0x80,
  0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x81, 0x80, 0x18, 0x10, 0x00, 0x01, 0x00, 0x01, 0x00, 0x07, 0xC0,
  0x1F, 0xFC, 0x31, 0x0C, 0x61, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00,
  0x81, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0x61, 0x00, 0x31, 0x00,
  0x1D, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0x70, 0x01, 0x18, 0x01, 0x0C,
  0x01, 0x06, 0x01, 0x02, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03, 0x01, 0x02,
  0x01, 0x06, 0x01, 0x06, 0xC1, 0x1C, 0xFF, 0xF0, 0x1F, 0xC0, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x10,
  0x18, 0x60, 0x18, 0x0C, 0x10, 0x08, 0x04, 0x08, 0x0C, 0x06, 0x06, 0x04,
  0x03, 0x03, 0x02, 0x01, 0x81, 0x83, 0x00, 0xC0, 0xC1, 0x00, 0x60, 0x61,
  0x80, 0x30, 0x30, 0x80, 0x18, 0x18, 0x40, 0x0C, 0x0C, 0x60, 0x06, 0x06,
  0x23, 0xE3, 0x03, 0x33, 0x18, 0x81, 0x11, 0x06, 0x60, 0x88, 0x83, 0x30,
  0xCC, 0xC0, 0x8F, 0xC4, 0x60, 0x43, 0xC6, 0x20, 0x20, 0x02, 0x10, 0x18,
  0x01, 0x08, 0x0C, 0x01, 0x84, 0x06, 0x00, 0x82, 0x03, 0x00, 0xC1, 0x01,
  0x80, 0x40, 0x80, 0xC0, 0x20, 0x60, 0x40, 0x30, 0x30, 0x20, 0x10, 0x08,
  0x30, 0x18, 0x04, 0x18, 0x0C, 0x03, 0x18, 0x0C, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xFC, 0x00, 0x60, 0xC0, 0x0C, 0x08, 0x01, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x10, 0x18, 0x02, 0x02, 0x00, 0x60, 0xC0,
  0x04, 0x10, 0x00, 0xC6, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x1D, 0x80, 0x06, 0x30, 0x01, 0x83, 0x01, 0x30, 0x30, 0x2C, 0x02, 0x0D,
  0x80, 0x61, 0xB0, 0x06, 0x34, 0x00, 0x44, 0x80, 0x0D, 0x90, 0x00, 0xE3,
  0x00, 0x0C, 0x60, 0x03, 0x84, 0x00, 0xD8, 0xC0, 0x31, 0x8E, 0x1C, 0x30,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x30, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x03, 0xC0, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x40, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0xC3, 0x0F, 0xED, 0xF0, 0xFC, 0x00, 0xC0, 0x06,
  0x80, 0x33, 0x00, 0x86, 0x06, 0x08, 0x30, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x33, 0x36, 0x66, 0x44, 0xC8, 0x80, 0xFF, 0xFF, 0xF0, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x18, 0x18, 0x10, 0x08,
  0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x40, 0x02,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0x40, 0x02, 0x40, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x30, 0x0C,
  0x30, 0x0C, 0x18, 0x18, 0x0E, 0x70, 0x07, 0xE0, 0x03, 0x0F, 0x1F, 0x33,
  0x63, 0xC3, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x07, 0xC0, 0x7F, 0xE1, 0xC0, 0xE2, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xE3, 0x80, 0xE6, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x18, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xD0, 0x03, 0xBC,
  0x1E, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00,
  0x63, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x18, 0x0C, 0x04, 0x03, 0x03, 0x00, 0xC0, 0x80, 0x30,
  0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x3F, 0xFC, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x6F, 0xC0, 0x7F, 0xF0, 0x20, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x80,
  0x18, 0xE0, 0x70, 0x7F, 0xE0, 0x00, 0xF8, 0x03, 0xFC, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x47, 0xF0, 0xCC, 0x38, 0xD8,
  0x0C, 0xF0, 0x06, 0xE0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x02, 0x20,
  0x06, 0x30, 0x06, 0x18, 0x0C, 0x1C, 0x18, 0x07, 0xF0, 0x00, 0x80, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0x60,
  0x06, 0x40, 0x06, 0x40, 0x06, 0x40, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x0C, 0x18, 0x18, 0x0C, 0x30, 0x07, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x18,
  0x38, 0x30, 0x1C, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x70,
  0x0C, 0x38, 0x38, 0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x00,
  0xC6, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xB0, 0x03, 0x60,
  0x0A, 0x60, 0x34, 0x7F, 0xC8, 0x7E, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x10, 0x78, 0x3F, 0xC0, 0x5F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x27, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x33, 0x66, 0x64, 0x4C, 0x88, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x1E, 0x0F, 0xFC, 0xC0, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x06, 0x00,
  0x88, 0x07, 0xF0, 0x36, 0x03, 0x04, 0x0D, 0x81, 0x81, 0x03, 0x40, 0x40,
  0x40, 0x50, 0x30, 0x10, 0x14, 0x08, 0x04, 0x07, 0x02, 0x01, 0x01, 0xC0,
  0x80, 0x40, 0x70, 0x60, 0x30, 0x1C, 0x18, 0x0C, 0x07, 0x02, 0x03, 0x03,
  0xC0, 0x80, 0xC0, 0xF0, 0x20, 0x30, 0x34, 0x0C, 0x1C, 0x09, 0x03, 0x05,
  0x86, 0x60, 0x77, 0x37, 0x18, 0x0F, 0x87, 0x86, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x20, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x09, 0x00, 0x00,
  0x90, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x10, 0x80, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x04, 0x02, 0x00, 0xC0, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF,
  0x01, 0x80, 0x18, 0x18, 0x01, 0x81, 0x00, 0x18, 0x30, 0x00, 0x83, 0x00,
  0x0C, 0x30, 0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40,
  0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x30, 0xFF, 0xF0, 0x80, 0x38, 0x80,
  0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80,
  0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0xF0, 0xFF,
  0xC0, 0x80, 0x78, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x7F, 0xF0, 0x70, 0x0C, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x1C, 0x07, 0xFE, 0xFF, 0xE0, 0x20,
  0x1E, 0x08, 0x01, 0xC2, 0x00, 0x38, 0x80, 0x06, 0x20, 0x00, 0xC8, 0x00,
  0x32, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00,
  0x1A, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x62, 0x00, 0x30,
  0x80, 0x38, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xD0, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFE,
  0xFF, 0xF4, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x0E, 0x0C, 0x00, 0x20,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x80, 0x0C, 0x0F, 0x01, 0xE0, 0x1F,
  0xFC, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x3F, 0x80, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x77, 0xF1, 0xE0, 0x80, 0x06, 0x80, 0x0C, 0x80,
  0x18, 0x80, 0x38, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0, 0x80, 0xC0, 0x81,
  0x80, 0x83, 0x00, 0x83, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x9C, 0x00, 0x9C,
  0x00, 0xB6, 0x00, 0xE3, 0x00, 0xC3, 0x00, 0x81, 0x80, 0x81, 0x80, 0x80,
  0xC0, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x18, 0x80,
  0x18, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x07, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xB0, 0x00, 0x0F,
  0xB0, 0x00, 0x0F, 0xB0, 0x00, 0x0B, 0x98, 0x00, 0x1B, 0x98, 0x00, 0x1B,
  0x98, 0x00, 0x13, 0x88, 0x00, 0x33, 0x8C, 0x00, 0x33, 0x8C, 0x00, 0x23,
  0x84, 0x00, 0x63, 0x86, 0x00, 0x63, 0x86, 0x00, 0x43, 0x82, 0x00, 0xC3,
  0x83, 0x00, 0xC3, 0x83, 0x00, 0x83, 0x81, 0x01, 0x83, 0x81, 0x81, 0x83,
  0x81, 0x81, 0x03, 0x80, 0x83, 0x03, 0x80, 0xC3, 0x03, 0x80, 0xC2, 0x03,
  0x80, 0x46, 0x03, 0x80, 0x66, 0x03, 0x80, 0x64, 0x03, 0x80, 0x2C, 0x03,
  0x80, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xE6, 0x00, 0x39, 0x80,
  0x0E, 0x30, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x38, 0x60, 0x0E, 0x0C, 0x03,
  0x83, 0x00, 0xE0, 0x60, 0x38, 0x18, 0x0E, 0x03, 0x03, 0x80, 0xC0, 0xE0,
  0x18, 0x38, 0x06, 0x0E, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x06, 0x38, 0x01,
  0x8E, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x0F, 0xFC,
  0x00, 0x70, 0x18, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x08, 0x00, 0x04, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90,
  0x00, 0x02, 0x40, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x18,
  0x1C, 0x00, 0x60, 0x38, 0x07, 0x00, 0x78, 0x78, 0x00, 0x7F, 0x80, 0xFF,
  0xC2, 0x03, 0xC8, 0x03, 0xA0, 0x06, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x68,
  0x01, 0xA0, 0x1C, 0xFF, 0xE3, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00,
  0x70, 0x18, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x08, 0x00, 0x04, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x90, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90, 0x00,
  0x02, 0x40, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x20, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x18, 0x1C,
  0x00, 0x60, 0x38, 0x07, 0x00, 0x78, 0x78, 0x00, 0x7F, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xC0, 0x80, 0xF0, 0x80, 0x18,
  0x80, 0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30,
  0x83, 0xE0, 0xFF, 0x80, 0x81, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x40,
  0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x18,
  0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x07, 0x03, 0xF0, 0x3F, 0xFC,
  0xE0, 0x13, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xD0, 0x03, 0xB8, 0x1E, 0x3F, 0xF0, 0xFF, 0xFF, 0x80, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x18, 0xC0, 0x06, 0x38, 0x03, 0x07, 0x83, 0x80, 0x7F, 0xC0,
  0xC0, 0x00, 0x68, 0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0x40, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x82, 0x00, 0x30,
  0x60, 0x04, 0x0C, 0x01, 0x80, 0x80, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x04, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00,
  0x20, 0x80, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x80, 0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x1B, 0x00, 0x1C,
  0x00, 0x36, 0x00, 0x3C, 0x00, 0x64, 0x00, 0x78, 0x00, 0x8C, 0x00, 0xB0,
  0x03, 0x18, 0x01, 0x20, 0x06, 0x30, 0x06, 0x60, 0x0C, 0x20, 0x0C, 0xC0,
  0x10, 0x60, 0x19, 0x80, 0x60, 0xC0, 0x21, 0x00, 0xC1, 0x80, 0xC2, 0x01,
  0x83, 0x01, 0x86, 0x02, 0x02, 0x03, 0x0C, 0x0C, 0x06, 0x04, 0x18, 0x18,
  0x0C, 0x08, 0x10, 0x30, 0x18, 0x30, 0x30, 0x60, 0x10, 0x60, 0x60, 0x80,
  0x30, 0xC0, 0xC3, 0x00, 0x61, 0x00, 0x86, 0x00, 0xC6, 0x01, 0x0C, 0x00,
  0x8C, 0x03, 0x10, 0x01, 0x18, 0x06, 0x60, 0x03, 0x20, 0x0C, 0xC0, 0x06,
  0x40, 0x09, 0x80, 0x0D, 0x80, 0x1A, 0x00, 0x0B, 0x00, 0x34, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x60, 0x01, 0x98, 0x01, 0x84, 0x00, 0xC3, 0x00, 0xC1,
  0x80, 0x60, 0x60, 0x60, 0x30, 0x30, 0x0C, 0x10, 0x06, 0x18, 0x01, 0x08,
  0x00, 0xCC, 0x00, 0x26, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xE0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x30, 0x30, 0x18, 0x18, 0x18, 0x04, 0x0C, 0x03, 0x0C, 0x01,
  0x86, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xB0,
  0x01, 0x98, 0x00, 0xC4, 0x00, 0x43, 0x00, 0x61, 0x80, 0x30, 0x60, 0x10,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x00, 0x82, 0x00, 0x63,
  0x00, 0x11, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0xFF, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1A, 0x00,
  0x04, 0xC0, 0x03, 0x10, 0x00, 0x86, 0x00, 0x60, 0x80, 0x10, 0x30, 0x0C,
  0x0C, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00,
  0x66, 0x00, 0x1B, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x80, 0x03, 0x01, 0xFF, 0x0C, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x0F, 0xF1, 0xC0,
  0xB8, 0x05, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x02, 0xE0, 0x15, 0xC3, 0x27, 0xF1, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC1, 0xC0, 0xCF, 0xF0, 0xD8, 0x18, 0xD0, 0x0C, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0xE0, 0x06, 0xE0, 0x06, 0xF0, 0x0C, 0xD0, 0x0C, 0xCC, 0x38, 0xC7, 0xF0,
  0x01, 0xE0, 0x3F, 0xC7, 0x02, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x60, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x03, 0xC3, 0x0F,
  0xF3, 0x18, 0x1B, 0x30, 0x0B, 0x30, 0x07, 0x60, 0x07, 0x60, 0x03, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x60,
  0x07, 0x20, 0x07, 0x30, 0x0B, 0x1C, 0x33, 0x0F, 0xE3, 0x01, 0x80, 0x1F,
  0xE0, 0x60, 0xE1, 0x80, 0xC2, 0x00, 0xCC, 0x00, 0x98, 0x01, 0x20, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x47, 0x03, 0x03, 0xFC, 0x00, 0xE0, 0x3F, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFC,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0xC0, 0x0F,
  0xF3, 0x18, 0x1B, 0x30, 0x0F, 0x20, 0x07, 0x60, 0x07, 0x60, 0x03, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x60,
  0x07, 0x20, 0x0F, 0x30, 0x0B, 0x1C, 0x33, 0x0F, 0xE3, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x40,
  0x0C, 0x60, 0x38, 0x3F, 0xF0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0F,
  0x0C, 0xFF, 0x36, 0x0E, 0xD0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x04, 0xDF, 0x80, 0x00, 0x1B, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x0C, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x19, 0xF1, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x2C, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x03, 0x0C, 0x08, 0x30, 0x60, 0xC3,
  0x03, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xDE, 0x03, 0x4C, 0x0F, 0x30, 0x38,
  0x60, 0xC1, 0x83, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x63, 0x00, 0xCC,
  0x03, 0x30, 0x06, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x78, 0x67, 0xF0, 0xFE, 0x36, 0x0C, 0xC1, 0x9A,
  0x02, 0x40, 0x6E, 0x01, 0xC0, 0x37, 0x00, 0xE0, 0x0B, 0x00, 0x70, 0x05,
  0x80, 0x10, 0x02, 0xC0, 0x08, 0x01, 0xE0, 0x04, 0x00, 0xF0, 0x02, 0x00,
  0x78, 0x01, 0x00, 0x3C, 0x00, 0x80, 0x1E, 0x00, 0x40, 0x0F, 0x00, 0x20,
  0x07, 0x80, 0x10, 0x03, 0xC0, 0x08, 0x01, 0xE0, 0x04, 0x00, 0xF0, 0x02,
  0x00, 0x78, 0x01, 0x00, 0x3C, 0x00, 0x80, 0x1E, 0x00, 0x40, 0x0F, 0x00,
  0x20, 0x07, 0x80, 0x10, 0x03, 0x01, 0xC3, 0x3F, 0xCD, 0x81, 0xB4, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x01,
  0xC0, 0x0F, 0xF0, 0x18, 0x1C, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60,
  0x02, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x1C, 0x38, 0x0F, 0xF0, 0x01,
  0xC0, 0xC7, 0xF0, 0xCC, 0x18, 0xD0, 0x0C, 0xF0, 0x06, 0xE0, 0x06, 0xE0,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xE0,
  0x06, 0xE0, 0x06, 0xF0, 0x0C, 0xD8, 0x0C, 0xCC, 0x38, 0xC7, 0xF0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xF3, 0x18,
  0x1B, 0x30, 0x0B, 0x30, 0x07, 0x60, 0x07, 0x60, 0x03, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30,
  0x0F, 0x30, 0x0B, 0x1C, 0x33, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x03, 0xB3, 0xFD, 0xC3, 0x40, 0xF0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x07, 0x83, 0xFF,
  0x60, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x03, 0x00, 0x38, 0x06, 0xE0, 0xE7, 0xF8, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x83, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x04, 0x03, 0x10, 0xF8, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xD8, 0x05, 0x60, 0x34, 0xC1, 0x91, 0xFC, 0x40, 0xC0,
  0x06, 0x80, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x00, 0xC4, 0x01, 0x8C, 0x02,
  0x18, 0x0C, 0x10, 0x18, 0x30, 0x20, 0x60, 0xC0, 0xC1, 0x80, 0x83, 0x01,
  0x84, 0x03, 0x18, 0x02, 0x30, 0x06, 0x40, 0x0C, 0x80, 0x1B, 0x00, 0x16,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x01, 0xB0, 0x06,
  0x00, 0xD8, 0x07, 0x80, 0x6C, 0x03, 0xC0, 0x22, 0x01, 0x20, 0x31, 0x80,
  0x90, 0x18, 0xC0, 0xCC, 0x0C, 0x60, 0x66, 0x04, 0x10, 0x33, 0x02, 0x0C,
  0x10, 0x83, 0x06, 0x18, 0x61, 0x83, 0x0C, 0x30, 0x80, 0x86, 0x18, 0x40,
  0x42, 0x04, 0x60, 0x33, 0x03, 0x30, 0x19, 0x81, 0x90, 0x04, 0xC0, 0xC8,
  0x02, 0x40, 0x2C, 0x01, 0xE0, 0x16, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x07,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0xC0, 0x10, 0xC0,
  0x61, 0x80, 0x81, 0x83, 0x03, 0x0C, 0x03, 0x18, 0x06, 0x60, 0x06, 0xC0,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xD8, 0x03, 0x30, 0x06,
  0x30, 0x18, 0x60, 0x30, 0x60, 0xC0, 0xC1, 0x80, 0xC6, 0x01, 0x88, 0x01,
  0xB0, 0x03, 0x80, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x20, 0x06, 0x30,
  0x04, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x08, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x18, 0x0C, 0x10, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x20, 0x06, 0x60, 0x02,
  0x60, 0x02, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x7F,
  0xF0, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x60, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x03, 0xC0,
  0x78, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x3E, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x03, 0x80,
  0xF0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x0F, 0x81,
  0xC0, 0x00, 0x18, 0x00, 0x7F, 0x01, 0xC1, 0xC3, 0x80, 0xFE,
};

const GFXglyph NotoSans_Condensed_ExtraLight44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 8, 11, 14, 3, -31 },
  { 24, 20, 31, 22, 1, -31 },
  { 102, 16, 36, 20, 2, -33 },
  { 174, 25, 32, 29, 2, -32 },
  { 274, 19, 32, 22, 2, -32 },
  { 350, 2, 11, 8, 3, -31 },
  { 353, 8, 38, 12, 2, -31 },
  { 391, 8, 38, 12, 2, -31 },
  { 429, 14, 13, 18, 2, -33 },
  { 452, 16, 21, 20, 2, -26 },
  { 494, 4, 11, 8, 2, -5 },
  { 500, 10, 2, 12, 1, -13 },
  { 503, 3, 3, 9, 3, -3 },
  { 505, 13, 31, 15, 1, -31 },
  { 556, 16, 32, 20, 2, -32 },
  { 620, 8, 31, 20, 4, -31 },
  { 651, 15, 32, 20, 2, -32 },
  { 711, 15, 32, 20, 2, -32 },
  { 771, 18, 32, 20, 1, -32 },
  { 843, 16, 31, 20, 2, -31 },
  { 905, 16, 33, 20, 2, -32 },
  { 971, 16, 31, 20, 2, -31 },
  { 1033, 16, 32, 20, 2, -32 },
  { 1097, 15, 32, 20, 2, -32 },
  { 1157, 3, 24, 9, 3, -24 },
  { 1166, 4, 30, 9, 2, -24 },
  { 1181, 16, 19, 20, 2, -25 },
  { 1219, 16, 11, 20, 2, -21 },
  { 1241, 16, 19, 20, 2, -25 },
  { 1279, 12, 32, 14, 1, -32 },
  { 1327, 26, 35, 31, 2, -31 },
  { 1441, 20, 31, 20, 0, -31 },
  { 1519, 16, 31, 22, 4, -31 },
  { 1581, 18, 32, 21, 2, -32 },
  { 1653, 18, 31, 24, 4, -31 },
  { 1723, 13, 31, 19, 4, -31 },
  { 1774, 13, 31, 18, 4, -31 },
  { 1825, 21, 32, 26, 2, -32 },
  { 1909, 17, 31, 25, 4, -31 },
  { 1975, 7, 31, 11, 2, -31 },
  { 2003, 9, 39, 9, -3, -31 },
  { 2047, 16, 31, 20, 4, -31 },
  { 2109, 13, 31, 17, 4, -31 },
  { 2160, 24, 31, 32, 4, -31 },
  { 2253, 18, 31, 25, 4, -31 },
  { 2323, 22, 32, 26, 2, -32 },
  { 2411, 14, 31, 20, 4, -31 },
  { 2466, 22, 39, 26, 2, -32 },
  { 2574, 16, 31, 21, 4, -31 },
  { 2636, 15, 32, 19, 2, -32 },
  { 2696, 17, 31, 17, 0, -31 },
  { 2762, 18, 31, 25, 3, -31 },
  { 2832, 19, 31, 19, 0, -31 },
  { 2906, 31, 31, 32, 1, -31 },
  { 3027, 17, 31, 18, 0, -31 },
  { 3093, 17, 31, 17, 0, -31 },
  { 3159, 16, 31, 18, 1, -31 },
  { 3221, 8, 38, 14, 4, -31 },
  { 3259, 13, 31, 15, 1, -31 },
  { 3310, 9, 38, 14, 1, -31 },
  { 3353, 18, 16, 20, 1, -31 },
  { 3389, 18, 1, 18, 0, 4 },
  { 3392, 7, 7, 11, 2, -34 },
  { 3399, 13, 24, 18, 2, -24 },
  { 3438, 16, 33, 21, 3, -33 },
  { 3504, 13, 24, 16, 2, -24 },
  { 3543, 16, 33, 21, 2, -33 },
  { 3609, 15, 24, 19, 2, -24 },
  { 3654, 12, 34, 11, 0, -34 },
  { 3705, 16, 35, 21, 2, -24 },
  { 3775, 14, 33, 21, 3, -33 },
  { 3833, 3, 32, 9, 3, -32 },
  { 3845, 7, 43, 9, -1, -32 },
  { 3883, 14, 33, 17, 3, -33 },
  { 3941, 2, 33, 8, 3, -33 },
  { 3950, 25, 24, 31, 3, -24 },
  { 4025, 14, 24, 21, 3, -24 },
  { 4067, 16, 24, 20, 2, -24 },
  { 4115, 16, 34, 21, 3, -24 },
  { 4183, 16, 34, 21, 2, -24 },
  { 4251, 10, 24, 13, 3, -24 },
  { 4281, 12, 24, 16, 2, -24 },
  { 4317, 9, 29, 11, 1, -29 },
  { 4350, 14, 23, 21, 3, -23 },
  { 4391, 15, 23, 15, 0, -23 },
  { 4435, 25, 23, 26, 0, -23 },
  { 4507, 15, 23, 17, 1, -23 },
  { 4551, 16, 34, 16, 0, -23 },
  { 4619, 12, 23, 14, 1, -23 },
  { 4654, 11, 38, 15, 2, -31 },
  { 4707, 1, 45, 19, 9, -34 },
  { 4713, 11, 38, 15, 2, -31 },
  { 4766, 16, 4, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_ExtraLight44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT44PT7B_H_
