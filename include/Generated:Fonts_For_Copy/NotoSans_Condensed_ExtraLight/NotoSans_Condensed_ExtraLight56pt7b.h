#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT56PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight56pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x6F, 0xFE, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x01, 0x00, 0x01, 0x80, 0x40, 0x00, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x02, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x10, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x79, 0x87, 0x87, 0x0C, 0x04, 0x70, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x83, 0x00,
  0x0E, 0x18, 0x00, 0x38, 0xC0, 0x00, 0xF6, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x6F, 0x00, 0x03, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0xC0, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x38, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60,
  0x06, 0x07, 0x00, 0x30, 0x73, 0x81, 0x87, 0x1F, 0xCD, 0xF0, 0x3F, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x00, 0xE7, 0x00,
  0x0C, 0x03, 0x07, 0x00, 0x30, 0x06, 0x06, 0x00, 0x60, 0x08, 0x0C, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x18,
  0x01, 0x80, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x40, 0x06, 0x01, 0x81, 0x80,
  0x0C, 0x03, 0x03, 0x00, 0x18, 0x06, 0x0C, 0x00, 0x30, 0x0C, 0x18, 0x00,
  0x60, 0x18, 0x20, 0x00, 0xC0, 0x30, 0xC0, 0xC1, 0x80, 0x61, 0x87, 0xE3,
  0x00, 0xC6, 0x18, 0xE6, 0x01, 0x8C, 0x60, 0xC6, 0x06, 0x10, 0xC0, 0xCC,
  0x0C, 0x63, 0x01, 0x9C, 0x38, 0xC6, 0x03, 0x1C, 0xE3, 0x0C, 0x03, 0x1F,
  0x86, 0x10, 0x06, 0x08, 0x08, 0x20, 0x0C, 0x00, 0x30, 0xC0, 0x18, 0x00,
  0x61, 0x80, 0x30, 0x01, 0x83, 0x00, 0x60, 0x03, 0x06, 0x00, 0xC0, 0x06,
  0x0C, 0x01, 0x80, 0x18, 0x18, 0x03, 0x00, 0x30, 0x10, 0x06, 0x00, 0xC0,
  0x20, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x01, 0x81, 0x80, 0x60, 0x03, 0x06, 0x00, 0xC0, 0x03,
  0x1C, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x33, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x30, 0x06,
  0x30, 0x1C, 0x03, 0x38, 0x06, 0x01, 0x98, 0x01, 0x80, 0xCC, 0x00, 0xE0,
  0xCE, 0x00, 0x38, 0x66, 0x00, 0x0C, 0x33, 0x00, 0x03, 0x31, 0x80, 0x01,
  0xD8, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00,
  0x0F, 0x07, 0x00, 0x0E, 0xC1, 0x80, 0x0E, 0x70, 0xF0, 0x0E, 0x1C, 0x3E,
  0x7E, 0x06, 0x07, 0xFC, 0x03, 0x80, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x02, 0x02, 0x03, 0xE1, 0x0F, 0x3E, 0xBE,
  0x03, 0xF8, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x31, 0x80, 0x30,
  0x60, 0x30, 0x18, 0x38, 0x0E, 0x08, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x73, 0x18,
  0xCC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x3F,
  0xC0, 0x0F, 0xBE, 0x00, 0xC0, 0x70, 0x18, 0x03, 0x83, 0x80, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xE6,
  0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xC3,
  0x00, 0x18, 0x38, 0x01, 0x81, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x3B, 0x1C, 0xCE, 0x37, 0x0F,
  0x83, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x1F, 0x9F,
  0x07, 0x80, 0x38, 0x20, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x40, 0x00, 0xFF, 0xE0, 0x3F, 0x9F, 0x07, 0x80, 0x38, 0xE0, 0x01,
  0xC4, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0xE0,
  0x03, 0x8F, 0xE3, 0xF0, 0x3F, 0xFC, 0x00, 0x0A, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x70, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x67, 0xF8, 0x07, 0xFF, 0xE0, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x80, 0x03, 0x8C, 0x00, 0xF0, 0xFE, 0xFE, 0x03, 0xFF,
  0x80, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0xC3, 0xFE, 0x0C, 0x78,
  0xF0, 0xCC, 0x03, 0x8D, 0x80, 0x1C, 0xF0, 0x00, 0xCE, 0x00, 0x0E, 0xE0,
  0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x18, 0x01,
  0xC1, 0xC0, 0x38, 0x0F, 0x8F, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x03, 0xFE,
  0x00, 0x3E, 0xFC, 0x03, 0x80, 0x70, 0x30, 0x01, 0xC3, 0x80, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x33, 0x80, 0x01,
  0x8C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x70,
  0x07, 0x01, 0xC0, 0x70, 0x07, 0x87, 0x00, 0x0E, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xF8, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x80, 0x70, 0x07, 0x03, 0x00,
  0x18, 0x30, 0x00, 0x63, 0x80, 0x03, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x76,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00,
  0x3B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x0E, 0x0E,
  0x00, 0xE0, 0x3E, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0xC0, 0x0F, 0x9F, 0x01, 0xC0, 0x38, 0x18, 0x01, 0x83, 0x00,
  0x0C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x76, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x77, 0x00, 0x07,
  0x30, 0x00, 0xF3, 0x80, 0x1B, 0x1C, 0x03, 0xB0, 0xF0, 0xF3, 0x07, 0xFC,
  0x30, 0x0F, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x03,
  0x8F, 0xC0, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0xFF, 0xF4, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x18, 0xF3, 0xCE, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xC3, 0xF7, 0xE2,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x01, 0x86, 0x00, 0x1E, 0x00,
  0x63, 0x00, 0x3F, 0xE0, 0x33, 0x00, 0x78, 0x30, 0x19, 0x80, 0x30, 0x18,
  0x0C, 0xC0, 0x30, 0x0C, 0x03, 0x60, 0x38, 0x06, 0x01, 0xE0, 0x18, 0x03,
  0x00, 0xF0, 0x0C, 0x01, 0x80, 0x78, 0x0C, 0x00, 0xC0, 0x3C, 0x06, 0x00,
  0x60, 0x1E, 0x03, 0x00, 0x30, 0x0F, 0x01, 0x80, 0x18, 0x07, 0x80, 0xC0,
  0x1C, 0x03, 0xC0, 0x60, 0x0C, 0x01, 0xE0, 0x30, 0x06, 0x00, 0xF0, 0x18,
  0x03, 0x00, 0x58, 0x0C, 0x01, 0x80, 0x6C, 0x03, 0x01, 0xE0, 0x36, 0x01,
  0x80, 0xF0, 0x1B, 0x00, 0xE0, 0xC8, 0x18, 0xC0, 0x38, 0xE6, 0x18, 0x60,
  0x0F, 0xE1, 0xFC, 0x30, 0x01, 0xC0, 0x78, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xC0, 0x0F, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00,
  0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC,
  0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xC0, 0x07, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x78, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0xF0,
  0x03, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x40, 0x3F, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0x0A, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x0C, 0x01, 0xF0, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0xC3,
  0x00, 0x03, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x30, 0x00,
  0x70, 0xC0, 0x03, 0x83, 0x00, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE3, 0xF8, 0x07, 0x80, 0x0F, 0x03, 0x80,
  0x00, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC1, 0xE0, 0x00,
  0x30, 0x3E, 0x00, 0x1C, 0x03, 0xF9, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xDF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x07, 0xFB, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x1A, 0x1E, 0xFF, 0x3F, 0x00, 0xC0, 0x00, 0x7C,
  0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x70,
  0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x0C, 0x38,
  0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xCF, 0x00, 0x0D, 0xF8, 0x00, 0xD9,
  0x80, 0x0F, 0x1C, 0x00, 0xE0, 0xC0, 0x0C, 0x0E, 0x00, 0xC0, 0x60, 0x0C,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0xC0,
  0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xBF, 0x00, 0x00, 0x03, 0x7B, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x19,
  0xEC, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x67, 0x98, 0x00, 0x01, 0x8F,
  0x30, 0x00, 0x03, 0x1E, 0x30, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x18, 0x78,
  0xC0, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x61, 0xE1, 0x80, 0x01, 0x83, 0xC3,
  0x00, 0x03, 0x07, 0x83, 0x00, 0x06, 0x0F, 0x06, 0x00, 0x18, 0x1E, 0x0C,
  0x00, 0x30, 0x3C, 0x0C, 0x00, 0x60, 0x78, 0x18, 0x01, 0x80, 0xF0, 0x30,
  0x03, 0x01, 0xE0, 0x30, 0x06, 0x03, 0xC0, 0x60, 0x18, 0x07, 0x80, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x60, 0x1E, 0x01, 0x81, 0x80, 0x3C, 0x03, 0x03,
  0x00, 0x78, 0x03, 0x06, 0x00, 0xF0, 0x06, 0x18, 0x01, 0xE0, 0x0C, 0x30,
  0x03, 0xC0, 0x1C, 0x60, 0x07, 0x80, 0x19, 0xC0, 0x0F, 0x00, 0x33, 0x00,
  0x1E, 0x00, 0x76, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFB, 0x00,
  0x01, 0xF6, 0x00, 0x03, 0xE6, 0x00, 0x07, 0xCC, 0x00, 0x0F, 0x8C, 0x00,
  0x1F, 0x18, 0x00, 0x3E, 0x18, 0x00, 0x7C, 0x30, 0x00, 0xF8, 0x30, 0x01,
  0xF0, 0x60, 0x03, 0xE0, 0x60, 0x07, 0xC0, 0xE0, 0x0F, 0x80, 0xC0, 0x1F,
  0x01, 0xC0, 0x3E, 0x01, 0x80, 0x7C, 0x03, 0x80, 0xF8, 0x03, 0x01, 0xF0,
  0x07, 0x03, 0xE0, 0x06, 0x07, 0xC0, 0x0E, 0x0F, 0x80, 0x0C, 0x1F, 0x00,
  0x1C, 0x3E, 0x00, 0x18, 0x7C, 0x00, 0x38, 0xF8, 0x00, 0x31, 0xF0, 0x00,
  0x73, 0xE0, 0x00, 0x67, 0xC0, 0x00, 0xEF, 0x80, 0x00, 0xDF, 0x00, 0x01,
  0xDE, 0x00, 0x01, 0xBC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF,
  0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0C, 0x01, 0xE3, 0x00, 0x1C, 0xC0, 0x03,
  0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x1C, 0xC0, 0x1E,
  0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xE0,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xC0, 0x1E, 0x0C, 0x00, 0x70, 0xC0, 0x03,
  0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x07, 0x0C,
  0x00, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xC0, 0x60, 0x0C, 0x07, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00,
  0x38, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0,
  0x00, 0x6C, 0x00, 0x07, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x3F, 0x7F, 0x1E,
  0x00, 0x63, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x30, 0x01,
  0xC7, 0xF3, 0xF0, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x18,
  0xC0, 0x00, 0x71, 0xC0, 0x00, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x1E, 0x01,
  0xFB, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x80,
  0x00, 0xCC, 0x00, 0x0D, 0x80, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x07, 0x38,
  0x00, 0x36, 0x00, 0x0C, 0x30, 0x00, 0xCC, 0x00, 0x18, 0x60, 0x01, 0x98,
  0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0xE1, 0x80, 0x06, 0x30, 0x01, 0x81,
  0x80, 0x1C, 0x60, 0x03, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0x60,
  0xC0, 0x1C, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x1C, 0x01, 0x83, 0x00, 0x60,
  0x18, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x0C, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x07, 0x00, 0xE0, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0xE0, 0x30, 0x18,
  0x01, 0x81, 0x80, 0x60, 0x30, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x06, 0x06,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x03, 0x06,
  0x00, 0x18, 0x60, 0x06, 0x1C, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0x71,
  0x80, 0x0C, 0x60, 0x00, 0x67, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x31,
  0x80, 0x01, 0x98, 0x00, 0x37, 0x00, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x03,
  0x60, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x61, 0x80, 0x03,
  0x86, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0x60, 0x0E, 0x01,
  0x80, 0x30, 0x07, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x38, 0x18, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x1B, 0x80,
  0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x06, 0x1C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x01, 0x80,
  0x1C, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x30, 0x0C, 0x00, 0xE0, 0x70,
  0x01, 0x81, 0x80, 0x07, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x66, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x66,
  0x00, 0x03, 0x9C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x60, 0x06, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x1C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xDC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x06, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x38, 0x06, 0x00, 0x60,
  0x06, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x6E, 0x00, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x03, 0xF8, 0x1F, 0xFF, 0x07, 0x01,
  0xC2, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x03, 0xFC,
  0x1F, 0xFE, 0x1E, 0x03, 0x38, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x6C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xB0,
  0x01, 0x58, 0x01, 0xA6, 0x01, 0x93, 0xC3, 0x88, 0x7F, 0x84, 0x04, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F, 0xC0, 0xC7,
  0xFF, 0x0C, 0xE0, 0x38, 0xCC, 0x01, 0xCD, 0x80, 0x0C, 0xD0, 0x00, 0xEF,
  0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6F, 0x00, 0x0E, 0xD0,
  0x00, 0xCD, 0x80, 0x1C, 0xCC, 0x03, 0x8C, 0x79, 0xF0, 0xC3, 0xFE, 0x00,
  0x03, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0x01, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x01, 0x0F, 0xDF,
  0x03, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x3F, 0x83, 0x0F, 0xFE, 0x31, 0xE0, 0x73, 0x18, 0x03, 0x33, 0x00,
  0x1B, 0x70, 0x00, 0xB6, 0x00, 0x0F, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x0F, 0x70, 0x00, 0xB3, 0x80, 0x1B, 0x1C, 0x03, 0x30, 0xF1,
  0xE3, 0x07, 0xFC, 0x30, 0x04, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x78,
  0x1C, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x60, 0xF8, 0xFC, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x0F, 0xF0,
  0x78, 0x41, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xFF, 0x8F, 0xFE, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x03, 0xF8, 0x30, 0xFF, 0xE3, 0x1E, 0x07, 0x33, 0x80, 0x1B, 0x30, 0x00,
  0xB7, 0x00, 0x0F, 0x60, 0x00, 0xF6, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x0F,
  0x60, 0x00, 0xB3, 0x00, 0x1B, 0x38, 0x01, 0x71, 0xC0, 0x37, 0x0F, 0x1E,
  0x70, 0x7F, 0xC7, 0x00, 0x60, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x60, 0x03, 0x87, 0xE3, 0xF0, 0x1F, 0xFC, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x7F, 0x0C, 0x7F, 0xE3,
  0x38, 0x1C, 0xCC, 0x03, 0xB6, 0x00, 0x6F, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0C, 0x5F, 0xF4, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x07, 0x07, 0x07, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0xFC,
  0xF8, 0x20, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x1C,
  0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x0E, 0x18, 0x0E, 0x0C, 0x06, 0x06, 0x06,
  0x03, 0x07, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x31, 0xE0, 0x19,
  0xB0, 0x0D, 0x9C, 0x07, 0x86, 0x03, 0xC3, 0x81, 0xC0, 0xC0, 0xC0, 0x70,
  0x60, 0x18, 0x30, 0x0E, 0x18, 0x03, 0x0C, 0x01, 0xC6, 0x00, 0x63, 0x00,
  0x39, 0x80, 0x0C, 0xC0, 0x07, 0x60, 0x01, 0xB0, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3, 0xF8, 0x0F,
  0xE1, 0x8F, 0xF8, 0x3F, 0xE3, 0x30, 0x38, 0xC0, 0xE6, 0xC0, 0x33, 0x00,
  0xED, 0x00, 0x34, 0x00, 0xDE, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xE0, 0x01,
  0xF0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x07, 0x80, 0x03, 0x00, 0x0F,
  0x00, 0x06, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x78,
  0x00, 0x30, 0x00, 0xF0, 0x00, 0x60, 0x01, 0xE0, 0x00, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0x07, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0x0C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x78, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0x60, 0x01, 0xE0, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x03,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x18,
  0x00, 0x78, 0x00, 0x30, 0x00, 0xC0, 0xC1, 0xFC, 0x31, 0xFF, 0x8C, 0xE0,
  0x73, 0x70, 0x0E, 0xD8, 0x01, 0xBC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x18,
  0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x38,
  0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0xC1, 0xFC, 0x0C, 0x7F,
  0xF0, 0xCE, 0x03, 0x8C, 0xC0, 0x1C, 0xD8, 0x00, 0xCD, 0x00, 0x0E, 0xF0,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xF0, 0x00, 0xED, 0x00,
  0x0C, 0xD8, 0x01, 0xCC, 0xC0, 0x38, 0xC7, 0x9F, 0x0C, 0x3F, 0xE0, 0xC0,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x30, 0xFF,
  0xE3, 0x1E, 0x07, 0x31, 0x80, 0x33, 0x30, 0x01, 0xB7, 0x00, 0x0B, 0x60,
  0x00, 0xF6, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x0F, 0x60, 0x00, 0xB7, 0x00,
  0x1B, 0x38, 0x01, 0x71, 0xC0, 0x77, 0x0F, 0x1E, 0x70, 0x7F, 0xC7, 0x00,
  0x60, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0xC1, 0xFC, 0x7F, 0xCE,
  0x1C, 0xC0, 0xD8, 0x0D, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xFC, 0x1F, 0xFF, 0x38, 0x06, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x80, 0x06, 0xC0,
  0x0E, 0xFC, 0xFC, 0x3F, 0xF0, 0x03, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xFF, 0xFF, 0xF1, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xF3, 0x07, 0xF0, 0x18, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03,
  0xD8, 0x00, 0xB7, 0x00, 0x6C, 0xE0, 0x33, 0x3E, 0x78, 0xC3, 0xFC, 0x30,
  0x10, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x77,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x38, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x70, 0x30, 0x06, 0x06, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xE6, 0x00, 0x0C, 0xC0, 0x01,
  0xB8, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xCC, 0x00, 0xD8,
  0x01, 0x98, 0x01, 0xB0, 0x03, 0x30, 0x03, 0x60, 0x0C, 0x30, 0x0C, 0x60,
  0x18, 0x60, 0x18, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x61, 0x80, 0x63, 0x01,
  0x81, 0x81, 0x83, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x38, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x60, 0x30, 0xC0,
  0x30, 0xC0, 0x61, 0x80, 0x61, 0x80, 0xC3, 0x00, 0xE6, 0x00, 0xCC, 0x00,
  0xCC, 0x01, 0x98, 0x01, 0x98, 0x03, 0x30, 0x03, 0x30, 0x06, 0x60, 0x06,
  0xC0, 0x05, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xEE, 0x00, 0x18, 0xC0, 0x06, 0x1C, 0x00, 0xC1, 0x80, 0x30, 0x38,
  0x0E, 0x03, 0x01, 0x80, 0x70, 0x70, 0x06, 0x0C, 0x00, 0xE3, 0x80, 0x0C,
  0x60, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x03, 0x07, 0x00,
  0x60, 0xC0, 0x06, 0x38, 0x00, 0xE6, 0x00, 0x0D, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0xC0, 0x18,
  0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x70, 0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x9C, 0x00, 0x0D, 0x80, 0x00,
  0xD8, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x0D, 0xE0, 0x00, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xFC,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x03,
  0xC0, 0x7E, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x80, 0x70, 0x1F,
  0x0F, 0x00, 0x3F, 0xE8, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 40, 12, 4, -40 },
  { 21, 10, 14, 18, 4, -40 },
  { 39, 26, 40, 28, 1, -40 },
  { 169, 21, 46, 25, 2, -43 },
  { 290, 31, 42, 37, 3, -41 },
  { 453, 25, 42, 28, 2, -41 },
  { 585, 2, 14, 10, 4, -40 },
  { 589, 10, 49, 15, 3, -40 },
  { 651, 10, 49, 15, 2, -40 },
  { 713, 17, 18, 23, 3, -43 },
  { 752, 21, 26, 25, 2, -33 },
  { 821, 5, 13, 11, 2, -6 },
  { 830, 12, 2, 16, 2, -16 },
  { 833, 3, 4, 11, 4, -4 },
  { 835, 17, 40, 19, 1, -40 },
  { 920, 20, 41, 25, 3, -41 },
  { 1023, 10, 40, 25, 5, -40 },
  { 1073, 20, 41, 25, 2, -41 },
  { 1176, 20, 42, 25, 2, -41 },
  { 1281, 24, 40, 25, 1, -40 },
  { 1401, 20, 41, 25, 3, -40 },
  { 1504, 20, 41, 25, 3, -40 },
  { 1607, 19, 40, 25, 3, -40 },
  { 1702, 21, 41, 25, 2, -40 },
  { 1810, 20, 42, 25, 2, -41 },
  { 1915, 3, 30, 11, 4, -30 },
  { 1927, 6, 37, 11, 2, -30 },
  { 1955, 21, 24, 25, 2, -32 },
  { 2018, 21, 14, 25, 2, -27 },
  { 2055, 21, 24, 25, 2, -32 },
  { 2118, 15, 41, 18, 1, -41 },
  { 2195, 33, 45, 39, 3, -40 },
  { 2381, 25, 40, 25, 0, -40 },
  { 2506, 20, 40, 28, 5, -40 },
  { 2606, 22, 42, 27, 3, -41 },
  { 2722, 22, 40, 31, 5, -40 },
  { 2832, 16, 40, 24, 5, -40 },
  { 2912, 17, 40, 22, 5, -40 },
  { 2997, 26, 42, 33, 3, -41 },
  { 3134, 22, 40, 31, 5, -40 },
  { 3244, 10, 40, 14, 2, -40 },
  { 3294, 10, 50, 12, -3, -40 },
  { 3357, 20, 40, 25, 5, -40 },
  { 3457, 16, 40, 22, 5, -40 },
  { 3537, 31, 40, 40, 5, -40 },
  { 3692, 23, 40, 32, 5, -40 },
  { 3807, 27, 42, 33, 3, -41 },
  { 3949, 18, 40, 26, 5, -40 },
  { 4039, 27, 51, 33, 3, -41 },
  { 4212, 20, 40, 26, 5, -40 },
  { 4312, 19, 42, 25, 3, -41 },
  { 4412, 22, 40, 22, 0, -40 },
  { 4522, 23, 41, 31, 4, -40 },
  { 4640, 25, 40, 25, 0, -40 },
  { 4765, 39, 40, 41, 1, -40 },
  { 4960, 22, 40, 22, 0, -40 },
  { 5070, 22, 40, 22, 0, -40 },
  { 5180, 19, 40, 23, 2, -40 },
  { 5275, 11, 49, 17, 5, -40 },
  { 5343, 17, 40, 19, 1, -40 },
  { 5428, 11, 49, 17, 2, -40 },
  { 5496, 23, 21, 25, 1, -40 },
  { 5557, 23, 2, 22, 0, 5 },
  { 5563, 9, 9, 13, 2, -43 },
  { 5574, 17, 31, 24, 2, -30 },
  { 5640, 20, 44, 27, 4, -43 },
  { 5750, 16, 31, 21, 3, -30 },
  { 5812, 20, 44, 27, 3, -43 },
  { 5922, 19, 31, 24, 3, -30 },
  { 5996, 14, 43, 13, 1, -43 },
  { 6072, 20, 44, 27, 3, -30 },
  { 6182, 18, 43, 26, 4, -43 },
  { 6279, 3, 41, 11, 4, -41 },
  { 6295, 8, 55, 11, -1, -41 },
  { 6350, 17, 43, 21, 4, -43 },
  { 6442, 2, 43, 11, 4, -43 },
  { 6453, 31, 30, 39, 4, -30 },
  { 6570, 18, 30, 26, 4, -30 },
  { 6638, 20, 31, 26, 3, -30 },
  { 6716, 20, 43, 27, 4, -30 },
  { 6824, 20, 43, 27, 3, -30 },
  { 6932, 12, 30, 17, 4, -30 },
  { 6977, 16, 31, 20, 2, -30 },
  { 7039, 12, 38, 14, 1, -37 },
  { 7096, 18, 31, 26, 4, -30 },
  { 7166, 19, 30, 20, 0, -30 },
  { 7238, 31, 30, 33, 1, -30 },
  { 7355, 19, 30, 21, 1, -30 },
  { 7427, 20, 44, 20, 0, -30 },
  { 7537, 15, 30, 18, 2, -30 },
  { 7594, 15, 49, 19, 2, -40 },
  { 7686, 2, 57, 24, 11, -43 },
  { 7701, 15, 49, 19, 2, -40 },
  { 7793, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_ExtraLight56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT56PT7B_H_
