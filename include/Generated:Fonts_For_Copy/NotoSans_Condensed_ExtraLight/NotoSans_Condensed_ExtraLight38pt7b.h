#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT38PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xA1, 0x42, 0x85, 0x08, 0x03, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00,
  0x41, 0x80, 0x20, 0xC0, 0x30, 0x40, 0x18, 0x20, 0x08, 0x10, 0x7F, 0xFF,
  0x82, 0x04, 0x01, 0x06, 0x00, 0x83, 0x00, 0x41, 0x00, 0x60, 0x80, 0x30,
  0x40, 0x10, 0x20, 0x08, 0x10, 0x7F, 0xFF, 0x82, 0x0C, 0x01, 0x06, 0x01,
  0x82, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x30,
  0x04, 0x18, 0x00, 0x02, 0x00, 0x10, 0x01, 0xC0, 0x7F, 0xE6, 0x21, 0x61,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x84, 0x06, 0x20,
  0x19, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x13, 0x80, 0x84, 0x04, 0x30,
  0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x1C, 0x11, 0xBC, 0xB8, 0x7F,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x08, 0x10,
  0x80, 0x40, 0x86, 0x04, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x02, 0x04, 0x10,
  0x10, 0x20, 0x80, 0x81, 0x08, 0x04, 0x08, 0x40, 0x20, 0x46, 0x01, 0x02,
  0x21, 0x88, 0x11, 0x3E, 0x60, 0x91, 0x09, 0x0C, 0x90, 0x48, 0x4C, 0x83,
  0x3C, 0x44, 0x18, 0x42, 0x20, 0x40, 0x21, 0x02, 0x01, 0x08, 0x10, 0x18,
  0x40, 0x80, 0x82, 0x04, 0x04, 0x10, 0x20, 0x40, 0x83, 0x02, 0x04, 0x18,
  0x30, 0x30, 0x81, 0x00, 0x8C, 0x18, 0x03, 0xC0, 0x02, 0x00, 0x0F, 0xC0,
  0x04, 0x30, 0x06, 0x08, 0x02, 0x06, 0x01, 0x03, 0x00, 0x81, 0x80, 0x40,
  0xC0, 0x30, 0x40, 0x08, 0x20, 0x04, 0x20, 0x01, 0x30, 0x00, 0xF0, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x66, 0x00, 0x61, 0x03, 0x60, 0x41, 0x20, 0x30,
  0x90, 0x0C, 0x48, 0x02, 0x64, 0x01, 0xA2, 0x00, 0x71, 0x00, 0x30, 0xC0,
  0x1C, 0x60, 0x1B, 0x18, 0x38, 0x87, 0xF0, 0x70, 0xFF, 0xC0, 0x06, 0x18,
  0x60, 0x83, 0x04, 0x08, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xC0, 0x81, 0x83, 0x02,
  0x02, 0x06, 0x06, 0xC0, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x06, 0x04, 0x0C,
  0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x18, 0x30, 0x41, 0x82, 0x0C, 0x30, 0xC0, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0xC4, 0x37, 0xDE, 0x0E, 0x00, 0xE0, 0x09, 0x01, 0x18, 0x30,
  0xC6, 0x04, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x33, 0x32,
  0x26, 0x64, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x02, 0x00, 0xFE, 0x04,
  0x18, 0x40, 0x46, 0x03, 0x20, 0x09, 0x00, 0x58, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xA0, 0x0D, 0x00, 0x4C, 0x02, 0x60,
  0x31, 0x81, 0x06, 0x38, 0x1F, 0x00, 0x06, 0x1C, 0x69, 0x96, 0x38, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x06, 0x01, 0xFE, 0x38, 0x18, 0x80,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0xFF, 0xF0, 0x06, 0x01, 0xFE, 0x38, 0x19, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x0F, 0x80, 0x7E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0xB0, 0x39,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x70, 0x00, 0x50, 0x00, 0xD0, 0x00, 0x90,
  0x01, 0x90, 0x01, 0x10, 0x03, 0x10, 0x02, 0x10, 0x04, 0x10, 0x0C, 0x10,
  0x08, 0x10, 0x18, 0x10, 0x10, 0x10, 0x30, 0x10, 0x20, 0x10, 0x60, 0x10,
  0xC0, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x7F, 0xF3, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xFF, 0x86, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x36, 0x07, 0x1F, 0xE0, 0x07, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x31, 0xE1, 0xBF, 0xCF,
  0x03, 0x50, 0x0B, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xA0, 0x05, 0x00, 0x6C, 0x03, 0x20, 0x31, 0xC3, 0x03, 0xF0,
  0xFF, 0xF8, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x1F, 0xC0, 0xC1, 0x86,
  0x03, 0x10, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0x90, 0x06, 0x60, 0x10,
  0x80, 0xC3, 0x06, 0x03, 0x70, 0x07, 0x00, 0x36, 0x03, 0x0E, 0x18, 0x0C,
  0x40, 0x13, 0x00, 0x68, 0x00, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x28, 0x00,
  0xB0, 0x06, 0x60, 0x10, 0xC1, 0x81, 0xFC, 0x00, 0x02, 0x00, 0xFE, 0x0C,
  0x18, 0xC0, 0x4C, 0x03, 0x60, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0D, 0x00, 0xAC, 0x0D, 0x3F, 0xD8,
  0x30, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x33,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x32, 0x26, 0x44, 0xC0,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x02, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x00, 0x80, 0x00, 0x08, 0x3F, 0xC8,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x03, 0x80, 0x60, 0x00, 0xFF, 0x00, 0x0E,
  0x06, 0x00, 0x60, 0x06, 0x03, 0x00, 0x08, 0x18, 0x00, 0x10, 0xC0, 0x00,
  0x62, 0x00, 0x00, 0x98, 0x02, 0x03, 0x60, 0x7F, 0x0D, 0x03, 0x0C, 0x14,
  0x18, 0x30, 0x70, 0x40, 0xC1, 0xC1, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x30,
  0x20, 0x60, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60,
  0x70, 0x41, 0x83, 0xC1, 0x8D, 0x09, 0x03, 0x66, 0xC4, 0x07, 0x0E, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x01, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x50, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x11, 0x00, 0x08,
  0x80, 0x04, 0x60, 0x06, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x83, 0x00,
  0xC0, 0x80, 0x40, 0x40, 0x20, 0x30, 0x3F, 0xF8, 0x1F, 0xFC, 0x08, 0x02,
  0x0C, 0x01, 0x86, 0x00, 0x42, 0x00, 0x21, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x02, 0x40, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x20, 0xFF, 0xC3, 0x01, 0xCC,
  0x01, 0xB0, 0x06, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0xC0, 0x0B,
  0x00, 0x6C, 0x01, 0x30, 0x1C, 0xFF, 0xC3, 0x03, 0x8C, 0x03, 0xB0, 0x02,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x06, 0xC0, 0x1B, 0x03, 0xCF, 0xFC, 0x00, 0x00, 0x20, 0x07, 0xFC,
  0x38, 0x08, 0xE0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x18, 0x1F,
  0xF0, 0xFF, 0x80, 0xC0, 0xE0, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x0C, 0xC0,
  0x04, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x30, 0xC1, 0xE0, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x70, 0x1C,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x32, 0x00, 0x0C, 0xC0, 0x03, 0x18,
  0x00, 0xC3, 0x00, 0x30, 0x70, 0x1C, 0x0F, 0xFC, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x08, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06,
  0xF9, 0xE0, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0x30, 0x18, 0xC0, 0x43, 0x03,
  0x0C, 0x18, 0x30, 0xC0, 0xC3, 0x03, 0x18, 0x0C, 0xC0, 0x32, 0x00, 0xDC,
  0x03, 0xD0, 0x0E, 0x60, 0x30, 0xC0, 0xC3, 0x03, 0x06, 0x0C, 0x08, 0x30,
  0x30, 0xC0, 0x43, 0x01, 0x8C, 0x02, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x2C,
  0x00, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0xFF, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x5F, 0x00, 0x06, 0xE8, 0x00, 0x37, 0x60, 0x01, 0x3B, 0x00,
  0x09, 0xC8, 0x00, 0xCE, 0x60, 0x04, 0x73, 0x00, 0x23, 0x88, 0x03, 0x1C,
  0x60, 0x10, 0xE3, 0x00, 0x87, 0x08, 0x0C, 0x38, 0x60, 0x41, 0xC3, 0x02,
  0x0E, 0x08, 0x30, 0x70, 0x61, 0x03, 0x83, 0x08, 0x1C, 0x08, 0xC0, 0xE0,
  0x64, 0x07, 0x03, 0x20, 0x38, 0x0B, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0C, 0x02, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xD0,
  0x03, 0xD8, 0x03, 0xC8, 0x03, 0xCC, 0x03, 0xC4, 0x03, 0xC6, 0x03, 0xC2,
  0x03, 0xC3, 0x03, 0xC1, 0x03, 0xC1, 0x83, 0xC0, 0x83, 0xC0, 0xC3, 0xC0,
  0x43, 0xC0, 0x63, 0xC0, 0x23, 0xC0, 0x33, 0xC0, 0x13, 0xC0, 0x1B, 0xC0,
  0x0B, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x00, 0x40, 0x01,
  0xFE, 0x00, 0xC0, 0xE0, 0x60, 0x0C, 0x30, 0x01, 0x08, 0x00, 0x66, 0x00,
  0x09, 0x00, 0x02, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x26, 0x00,
  0x08, 0x80, 0x06, 0x30, 0x03, 0x06, 0x00, 0x80, 0xE0, 0xC0, 0x1F, 0xE0,
  0xFF, 0x86, 0x0F, 0x30, 0x0D, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x2C, 0x03, 0x60, 0x33, 0xFF,
  0x1F, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x40, 0x01, 0xFE,
  0x00, 0xC0, 0xE0, 0x60, 0x0C, 0x30, 0x01, 0x08, 0x00, 0x66, 0x00, 0x09,
  0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x05, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x08,
  0x80, 0x06, 0x30, 0x03, 0x06, 0x00, 0x80, 0xE0, 0xE0, 0x1F, 0xE0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0xFF, 0x83, 0x07, 0x8C, 0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x6C,
  0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x63,
  0x0F, 0x0F, 0xF0, 0x30, 0x40, 0xC1, 0x83, 0x02, 0x0C, 0x0C, 0x30, 0x10,
  0xC0, 0x63, 0x00, 0x8C, 0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x2C, 0x00,
  0xC0, 0x01, 0x00, 0xFF, 0xCC, 0x04, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0xB0, 0x39, 0xFF, 0x00, 0xFF,
  0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50, 0x01, 0xB0, 0x02, 0x60,
  0x0C, 0x70, 0x70, 0x3F, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0x90, 0x00, 0xC8,
  0x00, 0x66, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x04,
  0x08, 0x02, 0x04, 0x03, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0xC0, 0x20,
  0x60, 0x18, 0x20, 0x04, 0x10, 0x02, 0x18, 0x01, 0x88, 0x00, 0xC4, 0x00,
  0x22, 0x00, 0x13, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x00, 0xC0, 0x0D, 0x80, 0x38,
  0x01, 0xB0, 0x07, 0x00, 0x22, 0x00, 0xB0, 0x04, 0x40, 0x16, 0x01, 0x88,
  0x02, 0x40, 0x31, 0x80, 0xC8, 0x04, 0x30, 0x19, 0x00, 0x82, 0x02, 0x30,
  0x30, 0x40, 0x46, 0x06, 0x0C, 0x18, 0x40, 0xC1, 0x83, 0x08, 0x10, 0x10,
  0x41, 0x86, 0x02, 0x08, 0x30, 0xC0, 0x61, 0x02, 0x18, 0x0C, 0x60, 0x42,
  0x01, 0x8C, 0x08, 0x40, 0x11, 0x01, 0x98, 0x02, 0x20, 0x33, 0x00, 0x6C,
  0x02, 0x40, 0x0D, 0x80, 0x48, 0x00, 0xA0, 0x0B, 0x00, 0x14, 0x01, 0xE0,
  0x02, 0x80, 0x18, 0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60,
  0x06, 0x40, 0x18, 0xC0, 0x20, 0x80, 0xC1, 0x81, 0x81, 0x02, 0x03, 0x0C,
  0x02, 0x10, 0x04, 0x60, 0x0C, 0x80, 0x0B, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x60, 0x06, 0x40, 0x08, 0xC0, 0x30, 0x80, 0x41,
  0x81, 0x81, 0x02, 0x02, 0x0C, 0x06, 0x10, 0x04, 0x60, 0x0C, 0xC0, 0x0B,
  0x00, 0x18, 0xC0, 0x06, 0x80, 0x19, 0x80, 0x33, 0x00, 0x42, 0x01, 0x86,
  0x02, 0x04, 0x04, 0x0C, 0x18, 0x18, 0x20, 0x10, 0xC0, 0x31, 0x00, 0x22,
  0x00, 0x6C, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x3F,
  0xFE, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x01, 0x80, 0x07,
  0x00, 0x0B, 0x00, 0x32, 0x00, 0x46, 0x01, 0x84, 0x02, 0x0C, 0x0C, 0x08,
  0x10, 0x18, 0x60, 0x10, 0x80, 0x33, 0x00, 0x24, 0x00, 0x78, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x3F, 0x8C, 0x18,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xE3, 0xFD, 0xC0,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x78, 0x15, 0x06, 0x9F,
  0x90, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x7E, 0x2C, 0x19, 0x40, 0x6C, 0x01, 0x60, 0x0F,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xA8, 0x0D, 0x60, 0xC8, 0xFC,
  0x00, 0x0F, 0xE3, 0x04, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xE0, 0x87, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0xFE, 0x4C, 0x1A, 0xC0,
  0x76, 0x01, 0xA0, 0x0F, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1A, 0x00, 0xD8,
  0x0A, 0x60, 0xD1, 0xFC, 0x80, 0x1F, 0xC1, 0x83, 0x08, 0x08, 0xC0, 0x64,
  0x01, 0x60, 0x0B, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0E, 0x0C,
  0x1F, 0xC0, 0x07, 0xC3, 0x90, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x3F, 0xC1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x00, 0x1F, 0xC9, 0x83, 0x58, 0x0E, 0xC0, 0x34, 0x01, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x68, 0x03, 0x40, 0x1B, 0x01, 0x4C, 0x1A, 0x3F, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xE0, 0x0C, 0xC1,
  0xC3, 0xFC, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x09, 0xFC, 0xB0, 0x6A, 0x02, 0xC0, 0x3C, 0x03,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xBC,
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x08, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0xF0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x0E,
  0x03, 0x40, 0xC8, 0x11, 0x04, 0x21, 0x84, 0x60, 0x88, 0x13, 0x02, 0xF0,
  0x52, 0x0C, 0x61, 0x04, 0x20, 0xC4, 0x08, 0x81, 0x90, 0x12, 0x03, 0x40,
  0x28, 0x06, 0xFF, 0xFF, 0xFF, 0xF8, 0x9F, 0x87, 0xE5, 0x86, 0x41, 0xA8,
  0x14, 0x05, 0x80, 0xE0, 0x2C, 0x06, 0x01, 0xC0, 0x10, 0x0E, 0x00, 0x80,
  0x70, 0x04, 0x03, 0x80, 0x20, 0x1C, 0x01, 0x00, 0xE0, 0x08, 0x07, 0x00,
  0x40, 0x38, 0x02, 0x01, 0xC0, 0x10, 0x0E, 0x00, 0x80, 0x70, 0x04, 0x03,
  0x80, 0x20, 0x1C, 0x01, 0x00, 0xE0, 0x08, 0x07, 0x00, 0x40, 0x30, 0x8F,
  0xCB, 0x06, 0xA0, 0x2C, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x1F, 0xC0, 0xC1, 0x86, 0x03, 0x18, 0x06,
  0x40, 0x0B, 0x00, 0x2C, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x2C, 0x00, 0x90, 0x06, 0x60, 0x18, 0x80,
  0xC3, 0x06, 0x07, 0xF0, 0x8F, 0xC4, 0x83, 0x28, 0x0D, 0xC0, 0x2C, 0x01,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x15, 0x01, 0xA4, 0x19, 0x1F,
  0x88, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x1F, 0xC9, 0x83, 0x58, 0x0A, 0xC0, 0x34, 0x01,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x01, 0x4C, 0x1A, 0x3F,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x9F, 0x90, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x1F, 0xE6, 0x05, 0x80, 0x20, 0x04, 0x00, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0F, 0x03, 0x3F, 0xC0, 0x20, 0x20, 0x20, 0x20, 0x20, 0xFF, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x30, 0x30, 0x1F, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x5C, 0x05, 0x61, 0x93, 0xF1, 0xC0,
  0x1A, 0x00, 0xD0, 0x04, 0xC0, 0x26, 0x03, 0x10, 0x18, 0x80, 0x86, 0x04,
  0x10, 0x60, 0x82, 0x06, 0x10, 0x31, 0x80, 0x8C, 0x04, 0x40, 0x32, 0x00,
  0xB0, 0x05, 0x00, 0x28, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x30, 0x0D, 0x00,
  0xC0, 0x24, 0x03, 0x80, 0x98, 0x0A, 0x06, 0x20, 0x68, 0x18, 0x81, 0x20,
  0x42, 0x04, 0xC1, 0x0C, 0x13, 0x04, 0x30, 0xC4, 0x30, 0x42, 0x10, 0xC1,
  0x08, 0x62, 0x06, 0x21, 0x88, 0x19, 0x82, 0x60, 0x24, 0x09, 0x80, 0x90,
  0x34, 0x03, 0x40, 0xD0, 0x0F, 0x01, 0x40, 0x18, 0x07, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x60, 0xC0, 0x34, 0x02, 0x60, 0x63, 0x04, 0x10, 0xC1, 0x88,
  0x09, 0x80, 0xD0, 0x07, 0x00, 0x60, 0x06, 0x00, 0xF0, 0x09, 0x01, 0x88,
  0x10, 0xC3, 0x04, 0x20, 0x66, 0x02, 0x40, 0x3C, 0x01, 0xC0, 0x0D, 0x00,
  0x26, 0x01, 0x88, 0x06, 0x20, 0x10, 0xC0, 0xC3, 0x03, 0x04, 0x08, 0x10,
  0x20, 0x61, 0x80, 0x84, 0x02, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0x48, 0x01,
  0x20, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x26, 0x00, 0xF0, 0x00,
  0x7F, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0xFF, 0x03, 0xC1, 0x80, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x0C, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x1C, 0x01, 0xC1, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x3E,
  0x03, 0xC7, 0x0E, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLight38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 27, 8, 3, -27 },
  { 8, 7, 10, 12, 3, -27 },
  { 17, 17, 27, 19, 1, -27 },
  { 75, 13, 31, 17, 2, -29 },
  { 126, 21, 28, 25, 2, -28 },
  { 200, 17, 28, 19, 2, -28 },
  { 260, 1, 10, 7, 3, -27 },
  { 262, 7, 33, 10, 2, -27 },
  { 291, 7, 33, 10, 1, -27 },
  { 320, 12, 12, 16, 2, -29 },
  { 338, 15, 17, 17, 1, -22 },
  { 370, 4, 9, 7, 1, -4 },
  { 375, 9, 1, 11, 1, -11 },
  { 377, 2, 3, 8, 3, -3 },
  { 378, 11, 27, 13, 1, -27 },
  { 416, 13, 28, 17, 2, -28 },
  { 462, 7, 27, 17, 3, -27 },
  { 486, 13, 28, 17, 2, -28 },
  { 532, 13, 28, 17, 2, -28 },
  { 578, 16, 27, 17, 1, -27 },
  { 632, 13, 27, 17, 2, -27 },
  { 676, 13, 27, 17, 2, -27 },
  { 720, 13, 27, 17, 2, -27 },
  { 764, 14, 27, 17, 2, -27 },
  { 812, 13, 28, 17, 2, -28 },
  { 858, 2, 20, 8, 3, -20 },
  { 863, 4, 25, 8, 1, -20 },
  { 876, 15, 17, 17, 1, -22 },
  { 908, 15, 9, 17, 1, -18 },
  { 925, 15, 17, 17, 1, -22 },
  { 957, 10, 28, 12, 1, -28 },
  { 992, 22, 31, 26, 2, -27 },
  { 1078, 17, 27, 17, 0, -27 },
  { 1136, 14, 27, 19, 3, -27 },
  { 1184, 15, 28, 18, 2, -28 },
  { 1237, 16, 27, 21, 3, -27 },
  { 1291, 12, 27, 17, 3, -27 },
  { 1332, 12, 27, 15, 3, -27 },
  { 1373, 18, 28, 22, 2, -28 },
  { 1436, 15, 27, 21, 3, -27 },
  { 1487, 6, 27, 10, 2, -27 },
  { 1508, 7, 34, 8, -2, -27 },
  { 1538, 14, 27, 17, 3, -27 },
  { 1586, 11, 27, 15, 3, -27 },
  { 1624, 21, 27, 27, 3, -27 },
  { 1695, 16, 27, 22, 3, -27 },
  { 1749, 18, 28, 22, 2, -28 },
  { 1812, 13, 27, 17, 3, -27 },
  { 1856, 18, 34, 22, 2, -28 },
  { 1933, 14, 27, 18, 3, -27 },
  { 1981, 13, 28, 17, 2, -28 },
  { 2027, 15, 27, 15, 0, -27 },
  { 2078, 15, 27, 21, 3, -27 },
  { 2129, 17, 27, 17, 0, -27 },
  { 2187, 27, 27, 28, 0, -27 },
  { 2279, 15, 27, 15, 0, -27 },
  { 2330, 15, 27, 15, 0, -27 },
  { 2381, 13, 27, 15, 1, -27 },
  { 2425, 8, 33, 12, 3, -27 },
  { 2458, 11, 27, 13, 1, -27 },
  { 2496, 8, 33, 12, 1, -27 },
  { 2529, 15, 14, 17, 1, -27 },
  { 2556, 15, 2, 15, 0, 3 },
  { 2560, 6, 6, 9, 2, -29 },
  { 2565, 11, 20, 16, 2, -20 },
  { 2593, 13, 29, 18, 3, -29 },
  { 2641, 11, 20, 14, 2, -20 },
  { 2669, 13, 29, 18, 2, -29 },
  { 2717, 13, 20, 17, 2, -20 },
  { 2750, 10, 29, 9, 0, -29 },
  { 2787, 13, 29, 18, 2, -20 },
  { 2835, 12, 29, 18, 3, -29 },
  { 2879, 2, 28, 7, 3, -28 },
  { 2886, 6, 37, 7, -1, -28 },
  { 2914, 11, 29, 14, 3, -29 },
  { 2954, 1, 29, 7, 3, -29 },
  { 2958, 21, 20, 26, 3, -20 },
  { 3011, 12, 20, 18, 3, -20 },
  { 3041, 14, 20, 18, 2, -20 },
  { 3076, 13, 29, 18, 3, -20 },
  { 3124, 13, 29, 18, 2, -20 },
  { 3172, 8, 20, 12, 3, -20 },
  { 3192, 11, 20, 14, 1, -20 },
  { 3220, 8, 25, 10, 1, -25 },
  { 3245, 12, 20, 18, 3, -20 },
  { 3275, 13, 20, 13, 0, -20 },
  { 3308, 22, 20, 22, 0, -20 },
  { 3363, 12, 20, 14, 1, -20 },
  { 3393, 14, 29, 14, 0, -20 },
  { 3444, 10, 20, 12, 1, -20 },
  { 3469, 10, 33, 13, 2, -27 },
  { 3511, 2, 38, 16, 7, -29 },
  { 3521, 10, 33, 13, 2, -27 },
  { 3563, 15, 3, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_ExtraLight38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT38PT7B_H_
