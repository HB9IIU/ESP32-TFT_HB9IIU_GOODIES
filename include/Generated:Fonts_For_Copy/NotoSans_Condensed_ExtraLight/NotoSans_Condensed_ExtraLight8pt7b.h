#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT8PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x56, 0xF6, 0xFA, 0x7B, 0x17, 0xC0, 0x55, 0x2C, 0xD2,
  0xAC, 0x4A, 0x4D, 0xAF, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0xCC, 0x4B, 0xA0,
  0xC0, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x76, 0xDA, 0xC0, 0xFC, 0xE4, 0x95,
  0xC0, 0xE4, 0xB3, 0xC0, 0x22, 0x6A, 0xF2, 0x73, 0x13, 0xC0, 0x73, 0x5B,
  0xC0, 0xE4, 0x94, 0x80, 0x75, 0xDB, 0xC0, 0x76, 0xB2, 0xC0, 0x10, 0x18,
  0x2B, 0x10, 0xFC, 0x8C, 0xE0, 0xD5, 0xA0, 0x32, 0x6F, 0xBF, 0xC1, 0xC0,
  0x44, 0x6E, 0x99, 0xD7, 0xDB, 0xC0, 0x78, 0x88, 0x87, 0xD6, 0xDB, 0x80,
  0xEB, 0xB0, 0xEB, 0xA0, 0x78, 0x89, 0x97, 0xB6, 0xFB, 0x40, 0xD5, 0x70,
  0xFE, 0xBA, 0x4D, 0x40, 0xAA, 0xB0, 0x99, 0x9B, 0xFD, 0xB6, 0xFF, 0x40,
  0x69, 0x99, 0x97, 0xFE, 0xA0, 0x69, 0x99, 0x97, 0x10, 0xD6, 0xED, 0x40,
  0x73, 0x13, 0xC0, 0xE9, 0x24, 0x80, 0xB6, 0xDB, 0xC0, 0x99, 0xA6, 0x44,
  0xA6, 0x9B, 0x6E, 0x49, 0x20, 0xB5, 0x2B, 0x40, 0xB5, 0x24, 0x80, 0xE5,
  0x29, 0xC0, 0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x4E, 0x80, 0xE0, 0xC0,
  0x6E, 0xF0, 0xAF, 0xF0, 0xF2, 0x70, 0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0xFA,
  0xA0, 0xF6, 0xF3, 0xC0, 0xAF, 0xF0, 0xBC, 0xBF, 0xAE, 0xB0, 0xFC, 0xFD,
  0xDD, 0xFF, 0xF6, 0xF0, 0xFF, 0xA0, 0xF6, 0xF2, 0x40, 0xF0, 0xF8, 0xF0,
  0xEA, 0xC0, 0xFF, 0xB7, 0x20, 0xAF, 0x74, 0xA0, 0xA9, 0x50, 0xB5, 0x25,
  0x00, 0xD7, 0x57, 0x54, 0xFF, 0x95, 0x5C, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLight8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 6, 4, 0, -6 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 0, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 3, 2, 3, 0, -6 },
  { 22, 3, 4, 4, 0, -5 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 3, 6, 3, 0, -6 },
  { 30, 3, 6, 4, 0, -6 },
  { 33, 1, 6, 4, 1, -6 },
  { 34, 3, 6, 4, 0, -6 },
  { 37, 3, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 3, 6, 4, 0, -6 },
  { 46, 3, 6, 4, 0, -6 },
  { 49, 3, 6, 4, 0, -6 },
  { 52, 3, 6, 4, 0, -6 },
  { 55, 3, 6, 4, 0, -6 },
  { 58, 1, 4, 2, 0, -4 },
  { 59, 1, 5, 2, 0, -4 },
  { 60, 3, 4, 4, 0, -5 },
  { 62, 3, 2, 4, 0, -4 },
  { 63, 3, 4, 4, 0, -5 },
  { 65, 2, 6, 3, 0, -6 },
  { 67, 5, 7, 6, 0, -6 },
  { 72, 4, 6, 4, 0, -6 },
  { 75, 3, 6, 4, 1, -6 },
  { 78, 4, 6, 4, 0, -6 },
  { 81, 3, 6, 4, 1, -6 },
  { 84, 2, 6, 3, 1, -6 },
  { 86, 2, 6, 3, 1, -6 },
  { 88, 4, 6, 5, 0, -6 },
  { 91, 3, 6, 4, 1, -6 },
  { 94, 2, 6, 2, 0, -6 },
  { 96, 1, 7, 2, 0, -6 },
  { 97, 3, 6, 4, 1, -6 },
  { 100, 2, 6, 3, 1, -6 },
  { 102, 4, 6, 6, 1, -6 },
  { 105, 3, 6, 5, 1, -6 },
  { 108, 4, 6, 5, 0, -6 },
  { 111, 2, 6, 4, 1, -6 },
  { 113, 4, 7, 5, 0, -6 },
  { 117, 3, 6, 4, 1, -6 },
  { 120, 3, 6, 4, 0, -6 },
  { 123, 3, 6, 3, 0, -6 },
  { 126, 3, 6, 4, 1, -6 },
  { 129, 4, 6, 4, 0, -6 },
  { 132, 6, 6, 6, 0, -6 },
  { 137, 3, 6, 3, 0, -6 },
  { 140, 3, 6, 3, 0, -6 },
  { 143, 3, 6, 3, 0, -6 },
  { 146, 1, 7, 2, 1, -6 },
  { 147, 3, 6, 3, 0, -6 },
  { 150, 2, 7, 2, 0, -6 },
  { 152, 3, 3, 4, 0, -6 },
  { 154, 3, 1, 3, 0, 0 },
  { 155, 2, 1, 2, 0, -6 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 2, 6, 4, 1, -6 },
  { 160, 3, 4, 3, 0, -4 },
  { 162, 3, 6, 4, 0, -6 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 2, 6, 2, 0, -6 },
  { 169, 3, 6, 4, 0, -4 },
  { 172, 2, 6, 4, 1, -6 },
  { 174, 1, 6, 2, 0, -6 },
  { 175, 1, 8, 2, 0, -6 },
  { 176, 2, 6, 3, 1, -6 },
  { 178, 1, 6, 2, 0, -6 },
  { 179, 4, 4, 6, 1, -4 },
  { 181, 2, 4, 4, 1, -4 },
  { 182, 3, 4, 4, 0, -4 },
  { 184, 2, 6, 4, 1, -4 },
  { 186, 3, 6, 4, 0, -4 },
  { 189, 1, 4, 2, 1, -4 },
  { 190, 3, 4, 3, 0, -4 },
  { 192, 2, 5, 2, 0, -5 },
  { 194, 2, 4, 4, 1, -4 },
  { 195, 3, 4, 3, 0, -4 },
  { 197, 5, 4, 5, 0, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 3, 6, 3, 0, -4 },
  { 205, 2, 4, 3, 0, -4 },
  { 206, 2, 7, 3, 0, -6 },
  { 208, 1, 8, 3, 1, -6 },
  { 209, 2, 7, 3, 0, -6 },
  { 211, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_ExtraLight8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT8PT7B_H_
