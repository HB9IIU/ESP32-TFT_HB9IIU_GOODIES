#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT26PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight26pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x2C, 0x9C, 0xE7, 0x18, 0xC6, 0x20, 0x08,
  0x81, 0x10, 0x22, 0x08, 0x41, 0x08, 0x21, 0x3F, 0xF8, 0x88, 0x11, 0x02,
  0x20, 0x44, 0x10, 0x8F, 0xFE, 0x42, 0x08, 0x41, 0x10, 0x22, 0x04, 0x41,
  0x08, 0x00, 0x08, 0x04, 0x0F, 0xC9, 0x18, 0x84, 0x42, 0x21, 0x10, 0x48,
  0x14, 0x07, 0x01, 0x40, 0x98, 0x44, 0x22, 0x11, 0x08, 0xC4, 0xFF, 0xC1,
  0x00, 0x80, 0x40, 0x30, 0x10, 0x90, 0x41, 0x10, 0x84, 0x22, 0x08, 0x44,
  0x10, 0x88, 0x21, 0x20, 0x42, 0x40, 0x85, 0x3C, 0x8A, 0x89, 0x25, 0x09,
  0x92, 0x10, 0x24, 0x20, 0x88, 0x41, 0x10, 0x82, 0x21, 0x08, 0x44, 0x10,
  0x48, 0x40, 0xE0, 0x1C, 0x02, 0x20, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10,
  0x22, 0x01, 0x60, 0x1C, 0x01, 0x80, 0x64, 0x04, 0x42, 0x82, 0x28, 0x12,
  0x81, 0xC8, 0x0C, 0x80, 0xC4, 0x16, 0x3E, 0x30, 0xFE, 0x08, 0x84, 0x42,
  0x21, 0x08, 0xC4, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x42, 0x08, 0x60,
  0x82, 0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x62, 0x10, 0x8C,
  0x42, 0x22, 0x00, 0x08, 0x08, 0x08, 0xEB, 0x1C, 0x14, 0x24, 0x62, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x55, 0xA0, 0xFC, 0xC0, 0x02, 0x04, 0x08, 0x20, 0x41, 0x02,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x00, 0x1C,
  0x19, 0x98, 0x48, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x10, 0x87, 0x80, 0x08, 0xCA, 0x98,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1C, 0x31, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x40, 0x40, 0x60, 0x20, 0x3F, 0xE0, 0x1C, 0x21, 0xA0, 0x60, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x06, 0x1E, 0x00, 0xC0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xC0, 0xBF, 0x80, 0x00, 0x80, 0x30, 0x06, 0x01, 0x40, 0x68,
  0x09, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x82, 0x10, 0x44, 0x09, 0xFF,
  0xC0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x7E, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xC0, 0x9F, 0x80, 0x07, 0x86, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x9F, 0x28, 0x2C, 0x0B, 0x02, 0x80, 0xF0, 0x34,
  0x09, 0x02, 0x40, 0x88, 0x41, 0xF0, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x00, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x40, 0x90, 0x24,
  0x08, 0x84, 0x1E, 0x07, 0x02, 0x31, 0x06, 0xC0, 0xA0, 0x28, 0x06, 0x02,
  0xC0, 0x90, 0x63, 0xF0, 0x1C, 0x11, 0x90, 0x58, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xA0, 0xD8, 0xE7, 0x90, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01,
  0x1F, 0x00, 0xC0, 0x0C, 0x4C, 0x00, 0x00, 0x00, 0x24, 0x94, 0x80, 0x00,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x80, 0x10, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x00, 0x71,
  0x18, 0x10, 0x20, 0x20, 0x81, 0x02, 0x08, 0x20, 0x81, 0x02, 0x04, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x80, 0x06, 0x30, 0x18, 0x08, 0x30, 0x04,
  0x20, 0x02, 0x40, 0x02, 0x43, 0xE2, 0x46, 0x21, 0x44, 0x21, 0x84, 0x21,
  0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x84, 0x62, 0x44, 0x62, 0x43, 0x9C,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xA0, 0x09, 0x00, 0x90, 0x09, 0x01, 0x10, 0x10, 0x81,
  0x08, 0x20, 0x83, 0xFC, 0x20, 0x42, 0x04, 0x40, 0x44, 0x02, 0x40, 0x28,
  0x02, 0x80, 0x10, 0xF8, 0x21, 0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A,
  0x02, 0x83, 0x3F, 0x88, 0x1A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xA0, 0x6F, 0xE0, 0x07, 0xC3, 0x04, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x03, 0x00, 0x3F, 0x80, 0xF0, 0x10, 0xE2, 0x06, 0x40, 0x68,
  0x05, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x05,
  0x00, 0xA0, 0x14, 0x06, 0x80, 0x90, 0x63, 0xF0, 0x00, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x03,
  0xC0, 0x61, 0x84, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x7E, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x24,
  0x01, 0x20, 0x08, 0xC0, 0x43, 0xFC, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x7F, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x86, 0x6C, 0x80, 0xA0, 0x68, 0x12, 0x08,
  0x86, 0x21, 0x08, 0x82, 0x40, 0xB0, 0x2C, 0x0C, 0x82, 0x20, 0x84, 0x21,
  0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0C, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x2D, 0x00, 0x5A, 0x00, 0xB4,
  0x02, 0x64, 0x04, 0xC8, 0x09, 0x90, 0x23, 0x10, 0x46, 0x20, 0x8C, 0x42,
  0x18, 0x44, 0x30, 0x88, 0x61, 0x20, 0xC1, 0x41, 0x82, 0x83, 0x06, 0x06,
  0x04, 0x08, 0x80, 0x38, 0x07, 0x00, 0xD0, 0x1A, 0x03, 0x20, 0x64, 0x0C,
  0x41, 0x88, 0x30, 0x86, 0x10, 0xC1, 0x18, 0x23, 0x02, 0x60, 0x4C, 0x05,
  0x80, 0xB0, 0x0E, 0x01, 0x80, 0x07, 0x80, 0xC2, 0x08, 0x08, 0x40, 0x24,
  0x01, 0x20, 0x09, 0x00, 0x28, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x80,
  0x14, 0x00, 0xA0, 0x0D, 0x00, 0x4C, 0x02, 0x20, 0x20, 0x83, 0x03, 0xF0,
  0xF8, 0x43, 0x20, 0x50, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x41, 0xBF,
  0x90, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x07, 0x80,
  0xC2, 0x08, 0x08, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x28, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x0D, 0x00, 0x4C, 0x02,
  0x20, 0x30, 0x83, 0x03, 0xF0, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0xF8, 0x23, 0x88, 0x12, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20,
  0x8F, 0xC2, 0x10, 0x84, 0x20, 0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0C,
  0x1F, 0x10, 0x50, 0x18, 0x08, 0x04, 0x01, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0xBF, 0x80, 0xFF, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x14, 0x02, 0x40, 0x4C, 0x10, 0xFC,
  0x00, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x88, 0x11, 0x04,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x81, 0x10, 0x12, 0x02, 0x40, 0x50, 0x0A,
  0x00, 0xC0, 0x10, 0x00, 0x80, 0x40, 0x28, 0x08, 0x09, 0x03, 0x01, 0x20,
  0x50, 0x24, 0x0A, 0x04, 0x81, 0x41, 0x08, 0x28, 0x21, 0x08, 0x84, 0x21,
  0x10, 0x84, 0x22, 0x30, 0x44, 0x44, 0x09, 0x08, 0x81, 0x20, 0x90, 0x24,
  0x12, 0x02, 0x82, 0x80, 0x50, 0x50, 0x0C, 0x0A, 0x01, 0x80, 0xC0, 0x30,
  0x10, 0x00, 0x40, 0x50, 0x32, 0x08, 0x82, 0x11, 0x04, 0x41, 0xA0, 0x28,
  0x0C, 0x01, 0x00, 0xC0, 0x28, 0x12, 0x04, 0x42, 0x10, 0x82, 0x40, 0x90,
  0x38, 0x04, 0x80, 0x60, 0x14, 0x09, 0x02, 0x21, 0x08, 0x42, 0x10, 0x48,
  0x12, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0xFF, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0x40, 0x3F, 0xE0,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x43, 0xE0, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04,
  0x03, 0x00, 0xC0, 0x48, 0x12, 0x08, 0x42, 0x11, 0x02, 0x40, 0xA0, 0x10,
  0xFF, 0xC0, 0x84, 0x21, 0x3C, 0x42, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x61,
  0xC1, 0x81, 0x81, 0x83, 0xC3, 0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x79, 0x42, 0xC1, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xE0, 0xB0, 0x57, 0xC0, 0x1F, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x11, 0xE4, 0x85, 0x40, 0xD0, 0x3C, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x40, 0xD0, 0x36, 0x14, 0xF9, 0x1E, 0x10, 0x90, 0x48,
  0x14, 0x0C, 0x07, 0xFF, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x08, 0xF8,
  0x0E, 0x20, 0x81, 0x02, 0x04, 0x3F, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x1E, 0x90, 0xD0, 0x28, 0x1C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x28, 0x16, 0x19, 0xF4, 0x02, 0x01,
  0x00, 0x80, 0x60, 0x4F, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9E,
  0xA3, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC7, 0xFF, 0xE0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x49, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x84, 0x88,
  0x90, 0x90, 0xB0, 0xD0, 0x88, 0x88, 0x84, 0x84, 0x82, 0x83, 0xFF, 0xFF,
  0xF0, 0xBC, 0x7B, 0x0A, 0x3C, 0x30, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18,
  0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06,
  0x04, 0x10, 0x9E, 0xA3, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x14, 0x09, 0x02, 0x21, 0x87, 0xC0, 0x9E, 0x50,
  0xB0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x2C,
  0x15, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x90, 0xD0,
  0x28, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x28, 0x16, 0x19,
  0xF4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x9E, 0x8C, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x3E, 0x86, 0x04, 0x08, 0x08,
  0x0C, 0x06, 0x06, 0x04, 0x08, 0x18, 0x3F, 0x80, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x1C, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC3, 0x7D, 0x80,
  0xC0, 0x50, 0x48, 0x24, 0x11, 0x18, 0x88, 0x44, 0x22, 0x0A, 0x05, 0x02,
  0x81, 0x40, 0x40, 0x81, 0x02, 0x83, 0x05, 0x06, 0x12, 0x14, 0x24, 0x28,
  0x44, 0x48, 0x88, 0x92, 0x12, 0x24, 0x24, 0x48, 0x48, 0x90, 0x50, 0xA0,
  0xC1, 0x81, 0x83, 0x03, 0x06, 0x00, 0x40, 0xA0, 0x88, 0x46, 0x41, 0x20,
  0x60, 0x30, 0x18, 0x14, 0x09, 0x08, 0x84, 0x24, 0x16, 0x04, 0x80, 0xA0,
  0x50, 0x28, 0x22, 0x11, 0x08, 0x88, 0x44, 0x12, 0x09, 0x05, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x1C, 0x00, 0xFE, 0x08, 0x10,
  0x40, 0x83, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x1F, 0xC0, 0x02, 0x18,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x02, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0xC0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x70, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x38, 0x00, 0xF8, 0x61, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLight26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 19, 5, 2, -19 },
  { 6, 5, 7, 8, 2, -19 },
  { 11, 11, 19, 13, 1, -19 },
  { 38, 9, 22, 12, 1, -20 },
  { 63, 15, 19, 17, 1, -19 },
  { 99, 12, 19, 13, 1, -19 },
  { 128, 1, 7, 5, 2, -19 },
  { 129, 5, 23, 7, 1, -19 },
  { 144, 5, 23, 7, 1, -19 },
  { 159, 8, 8, 11, 1, -20 },
  { 167, 10, 12, 12, 1, -15 },
  { 182, 2, 6, 5, 1, -3 },
  { 184, 6, 1, 7, 1, -8 },
  { 185, 1, 2, 5, 2, -2 },
  { 186, 7, 19, 9, 1, -19 },
  { 203, 9, 19, 12, 1, -19 },
  { 225, 5, 19, 12, 2, -19 },
  { 237, 9, 19, 12, 1, -19 },
  { 259, 9, 19, 12, 1, -19 },
  { 281, 11, 19, 12, 0, -19 },
  { 308, 9, 19, 12, 1, -19 },
  { 330, 10, 19, 12, 1, -19 },
  { 354, 9, 19, 12, 1, -19 },
  { 376, 10, 19, 12, 1, -19 },
  { 400, 9, 19, 12, 1, -19 },
  { 422, 1, 14, 5, 2, -14 },
  { 424, 3, 17, 5, 1, -14 },
  { 431, 10, 11, 12, 1, -15 },
  { 445, 10, 6, 12, 1, -12 },
  { 453, 10, 11, 12, 1, -15 },
  { 467, 7, 19, 8, 1, -19 },
  { 484, 16, 21, 18, 1, -19 },
  { 526, 12, 19, 12, 0, -19 },
  { 555, 10, 19, 13, 2, -19 },
  { 579, 11, 19, 12, 1, -19 },
  { 606, 11, 19, 14, 2, -19 },
  { 633, 8, 19, 11, 2, -19 },
  { 652, 8, 19, 10, 2, -19 },
  { 671, 13, 19, 15, 1, -19 },
  { 702, 10, 19, 15, 2, -19 },
  { 726, 4, 19, 7, 1, -19 },
  { 736, 5, 24, 5, -2, -19 },
  { 751, 10, 19, 12, 2, -19 },
  { 775, 8, 19, 10, 2, -19 },
  { 794, 15, 19, 19, 2, -19 },
  { 830, 11, 19, 15, 2, -19 },
  { 857, 13, 19, 15, 1, -19 },
  { 888, 9, 19, 12, 2, -19 },
  { 910, 13, 23, 15, 1, -19 },
  { 948, 10, 19, 12, 2, -19 },
  { 972, 9, 19, 11, 1, -19 },
  { 994, 10, 19, 10, 0, -19 },
  { 1018, 11, 19, 15, 2, -19 },
  { 1045, 11, 19, 11, 0, -19 },
  { 1072, 19, 19, 19, 0, -19 },
  { 1118, 10, 19, 10, 0, -19 },
  { 1142, 10, 19, 10, 0, -19 },
  { 1166, 9, 19, 11, 1, -19 },
  { 1188, 5, 23, 8, 2, -19 },
  { 1203, 7, 19, 9, 1, -19 },
  { 1220, 5, 23, 8, 1, -19 },
  { 1235, 10, 10, 12, 1, -19 },
  { 1248, 10, 1, 10, 0, 2 },
  { 1250, 4, 4, 6, 1, -20 },
  { 1252, 8, 14, 11, 1, -14 },
  { 1266, 9, 20, 12, 2, -20 },
  { 1289, 8, 14, 10, 1, -14 },
  { 1303, 10, 20, 12, 1, -20 },
  { 1328, 9, 14, 11, 1, -14 },
  { 1344, 7, 20, 6, 0, -20 },
  { 1362, 9, 20, 12, 1, -14 },
  { 1385, 8, 20, 12, 2, -20 },
  { 1405, 1, 19, 5, 2, -19 },
  { 1408, 3, 25, 5, 0, -19 },
  { 1418, 8, 20, 10, 2, -20 },
  { 1438, 1, 20, 5, 2, -20 },
  { 1441, 14, 14, 18, 2, -14 },
  { 1466, 8, 14, 12, 2, -14 },
  { 1480, 10, 14, 12, 1, -14 },
  { 1498, 9, 20, 12, 2, -14 },
  { 1521, 9, 20, 12, 1, -14 },
  { 1544, 6, 14, 8, 2, -14 },
  { 1555, 7, 14, 9, 1, -14 },
  { 1568, 6, 17, 7, 0, -17 },
  { 1581, 8, 14, 12, 2, -14 },
  { 1595, 9, 14, 9, 0, -14 },
  { 1611, 15, 14, 15, 0, -14 },
  { 1638, 9, 14, 10, 0, -14 },
  { 1654, 9, 20, 9, 0, -14 },
  { 1677, 7, 14, 8, 1, -14 },
  { 1690, 7, 23, 9, 1, -19 },
  { 1711, 1, 26, 11, 5, -20 },
  { 1715, 7, 23, 9, 1, -19 },
  { 1736, 10, 2, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraLight26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT26PT7B_H_
