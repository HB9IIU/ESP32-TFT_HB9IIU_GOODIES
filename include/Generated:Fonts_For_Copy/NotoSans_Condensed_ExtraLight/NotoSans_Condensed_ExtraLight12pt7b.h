#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT12PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x28, 0xA2, 0x9F, 0x49, 0x4F, 0x94, 0x50, 0x33,
  0x29, 0x46, 0x1C, 0xA5, 0x71, 0x00, 0xCB, 0x2B, 0x2C, 0xEF, 0xD3, 0x55,
  0x4C, 0x21, 0x45, 0x14, 0x21, 0x59, 0x62, 0x74, 0xF0, 0x6A, 0xAA, 0xA4,
  0x89, 0x12, 0x49, 0x4A, 0x00, 0x5F, 0x50, 0x21, 0x3E, 0x42, 0x10, 0x68,
  0xE0, 0x80, 0x11, 0x22, 0x24, 0x44, 0x80, 0x69, 0x99, 0x99, 0x99, 0xE0,
  0x75, 0x55, 0x40, 0xE1, 0x11, 0x22, 0x48, 0xF0, 0x74, 0x42, 0x13, 0x04,
  0x21, 0xF0, 0x10, 0x8C, 0x65, 0x4B, 0xE2, 0x10, 0xE8, 0x88, 0xE1, 0x11,
  0xE0, 0x68, 0x8C, 0xB9, 0x99, 0xE0, 0xF1, 0x22, 0x24, 0x44, 0x80, 0x69,
  0x99, 0x69, 0x99, 0xE0, 0x69, 0x99, 0x97, 0x12, 0xE0, 0x84, 0x40, 0x1A,
  0x09, 0xB0, 0xC1, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0xE4, 0x92,
  0x90, 0x40, 0x38, 0x8A, 0x0D, 0xDC, 0xB9, 0x74, 0xDE, 0x80, 0xF0, 0x21,
  0x0C, 0xA5, 0x3A, 0x31, 0x88, 0xE9, 0x99, 0xE9, 0x99, 0xF0, 0x78, 0x88,
  0x88, 0x88, 0x70, 0xE4, 0xA3, 0x18, 0xC6, 0x31, 0xF0, 0xF8, 0x88, 0xE8,
  0x88, 0xF0, 0xF8, 0x88, 0xE8, 0x88, 0x80, 0x7C, 0x21, 0x09, 0x46, 0x31,
  0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xEA, 0xAA, 0xC0, 0x24, 0x92,
  0x49, 0x27, 0x00, 0x99, 0xAC, 0xCA, 0xA9, 0x90, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0x83, 0x06, 0x1E, 0x3C, 0xB5, 0x6A, 0xD9, 0x92, 0x8C, 0x73, 0x9A,
  0xD6, 0x71, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xE9, 0x99, 0x9E,
  0x88, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x82, 0xE9, 0x99, 0xDA,
  0xA9, 0x90, 0x78, 0x88, 0x43, 0x11, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x8C, 0x62, 0x95, 0x29, 0x44,
  0x20, 0x88, 0xC4, 0x66, 0x4A, 0xA5, 0x52, 0xA9, 0x98, 0xC4, 0x22, 0x00,
  0x8A, 0x94, 0xC2, 0x31, 0x4A, 0x88, 0x8C, 0x94, 0xA6, 0x10, 0x84, 0x20,
  0x70, 0x84, 0x42, 0x11, 0x08, 0xF8, 0xEA, 0xAA, 0xAC, 0x88, 0x44, 0x42,
  0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x21, 0x14, 0x98, 0x80, 0xF8,
  0xD0, 0x71, 0x79, 0x97, 0x88, 0xE9, 0x99, 0x99, 0xF0, 0xF2, 0x49, 0xC0,
  0x11, 0x79, 0x99, 0x99, 0xF0, 0xE9, 0xF8, 0x8F, 0x6B, 0xA4, 0x92, 0x40,
  0xF9, 0x99, 0x9F, 0x11, 0xE0, 0x88, 0xE9, 0x99, 0x99, 0x90, 0x9F, 0x80,
  0x41, 0x55, 0x56, 0x88, 0x8A, 0xCC, 0xCA, 0xB0, 0xFF, 0x80, 0xFF, 0x26,
  0x4C, 0x99, 0x32, 0x40, 0xF9, 0x99, 0x99, 0xF9, 0x99, 0x9E, 0xF9, 0x99,
  0x9F, 0x88, 0x80, 0xF9, 0x99, 0x9F, 0x11, 0x10, 0xF2, 0x49, 0x00, 0xF8,
  0x61, 0x1F, 0x5D, 0x24, 0x93, 0x99, 0x99, 0x9F, 0x99, 0x56, 0x62, 0x93,
  0x25, 0xB3, 0x66, 0x48, 0x80, 0xD6, 0x22, 0x59, 0x99, 0x56, 0x22, 0x24,
  0x80, 0x72, 0x24, 0x4F, 0x2A, 0x49, 0x24, 0x91, 0x80, 0xFF, 0xF0, 0x89,
  0x24, 0xD2, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLight12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 6, 9, 6, 0, -9 },
  { 11, 5, 10, 5, 0, -9 },
  { 18, 6, 9, 8, 1, -9 },
  { 25, 6, 9, 6, 0, -9 },
  { 32, 1, 4, 2, 1, -9 },
  { 33, 2, 11, 3, 1, -9 },
  { 36, 3, 11, 3, 0, -9 },
  { 41, 3, 4, 5, 1, -9 },
  { 43, 5, 6, 5, 0, -7 },
  { 47, 2, 3, 2, 0, -1 },
  { 48, 3, 1, 3, 0, -4 },
  { 49, 1, 1, 2, 1, -1 },
  { 50, 4, 9, 4, 0, -9 },
  { 55, 4, 9, 5, 1, -9 },
  { 60, 2, 9, 5, 1, -9 },
  { 63, 4, 9, 5, 1, -9 },
  { 68, 5, 9, 5, 0, -9 },
  { 74, 5, 9, 5, 0, -9 },
  { 80, 4, 9, 5, 1, -9 },
  { 85, 4, 9, 5, 1, -9 },
  { 90, 4, 9, 5, 1, -9 },
  { 95, 4, 9, 5, 1, -9 },
  { 100, 4, 9, 5, 1, -9 },
  { 105, 1, 6, 2, 1, -6 },
  { 106, 2, 8, 2, 0, -6 },
  { 108, 5, 5, 5, 0, -7 },
  { 112, 5, 3, 5, 0, -6 },
  { 114, 5, 5, 5, 0, -7 },
  { 118, 3, 9, 4, 0, -9 },
  { 122, 7, 10, 8, 1, -9 },
  { 131, 5, 9, 5, 0, -9 },
  { 137, 4, 9, 6, 1, -9 },
  { 142, 4, 9, 6, 1, -9 },
  { 147, 5, 9, 7, 1, -9 },
  { 153, 4, 9, 5, 1, -9 },
  { 158, 4, 9, 5, 1, -9 },
  { 163, 5, 9, 7, 1, -9 },
  { 169, 5, 9, 7, 1, -9 },
  { 175, 2, 9, 3, 1, -9 },
  { 178, 3, 11, 2, -1, -9 },
  { 183, 4, 9, 5, 1, -9 },
  { 188, 4, 9, 5, 1, -9 },
  { 193, 7, 9, 9, 1, -9 },
  { 201, 5, 9, 7, 1, -9 },
  { 207, 5, 9, 7, 1, -9 },
  { 213, 4, 9, 5, 1, -9 },
  { 218, 5, 11, 7, 1, -9 },
  { 225, 4, 9, 6, 1, -9 },
  { 230, 4, 9, 5, 1, -9 },
  { 235, 5, 9, 5, 0, -9 },
  { 241, 5, 9, 7, 1, -9 },
  { 247, 5, 9, 5, 0, -9 },
  { 253, 9, 9, 9, 0, -9 },
  { 264, 5, 9, 5, 0, -9 },
  { 270, 5, 9, 5, 0, -9 },
  { 276, 5, 9, 5, 0, -9 },
  { 282, 2, 11, 4, 1, -9 },
  { 285, 4, 9, 4, 0, -9 },
  { 290, 3, 11, 4, 0, -9 },
  { 295, 5, 5, 5, 0, -9 },
  { 299, 5, 1, 5, 0, 1 },
  { 300, 2, 2, 3, 0, -9 },
  { 301, 4, 6, 5, 0, -6 },
  { 304, 4, 9, 6, 1, -9 },
  { 309, 3, 6, 4, 1, -6 },
  { 312, 4, 9, 6, 1, -9 },
  { 317, 4, 6, 5, 1, -6 },
  { 320, 3, 9, 3, 0, -9 },
  { 324, 4, 9, 6, 1, -6 },
  { 329, 4, 9, 6, 1, -9 },
  { 334, 1, 9, 2, 1, -9 },
  { 336, 2, 12, 2, 0, -9 },
  { 339, 4, 9, 5, 1, -9 },
  { 344, 1, 9, 2, 1, -9 },
  { 346, 7, 6, 8, 1, -6 },
  { 352, 4, 6, 6, 1, -6 },
  { 355, 4, 6, 6, 1, -6 },
  { 358, 4, 9, 6, 1, -6 },
  { 363, 4, 9, 6, 1, -6 },
  { 368, 3, 6, 4, 1, -6 },
  { 371, 4, 6, 4, 0, -6 },
  { 374, 3, 8, 3, 0, -8 },
  { 377, 4, 6, 6, 1, -6 },
  { 380, 4, 6, 4, 0, -6 },
  { 383, 7, 6, 7, 0, -6 },
  { 389, 4, 6, 5, 0, -6 },
  { 392, 4, 9, 4, 0, -6 },
  { 397, 4, 6, 4, 0, -6 },
  { 400, 3, 11, 4, 1, -9 },
  { 405, 1, 12, 5, 2, -9 },
  { 407, 3, 11, 4, 1, -9 },
  { 412, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_ExtraLight12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT12PT7B_H_
