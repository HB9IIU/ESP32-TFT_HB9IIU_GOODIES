#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT66PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight66pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x6F, 0xFF,
  0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0x80,
  0xEC, 0x07, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x06,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x38, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x03, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0E, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xB1, 0xFC, 0x3C,
  0x30, 0x18, 0x38, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x70, 0x30, 0x00, 0x38, 0x30, 0x00, 0x1E, 0x30, 0x00, 0x0F,
  0xB0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x33, 0xE0, 0x00, 0x30, 0xF0, 0x00, 0x30, 0x78, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x07, 0x00, 0x30, 0x07, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x1C, 0xC0, 0x30, 0x78, 0xF8, 0x31, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xC0, 0x07, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x70,
  0x00, 0x60, 0x03, 0x01, 0x80, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x60, 0x01, 0xC0,
  0x0C, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0x03, 0x01, 0x80,
  0x03, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x06,
  0x06, 0x00, 0x06, 0x00, 0x30, 0x60, 0x00, 0x38, 0x01, 0x83, 0x00, 0x01,
  0xC0, 0x1C, 0x38, 0x3E, 0x0E, 0x00, 0xE1, 0x83, 0xF8, 0x30, 0x07, 0x0C,
  0x38, 0xE1, 0x80, 0x30, 0xC3, 0x83, 0x8C, 0x01, 0x86, 0x18, 0x0C, 0x70,
  0x1C, 0x71, 0xC0, 0x71, 0x80, 0xC3, 0x0C, 0x01, 0x8E, 0x0E, 0x18, 0x60,
  0x0C, 0x3C, 0xE1, 0x83, 0x00, 0x70, 0xFE, 0x0C, 0x38, 0x03, 0x81, 0xC0,
  0xE1, 0xC0, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x60, 0x03,
  0x00, 0x03, 0x83, 0x00, 0x18, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x01, 0xC0,
  0xC0, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x07, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x18, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x0C, 0x06,
  0x00, 0x30, 0x00, 0x70, 0x70, 0x01, 0x80, 0x01, 0xEF, 0x00, 0x1C, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x78, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0xE3, 0x80, 0x70, 0x07, 0x38, 0x03, 0x80, 0x31, 0x80, 0x0E, 0x01, 0x9C,
  0x00, 0x38, 0x0C, 0xE0, 0x01, 0xC0, 0xE6, 0x00, 0x07, 0x06, 0x30, 0x00,
  0x1C, 0x31, 0x80, 0x00, 0x63, 0x8C, 0x00, 0x03, 0x98, 0x60, 0x00, 0x0F,
  0xC3, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xFC, 0x1C, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x73, 0x83, 0x80,
  0x0F, 0x0E, 0x0F, 0x00, 0xF0, 0x30, 0x3F, 0xFE, 0x01, 0xC0, 0xFF, 0xE0,
  0x07, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x80, 0x3E, 0x04, 0x07, 0xFC, 0x21, 0xF8, 0xFD,
  0x7E, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00,
  0x06, 0x30, 0x00, 0x60, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x03, 0x00,
  0x70, 0x38, 0x03, 0x80, 0x80, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC6, 0x18, 0xE3, 0x0C, 0x30,
  0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x3E, 0x03, 0xB0, 0x79, 0x87, 0x8C, 0x78, 0x67, 0x03, 0xF0, 0x1B, 0x00,
  0xD0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xE0, 0x0F,
  0x07, 0x00, 0x0F, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xE0, 0x0F, 0x0F, 0x00, 0x07, 0x08, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC8, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x01, 0xE8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0C,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x7F, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC4, 0x00, 0x0F, 0x0E, 0x00, 0x7C, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x04, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x7F, 0x80, 0x61, 0xFF, 0xE0, 0x63, 0xE1,
  0xF0, 0x67, 0x00, 0x78, 0x6E, 0x00, 0x38, 0x6C, 0x00, 0x1C, 0x78, 0x00,
  0x0C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x18, 0x00,
  0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0x00, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xEF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xEF, 0x00, 0x03, 0x83, 0xC0, 0x0F, 0x01, 0xE0, 0x1E,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x60,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xB8,
  0x00, 0x0B, 0x30, 0x00, 0x36, 0x70, 0x00, 0xCC, 0x70, 0x03, 0xB8, 0x7C,
  0x3E, 0x70, 0x7F, 0xF0, 0xE0, 0x3F, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x04, 0x01, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xEF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xE0, 0x1C, 0x3C, 0x78, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC7, 0x0E,
  0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xC1, 0x86, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE1, 0xC0, 0x3C, 0x40, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x03, 0xF0, 0x01, 0x8E, 0x00, 0x1F,
  0xFC, 0x03, 0x1C, 0x00, 0xF8, 0x78, 0x07, 0x30, 0x03, 0xC0, 0x70, 0x0E,
  0x60, 0x07, 0x00, 0xE0, 0x0D, 0xC0, 0x1C, 0x01, 0xC0, 0x1B, 0x80, 0x30,
  0x03, 0x00, 0x36, 0x00, 0xE0, 0x06, 0x00, 0x6C, 0x01, 0x80, 0x0C, 0x00,
  0xD8, 0x03, 0x00, 0x18, 0x01, 0xB0, 0x06, 0x00, 0x30, 0x03, 0x60, 0x1C,
  0x00, 0x60, 0x06, 0xC0, 0x38, 0x00, 0xC0, 0x0F, 0x80, 0x70, 0x01, 0x80,
  0x1F, 0x00, 0xE0, 0x03, 0x00, 0x3E, 0x01, 0xC0, 0x06, 0x00, 0x6C, 0x03,
  0x80, 0x1C, 0x00, 0xD8, 0x07, 0x00, 0x38, 0x01, 0xB0, 0x0E, 0x00, 0x70,
  0x07, 0x60, 0x0C, 0x00, 0xE0, 0x0C, 0xC0, 0x18, 0x03, 0xC0, 0x19, 0x80,
  0x38, 0x06, 0x80, 0x73, 0x00, 0x30, 0x19, 0x80, 0xC7, 0x00, 0x70, 0x73,
  0x83, 0x8E, 0x00, 0x7F, 0xC3, 0xFE, 0x0C, 0x00, 0x7F, 0x03, 0xF8, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x18, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xC0,
  0x07, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0xF0, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xC0, 0x0F, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0xF0, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x07, 0xC0, 0x06, 0x03, 0xC0, 0x00, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x40, 0x7E, 0x00, 0x60, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x0C, 0x00, 0xFE, 0x03, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x78, 0x30, 0x00,
  0x0F, 0x0C, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0C, 0x00,
  0x07, 0x83, 0x00, 0x07, 0x80, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF6, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x0C,
  0x03, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0xFF,
  0xCF, 0xF8, 0x3E, 0x00, 0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x01,
  0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0E,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x38,
  0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0xC0,
  0x00, 0xC3, 0x80, 0x00, 0xC7, 0x80, 0x00, 0xC7, 0x80, 0x00, 0xCF, 0xC0,
  0x00, 0xDD, 0xC0, 0x00, 0xD8, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x00, 0x3B, 0xDC, 0x00, 0x00, 0x03,
  0xBD, 0xC0, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x07, 0x3C, 0xC0, 0x00,
  0x00, 0x73, 0xCE, 0x00, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x00, 0xE3, 0xC6,
  0x00, 0x00, 0x0E, 0x3C, 0x70, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x1C,
  0x3C, 0x30, 0x00, 0x01, 0xC3, 0xC3, 0x80, 0x00, 0x18, 0x3C, 0x18, 0x00,
  0x03, 0x83, 0xC1, 0x80, 0x00, 0x38, 0x3C, 0x1C, 0x00, 0x03, 0x03, 0xC0,
  0xC0, 0x00, 0x70, 0x3C, 0x0C, 0x00, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x60,
  0x3C, 0x06, 0x00, 0x0E, 0x03, 0xC0, 0x60, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0x0C, 0x03, 0xC0, 0x30, 0x01, 0xC0, 0x3C, 0x03, 0x00, 0x1C, 0x03, 0xC0,
  0x38, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x38, 0x03, 0xC0, 0x18, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x30, 0x03, 0xC0, 0x0C, 0x07, 0x00, 0x3C, 0x00, 0xC0,
  0x70, 0x03, 0xC0, 0x0E, 0x06, 0x00, 0x3C, 0x00, 0x60, 0xE0, 0x03, 0xC0,
  0x06, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0xC0, 0x03, 0xC0, 0x03, 0x1C, 0x00,
  0x3C, 0x00, 0x31, 0xC0, 0x03, 0xC0, 0x03, 0x98, 0x00, 0x3C, 0x00, 0x1B,
  0x80, 0x03, 0xC0, 0x01, 0xB8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F,
  0x30, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x3C, 0x70, 0x00,
  0x0F, 0x0C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x3C, 0x1C,
  0x00, 0x0F, 0x03, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x18, 0x00, 0x3C,
  0x07, 0x00, 0x0F, 0x00, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x06, 0x00,
  0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x01,
  0x80, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x0C, 0x03, 0xC0, 0x03, 0x80, 0xF0,
  0x00, 0x60, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x03, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x38, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x0C, 0x01, 0xFC, 0x30, 0x00, 0xF8, 0xC0, 0x00, 0xF3, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xEC, 0x00, 0x03,
  0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x30,
  0x00, 0xF0, 0xC0, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0xC0, 0x1F, 0xC0, 0xC0, 0x01, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0xE0, 0xC0, 0x03, 0xC0, 0xC0, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x78, 0x00, 0xE1, 0xC0, 0x00, 0x47, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC8, 0x00,
  0x0F, 0x1E, 0x00, 0x3C, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xD8, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x80, 0x00, 0x19,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x33, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x61, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x03, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0x70, 0x06, 0x00, 0x70, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x60,
  0x06, 0x00, 0x70, 0x06, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x70, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x30, 0x03, 0x01, 0xC0,
  0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x06, 0x07, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x60, 0x01, 0x83, 0x80, 0x01,
  0xC3, 0x80, 0x06, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0xC7, 0x00, 0x00, 0xE3,
  0x00, 0x03, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x70,
  0x00, 0x39, 0x80, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x00, 0x76, 0x00,
  0x01, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x1B, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0xC0, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x18,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x18, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0,
  0x60, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0x0E, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0x60, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x70,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x81, 0xC0, 0x3C, 0x10, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xC0, 0x31, 0xE0, 0x03,
  0x38, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xBE, 0x00, 0x1B, 0x70, 0x03, 0x37, 0x80, 0x73, 0x3F,
  0x7E, 0x30, 0xFF, 0x83, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x60, 0xFF, 0xC0, 0xC3, 0xFF, 0xC1, 0x8E, 0x01, 0xE3, 0x38,
  0x01, 0xC6, 0xE0, 0x01, 0xCD, 0x80, 0x01, 0x9A, 0x00, 0x03, 0xBC, 0x00,
  0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xED, 0x80, 0x03, 0x9B, 0x00, 0x07, 0x33, 0x00, 0x1C, 0x63, 0x80,
  0xF0, 0xC3, 0xFF, 0xC1, 0x83, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7C, 0x02, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x02, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x07, 0x01, 0xFF, 0x07, 0x03, 0xFF, 0xC7, 0x07, 0x80,
  0xE7, 0x0E, 0x00, 0x77, 0x1C, 0x00, 0x37, 0x18, 0x00, 0x1F, 0x38, 0x00,
  0x0F, 0x30, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x1C, 0x00,
  0x37, 0x1E, 0x00, 0x73, 0x0F, 0x00, 0xE3, 0x07, 0xFF, 0xC3, 0x01, 0xFF,
  0x03, 0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x01, 0xC0, 0x78, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0x80, 0x03, 0x8E,
  0x00, 0x06, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x08, 0x1E,
  0x00, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xFF, 0x83, 0x03, 0xFF, 0xC3, 0x0F, 0x00, 0xE7, 0x0E, 0x00, 0x37,
  0x1C, 0x00, 0x37, 0x38, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x30, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x37, 0x1E, 0x00, 0x77,
  0x0F, 0x00, 0xE7, 0x07, 0xFF, 0xC7, 0x01, 0xFF, 0x07, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x40, 0x00, 0x38, 0x30, 0x00, 0xF0,
  0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x18, 0x3F, 0xF0, 0xC3, 0xFF, 0xC6, 0x38, 0x0F, 0x33, 0x80, 0x39, 0xB8,
  0x00, 0xED, 0x80, 0x03, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x73, 0xBE, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x74,
  0xF3, 0xF1, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x38,
  0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x1C,
  0x0C, 0x03, 0x80, 0xC0, 0x70, 0x0C, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x1C,
  0x00, 0xC1, 0x80, 0x0C, 0x38, 0x00, 0xC7, 0xC0, 0x0C, 0xEC, 0x00, 0xCC,
  0xE0, 0x0D, 0x86, 0x00, 0xF8, 0x70, 0x0F, 0x03, 0x00, 0xE0, 0x38, 0x0C,
  0x01, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60,
  0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00,
  0x38, 0x0C, 0x1F, 0xE0, 0x1F, 0xF0, 0xC7, 0xFF, 0x03, 0xFF, 0x8C, 0xE0,
  0x38, 0x70, 0x3C, 0xCC, 0x01, 0xCE, 0x00, 0xED, 0x80, 0x0C, 0xC0, 0x0E,
  0xD0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x07, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x06, 0x0F, 0xFC, 0x30, 0xFF, 0xF1, 0x8E,
  0x03, 0xCC, 0xE0, 0x0F, 0x6C, 0x00, 0x3B, 0x60, 0x00, 0xDE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70,
  0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x07, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0x83, 0xFF, 0x03, 0x0F,
  0xFF, 0x06, 0x38, 0x07, 0x0C, 0xE0, 0x07, 0x19, 0x80, 0x07, 0x36, 0x00,
  0x06, 0x68, 0x00, 0x0E, 0xF0, 0x00, 0x0D, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x6F, 0x00, 0x01, 0xDA, 0x00, 0x03, 0xB6, 0x00, 0x0E, 0x6E, 0x00,
  0x1C, 0xCE, 0x00, 0x71, 0x8E, 0x03, 0xC3, 0x0F, 0xFF, 0x06, 0x0F, 0xFC,
  0x0C, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xFF, 0x83, 0x03, 0xFF, 0xC7, 0x07, 0x80, 0xE7, 0x0E, 0x00, 0x77, 0x1C,
  0x00, 0x37, 0x18, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x30, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x1F, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x37, 0x1E, 0x00, 0x67, 0x0F,
  0x00, 0xE7, 0x07, 0xFF, 0xC7, 0x01, 0xFF, 0x07, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x23, 0x07, 0xFC, 0x3F, 0xF1, 0xC1,
  0xCE, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0x00, 0x63, 0x80, 0x04, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xC0, 0x01, 0xDE, 0x00, 0xF3, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3E, 0x00,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x1C, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x05, 0xF0, 0x00, 0x6D,
  0xC0, 0x06, 0x6E, 0x00, 0x33, 0x3C, 0x07, 0x18, 0xFF, 0xF0, 0xC3, 0xFF,
  0x06, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x70, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0E, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xB8, 0x00, 0x1C, 0x00, 0x0C, 0xC0,
  0x01, 0xF0, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x07, 0x38, 0x00, 0x6C, 0x00,
  0x31, 0xC0, 0x03, 0x60, 0x01, 0x86, 0x00, 0x3B, 0x80, 0x0C, 0x30, 0x01,
  0x8C, 0x00, 0xE1, 0x80, 0x0C, 0x60, 0x07, 0x0E, 0x00, 0x63, 0x00, 0x30,
  0x70, 0x07, 0x1C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x1C, 0x0C, 0x01, 0x83,
  0x00, 0xE0, 0x70, 0x0C, 0x18, 0x06, 0x03, 0x80, 0xE0, 0xE0, 0x30, 0x0C,
  0x06, 0x07, 0x01, 0x80, 0x60, 0x30, 0x18, 0x1C, 0x03, 0x81, 0x80, 0xC0,
  0xC0, 0x1C, 0x1C, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x03, 0x06,
  0x00, 0xC3, 0x80, 0x1C, 0x30, 0x06, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0xC0,
  0x03, 0x18, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x70, 0x00, 0xE6, 0x00,
  0x33, 0x80, 0x07, 0x70, 0x01, 0x98, 0x00, 0x1B, 0x80, 0x0E, 0xC0, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x86,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x30, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0x80,
  0x70, 0x07, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x71, 0xC0,
  0x01, 0xC6, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xEE,
  0x00, 0x07, 0x18, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x80,
  0x1C, 0x06, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x30, 0x0C, 0x00, 0xE0, 0x70,
  0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x30, 0x00, 0x39, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x0E, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00,
  0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x70, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x80,
  0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC1,
  0x80, 0x00, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0xCF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x1F,
  0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x37,
  0x03, 0xE0, 0x1F, 0x00, 0x3F, 0xFE, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x1E,
  0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 47, 14, 5, -47 },
  { 25, 13, 17, 21, 4, -47 },
  { 53, 30, 47, 33, 1, -47 },
  { 230, 24, 54, 30, 3, -50 },
  { 392, 37, 49, 43, 3, -48 },
  { 619, 29, 49, 33, 3, -48 },
  { 797, 3, 17, 11, 4, -47 },
  { 804, 12, 57, 18, 3, -47 },
  { 890, 13, 57, 18, 2, -47 },
  { 983, 21, 21, 27, 3, -50 },
  { 1039, 26, 31, 30, 2, -39 },
  { 1140, 6, 16, 13, 3, -7 },
  { 1152, 15, 2, 19, 2, -19 },
  { 1156, 4, 5, 13, 5, -5 },
  { 1159, 20, 47, 22, 1, -47 },
  { 1277, 24, 49, 30, 3, -48 },
  { 1424, 13, 47, 30, 5, -47 },
  { 1501, 23, 48, 30, 3, -48 },
  { 1639, 23, 49, 30, 3, -48 },
  { 1780, 28, 47, 30, 1, -47 },
  { 1945, 23, 48, 30, 4, -47 },
  { 2083, 24, 49, 30, 3, -48 },
  { 2230, 23, 47, 30, 3, -47 },
  { 2366, 24, 49, 30, 3, -48 },
  { 2513, 23, 49, 30, 3, -48 },
  { 2654, 4, 35, 13, 5, -35 },
  { 2672, 7, 44, 13, 2, -35 },
  { 2711, 26, 29, 30, 2, -38 },
  { 2806, 26, 16, 30, 2, -31 },
  { 2858, 26, 29, 30, 2, -38 },
  { 2953, 18, 48, 21, 1, -48 },
  { 3061, 39, 53, 46, 3, -47 },
  { 3320, 30, 47, 30, 0, -47 },
  { 3497, 24, 47, 33, 6, -47 },
  { 3638, 26, 49, 32, 4, -48 },
  { 3798, 26, 47, 36, 6, -47 },
  { 3951, 19, 47, 29, 6, -47 },
  { 4063, 19, 47, 26, 6, -47 },
  { 4175, 30, 49, 39, 4, -48 },
  { 4359, 25, 47, 37, 6, -47 },
  { 4506, 11, 47, 17, 3, -47 },
  { 4571, 12, 59, 14, -4, -47 },
  { 4660, 24, 47, 29, 6, -47 },
  { 4801, 19, 47, 26, 6, -47 },
  { 4913, 36, 47, 48, 6, -47 },
  { 5125, 26, 47, 38, 6, -47 },
  { 5278, 31, 49, 39, 4, -48 },
  { 5468, 22, 47, 30, 6, -47 },
  { 5598, 31, 59, 39, 4, -48 },
  { 5827, 24, 47, 31, 6, -47 },
  { 5968, 23, 49, 29, 3, -48 },
  { 6109, 26, 47, 26, 0, -47 },
  { 6262, 27, 48, 37, 5, -47 },
  { 6424, 29, 47, 29, 0, -47 },
  { 6595, 46, 47, 48, 1, -47 },
  { 6866, 26, 47, 26, 0, -47 },
  { 7019, 26, 47, 26, 0, -47 },
  { 7172, 23, 47, 27, 2, -47 },
  { 7308, 13, 57, 20, 5, -47 },
  { 7401, 20, 47, 22, 1, -47 },
  { 7519, 13, 57, 20, 2, -47 },
  { 7612, 26, 25, 30, 2, -47 },
  { 7694, 27, 2, 26, 0, 6 },
  { 7701, 10, 10, 16, 3, -50 },
  { 7714, 20, 37, 28, 3, -36 },
  { 7807, 23, 51, 32, 5, -50 },
  { 7954, 20, 37, 24, 3, -36 },
  { 8047, 24, 51, 32, 3, -50 },
  { 8200, 22, 37, 29, 3, -36 },
  { 8302, 17, 50, 16, 1, -50 },
  { 8409, 24, 52, 32, 3, -36 },
  { 8565, 21, 50, 31, 5, -50 },
  { 8697, 5, 48, 13, 4, -48 },
  { 8727, 9, 64, 13, -1, -48 },
  { 8799, 20, 50, 25, 5, -50 },
  { 8924, 2, 50, 12, 5, -50 },
  { 8937, 36, 36, 46, 5, -36 },
  { 9099, 21, 36, 31, 5, -36 },
  { 9194, 24, 37, 30, 3, -36 },
  { 9305, 23, 51, 32, 5, -36 },
  { 9452, 24, 51, 32, 3, -36 },
  { 9605, 14, 36, 20, 5, -36 },
  { 9668, 19, 37, 24, 2, -36 },
  { 9756, 14, 44, 17, 1, -43 },
  { 9833, 21, 36, 31, 5, -35 },
  { 9928, 23, 35, 23, 0, -35 },
  { 10029, 37, 35, 38, 1, -35 },
  { 10191, 22, 35, 25, 1, -35 },
  { 10288, 24, 51, 24, 0, -35 },
  { 10441, 18, 35, 21, 2, -35 },
  { 10520, 17, 57, 23, 3, -47 },
  { 10642, 2, 66, 28, 13, -50 },
  { 10659, 17, 57, 23, 3, -47 },
  { 10781, 26, 6, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_ExtraLight66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT66PT7B_H_
