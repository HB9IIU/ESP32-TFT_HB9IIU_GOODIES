#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT48PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight48pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00,
  0x17, 0xF8, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x08, 0x0C,
  0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x18, 0x08, 0x00,
  0x60, 0x20, 0x01, 0x81, 0x80, 0x04, 0x06, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0,
  0x02, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x02, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x01, 0x81, 0x80, 0x04, 0x06,
  0x00, 0x10, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00,
  0x30, 0x10, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x70, 0x01, 0xFF, 0xC3, 0xC8,
  0xF1, 0x84, 0x09, 0x82, 0x01, 0x81, 0x00, 0xC0, 0x80, 0x60, 0x40, 0x30,
  0x20, 0x18, 0x10, 0x0C, 0x08, 0x03, 0x04, 0x01, 0x82, 0x00, 0x61, 0x00,
  0x1C, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x09, 0xC0, 0x04,
  0x70, 0x02, 0x0C, 0x01, 0x03, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x20, 0x20,
  0x10, 0x30, 0x08, 0x18, 0x04, 0x0C, 0x02, 0x0D, 0x01, 0x0E, 0xE0, 0x8E,
  0x3F, 0xFE, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x00, 0xC2, 0x00, 0x60, 0x30,
  0x60, 0x08, 0x06, 0x04, 0x03, 0x00, 0x80, 0xC0, 0x40, 0x10, 0x18, 0x18,
  0x06, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x40, 0x18, 0x0C, 0x18, 0x03, 0x01,
  0x82, 0x00, 0x60, 0x30, 0xC0, 0x0C, 0x06, 0x18, 0x01, 0x80, 0xC2, 0x00,
  0x30, 0x18, 0xC3, 0xC2, 0x03, 0x11, 0xDC, 0x40, 0x66, 0x30, 0xCC, 0x08,
  0xCC, 0x19, 0x83, 0x11, 0x81, 0x18, 0xC6, 0x20, 0x31, 0xF8, 0x84, 0x06,
  0x1C, 0x31, 0x80, 0xC0, 0x06, 0x30, 0x18, 0x00, 0x86, 0x03, 0x00, 0x30,
  0xC0, 0x60, 0x06, 0x18, 0x0C, 0x01, 0x83, 0x01, 0x80, 0x30, 0x60, 0x30,
  0x04, 0x04, 0x06, 0x01, 0x80, 0x80, 0xC0, 0x30, 0x18, 0x10, 0x0C, 0x03,
  0x02, 0x01, 0x80, 0x20, 0xC0, 0x20, 0x06, 0x30, 0x0C, 0x00, 0x7C, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0x06, 0x00, 0x30, 0x10, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0xC0, 0x60, 0x06, 0x03, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x02, 0x18,
  0x00, 0x19, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0x30, 0x00, 0x71, 0xC0, 0x03, 0x06, 0x03, 0x30, 0x18, 0x19, 0x80, 0x60,
  0xD8, 0x03, 0x06, 0xC0, 0x0C, 0x26, 0x00, 0x33, 0x30, 0x01, 0x99, 0x80,
  0x07, 0x8C, 0x00, 0x1C, 0x60, 0x00, 0xE1, 0x80, 0x0F, 0x0C, 0x00, 0xEC,
  0x30, 0x0E, 0x31, 0xE1, 0xC1, 0x83, 0xFC, 0x06, 0xFF, 0xFF, 0xF5, 0x01,
  0x81, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x08, 0x18, 0x3E, 0x21, 0xCF, 0xDE,
  0x01, 0xE0, 0x03, 0x80, 0x04, 0x80, 0x19, 0x80, 0x61, 0x81, 0x81, 0x06,
  0x03, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x33, 0x33, 0x76, 0x66, 0x4C, 0xC0,
  0xFF, 0xFF, 0xFC, 0x5F, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0x87, 0x03,
  0x01, 0xC1, 0x80, 0x61, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x01,
  0x30, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x08, 0x30,
  0x0C, 0x1C, 0x0C, 0x07, 0x9E, 0x00, 0xFC, 0x00, 0x01, 0x83, 0xC3, 0xE3,
  0xB3, 0x9B, 0x0F, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x03,
  0xC0, 0x0F, 0xFC, 0x1E, 0x07, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x1E, 0x07, 0x1C, 0x00, 0xC8, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x80, 0x0E,
  0x7C, 0x1E, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0A,
  0x00, 0x01, 0xA0, 0x00, 0x12, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x06,
  0x20, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x01, 0x82, 0x00, 0x18, 0x20, 0x03,
  0x02, 0x00, 0x30, 0x20, 0x06, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x01,
  0x80, 0x20, 0x18, 0x02, 0x03, 0x00, 0x20, 0x30, 0x02, 0x06, 0x00, 0x20,
  0x60, 0x02, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x7F, 0xFC, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0x00, 0xFF, 0xF0,
  0xF0, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x1C, 0xF0, 0x78,
  0x7F, 0xE0, 0x00, 0x78, 0x03, 0xFE, 0x07, 0x02, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCF, 0xF8, 0x98, 0x0C,
  0xB0, 0x06, 0xA0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x60, 0x03, 0x60, 0x06, 0x30, 0x06, 0x38, 0x0C, 0x1C, 0x38, 0x0F, 0xF0,
  0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x18,
  0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07, 0x06, 0x03, 0x80, 0xE1,
  0xC0, 0x1C, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xE3, 0x80, 0x70, 0x30,
  0x38, 0x06, 0x1C, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x0C, 0x38, 0x07, 0x07, 0x87, 0x80, 0xFF, 0x80, 0x01, 0xC0,
  0x07, 0xFC, 0x07, 0x07, 0x06, 0x01, 0x87, 0x00, 0x63, 0x00, 0x11, 0x80,
  0x0D, 0x80, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x03, 0x60, 0x03, 0xB0, 0x01,
  0xCC, 0x01, 0x67, 0x03, 0xB1, 0xFF, 0x98, 0x3F, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x10, 0x78, 0x0F, 0xF0,
  0x00, 0x5F, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0xFC, 0x31,
  0x9E, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0xC6, 0x33, 0x18, 0xC6, 0x23, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x00, 0x0E, 0x03, 0xFE, 0x38, 0x38, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x46, 0x00, 0x30, 0x06,
  0x60, 0x1F, 0xE0, 0x64, 0x03, 0x82, 0x02, 0xC0, 0x60, 0x20, 0x2C, 0x06,
  0x06, 0x03, 0xC0, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03, 0x80, 0x80, 0x60,
  0x38, 0x18, 0x06, 0x03, 0x81, 0x80, 0x60, 0x38, 0x18, 0x06, 0x03, 0x81,
  0x80, 0x60, 0x38, 0x18, 0x06, 0x03, 0x81, 0x80, 0x60, 0x28, 0x08, 0x0E,
  0x06, 0x80, 0xC0, 0xA0, 0x6C, 0x0C, 0x0A, 0x04, 0xC0, 0x61, 0xB0, 0xCC,
  0x03, 0xF1, 0xF8, 0x40, 0x1C, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x01, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x16,
  0x00, 0x00, 0xC8, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00,
  0x01, 0x84, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC0, 0x80, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0x40, 0x06, 0x01,
  0x80, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x20, 0x03, 0x01, 0x80, 0x04, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00,
  0x46, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x30,
  0xFF, 0xF8, 0x30, 0x3F, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x01, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF8, 0x30, 0x03, 0x8C, 0x00, 0x73, 0x00, 0x0E, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x73, 0x00, 0x38,
  0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x1E, 0x03,
  0x87, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x20,
  0x78, 0x78, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0C, 0x1F, 0xC0, 0xC0, 0x0E,
  0x0C, 0x00, 0x70, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x01,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0,
  0x3C, 0x03, 0xC1, 0xC0, 0x02, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xE0, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x07, 0x00,
  0x0C, 0x0F, 0x83, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0C, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x87,
  0x7F, 0x04, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0x98, 0x01, 0x8C,
  0x01, 0xC6, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x60, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x38, 0x01, 0x9C,
  0x00, 0xDF, 0x00, 0x79, 0x80, 0x38, 0x60, 0x1C, 0x30, 0x0C, 0x0C, 0x06,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xE0, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1D, 0x80, 0x06, 0xC0,
  0x01, 0xE0, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xBF, 0x00, 0x00, 0x37, 0xB0, 0x00, 0x06,
  0xF6, 0x00, 0x00, 0x9E, 0xC0, 0x00, 0x33, 0xCC, 0x00, 0x06, 0x79, 0x80,
  0x00, 0x8F, 0x30, 0x00, 0x31, 0xE3, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x87,
  0x8C, 0x00, 0x30, 0xF0, 0xC0, 0x06, 0x1E, 0x18, 0x00, 0x83, 0xC3, 0x00,
  0x30, 0x78, 0x30, 0x06, 0x0F, 0x06, 0x00, 0x81, 0xE0, 0xC0, 0x30, 0x3C,
  0x0C, 0x06, 0x07, 0x81, 0x80, 0x80, 0xF0, 0x30, 0x30, 0x1E, 0x03, 0x06,
  0x03, 0xC0, 0x60, 0x80, 0x78, 0x0C, 0x30, 0x0F, 0x00, 0xC6, 0x01, 0xE0,
  0x18, 0x80, 0x3C, 0x03, 0x30, 0x07, 0x80, 0x36, 0x00, 0xF0, 0x06, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0x80, 0x0C, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xD8, 0x00, 0x3D,
  0x80, 0x03, 0xCC, 0x00, 0x3C, 0xC0, 0x03, 0xC6, 0x00, 0x3C, 0x60, 0x03,
  0xC3, 0x00, 0x3C, 0x30, 0x03, 0xC1, 0x80, 0x3C, 0x18, 0x03, 0xC0, 0xC0,
  0x3C, 0x0C, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x30, 0x3C, 0x03,
  0x03, 0xC0, 0x18, 0x3C, 0x01, 0x83, 0xC0, 0x0C, 0x3C, 0x00, 0xC3, 0xC0,
  0x06, 0x3C, 0x00, 0x63, 0xC0, 0x03, 0x3C, 0x00, 0x33, 0xC0, 0x01, 0xBC,
  0x00, 0x1B, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x1C, 0x0F, 0x00, 0x60, 0x07, 0x01,
  0x80, 0x07, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0x80, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x86,
  0x00, 0x07, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x0F,
  0x8F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0xC1, 0xF8, 0xC0, 0x1C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0,
  0x0E, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xE0, 0xFE, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x1C, 0x0F, 0x00, 0x60, 0x07,
  0x01, 0x80, 0x07, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x08, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x86, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0xC0,
  0x0F, 0x8F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xE0, 0x60, 0xFC, 0x30, 0x07, 0x18,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x18, 0xC0, 0x38, 0x7F, 0xF8, 0x3F, 0xF0, 0x18, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x18, 0x60, 0x0C,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0x87, 0x01,
  0xC7, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x80, 0x0E, 0x7C, 0x1E, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0C, 0xC0, 0x01, 0x9C, 0x00, 0x61, 0xC0, 0x1C, 0x1E, 0x0F,
  0x00, 0xFF, 0x80, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x03, 0x10, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x08, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x04, 0x01, 0x00,
  0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00,
  0x63, 0x00, 0x01, 0x10, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x36, 0x00, 0x34, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0D,
  0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0x20, 0x02, 0x60, 0x06, 0x18, 0x03,
  0x10, 0x03, 0x0C, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0xC1, 0x00,
  0x43, 0x00, 0xC0, 0xC0, 0x60, 0x80, 0x60, 0x60, 0x30, 0x60, 0x30, 0x30,
  0x18, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x08, 0x06, 0x04, 0x0C, 0x0C, 0x03,
  0x06, 0x02, 0x06, 0x01, 0x83, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC1, 0x80,
  0x20, 0x80, 0x61, 0x80, 0x18, 0xC0, 0x10, 0xC0, 0x0C, 0x60, 0x0C, 0x60,
  0x06, 0x30, 0x06, 0x30, 0x01, 0x18, 0x03, 0x30, 0x00, 0xC8, 0x00, 0x98,
  0x00, 0x6C, 0x00, 0x4C, 0x00, 0x36, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1A,
  0x00, 0x05, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xE6, 0x00, 0x18, 0x60,
  0x06, 0x0C, 0x00, 0xC0, 0x80, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x30,
  0x30, 0x06, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xC8, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC3,
  0x00, 0x30, 0x60, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00,
  0xDC, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x02, 0x10, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x10, 0x08, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x30, 0x03, 0x06, 0x00, 0x60, 0x80, 0x04, 0x30,
  0x00, 0xC6, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF,
  0xC0, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x09, 0x80, 0x01,
  0x98, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x0C,
  0x30, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0xE0, 0x3F, 0xE0, 0xC0, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xF0, 0x7F, 0xE3,
  0xC0, 0xCC, 0x01, 0xB0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xB0, 0x1B, 0x30, 0x66, 0x3F, 0x8C,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0xF8, 0x11,
  0xFF, 0x09, 0x81, 0xC5, 0x80, 0x72, 0x80, 0x19, 0xC0, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0xC0, 0x0C, 0xA0, 0x06, 0x48, 0x06,
  0x27, 0x0E, 0x11, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xE0, 0x46, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x0C, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0xF8, 0x21, 0xFF, 0x11, 0xC0, 0xC8, 0xC0, 0x34, 0xC0, 0x0A, 0x60,
  0x07, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x28, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x07, 0x30,
  0x02, 0x8C, 0x02, 0x47, 0x87, 0x20, 0xFE, 0x10, 0x01, 0xE0, 0x03, 0xFC,
  0x07, 0x07, 0x03, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0,
  0x06, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00, 0x58, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x02, 0x0E,
  0x0F, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x1F, 0xC1, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x0F,
  0xFC, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x47, 0x03, 0x23,
  0x00, 0xD3, 0x00, 0x29, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xA0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x19, 0x80, 0x14, 0xC0, 0x0A, 0x30, 0x09, 0x0E, 0x1C, 0x83, 0xF8,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x90, 0x01, 0x8F, 0x03, 0x83, 0xFF, 0x80,
  0x0E, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x0F, 0x84, 0x7F,
  0xC9, 0x81, 0x96, 0x01, 0xA8, 0x03, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x7F, 0xB0,
  0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80,
  0x06, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x08, 0x30, 0x69, 0xDF, 0x08, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x06, 0x80, 0x32, 0x01, 0x88, 0x06, 0x20, 0x30, 0x81, 0x82,
  0x0C, 0x08, 0x30, 0x21, 0x80, 0x8C, 0x02, 0x38, 0x09, 0xE0, 0x2C, 0xC0,
  0xA3, 0x03, 0x06, 0x0C, 0x18, 0x20, 0x30, 0x80, 0xC2, 0x01, 0x88, 0x06,
  0x20, 0x0C, 0x80, 0x32, 0x00, 0x68, 0x01, 0xA0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x7C, 0x23, 0xF8, 0x3F, 0xC9, 0x83, 0x18, 0x3A,
  0xC0, 0x6C, 0x06, 0xA0, 0x1A, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0,
  0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00,
  0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x38, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03,
  0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x03, 0x00, 0x30, 0x03, 0xE1, 0x1F, 0xF2, 0x60, 0x75, 0x80, 0x6A, 0x00,
  0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0x60,
  0x1C, 0x30, 0x03, 0x0C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00,
  0x90, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x09, 0x80,
  0x06, 0x60, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0x60, 0x18, 0x0E, 0x1C,
  0x01, 0xFE, 0x00, 0x03, 0xE0, 0x47, 0xFC, 0x26, 0x07, 0x16, 0x01, 0xCA,
  0x00, 0x65, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x00,
  0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x35,
  0x00, 0x32, 0xC0, 0x19, 0x20, 0x18, 0x9C, 0x38, 0x43, 0xF8, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xFC, 0x47, 0x03, 0x23, 0x00, 0xD3, 0x00, 0x29, 0x80, 0x1D, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x19, 0x80, 0x14, 0xC0, 0x1A, 0x30,
  0x09, 0x1E, 0x18, 0x83, 0xF8, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x03, 0xA3, 0xF9, 0x82, 0xC0, 0xA0, 0x28,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x07, 0xE0, 0xFF, 0xE7, 0x01, 0x98, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0xA0, 0x0E, 0xF0, 0xF1, 0xFF, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x03, 0xFF, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x18,
  0x06, 0x01, 0xC4, 0x3F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x07, 0x60, 0x07, 0x60, 0x0B,
  0x30, 0x1B, 0x3C, 0x73, 0x1F, 0xE3, 0xC0, 0x03, 0xB0, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x62, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08, 0x10,
  0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x03, 0x00, 0xC1, 0x80, 0x60, 0xC0,
  0x30, 0x40, 0x08, 0x60, 0x06, 0x30, 0x03, 0x18, 0x00, 0x98, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x1A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x60, 0x1A, 0x00, 0x98, 0x04, 0xC0, 0x66, 0x01, 0x30, 0x19, 0x80,
  0xCC, 0x06, 0x20, 0x31, 0x01, 0x0C, 0x0C, 0x60, 0xC3, 0x06, 0x18, 0x30,
  0xC1, 0x86, 0x0C, 0x10, 0x60, 0x82, 0x06, 0x18, 0x31, 0x81, 0x8C, 0x0C,
  0x60, 0x63, 0x03, 0x18, 0x08, 0xC0, 0x46, 0x03, 0x30, 0x19, 0x00, 0xC8,
  0x06, 0xC0, 0x36, 0x01, 0xB0, 0x05, 0x80, 0x6C, 0x01, 0xE0, 0x0A, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x08, 0x18, 0x0C, 0x30,
  0x04, 0x30, 0x06, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x10, 0x40, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x04, 0x06, 0x03, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x80, 0x20, 0xC0, 0x18, 0x60, 0x0C, 0x20, 0x02, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x23, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x01, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x78, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x80,
  0xF8, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x7D, 0xF0, 0x18, 0x0F, 0xBE, 0x00,
  0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraLight48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 34, 10, 4, -34 },
  { 14, 9, 12, 15, 3, -34 },
  { 28, 22, 34, 24, 1, -34 },
  { 122, 17, 39, 22, 2, -36 },
  { 205, 27, 35, 31, 2, -35 },
  { 324, 21, 35, 24, 2, -35 },
  { 416, 2, 12, 8, 3, -34 },
  { 419, 9, 42, 13, 2, -34 },
  { 467, 9, 42, 13, 2, -34 },
  { 515, 15, 15, 20, 2, -36 },
  { 544, 18, 22, 22, 2, -28 },
  { 594, 4, 11, 9, 2, -5 },
  { 600, 11, 2, 14, 1, -14 },
  { 603, 3, 4, 10, 3, -4 },
  { 605, 14, 34, 16, 1, -34 },
  { 665, 17, 35, 22, 2, -35 },
  { 740, 9, 34, 22, 4, -34 },
  { 779, 17, 35, 22, 2, -35 },
  { 854, 17, 35, 22, 2, -35 },
  { 929, 20, 34, 22, 1, -34 },
  { 1014, 16, 34, 22, 3, -34 },
  { 1082, 16, 36, 22, 3, -35 },
  { 1154, 17, 34, 22, 2, -34 },
  { 1227, 18, 35, 22, 2, -35 },
  { 1306, 17, 35, 22, 2, -35 },
  { 1381, 3, 26, 10, 3, -26 },
  { 1391, 5, 32, 10, 2, -26 },
  { 1411, 18, 20, 22, 2, -27 },
  { 1456, 18, 12, 22, 2, -23 },
  { 1483, 18, 20, 22, 2, -27 },
  { 1528, 13, 35, 15, 1, -35 },
  { 1585, 28, 38, 33, 3, -34 },
  { 1718, 22, 34, 22, 0, -34 },
  { 1812, 18, 34, 24, 4, -34 },
  { 1889, 19, 35, 23, 3, -35 },
  { 1973, 20, 34, 26, 4, -34 },
  { 2058, 14, 34, 21, 4, -34 },
  { 2118, 14, 34, 19, 4, -34 },
  { 2178, 22, 35, 28, 3, -35 },
  { 2275, 19, 34, 27, 4, -34 },
  { 2356, 8, 34, 12, 2, -34 },
  { 2390, 9, 43, 10, -3, -34 },
  { 2439, 17, 34, 21, 4, -34 },
  { 2512, 14, 34, 19, 4, -34 },
  { 2572, 27, 34, 35, 4, -34 },
  { 2687, 20, 34, 28, 4, -34 },
  { 2772, 23, 35, 28, 3, -35 },
  { 2873, 16, 34, 22, 4, -34 },
  { 2941, 23, 43, 28, 3, -35 },
  { 3065, 17, 34, 22, 4, -34 },
  { 3138, 17, 35, 21, 2, -35 },
  { 3213, 19, 34, 19, 0, -34 },
  { 3294, 19, 34, 27, 4, -34 },
  { 3375, 21, 34, 21, 0, -34 },
  { 3465, 33, 34, 35, 1, -34 },
  { 3606, 19, 34, 19, 0, -34 },
  { 3687, 19, 34, 19, 0, -34 },
  { 3768, 17, 34, 19, 1, -34 },
  { 3841, 9, 42, 15, 4, -34 },
  { 3889, 14, 34, 16, 1, -34 },
  { 3949, 9, 42, 15, 2, -34 },
  { 3997, 20, 18, 22, 1, -34 },
  { 4042, 19, 2, 19, 0, 4 },
  { 4047, 8, 8, 12, 2, -37 },
  { 4055, 15, 26, 20, 2, -26 },
  { 4104, 17, 36, 23, 4, -36 },
  { 4181, 14, 26, 18, 2, -26 },
  { 4227, 17, 36, 23, 2, -36 },
  { 4304, 17, 26, 21, 2, -26 },
  { 4360, 13, 37, 12, 0, -37 },
  { 4421, 17, 38, 23, 2, -26 },
  { 4502, 15, 36, 22, 4, -36 },
  { 4570, 3, 35, 9, 3, -35 },
  { 4584, 7, 47, 9, -1, -35 },
  { 4626, 14, 36, 18, 4, -36 },
  { 4689, 1, 36, 9, 4, -36 },
  { 4694, 26, 26, 33, 4, -26 },
  { 4779, 15, 26, 22, 4, -26 },
  { 4828, 18, 26, 22, 2, -26 },
  { 4887, 17, 37, 23, 4, -26 },
  { 4966, 17, 37, 23, 2, -26 },
  { 5045, 10, 26, 15, 4, -26 },
  { 5078, 14, 26, 17, 2, -26 },
  { 5124, 10, 32, 12, 1, -32 },
  { 5164, 16, 25, 22, 3, -25 },
  { 5214, 17, 25, 17, 0, -25 },
  { 5268, 26, 25, 28, 1, -25 },
  { 5350, 16, 25, 18, 1, -25 },
  { 5400, 17, 37, 17, 0, -25 },
  { 5479, 12, 25, 16, 2, -25 },
  { 5517, 13, 42, 17, 2, -34 },
  { 5586, 2, 49, 21, 9, -37 },
  { 5599, 13, 42, 17, 2, -34 },
  { 5668, 18, 4, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_ExtraLight48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT48PT7B_H_
