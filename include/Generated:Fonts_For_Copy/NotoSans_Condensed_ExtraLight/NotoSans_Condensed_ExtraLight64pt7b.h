#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT64PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight64pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0xFF, 0xFE,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x60, 0x30, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x38, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18, 0x01, 0x80, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x1E, 0x18, 0x3C,
  0x38, 0x30, 0x10, 0xE0, 0x60, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x07, 0x03,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x8C, 0x00, 0x07, 0xD8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x3C,
  0x00, 0x06, 0x1E, 0x00, 0x0C, 0x1E, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x1C,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x70, 0x03, 0x00, 0xE0,
  0x06, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x38, 0x00, 0xC0, 0xE4, 0x01, 0x83, 0x8F, 0x83, 0x1E, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x30, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x38, 0x30, 0x00, 0x60, 0x03,
  0x03, 0x80, 0x06, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x70, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x0C,
  0x1C, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x0C, 0x18, 0x3E, 0x0E,
  0x00, 0xC3, 0x07, 0xF8, 0x60, 0x0C, 0x30, 0xE1, 0x86, 0x01, 0xC7, 0x1C,
  0x1C, 0x60, 0x18, 0x61, 0x80, 0xC7, 0x01, 0x86, 0x38, 0x0E, 0x30, 0x38,
  0xC3, 0x00, 0x63, 0x87, 0x0C, 0x30, 0x06, 0x1F, 0xE1, 0xC3, 0x00, 0x60,
  0xFC, 0x18, 0x30, 0x07, 0x00, 0x01, 0x83, 0x00, 0x70, 0x00, 0x38, 0x70,
  0x07, 0x00, 0x03, 0x07, 0x00, 0x30, 0x00, 0x70, 0x70, 0x03, 0x00, 0x06,
  0x07, 0x00, 0x30, 0x00, 0x60, 0x70, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x70,
  0x00, 0xC0, 0x30, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x60, 0x03, 0x80, 0x30, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x60, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x60, 0x01, 0x80, 0xC0,
  0x06, 0x00, 0x0C, 0x1C, 0x00, 0xE0, 0x00, 0xF7, 0x80, 0x0C, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60,
  0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0xE7, 0x00, 0xE0, 0x0E, 0x60, 0x07, 0x00, 0xCE,
  0x00, 0x38, 0x0C, 0xE0, 0x01, 0x80, 0xCC, 0x00, 0x1C, 0x1C, 0xC0, 0x00,
  0xE1, 0x8C, 0x00, 0x06, 0x18, 0xC0, 0x00, 0x73, 0x8C, 0x00, 0x03, 0xB0,
  0xC0, 0x00, 0x1F, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xF0, 0x60, 0x00, 0x3B, 0x07, 0x00, 0x07, 0x38, 0x38, 0x00, 0xE1,
  0xC3, 0xC0, 0x3C, 0x0C, 0x1F, 0xFF, 0x80, 0xE0, 0x7F, 0xE0, 0x07, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xED, 0xB6, 0xDB, 0x60, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x0E, 0x06, 0x03, 0xF8, 0x61, 0xF3, 0xF6, 0xFC, 0x03,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x03, 0x8C, 0x00,
  0x30, 0xE0, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x1C, 0x03, 0x81, 0x80, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x86, 0x1C, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x23, 0xBF, 0xE7, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x06, 0x03,
  0x80, 0x0E, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x31, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE6, 0x00, 0x01, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0E, 0x00,
  0x0E, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0x3C, 0x0E, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xB0, 0xF3, 0x1E, 0x33,
  0x83, 0x70, 0x3E, 0x03, 0x40, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x03, 0xFE,
  0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x3C, 0x1C, 0x00, 0x78, 0x20, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xC0,
  0x3C, 0x3C, 0x00, 0x38, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC8, 0x00, 0x0F, 0x3C, 0x00, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x30, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0C, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x18,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x81, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x88, 0x00,
  0x1C, 0x38, 0x01, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x60, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x81, 0xFC, 0x03, 0x0F, 0xFE, 0x06, 0x78,
  0x1E, 0x0C, 0xC0, 0x0E, 0x3B, 0x00, 0x0E, 0x7C, 0x00, 0x0C, 0xF0, 0x00,
  0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0E,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xE6,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x86, 0x00, 0x07, 0x1C,
  0x00, 0x06, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0x73, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1C, 0x07,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x01, 0xE7, 0x80, 0x07, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x70, 0x01, 0xC1,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x06, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x70, 0xE0, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x78, 0x38, 0x00, 0xE0,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0xF7, 0x00,
  0x03, 0xCC, 0x00, 0x1B, 0x38, 0x00, 0xCC, 0x78, 0x07, 0x30, 0xFF, 0xF8,
  0xC1, 0xFF, 0x83, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x77, 0xBE, 0xE7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x39, 0xDF, 0xF3, 0x80, 0x1C, 0x3C, 0x78, 0xF1, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0xE1, 0xC3, 0x06, 0x1C, 0x30, 0x61, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x0F, 0x01, 0xE1, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x7C, 0x00, 0xE3, 0x80, 0x0F, 0xFE, 0x01, 0x8C, 0x00, 0x78,
  0x78, 0x06, 0x30, 0x03, 0x80, 0xE0, 0x1D, 0xC0, 0x1C, 0x03, 0x80, 0x77,
  0x00, 0x60, 0x0E, 0x00, 0xD8, 0x03, 0x80, 0x38, 0x03, 0x60, 0x0C, 0x00,
  0xC0, 0x0D, 0x80, 0x70, 0x03, 0x00, 0x36, 0x01, 0xC0, 0x0C, 0x00, 0xD8,
  0x06, 0x00, 0x30, 0x03, 0xE0, 0x18, 0x00, 0xC0, 0x0F, 0x80, 0x60, 0x03,
  0x00, 0x3E, 0x01, 0x80, 0x0C, 0x00, 0xF8, 0x06, 0x00, 0x30, 0x03, 0xE0,
  0x18, 0x00, 0xC0, 0x0F, 0x80, 0x60, 0x07, 0x00, 0x7E, 0x01, 0x80, 0x1C,
  0x01, 0xD8, 0x06, 0x00, 0x70, 0x06, 0x60, 0x1C, 0x01, 0x40, 0x19, 0x80,
  0x30, 0x0D, 0x00, 0xE6, 0x00, 0xC0, 0x36, 0x03, 0x18, 0x03, 0x81, 0x98,
  0x1C, 0x70, 0x07, 0x8E, 0x39, 0xE0, 0xC0, 0x0F, 0xF0, 0xFF, 0x03, 0x00,
  0x0F, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x70, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x1C, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x70, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xE0, 0x03, 0xE0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x78, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3E, 0x01, 0xE0, 0x78, 0x00, 0x20, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x70, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0x80,
  0x07, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x1F, 0x03, 0x80, 0x3F, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x60,
  0x38, 0x00, 0x01, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x0F, 0x00,
  0x00, 0x18, 0x3C, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x06, 0x03, 0xE0, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x81, 0xCF, 0xFC, 0xFF, 0x00,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00,
  0xE3, 0x80, 0x00, 0xE7, 0xC0, 0x00, 0xEE, 0xC0, 0x00, 0xEC, 0xE0, 0x00,
  0xFC, 0x70, 0x00, 0xF8, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xEC,
  0x00, 0x00, 0x03, 0x7E, 0xC0, 0x00, 0x00, 0x37, 0xEE, 0x00, 0x00, 0x07,
  0x7E, 0x60, 0x00, 0x00, 0x67, 0xE6, 0x00, 0x00, 0x06, 0x7E, 0x70, 0x00,
  0x00, 0xE7, 0xE3, 0x00, 0x00, 0x0C, 0x7E, 0x30, 0x00, 0x00, 0xC7, 0xE3,
  0x80, 0x00, 0x1C, 0x7E, 0x18, 0x00, 0x01, 0x87, 0xE1, 0x80, 0x00, 0x18,
  0x7E, 0x1C, 0x00, 0x03, 0x87, 0xE0, 0xC0, 0x00, 0x30, 0x7E, 0x0C, 0x00,
  0x03, 0x07, 0xE0, 0xE0, 0x00, 0x70, 0x7E, 0x06, 0x00, 0x06, 0x07, 0xE0,
  0x60, 0x00, 0x60, 0x7E, 0x07, 0x00, 0x0E, 0x07, 0xE0, 0x30, 0x00, 0xC0,
  0x7E, 0x03, 0x00, 0x0C, 0x07, 0xE0, 0x38, 0x01, 0xC0, 0x7E, 0x01, 0x80,
  0x1C, 0x07, 0xE0, 0x18, 0x01, 0x80, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0xE0,
  0x0C, 0x03, 0x80, 0x7E, 0x00, 0xC0, 0x30, 0x07, 0xE0, 0x0E, 0x07, 0x00,
  0x7E, 0x00, 0x60, 0x70, 0x07, 0xE0, 0x06, 0x06, 0x00, 0x7E, 0x00, 0x70,
  0xE0, 0x07, 0xE0, 0x03, 0x0E, 0x00, 0x7E, 0x00, 0x30, 0xC0, 0x07, 0xE0,
  0x03, 0x9C, 0x00, 0x7E, 0x00, 0x19, 0xC0, 0x07, 0xE0, 0x01, 0x98, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x0F, 0xB8, 0x00,
  0x03, 0xE6, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3E, 0x30, 0x00, 0x0F, 0x8E,
  0x00, 0x03, 0xE1, 0x80, 0x00, 0xF8, 0x70, 0x00, 0x3E, 0x0C, 0x00, 0x0F,
  0x83, 0x80, 0x03, 0xE0, 0x60, 0x00, 0xF8, 0x1C, 0x00, 0x3E, 0x03, 0x00,
  0x0F, 0x80, 0xE0, 0x03, 0xE0, 0x18, 0x00, 0xF8, 0x07, 0x00, 0x3E, 0x00,
  0xC0, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x06, 0x00, 0xF8, 0x01, 0xC0, 0x3E,
  0x00, 0x30, 0x0F, 0x80, 0x0E, 0x03, 0xE0, 0x01, 0xC0, 0xF8, 0x00, 0x70,
  0x3E, 0x00, 0x0E, 0x0F, 0x80, 0x03, 0x83, 0xE0, 0x00, 0x70, 0xF8, 0x00,
  0x1C, 0x3E, 0x00, 0x03, 0x8F, 0x80, 0x00, 0xE3, 0xE0, 0x00, 0x1C, 0xF8,
  0x00, 0x07, 0x3E, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x3B, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x38, 0x00,
  0xF8, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1B, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33,
  0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0xF0, 0xE0, 0x7F, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xBF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01,
  0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0x60, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x02,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC8, 0x00, 0x0F, 0x38,
  0x00, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0x8E, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0x30, 0x00,
  0x1D, 0x80, 0x00, 0xE1, 0x80, 0x00, 0xCC, 0x00, 0x07, 0x0E, 0x00, 0x06,
  0x70, 0x00, 0x30, 0x70, 0x00, 0x31, 0x80, 0x01, 0x81, 0x80, 0x03, 0x8C,
  0x00, 0x1C, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xE0, 0x70, 0x00, 0xC3, 0x80,
  0x07, 0x03, 0x80, 0x06, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x60, 0x03,
  0x80, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0xE0,
  0x1C, 0x00, 0xC0, 0xE0, 0x06, 0x00, 0xE0, 0x06, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x18, 0x03, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x1C, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x18, 0x0E,
  0x00, 0xC0, 0x70, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00,
  0x30, 0x18, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x06,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x80, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xC0,
  0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x63, 0x00, 0x00, 0x73, 0x00, 0x03, 0x98, 0x00, 0x01,
  0x98, 0x00, 0x0D, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0x86, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x06,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x71,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x06, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0xC0,
  0x01, 0x80, 0x60, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0x98, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x06, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00,
  0x70, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0C,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x18,
  0x30, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x20, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x01, 0xC1, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0xFF, 0xE0, 0xFF, 0xCC, 0x7C, 0x01, 0x9E, 0x00, 0x37, 0x00, 0x06, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x5B, 0x80,
  0x1B, 0x78, 0x06, 0x67, 0xEF, 0x8C, 0x7F, 0xE1, 0x80, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x04, 0x00, 0x60, 0xFF, 0x80, 0xC3, 0xFF, 0xC1,
  0x8E, 0x03, 0xC3, 0x30, 0x03, 0xC6, 0xC0, 0x03, 0x8D, 0x00, 0x03, 0x9E,
  0x00, 0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x1B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB8, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x33,
  0xC0, 0x00, 0xE6, 0x80, 0x01, 0x8D, 0x80, 0x07, 0x19, 0x80, 0x1C, 0x33,
  0x80, 0x78, 0x63, 0xFF, 0xE0, 0xC1, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xC0, 0x20, 0xF0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x20, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x04, 0x03, 0x80, 0xFF, 0x87, 0x07,
  0xFF, 0x8E, 0x1E, 0x03, 0x9C, 0x78, 0x01, 0x98, 0xE0, 0x01, 0xB3, 0x80,
  0x03, 0x67, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x3C, 0xC0, 0x00, 0x79, 0xC0, 0x01, 0xB3, 0x80, 0x03, 0x63, 0x80,
  0x0C, 0xC3, 0x80, 0x31, 0x83, 0xFF, 0xC3, 0x03, 0xFF, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0x70,
  0x0E, 0x00, 0xE0, 0x70, 0x01, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x39, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x02, 0x0F, 0x00, 0x38, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x70, 0x40, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x0C, 0x1F, 0xFE, 0x18, 0x78, 0x06,
  0x31, 0xE0, 0x06, 0x63, 0x80, 0x06, 0xCE, 0x00, 0x05, 0x98, 0x00, 0x0F,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xF3, 0x00, 0x01,
  0x67, 0x00, 0x07, 0xCE, 0x00, 0x0B, 0x8E, 0x00, 0x37, 0x0F, 0x01, 0xCE,
  0x0F, 0xFF, 0x1C, 0x0F, 0xFC, 0x38, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x08, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x10, 0x0C, 0x1F, 0xF0, 0xC7, 0xFF, 0x8C, 0xF0, 0x3C, 0xCC, 0x00,
  0xED, 0x80, 0x0E, 0xD0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x83, 0x9F, 0xCF, 0xC0,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x0E, 0xC0, 0x03, 0x98, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x07, 0x0C,
  0x00, 0xC1, 0x80, 0x38, 0x30, 0x0E, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18,
  0x1C, 0x03, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01, 0x8F, 0x00, 0x31,
  0xF0, 0x06, 0x66, 0x00, 0xD8, 0xE0, 0x1F, 0x0C, 0x03, 0xC1, 0xC0, 0x70,
  0x18, 0x0C, 0x03, 0x81, 0x80, 0x30, 0x30, 0x07, 0x06, 0x00, 0x60, 0xC0,
  0x0E, 0x18, 0x00, 0xC3, 0x00, 0x1C, 0x60, 0x01, 0x8C, 0x00, 0x39, 0x80,
  0x03, 0x30, 0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x20, 0x18, 0x7F, 0xC0, 0x7F, 0xC3, 0x1F, 0xFC, 0x1F, 0xFC, 0x67,
  0x03, 0xC7, 0x03, 0xCD, 0xC0, 0x39, 0xC0, 0x1D, 0xB0, 0x03, 0xB0, 0x03,
  0xBC, 0x00, 0x7C, 0x00, 0x37, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x10, 0x0C, 0x1F,
  0xF0, 0xC3, 0xFF, 0x8C, 0xF0, 0x3C, 0xCC, 0x00, 0xED, 0x80, 0x0E, 0xD0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x07, 0x01,
  0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x70,
  0x00, 0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC7,
  0x00, 0x03, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x01, 0x83,
  0xFE, 0x03, 0x0F, 0xFF, 0x06, 0x38, 0x0F, 0x0C, 0xC0, 0x0F, 0x1B, 0x00,
  0x0E, 0x36, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x19, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xCF, 0x00, 0x03, 0x9A, 0x00, 0x06, 0x36, 0x00,
  0x1C, 0x66, 0x00, 0x70, 0xCE, 0x01, 0xE1, 0x8F, 0xFF, 0x83, 0x07, 0xFC,
  0x06, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0xFE, 0x0C, 0x1F, 0xFE, 0x18, 0x78, 0x0E, 0x31, 0xE0, 0x06, 0x63, 0x80,
  0x06, 0xCE, 0x00, 0x0D, 0x9C, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80,
  0x00, 0x7B, 0x80, 0x00, 0xF3, 0x00, 0x01, 0x67, 0x00, 0x07, 0xCE, 0x00,
  0x1B, 0x8E, 0x00, 0x37, 0x0F, 0x01, 0xCE, 0x0F, 0xFF, 0x1C, 0x0F, 0xFC,
  0x38, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0xC1, 0xFF, 0x0F, 0xEC,
  0x70, 0x73, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0E, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x74, 0x00, 0x1E,
  0xF0, 0x07, 0x9F, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xF0,
  0x06, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xB6, 0x00, 0x1B, 0x70, 0x03, 0x33, 0x80, 0x63, 0x3F, 0xFE,
  0x30, 0xFF, 0x83, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x76,
  0x00, 0x01, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00,
  0x03, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0xC0, 0x06,
  0x07, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x70, 0x06, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x70, 0x18, 0x00, 0xC0,
  0xE0, 0x03, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80,
  0x01, 0x86, 0x00, 0x07, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00,
  0xEC, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x06, 0xE0, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x0E, 0x60, 0x00,
  0xF0, 0x00, 0xE6, 0x00, 0x1B, 0x80, 0x0C, 0x70, 0x01, 0x98, 0x00, 0xC7,
  0x00, 0x19, 0x80, 0x0C, 0x30, 0x01, 0x98, 0x01, 0xC3, 0x00, 0x39, 0xC0,
  0x18, 0x38, 0x03, 0x1C, 0x01, 0x83, 0x80, 0x30, 0xC0, 0x18, 0x18, 0x03,
  0x0C, 0x03, 0x81, 0x80, 0x70, 0xC0, 0x30, 0x1C, 0x06, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x60, 0x30, 0x0C, 0x06, 0x06, 0x07, 0x00, 0xC0, 0xE0, 0x60,
  0x70, 0x0E, 0x0C, 0x07, 0x06, 0x00, 0xE0, 0xC0, 0x30, 0x60, 0x06, 0x0C,
  0x03, 0x06, 0x00, 0x61, 0xC0, 0x30, 0xE0, 0x06, 0x18, 0x03, 0x8C, 0x00,
  0x71, 0x80, 0x18, 0xC0, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x19,
  0xC0, 0x03, 0x30, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x06, 0x00, 0x1C,
  0x1C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x07,
  0x03, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x70, 0x00, 0x61, 0x80, 0x01, 0xCE,
  0x00, 0x03, 0x30, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x00, 0x01, 0xCE, 0x00, 0x07,
  0x18, 0x00, 0x38, 0x70, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x80, 0x18, 0x06,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x60, 0x01, 0x83,
  0x80, 0x07, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x3B, 0x80, 0x00, 0x70, 0x60,
  0x00, 0x0E, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x60, 0x03, 0x00, 0xC0,
  0x06, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x70, 0x00, 0x70, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x01,
  0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x5F, 0xFE, 0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x00,
  0xFF, 0xF4, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLight64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 46, 14, 5, -46 },
  { 24, 12, 17, 20, 4, -46 },
  { 50, 29, 46, 32, 1, -46 },
  { 217, 23, 53, 29, 3, -49 },
  { 370, 36, 47, 42, 3, -46 },
  { 582, 28, 47, 32, 3, -46 },
  { 747, 3, 17, 11, 4, -46 },
  { 754, 12, 56, 17, 3, -46 },
  { 838, 12, 56, 17, 2, -46 },
  { 922, 20, 20, 26, 3, -49 },
  { 972, 25, 29, 29, 2, -37 },
  { 1063, 7, 15, 12, 2, -7 },
  { 1077, 14, 3, 18, 2, -19 },
  { 1083, 5, 5, 13, 4, -5 },
  { 1087, 19, 46, 21, 1, -46 },
  { 1197, 23, 47, 29, 3, -46 },
  { 1333, 12, 46, 29, 5, -46 },
  { 1402, 22, 46, 29, 3, -46 },
  { 1529, 22, 47, 29, 3, -46 },
  { 1659, 27, 46, 29, 1, -46 },
  { 1815, 22, 47, 29, 4, -46 },
  { 1945, 23, 47, 29, 3, -46 },
  { 2081, 23, 46, 29, 3, -46 },
  { 2214, 23, 47, 29, 3, -46 },
  { 2350, 22, 47, 29, 3, -46 },
  { 2480, 5, 34, 13, 4, -34 },
  { 2502, 7, 42, 13, 2, -34 },
  { 2539, 25, 28, 29, 2, -37 },
  { 2627, 25, 15, 29, 2, -30 },
  { 2674, 25, 28, 29, 2, -37 },
  { 2762, 18, 46, 20, 1, -46 },
  { 2866, 38, 52, 44, 3, -46 },
  { 3113, 29, 46, 29, 0, -46 },
  { 3280, 24, 46, 32, 5, -46 },
  { 3418, 25, 47, 31, 4, -46 },
  { 3565, 26, 46, 35, 5, -46 },
  { 3715, 20, 46, 28, 5, -46 },
  { 3830, 20, 46, 26, 5, -46 },
  { 3945, 29, 47, 37, 4, -46 },
  { 4116, 25, 46, 36, 5, -46 },
  { 4260, 10, 46, 16, 3, -46 },
  { 4318, 12, 57, 13, -4, -46 },
  { 4404, 24, 46, 29, 5, -46 },
  { 4542, 19, 46, 25, 5, -46 },
  { 4652, 36, 46, 46, 5, -46 },
  { 4859, 26, 46, 37, 5, -46 },
  { 5009, 30, 47, 38, 4, -46 },
  { 5186, 22, 46, 29, 5, -46 },
  { 5313, 30, 57, 38, 4, -46 },
  { 5527, 24, 46, 30, 5, -46 },
  { 5665, 22, 47, 28, 3, -46 },
  { 5795, 25, 46, 25, 0, -46 },
  { 5939, 26, 47, 36, 5, -46 },
  { 6092, 28, 46, 28, 0, -46 },
  { 6253, 45, 46, 47, 1, -46 },
  { 6512, 25, 46, 26, 0, -46 },
  { 6656, 25, 46, 25, 0, -46 },
  { 6800, 22, 46, 26, 2, -46 },
  { 6927, 13, 56, 20, 5, -46 },
  { 7018, 19, 46, 21, 1, -46 },
  { 7128, 13, 56, 20, 2, -46 },
  { 7219, 26, 24, 29, 2, -46 },
  { 7297, 26, 2, 26, 0, 6 },
  { 7304, 10, 10, 15, 3, -49 },
  { 7317, 19, 36, 27, 3, -35 },
  { 7403, 23, 50, 31, 5, -49 },
  { 7547, 19, 36, 23, 3, -35 },
  { 7633, 23, 50, 31, 3, -49 },
  { 7777, 22, 36, 28, 3, -35 },
  { 7876, 17, 49, 15, 1, -49 },
  { 7981, 23, 50, 31, 3, -35 },
  { 8125, 20, 49, 30, 5, -49 },
  { 8248, 4, 46, 12, 4, -46 },
  { 8271, 9, 61, 12, -1, -46 },
  { 8340, 19, 49, 24, 5, -49 },
  { 8457, 2, 49, 12, 5, -49 },
  { 8470, 35, 35, 45, 5, -35 },
  { 8624, 20, 35, 30, 5, -35 },
  { 8712, 23, 36, 30, 3, -35 },
  { 8816, 23, 50, 31, 5, -35 },
  { 8960, 23, 50, 31, 3, -35 },
  { 9104, 14, 34, 19, 5, -34 },
  { 9164, 19, 36, 23, 2, -35 },
  { 9250, 14, 43, 16, 1, -42 },
  { 9326, 20, 35, 30, 5, -34 },
  { 9414, 22, 34, 22, 0, -34 },
  { 9508, 36, 34, 37, 1, -34 },
  { 9661, 22, 34, 24, 1, -34 },
  { 9755, 23, 49, 23, 0, -34 },
  { 9896, 17, 34, 21, 2, -34 },
  { 9969, 16, 56, 22, 3, -46 },
  { 10081, 2, 65, 28, 13, -49 },
  { 10098, 16, 56, 22, 3, -46 },
  { 10210, 25, 6, 29, 2, -26 },
};

const GFXfont NotoSans_Condensed_ExtraLight64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT64PT7B_H_
