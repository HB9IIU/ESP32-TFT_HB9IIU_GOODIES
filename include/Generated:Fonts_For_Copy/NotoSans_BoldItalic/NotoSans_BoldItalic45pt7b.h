#ifndef _NOTOSANS_BOLDITALIC45PT7B_H_
#define _NOTOSANS_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x10, 0x00, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0x87, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1E, 0x3E, 0x1F, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x87, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xE7, 0x0C, 0x0F, 0xCF, 0x00,
  0x0F, 0xCE, 0x00, 0x0F, 0xCE, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3B, 0xFC, 0x00, 0x39, 0xFC,
  0x00, 0x39, 0xFC, 0x80, 0x39, 0xFC, 0xC0, 0x71, 0xF8, 0xF8, 0x77, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0x81, 0xFF, 0xC0, 0x07, 0xC0, 0xFF, 0xF0, 0x03, 0xE0, 0x3F,
  0xFE, 0x01, 0xF0, 0x1F, 0x9F, 0x80, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x03,
  0xF0, 0xF8, 0x1F, 0x00, 0xFC, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F, 0x83, 0xE0,
  0x0F, 0x87, 0xE1, 0xF0, 0x03, 0xE1, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x7E,
  0x00, 0x3E, 0x3F, 0x1F, 0x0E, 0x0F, 0x8F, 0xCF, 0x9F, 0xF3, 0xE7, 0xE7,
  0xCF, 0xFE, 0xFF, 0xFB, 0xF7, 0xFF, 0xBF, 0xFC, 0xF9, 0xFF, 0xF7, 0xFE,
  0x7C, 0xFC, 0xFC, 0xFF, 0x3E, 0x3E, 0x3F, 0x0C, 0x1F, 0x9F, 0x8F, 0xC0,
  0x07, 0xC7, 0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0x3F,
  0x00, 0xFC, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0xC3, 0xE0, 0x1F, 0x03, 0xF1,
  0xF8, 0x0F, 0x80, 0xFC, 0x7C, 0x07, 0xE0, 0x3F, 0x3F, 0x01, 0xF0, 0x07,
  0xFF, 0x80, 0xF8, 0x01, 0xFF, 0xE0, 0x7C, 0x00, 0x3F, 0xF0, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80,
  0x01, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0xFE, 0x07, 0xF1, 0xFF,
  0xFC, 0x1F, 0x8F, 0xFF, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x3F,
  0xDF, 0xC7, 0xF0, 0x7F, 0xFE, 0x1F, 0x80, 0xFF, 0xF0, 0xFE, 0x03, 0xFF,
  0x83, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0x0F, 0xF0, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x06,
  0x07, 0xC0, 0x3C, 0x3E, 0x01, 0xF9, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xDF, 0x87,
  0xFE, 0x00, 0x7E, 0xF8, 0x07, 0xF7, 0xC0, 0x7F, 0x3F, 0x01, 0xF0, 0xF8,
  0x07, 0x87, 0xE0, 0x08, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF0,
  0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0x7E, 0x3F, 0x80,
  0xFC, 0xFF, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xE0, 0x0F,
  0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x80, 0x7F, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFC, 0x0F, 0xF1, 0xFC,
  0x3F, 0xC3, 0xF8, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xFB, 0xFF,
  0xFC, 0x7F, 0xBF, 0x1F, 0x9F, 0xC3, 0xC7, 0xF0, 0xC1, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xC0, 0x7F, 0x00, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xE0, 0xFF,
  0x01, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0xC0, 0x03, 0xFC,
  0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE1, 0xFC, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x40, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x04, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x80, 0x0F, 0xF0, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x0F,
  0xEF, 0xF8, 0x1F, 0xBF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF9, 0xFF,
  0x9F, 0xF3, 0xFE, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0,
  0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xFC, 0x0F,
  0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x07, 0xF1, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC7,
  0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFF, 0x03,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0x8F,
  0xE0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0x80,
  0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xC1, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xF3, 0xF8, 0x07, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x20, 0x3F, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E,
  0x01, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x03, 0xF8, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x1C,
  0x03, 0xE1, 0xF8, 0x1F, 0xFE, 0x3F, 0x3F, 0x03, 0xFF, 0xE1, 0xF3, 0xE0,
  0xFF, 0xFE, 0x1F, 0x7E, 0x0F, 0xFF, 0xE1, 0xF7, 0xC1, 0xF8, 0x7C, 0x1F,
  0x7C, 0x3F, 0x07, 0xC1, 0xF7, 0xC3, 0xE0, 0x7C, 0x1F, 0xF8, 0x7E, 0x07,
  0xC1, 0xFF, 0x87, 0xC0, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0x83, 0xEF, 0x87,
  0xC0, 0xF8, 0x3E, 0xF8, 0x7C, 0x1F, 0x83, 0xEF, 0x87, 0xC1, 0xF0, 0x7C,
  0xF8, 0x7C, 0x3F, 0x0F, 0xCF, 0x87, 0xFF, 0xFF, 0xF8, 0xF8, 0x7F, 0xFF,
  0xFF, 0x07, 0xC3, 0xFE, 0x7F, 0xE0, 0x7C, 0x1F, 0xC3, 0xF8, 0x07, 0xE0,
  0x20, 0x04, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x7F, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xE1, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7F,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07,
  0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xF8, 0x7F, 0xC0,
  0x0C, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x01, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0xFF, 0x83, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x40, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xC0,
  0xFF, 0x80, 0x08, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0xFE, 0x07, 0xFF, 0xCF, 0xE0,
  0x7F, 0xF8, 0xFE, 0x07, 0xFF, 0x8F, 0xE0, 0x7F, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xFE, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x21,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x03,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F,
  0x81, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0x8F,
  0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFB, 0xF0, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07,
  0xDF, 0x80, 0xFC, 0xF8, 0x1F, 0xBF, 0x01, 0xF9, 0xF0, 0x3E, 0x7E, 0x03,
  0xF3, 0xE0, 0xFC, 0xFC, 0x07, 0xE7, 0xC1, 0xF3, 0xF8, 0x1F, 0x8F, 0x87,
  0xE7, 0xE0, 0x3F, 0x1F, 0x0F, 0x8F, 0xC0, 0x7E, 0x3E, 0x3F, 0x1F, 0x80,
  0xFC, 0x7C, 0x7C, 0x7F, 0x01, 0xF8, 0xF9, 0xF8, 0xFC, 0x07, 0xE1, 0xF3,
  0xE1, 0xF8, 0x0F, 0xC3, 0xEF, 0xC3, 0xF0, 0x1F, 0x87, 0xDF, 0x07, 0xE0,
  0x3F, 0x0F, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x3F,
  0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0xC0, 0xFC, 0x07, 0xE0, 0xFF, 0x81, 0xF8,
  0x0F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC0,
  0xFF, 0xC0, 0x07, 0xE0, 0x7F, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x03, 0xF0,
  0x1F, 0xFC, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x7E,
  0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x01, 0xFB, 0xF0, 0x1F,
  0x81, 0xF9, 0xFC, 0x0F, 0xC0, 0xFC, 0x7E, 0x0F, 0xE0, 0x7E, 0x3F, 0x07,
  0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0,
  0xFC, 0x0F, 0xC1, 0xF8, 0xFE, 0x07, 0xE0, 0xFE, 0x7E, 0x03, 0xF0, 0x3F,
  0x3F, 0x01, 0xF8, 0x1F, 0x9F, 0x81, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0x03,
  0xF7, 0xE0, 0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0, 0x3F, 0x80,
  0x3F, 0xF8, 0x1F, 0x80, 0x1F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFE, 0x07, 0xE0,
  0x03, 0xFE, 0x03, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x81, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xE1, 0xFF, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF1,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F,
  0xF3, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFE, 0x0F,
  0x07, 0xF0, 0x04, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF1, 0x00, 0x0F, 0xE3, 0x00, 0x3F, 0x87, 0xC1, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x9F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xFE, 0x01,
  0xFC, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xFE, 0x03, 0xF8, 0xFC,
  0x07, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xFE,
  0x07, 0xF0, 0xFC, 0x0F, 0xBE, 0x07, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F, 0xE0,
  0xFC, 0x1F, 0xBE, 0x0F, 0xC0, 0x7C, 0x1F, 0x3E, 0x0F, 0xC0, 0x7C, 0x3F,
  0x3F, 0x1F, 0xC0, 0x7C, 0x3E, 0x3F, 0x1F, 0x80, 0x7C, 0x7E, 0x3F, 0x3F,
  0x80, 0x7C, 0x7E, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x3F, 0x3F, 0x00, 0x7C,
  0xFC, 0x3F, 0x7E, 0x00, 0x7C, 0xF8, 0x3F, 0x7E, 0x00, 0x7D, 0xF8, 0x3F,
  0xFC, 0x00, 0x7D, 0xF0, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x3E, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xDF, 0x80, 0x1F, 0xC7, 0xF0, 0x0F,
  0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xF0,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE3, 0xF8, 0x01,
  0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x81, 0xF0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80,
  0x7C, 0x0F, 0x01, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F,
  0x00, 0x78, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0x80,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xFE, 0x7F,
  0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1E, 0x00, 0xFC, 0x1F, 0x03, 0xFF, 0x3F,
  0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF7, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xF8, 0x07, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE,
  0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0xC7, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xFD, 0xFF, 0xC0,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0x3E, 0x3F, 0xC0, 0x23, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x8F, 0xF0, 0x38, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0x1F, 0xC0, 0x1F, 0xE7, 0xF0, 0x1F, 0xFD, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E,
  0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xEF, 0x80, 0x3F, 0xF3, 0xE0, 0x07, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F,
  0x87, 0xF3, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x0F,
  0xE7, 0xE1, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x30, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0xFF, 0xCF, 0xC0, 0xFF, 0xE7, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xEF, 0xC0, 0x3F, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x06, 0x00, 0xFE, 0x03,
  0xF3, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE1,
  0xF0, 0x07, 0xE7, 0xFC, 0x07, 0xEF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFC, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x03, 0xF0, 0x3F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7E,
  0x3F, 0xC0, 0x0F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFC, 0x0F,
  0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x0F, 0xC0, 0x3E, 0x3F, 0xE0, 0xFF,
  0x81, 0xF3, 0xFF, 0x1F, 0xFC, 0x1F, 0xBF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFF,
  0xEF, 0xFF, 0x87, 0xFE, 0x7F, 0xF9, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xE1,
  0xFC, 0x0F, 0xF0, 0x3F, 0x1F, 0xE0, 0x7F, 0x81, 0xF8, 0xFE, 0x03, 0xF8,
  0x0F, 0xC7, 0xF0, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x07,
  0xC1, 0xF0, 0x07, 0xC7, 0xFC, 0x07, 0xCF, 0xFE, 0x0F, 0xDF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F,
  0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0xC3, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0xFF, 0x80, 0x1F, 0x7F, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFE, 0xFF, 0xC0, 0x3F, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x01,
  0xFF, 0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xBE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF7, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F,
  0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE,
  0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xF7, 0xE0, 0x3F, 0xE7, 0xE0, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xC1, 0xF0, 0x7C,
  0x7E, 0x07, 0xCF, 0xE0, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFC, 0x41, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFC, 0x0E, 0x1F, 0xC0, 0x21, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x80, 0x1F, 0xCE, 0x01,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x08, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE,
  0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0x7F, 0xFD, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFB, 0xF0, 0x3F, 0xF3, 0xF0, 0x1F, 0xC3, 0xE0, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x01, 0xFB, 0xF0, 0x3F, 0xE0,
  0x7F, 0x7E, 0x07, 0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0x83, 0xF9, 0xF8, 0x3F,
  0xF0, 0x7E, 0x3F, 0x07, 0xFE, 0x1F, 0xC7, 0xE1, 0xF7, 0xC3, 0xF0, 0xFC,
  0x3E, 0xF8, 0xFE, 0x1F, 0x8F, 0x9F, 0x1F, 0x83, 0xF1, 0xF3, 0xE3, 0xF0,
  0x7E, 0x3E, 0x7C, 0xFE, 0x0F, 0xCF, 0x8F, 0x9F, 0x81, 0xF9, 0xF1, 0xF7,
  0xF0, 0x3F, 0x7E, 0x3E, 0xFC, 0x07, 0xEF, 0x87, 0xDF, 0x80, 0xFD, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFC, 0x1E, 0xFC, 0x01, 0xFF, 0x83, 0xDF, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0x80,
  0x1F, 0xE1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0x00,
  0x04, 0xFF, 0x80, 0x17, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFC, 0x01, 0xFF, 0xA0, 0x00, 0xF8,
};

const GFXglyph NotoSans_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 33, 13, 0, -32 },
  { 59, 17, 11, 20, 4, -32 },
  { 83, 28, 32, 29, 1, -32 },
  { 195, 24, 37, 25, 1, -34 },
  { 306, 34, 33, 39, 3, -33 },
  { 447, 30, 33, 32, 1, -33 },
  { 571, 8, 11, 11, 4, -32 },
  { 582, 16, 39, 15, 2, -32 },
  { 660, 17, 40, 15, -3, -33 },
  { 745, 21, 21, 25, 4, -34 },
  { 801, 22, 22, 26, 2, -27 },
  { 862, 11, 11, 13, -2, -5 },
  { 878, 13, 6, 15, 1, -15 },
  { 888, 8, 8, 13, 0, -7 },
  { 896, 24, 32, 19, -2, -32 },
  { 992, 23, 33, 25, 1, -33 },
  { 1087, 18, 32, 25, 4, -32 },
  { 1159, 25, 33, 25, -1, -33 },
  { 1263, 24, 33, 25, 0, -33 },
  { 1362, 25, 32, 25, -1, -32 },
  { 1462, 24, 32, 25, 1, -32 },
  { 1558, 23, 33, 25, 2, -33 },
  { 1653, 25, 32, 25, 2, -32 },
  { 1753, 24, 33, 25, 1, -33 },
  { 1852, 22, 33, 25, 2, -33 },
  { 1943, 12, 26, 13, 0, -25 },
  { 1982, 14, 31, 13, -2, -25 },
  { 2037, 22, 24, 26, 2, -28 },
  { 2103, 22, 14, 26, 2, -23 },
  { 2142, 22, 24, 26, 2, -28 },
  { 2208, 19, 34, 21, 3, -33 },
  { 2289, 36, 36, 39, 2, -32 },
  { 2451, 29, 32, 28, -3, -32 },
  { 2567, 27, 32, 28, 1, -32 },
  { 2675, 26, 33, 28, 3, -33 },
  { 2783, 28, 32, 30, 1, -32 },
  { 2895, 25, 32, 24, 1, -32 },
  { 2995, 25, 32, 24, 1, -32 },
  { 3095, 28, 33, 31, 3, -33 },
  { 3211, 31, 32, 32, 1, -32 },
  { 3335, 21, 32, 17, -1, -32 },
  { 3419, 22, 42, 15, -7, -32 },
  { 3535, 31, 32, 28, 1, -32 },
  { 3659, 19, 32, 23, 1, -32 },
  { 3735, 39, 32, 40, 1, -32 },
  { 3891, 33, 32, 34, 1, -32 },
  { 4023, 29, 33, 33, 3, -33 },
  { 4143, 27, 32, 27, 1, -32 },
  { 4251, 29, 41, 33, 3, -33 },
  { 4400, 26, 32, 28, 1, -32 },
  { 4504, 23, 33, 24, 1, -33 },
  { 4599, 23, 32, 24, 4, -32 },
  { 4691, 29, 32, 31, 3, -32 },
  { 4807, 27, 32, 27, 4, -32 },
  { 4915, 40, 32, 40, 4, -32 },
  { 5075, 34, 32, 27, -3, -32 },
  { 5211, 26, 32, 25, 4, -32 },
  { 5315, 27, 32, 24, -1, -32 },
  { 5423, 19, 39, 15, -1, -32 },
  { 5516, 11, 32, 19, 5, -32 },
  { 5560, 19, 39, 15, -3, -32 },
  { 5653, 23, 21, 25, 1, -32 },
  { 5714, 19, 3, 18, -4, 4 },
  { 5722, 9, 7, 15, 7, -34 },
  { 5730, 24, 25, 27, 2, -25 },
  { 5805, 24, 34, 27, 1, -34 },
  { 5907, 20, 25, 22, 2, -25 },
  { 5970, 26, 34, 27, 2, -34 },
  { 6081, 22, 25, 25, 2, -25 },
  { 6150, 27, 45, 17, -5, -34 },
  { 6302, 25, 36, 27, 1, -25 },
  { 6415, 24, 34, 27, 1, -34 },
  { 6517, 13, 34, 13, 1, -34 },
  { 6573, 21, 45, 13, -6, -34 },
  { 6692, 27, 34, 26, 1, -34 },
  { 6807, 14, 34, 13, 1, -34 },
  { 6867, 37, 25, 41, 1, -25 },
  { 6983, 24, 25, 27, 1, -25 },
  { 7058, 22, 25, 26, 2, -25 },
  { 7127, 26, 36, 27, -1, -25 },
  { 7244, 24, 36, 27, 2, -25 },
  { 7352, 20, 25, 19, 1, -25 },
  { 7415, 20, 25, 21, 0, -25 },
  { 7478, 17, 30, 18, 2, -30 },
  { 7542, 24, 25, 27, 2, -25 },
  { 7617, 24, 25, 23, 2, -25 },
  { 7692, 35, 25, 35, 3, -25 },
  { 7802, 28, 25, 24, -2, -25 },
  { 7890, 29, 36, 23, -3, -25 },
  { 8021, 23, 25, 21, -1, -25 },
  { 8093, 19, 39, 16, 0, -32 },
  { 8186, 5, 44, 25, 10, -34 },
  { 8214, 18, 39, 16, -2, -32 },
  { 8302, 22, 8, 26, 2, -20 },
};

const GFXfont NotoSans_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_BOLDITALIC45PT7B_H_
