#ifndef _NOTOSANS_BOLDITALIC18PT7B_H_
#define _NOTOSANS_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x70, 0x06, 0x38, 0xE0, 0xEF,
  0x3C, 0xF6, 0xD8, 0x06, 0x60, 0x6C, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF,
  0x19, 0x81, 0x98, 0xFF, 0xE3, 0x30, 0x33, 0x03, 0x60, 0x66, 0x00, 0x03,
  0x00, 0x81, 0xFC, 0xFE, 0x3E, 0x0F, 0x03, 0xC0, 0x7C, 0x07, 0x83, 0xE8,
  0xBB, 0xFE, 0xFF, 0x02, 0x01, 0x80, 0x38, 0x39, 0xF0, 0xCE, 0xC6, 0x33,
  0x30, 0xCD, 0x83, 0x76, 0xEF, 0xB7, 0xDD, 0xB3, 0x0C, 0xCC, 0x33, 0x71,
  0x8D, 0x8C, 0x3E, 0x70, 0xF0, 0x0F, 0x01, 0xF8, 0x3B, 0x83, 0x38, 0x3B,
  0x03, 0xE0, 0x3C, 0x7F, 0xEE, 0xEE, 0xCC, 0x7C, 0xE3, 0x8F, 0xFC, 0x7D,
  0xE0, 0xFB, 0x6C, 0x0C, 0x63, 0x9C, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0E, 0x18, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC6,
  0x38, 0xC6, 0x30, 0x08, 0x1C, 0x98, 0xF8, 0x7F, 0x3B, 0xEC, 0x4C, 0x0C,
  0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x00, 0x37,
  0x6E, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x1F,
  0x9C, 0xEC, 0x7E, 0x3F, 0x1F, 0x0F, 0x86, 0xC7, 0x63, 0xB3, 0x9F, 0xC7,
  0xC0, 0x0E, 0x79, 0xF7, 0x6D, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x87,
  0x00, 0x0F, 0x0F, 0xE3, 0x3C, 0x87, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x0B, 0xFC, 0xFF, 0x00, 0x1F, 0x0F, 0xE1, 0x1C, 0x07, 0x01,
  0x87, 0xE1, 0xE0, 0x1C, 0x03, 0x80, 0xE8, 0x7B, 0xFC, 0xFE, 0x00, 0x01,
  0xC0, 0xE0, 0x78, 0x36, 0x1F, 0x86, 0xE3, 0x31, 0x8C, 0xFF, 0xBF, 0xE0,
  0x70, 0x18, 0x0E, 0x00, 0x1F, 0xC7, 0xF1, 0x80, 0xE0, 0x38, 0x0F, 0xC7,
  0xF8, 0x0E, 0x03, 0x80, 0xE8, 0x7B, 0xFC, 0xFE, 0x00, 0x0F, 0x8F, 0xCE,
  0x0E, 0x06, 0x07, 0xFB, 0xFD, 0xC6, 0xC3, 0x63, 0xB9, 0xDF, 0xC7, 0xC0,
  0x7F, 0xDF, 0xE0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x87, 0xF3, 0x9C, 0xE7, 0x39, 0xC7,
  0xE1, 0xE1, 0xFC, 0x63, 0xB8, 0xE6, 0x39, 0xFC, 0x3E, 0x00, 0x1E, 0x3F,
  0x9C, 0xDC, 0x7E, 0x3F, 0x1F, 0xFC, 0xF6, 0x07, 0x03, 0x03, 0x9F, 0x8F,
  0x80, 0x39, 0xCC, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x1C, 0x71, 0x80, 0x00,
  0x00, 0x00, 0x31, 0xC6, 0x38, 0x01, 0x83, 0xC7, 0x8F, 0x0E, 0x07, 0xC0,
  0x78, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x80, 0x70,
  0x1E, 0x01, 0xC0, 0x38, 0x79, 0xF1, 0xE0, 0xC0, 0x00, 0x3E, 0x7F, 0x67,
  0x07, 0x0E, 0x1E, 0x38, 0x30, 0x70, 0x00, 0x60, 0xF0, 0xE0, 0x03, 0xE0,
  0x7F, 0xE3, 0x81, 0x9C, 0x03, 0x67, 0xEF, 0x3B, 0x3C, 0xCC, 0xF6, 0x33,
  0xD9, 0xCF, 0x77, 0x6C, 0xEF, 0x38, 0x00, 0x70, 0x40, 0xFF, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0xEC, 0x19, 0x87, 0x38, 0xC7,
  0x3F, 0xE7, 0xFD, 0xC3, 0xB0, 0x3E, 0x06, 0x1F, 0x83, 0xFC, 0x63, 0x9C,
  0x73, 0x8E, 0x7F, 0x8F, 0xE1, 0x8E, 0x71, 0xCE, 0x39, 0xCF, 0x3F, 0xCF,
  0xF0, 0x0F, 0xC3, 0xFC, 0xF3, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xC4, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xFC, 0x19, 0xE3,
  0x86, 0x38, 0x73, 0x87, 0x38, 0x73, 0x06, 0x70, 0xE7, 0x1E, 0x73, 0xC7,
  0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF1, 0x80, 0xE0, 0x38, 0x0F, 0xE3, 0xF8,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xC7, 0xF1, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xF8, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0,
  0x00, 0x0F, 0xE3, 0xFC, 0xF1, 0x38, 0x07, 0x01, 0xC0, 0x78, 0xF7, 0x3E,
  0xE1, 0xDC, 0x3B, 0xC7, 0x3F, 0xC3, 0xF8, 0x1C, 0x38, 0xE1, 0x86, 0x1C,
  0x70, 0xE3, 0x87, 0x1F, 0xF8, 0xFF, 0x86, 0x1C, 0x70, 0xE3, 0x87, 0x1C,
  0x30, 0xE1, 0x8E, 0x1C, 0x00, 0x1F, 0x8F, 0xC3, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x0F, 0x8F, 0xC0, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE2,
  0xF1, 0xF0, 0xF0, 0x00, 0x1C, 0x78, 0xE7, 0x86, 0x38, 0x73, 0x83, 0xB8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03, 0x9C, 0x1C, 0xE0, 0xC3, 0x0E,
  0x1C, 0x00, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x7F, 0xFF, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E,
  0x36, 0x36, 0x3E, 0x36, 0x6E, 0x36, 0x6C, 0x76, 0xCC, 0x76, 0xDC, 0x67,
  0x9C, 0x67, 0x9C, 0xE7, 0x18, 0x1C, 0x1C, 0x78, 0x61, 0xE1, 0x8F, 0x86,
  0x3F, 0x38, 0xCC, 0xE3, 0x33, 0x0C, 0xEC, 0x73, 0xB1, 0xC7, 0xC6, 0x1F,
  0x18, 0x78, 0xE0, 0xE0, 0x0F, 0x81, 0xFE, 0x38, 0xE7, 0x06, 0x70, 0x7E,
  0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF8, 0x67, 0x9C, 0x73, 0x8E, 0x71, 0xCF, 0xF1, 0xFC, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x0F, 0x81, 0xFE, 0x3C, 0xE7, 0x06,
  0x70, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xF3, 0xC7, 0xF8,
  0x3F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x1F, 0x83, 0xF8, 0x67, 0x9C, 0x73,
  0x8E, 0x73, 0x8F, 0xF1, 0xF8, 0x73, 0x0E, 0x71, 0xCE, 0x38, 0xEE, 0x1C,
  0x0F, 0x87, 0xF3, 0x88, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xC8, 0x73, 0xFC, 0x7C, 0x00, 0x7F, 0xDF, 0xF8, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x00, 0x38, 0x73,
  0x86, 0x30, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE3, 0x87, 0xF8, 0x3E, 0x00, 0xC1, 0xF0, 0x7C, 0x3B, 0x0E, 0xC7,
  0x39, 0x8E, 0xE3, 0xB0, 0xFC, 0x3E, 0x07, 0x81, 0xC0, 0x70, 0x00, 0xC3,
  0x87, 0xC3, 0x86, 0xC7, 0x8E, 0xC7, 0x8C, 0xC7, 0x9C, 0xCD, 0x98, 0xCD,
  0xB8, 0xD9, 0xB8, 0xD9, 0xB0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1,
  0xC0, 0x1C, 0x38, 0xE3, 0x83, 0x9C, 0x1D, 0xC0, 0xFC, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x1D, 0x80, 0xEE, 0x0E, 0x70, 0xE1, 0x8E, 0x0E, 0x00, 0xC1,
  0xF8, 0xEE, 0x71, 0x9C, 0x6E, 0x1F, 0x07, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x47, 0xF8, 0xFF, 0x80,
  0x1E, 0x3C, 0x61, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x18,
  0x3C, 0x78, 0xCC, 0xEE, 0x66, 0x66, 0x77, 0x33, 0x30, 0x1E, 0x3C, 0x18,
  0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x86, 0x3C, 0x78, 0x06,
  0x03, 0x03, 0xC1, 0xE1, 0xB1, 0x8C, 0xC7, 0xC3, 0xFF, 0xDD, 0x80, 0x1D,
  0xBF, 0xDC, 0xFC, 0x7E, 0x37, 0x1B, 0x9D, 0xCE, 0xFF, 0x3B, 0x00, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x3B, 0x8F, 0xF3, 0x9C, 0xC7, 0x71, 0xDC, 0x77,
  0x19, 0xCE, 0x7F, 0x3F, 0x80, 0x1F, 0x7F, 0x72, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE2, 0xFC, 0x7C, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x1D, 0x9F, 0xE7, 0x3B,
  0x8E, 0xE3, 0x38, 0xCC, 0x73, 0x9C, 0xFF, 0x1F, 0x80, 0x1E, 0x1F, 0x9C,
  0xFC, 0x6F, 0xF7, 0xF3, 0x01, 0xC2, 0xFE, 0x3F, 0x00, 0x01, 0xE0, 0x78,
  0x1D, 0x03, 0x80, 0xF8, 0x3F, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0xF8, 0x1E, 0x00, 0x0E, 0xCF,
  0xF3, 0x9D, 0xC7, 0x71, 0x9C, 0x67, 0x39, 0xCE, 0x7F, 0x8E, 0xC0, 0x32,
  0x1C, 0xFE, 0x3F, 0x00, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x3B, 0x8F, 0xF3,
  0x9C, 0xE7, 0x71, 0xDC, 0x77, 0x19, 0x8E, 0x63, 0xB8, 0xE0, 0x08, 0x71,
  0x80, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x63, 0x80, 0x02, 0x07, 0x06,
  0x00, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0xF0, 0xF0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x8E, 0x73, 0x8E,
  0xE1, 0xB8, 0x7E, 0x0F, 0xC1, 0xDC, 0x3B, 0x86, 0x39, 0xC7, 0x00, 0x1C,
  0x71, 0x86, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x63, 0x80, 0x33, 0x9E,
  0x6F, 0xFC, 0xE7, 0x99, 0xCE, 0x37, 0x1C, 0x6E, 0x31, 0xDC, 0x63, 0xB1,
  0xC7, 0x63, 0x8D, 0xC7, 0x38, 0x33, 0x8D, 0xF3, 0x9C, 0xE7, 0x71, 0xDC,
  0x77, 0x19, 0x8E, 0x63, 0xB8, 0xE0, 0x1E, 0x3F, 0x9C, 0xFC, 0x7E, 0x3F,
  0x1F, 0x0D, 0xCE, 0xFE, 0x3E, 0x00, 0x19, 0xC3, 0xFC, 0x73, 0x8C, 0x73,
  0x8E, 0x71, 0xCE, 0x31, 0xCE, 0x3F, 0x8E, 0xE1, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x00, 0x1D, 0xBF, 0xDC, 0xFC, 0x7E, 0x37, 0x1B, 0x1D, 0xCE, 0xFF,
  0x3B, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x3B, 0x37, 0x3F, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0x1F, 0x3F, 0x71, 0x70, 0x3C, 0x1E, 0x0E, 0x86,
  0xFE, 0xFC, 0x18, 0x61, 0xFF, 0xE7, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0xE3,
  0xC0, 0x71, 0xDC, 0x66, 0x39, 0x8E, 0xE3, 0xB8, 0xCE, 0x73, 0x9C, 0xFB,
  0x1D, 0xC0, 0xE3, 0xF1, 0xF9, 0xDC, 0xCE, 0xE3, 0x61, 0xF0, 0xF0, 0x78,
  0x38, 0x00, 0xE7, 0x1F, 0x9C, 0x6E, 0x53, 0xBB, 0x4E, 0xEF, 0x73, 0xED,
  0xCF, 0xB6, 0x3C, 0x78, 0xF1, 0xC1, 0xC7, 0x00, 0x38, 0xF1, 0xDC, 0x1D,
  0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xB0, 0x73, 0x8F, 0x3C, 0x38,
  0xE7, 0x1C, 0xE7, 0x1C, 0xE1, 0xB8, 0x36, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1C, 0x0F, 0x81, 0xE0, 0x00, 0x3F, 0x9F, 0x81, 0xC1, 0xC1,
  0xC1, 0xC0, 0xC0, 0xE0, 0xFE, 0x7F, 0x00, 0x07, 0x0E, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0xF0, 0xE0, 0x70, 0x30, 0x70, 0x60, 0x70, 0x78, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x38, 0x30, 0x60, 0xC3, 0x87, 0x07, 0x1E,
  0x30, 0xE1, 0x83, 0x0E, 0x3C, 0x60, 0x70, 0xFF, 0xE3, 0xC0,
};

const GFXglyph NotoSans_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 6, 5, 8, 2, -13 },
  { 15, 12, 13, 12, 0, -13 },
  { 35, 10, 15, 10, 0, -14 },
  { 54, 14, 13, 15, 1, -13 },
  { 77, 12, 13, 13, 1, -13 },
  { 97, 3, 5, 5, 2, -13 },
  { 99, 6, 16, 6, 1, -13 },
  { 111, 6, 16, 6, -1, -13 },
  { 123, 8, 9, 10, 2, -14 },
  { 132, 9, 9, 10, 1, -11 },
  { 143, 4, 4, 5, -1, -2 },
  { 145, 5, 2, 6, 0, -6 },
  { 147, 3, 3, 5, 0, -3 },
  { 149, 10, 13, 8, -1, -13 },
  { 166, 9, 13, 10, 1, -13 },
  { 181, 7, 13, 10, 2, -13 },
  { 193, 10, 13, 10, 0, -13 },
  { 210, 10, 13, 10, 0, -13 },
  { 227, 10, 13, 10, 0, -13 },
  { 244, 10, 13, 10, 0, -13 },
  { 261, 9, 13, 10, 1, -13 },
  { 276, 10, 13, 10, 1, -13 },
  { 293, 10, 13, 10, 0, -13 },
  { 310, 9, 13, 10, 1, -13 },
  { 325, 5, 10, 5, 0, -10 },
  { 332, 6, 12, 5, -1, -10 },
  { 341, 9, 9, 10, 1, -11 },
  { 352, 9, 5, 10, 1, -9 },
  { 358, 9, 9, 10, 1, -11 },
  { 369, 8, 13, 8, 1, -13 },
  { 382, 14, 15, 15, 1, -13 },
  { 409, 11, 13, 11, -1, -13 },
  { 427, 11, 13, 11, 0, -13 },
  { 445, 11, 13, 11, 1, -13 },
  { 463, 12, 13, 12, 0, -13 },
  { 483, 10, 13, 10, 0, -13 },
  { 500, 10, 13, 10, 0, -13 },
  { 517, 11, 13, 12, 1, -13 },
  { 535, 13, 13, 13, 0, -13 },
  { 557, 9, 13, 7, -1, -13 },
  { 572, 9, 17, 6, -3, -13 },
  { 592, 13, 13, 11, 0, -13 },
  { 614, 8, 13, 9, 0, -13 },
  { 627, 16, 13, 16, 0, -13 },
  { 653, 14, 13, 14, 0, -13 },
  { 676, 12, 13, 13, 1, -13 },
  { 696, 11, 13, 11, 0, -13 },
  { 714, 12, 16, 13, 1, -13 },
  { 738, 11, 13, 11, 0, -13 },
  { 756, 10, 13, 10, 0, -13 },
  { 773, 10, 13, 10, 1, -13 },
  { 790, 12, 13, 12, 1, -13 },
  { 810, 10, 13, 11, 2, -13 },
  { 827, 16, 13, 16, 2, -13 },
  { 853, 13, 13, 11, -1, -13 },
  { 875, 10, 13, 10, 2, -13 },
  { 892, 12, 13, 10, -1, -13 },
  { 912, 7, 16, 6, 0, -13 },
  { 926, 4, 13, 8, 2, -13 },
  { 933, 7, 16, 6, -1, -13 },
  { 947, 9, 8, 10, 0, -13 },
  { 956, 8, 1, 7, -2, 2 },
  { 957, 3, 3, 6, 3, -14 },
  { 959, 9, 10, 11, 1, -10 },
  { 971, 10, 14, 11, 0, -14 },
  { 989, 8, 10, 9, 1, -10 },
  { 999, 10, 14, 11, 1, -14 },
  { 1017, 9, 10, 10, 1, -10 },
  { 1029, 11, 18, 7, -2, -14 },
  { 1054, 10, 14, 11, 0, -10 },
  { 1072, 10, 14, 11, 0, -14 },
  { 1090, 6, 14, 5, 0, -14 },
  { 1101, 8, 18, 5, -2, -14 },
  { 1119, 11, 14, 10, 0, -14 },
  { 1139, 6, 14, 5, 0, -14 },
  { 1150, 15, 10, 16, 0, -10 },
  { 1169, 10, 10, 11, 0, -10 },
  { 1182, 9, 10, 11, 1, -10 },
  { 1194, 11, 14, 11, -1, -10 },
  { 1214, 9, 14, 11, 1, -10 },
  { 1230, 8, 10, 8, 0, -10 },
  { 1240, 8, 10, 9, 0, -10 },
  { 1250, 7, 12, 7, 1, -12 },
  { 1261, 10, 10, 11, 1, -10 },
  { 1274, 9, 10, 9, 1, -10 },
  { 1286, 14, 10, 14, 1, -10 },
  { 1304, 12, 10, 10, -1, -10 },
  { 1319, 11, 14, 9, -1, -10 },
  { 1339, 9, 10, 8, 0, -10 },
  { 1351, 8, 16, 6, 0, -13 },
  { 1367, 2, 18, 10, 4, -14 },
  { 1372, 7, 16, 6, -1, -13 },
  { 1386, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_BOLDITALIC18PT7B_H_
