#ifndef _NOTOSANS_BOLDITALIC48PT7B_H_
#define _NOTOSANS_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x03, 0x80, 0x00, 0x7F, 0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xEF, 0xC7, 0xE7,
  0xE3, 0xF3, 0xE1, 0xFB, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x3F,
  0x3E, 0x1F, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF9, 0xC7, 0x03, 0xF9, 0xE0, 0x81,
  0xFC, 0xF0, 0x00, 0xFE, 0x70, 0x00, 0x7F, 0x38, 0x00, 0x3F, 0xDC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x77,
  0xF8, 0x00, 0x39, 0xFC, 0x00, 0x1C, 0xFE, 0x00, 0x1E, 0x7F, 0x30, 0x0E,
  0x3F, 0x9E, 0x07, 0x3F, 0xCF, 0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xF8,
  0x0F, 0xFE, 0x00, 0x1F, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0xFF, 0x00,
  0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x7E, 0x00,
  0xFC, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x1F,
  0x80, 0x0F, 0xC3, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x3E, 0x3F, 0x8F, 0xC7,
  0xE7, 0xE7, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xEF, 0xFF, 0xDF, 0x9F, 0xFF,
  0x7F, 0xF9, 0xF3, 0xFF, 0xF7, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0xE7, 0xE7,
  0xE1, 0xF0, 0x78, 0xFC, 0x7E, 0x1F, 0x00, 0x0F, 0x8F, 0xC1, 0xF0, 0x01,
  0xF8, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x3F,
  0x00, 0x7C, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0xFC, 0x7E, 0x01, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x7E,
  0x00, 0xFF, 0xFC, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0x07, 0xFF, 0x00, 0xFE, 0x0F, 0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0x0F, 0xF3,
  0xF8, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x03, 0xFF,
  0xE0, 0xFE, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0x0F,
  0xF8, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x04, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3F, 0x1F, 0x00,
  0x7F, 0xBC, 0x01, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x83, 0x87, 0xFF, 0x80, 0x1F,
  0xDF, 0x00, 0x7F, 0x3E, 0x01, 0xFE, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xE0,
  0xFC, 0x00, 0x81, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x00,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x3F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xDF, 0xCF, 0xF7, 0xF0, 0xF8, 0xFE,
  0x0E, 0x1F, 0xC1, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0x80, 0xFF, 0x00, 0xE0,
  0x1F, 0xE0, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0x07, 0xFC, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF2, 0x00, 0x03,
  0xF8, 0xE0, 0x03, 0xFE, 0x3F, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x20, 0x00, 0xFF, 0x18, 0x00, 0xFF, 0x8F, 0xE7,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFC, 0x04, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0xFC, 0xFF, 0xC0, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x7F,
  0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xCF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0xC1, 0xFE, 0x0F, 0xE1,
  0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F,
  0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xE1, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFE, 0xFC, 0x0F, 0xFD, 0xFC, 0x03,
  0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xF1, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x3E, 0x0F, 0xE3, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0xC1, 0xF8, 0x7E, 0x03, 0xFF, 0xE1, 0xF1, 0xF8,
  0x1F, 0xFF, 0xC3, 0xE3, 0xF0, 0x7F, 0xFF, 0x87, 0xE7, 0xC1, 0xFC, 0x3E,
  0x0F, 0xDF, 0x83, 0xF0, 0x7C, 0x1F, 0xBE, 0x0F, 0xC0, 0xF8, 0x3F, 0x7C,
  0x3F, 0x03, 0xF0, 0x7C, 0xF8, 0x7E, 0x07, 0xC0, 0xFB, 0xF0, 0xF8, 0x0F,
  0x81, 0xF7, 0xE1, 0xF0, 0x1F, 0x03, 0xEF, 0x87, 0xE0, 0x7E, 0x0F, 0xDF,
  0x0F, 0xC0, 0xF8, 0x1F, 0x3E, 0x1F, 0x83, 0xF0, 0x7E, 0x7C, 0x3F, 0x07,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0xE7, 0xF1, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1,
  0xF0, 0xFF, 0xEF, 0xFF, 0x03, 0xE0, 0xFF, 0x8F, 0xFC, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xE0, 0xFF, 0xC0, 0x1C, 0x1F, 0xF0,
  0x00, 0x41, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1C, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0x80,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x83, 0xF8,
  0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0x03, 0xFF, 0x00,
  0x18, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xF3, 0xFC,
  0x0F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE, 0x3F, 0x80, 0xFF, 0xF8, 0xFE, 0x03,
  0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x81, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x03,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFC, 0x7F, 0xC0, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0x7E, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xBF, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xE0,
  0x3F, 0x7E, 0x03, 0xE7, 0xF0, 0x3F, 0xBF, 0x03, 0xF3, 0xF0, 0x1F, 0xDF,
  0x81, 0xF1, 0xF8, 0x0F, 0xC7, 0xC1, 0xF9, 0xFC, 0x07, 0xE3, 0xE0, 0xF8,
  0xFE, 0x03, 0xF1, 0xF0, 0xFC, 0x7F, 0x03, 0xF8, 0xF8, 0x7C, 0x3F, 0x01,
  0xFC, 0x7C, 0x7E, 0x3F, 0x80, 0xFC, 0x3E, 0x3E, 0x1F, 0xC0, 0x7E, 0x1F,
  0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0x9F, 0x07, 0xE0, 0x3F, 0x87, 0xDF, 0x83,
  0xF0, 0x1F, 0x83, 0xFF, 0x83, 0xF8, 0x0F, 0xC1, 0xFF, 0xC1, 0xFC, 0x07,
  0xE0, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0x80,
  0x0F, 0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x3F,
  0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xFC, 0x01, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x7E, 0xFE, 0x01, 0xFC, 0x07, 0xE7, 0xE0,
  0x1F, 0x80, 0x7E, 0x7F, 0x01, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x80, 0x7E,
  0x7F, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xC1, 0xFC,
  0x7F, 0x01, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0xC0, 0xFE, 0x7E, 0x01, 0xF8,
  0x0F, 0xE7, 0xE0, 0x1F, 0x80, 0xFE, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x3F,
  0xFC, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xCF, 0xFE,
  0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x80,
  0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0x7F, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xCF,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF1,
  0xF8, 0x1F, 0xE0, 0x0C, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x10, 0x00, 0xFF, 0x0E, 0x00, 0xFF, 0x87, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x9F,
  0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0,
  0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xF8,
  0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF8, 0x03, 0xF9, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xBE, 0x03, 0xF8, 0x3F, 0x03, 0xF7, 0xC0, 0xFE,
  0x07, 0xE0, 0x7E, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0x9F, 0x07, 0xF0, 0x1F,
  0x83, 0xF3, 0xE0, 0xFE, 0x03, 0xF0, 0xFE, 0x7C, 0x1F, 0x80, 0x7E, 0x1F,
  0x8F, 0x87, 0xF0, 0x0F, 0xC3, 0xF1, 0xF0, 0xFE, 0x01, 0xF8, 0xFC, 0x3E,
  0x3F, 0x80, 0x3F, 0x1F, 0x87, 0xC7, 0xF0, 0x07, 0xE7, 0xE0, 0xF8, 0xFC,
  0x00, 0xFC, 0xFC, 0x1F, 0x3F, 0x80, 0x1F, 0x9F, 0x03, 0xE7, 0xE0, 0x03,
  0xF7, 0xE0, 0x7D, 0xFC, 0x00, 0x7E, 0xFC, 0x0F, 0xBF, 0x00, 0x0F, 0xFF,
  0x01, 0xF7, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xEF,
  0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x0F,
  0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x00, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0xC3, 0xF0, 0x3F, 0xF9, 0xF8, 0x1F, 0xFF, 0x7E, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFE, 0x7E, 0x00, 0xFE, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x78, 0x01, 0xFC, 0xFF, 0x00, 0xFE,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0x9F,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7E, 0xFF, 0xF8, 0x3F, 0x3F,
  0xF8, 0x1F, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x07,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0xC1, 0xFF, 0x1F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xC1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x3F,
  0xF9, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07,
  0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0x80, 0x1F, 0xF9, 0xF0, 0x00, 0xFF,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFD, 0xFE, 0x1F, 0xE0, 0x7E, 0x1F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFE, 0x7F,
  0x0F, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x10, 0x7F, 0x80, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x8F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x07, 0xFF,
  0x3F, 0x01, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFD, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x04,
  0x00, 0x7F, 0x80, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1C, 0x00,
  0x7F, 0x1F, 0xE0, 0x1F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x80,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0x00, 0x30, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x09, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x41, 0xFC, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0x83, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x3F,
  0xC0, 0x03, 0xF3, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x7F, 0x1F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xE3, 0xFE, 0x07,
  0xF8, 0x07, 0xE7, 0xFF, 0x0F, 0xFC, 0x07, 0xEF, 0xFF, 0x1F, 0xFE, 0x07,
  0xDF, 0xFF, 0xBF, 0xFE, 0x0F, 0xDF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF8, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xF8, 0xFF,
  0x80, 0x7E, 0x7F, 0xF0, 0x1F, 0xBF, 0xFE, 0x07, 0xDF, 0xFF, 0x83, 0xF7,
  0xFF, 0xE0, 0xFF, 0xC7, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFF, 0x03,
  0xFC, 0x7F, 0xCF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0xC7, 0xF8, 0x00, 0xFC, 0xFF, 0xC0, 0x0F, 0xDF, 0xFE, 0x00, 0xFB, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0xCF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xDF, 0xFE, 0x01, 0xFC,
  0xFF, 0xC0, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x3F, 0xF8, 0xF8, 0x1F, 0xFF,
  0x7E, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1,
  0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE3, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xF8, 0x07, 0xFC, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x1F,
  0xC1, 0xF9, 0xFE, 0x0F, 0xDF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xC2, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFB, 0xF0, 0xFF, 0x01,
  0x87, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x88, 0x01,
  0xFC, 0x70, 0x1F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x30, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFE,
  0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC1, 0xFF, 0x0F,
  0xF3, 0xFF, 0x87, 0xFF, 0xEF, 0xC3, 0xFF, 0xF7, 0xC0, 0xFF, 0xF7, 0xE0,
  0x7F, 0xF3, 0xF0, 0x1F, 0xE1, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xBF, 0x00,
  0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x1F,
  0x83, 0xF8, 0x0F, 0xC3, 0xFC, 0x07, 0xE1, 0xFC, 0x03, 0xF1, 0xFE, 0x01,
  0xF8, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xBF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xE0, 0x3F, 0xBF, 0x81, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xF8, 0x1F, 0xEF,
  0xE0, 0xFF, 0xC0, 0xFE, 0x7F, 0x07, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0xF0,
  0x7F, 0x1F, 0xC3, 0xEF, 0x83, 0xF8, 0xFE, 0x1F, 0x7C, 0x3F, 0x87, 0xF1,
  0xFB, 0xE1, 0xFC, 0x3F, 0x8F, 0x9F, 0x1F, 0xC1, 0xFC, 0xFC, 0xF8, 0xFE,
  0x07, 0xE7, 0xE7, 0xCF, 0xE0, 0x3F, 0x3E, 0x3E, 0x7F, 0x01, 0xFB, 0xF1,
  0xF3, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x80, 0x7F, 0xF8, 0x7D, 0xF8, 0x03,
  0xEF, 0x83, 0xEF, 0xC0, 0x1F, 0x7C, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x23, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x02, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x40, 0x03, 0xF8,
};

const GFXglyph NotoSans_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 35, 14, 1, -34 },
  { 63, 17, 12, 22, 5, -34 },
  { 89, 30, 34, 31, 1, -34 },
  { 217, 25, 39, 26, 1, -36 },
  { 339, 36, 35, 41, 3, -35 },
  { 497, 32, 35, 34, 2, -35 },
  { 637, 8, 12, 12, 5, -34 },
  { 649, 18, 42, 16, 2, -34 },
  { 744, 18, 43, 16, -3, -35 },
  { 841, 23, 24, 26, 4, -37 },
  { 910, 23, 24, 27, 3, -29 },
  { 979, 11, 12, 14, -2, -6 },
  { 996, 13, 6, 16, 1, -16 },
  { 1006, 9, 8, 14, 0, -7 },
  { 1015, 26, 35, 20, -2, -35 },
  { 1129, 24, 35, 26, 2, -35 },
  { 1234, 19, 34, 26, 4, -34 },
  { 1315, 27, 35, 26, -1, -35 },
  { 1434, 26, 35, 26, 0, -35 },
  { 1548, 27, 34, 26, -1, -34 },
  { 1663, 25, 34, 26, 1, -34 },
  { 1770, 25, 35, 26, 2, -35 },
  { 1880, 27, 34, 26, 2, -34 },
  { 1995, 25, 35, 26, 1, -35 },
  { 2105, 24, 35, 26, 2, -35 },
  { 2210, 13, 28, 14, 0, -27 },
  { 2256, 16, 33, 14, -3, -27 },
  { 2322, 23, 25, 27, 3, -30 },
  { 2394, 23, 14, 27, 3, -24 },
  { 2435, 23, 25, 27, 3, -30 },
  { 2507, 20, 36, 22, 4, -35 },
  { 2597, 39, 38, 41, 2, -34 },
  { 2783, 30, 34, 30, -3, -34 },
  { 2911, 28, 34, 30, 1, -34 },
  { 3030, 28, 35, 29, 3, -35 },
  { 3153, 30, 34, 33, 1, -34 },
  { 3281, 27, 34, 26, 1, -34 },
  { 3396, 27, 34, 26, 1, -34 },
  { 3511, 30, 35, 33, 3, -35 },
  { 3643, 33, 34, 34, 1, -34 },
  { 3784, 22, 34, 18, -1, -34 },
  { 3878, 24, 44, 16, -8, -34 },
  { 4010, 33, 34, 29, 1, -34 },
  { 4151, 21, 34, 25, 1, -34 },
  { 4241, 41, 34, 42, 1, -34 },
  { 4416, 36, 34, 36, 1, -34 },
  { 4569, 31, 35, 35, 3, -35 },
  { 4705, 29, 34, 29, 1, -34 },
  { 4829, 31, 43, 35, 3, -35 },
  { 4996, 28, 34, 30, 1, -34 },
  { 5115, 25, 35, 25, 1, -35 },
  { 5225, 25, 34, 26, 4, -34 },
  { 5332, 31, 34, 33, 3, -34 },
  { 5464, 29, 34, 28, 4, -34 },
  { 5588, 43, 34, 43, 4, -34 },
  { 5771, 36, 34, 29, -3, -34 },
  { 5924, 27, 34, 27, 4, -34 },
  { 6039, 29, 34, 26, -1, -34 },
  { 6163, 20, 42, 16, -1, -34 },
  { 6268, 12, 35, 20, 5, -35 },
  { 6321, 20, 42, 16, -3, -34 },
  { 6426, 24, 22, 26, 1, -34 },
  { 6492, 20, 4, 19, -4, 4 },
  { 6502, 10, 8, 16, 7, -37 },
  { 6512, 26, 27, 28, 2, -27 },
  { 6600, 25, 36, 29, 1, -36 },
  { 6713, 22, 27, 23, 2, -27 },
  { 6788, 28, 36, 29, 2, -36 },
  { 6914, 24, 27, 27, 2, -27 },
  { 6995, 28, 49, 18, -5, -37 },
  { 7167, 27, 39, 29, 1, -27 },
  { 7299, 26, 36, 29, 1, -36 },
  { 7416, 14, 37, 14, 1, -37 },
  { 7481, 22, 49, 14, -6, -37 },
  { 7616, 29, 36, 27, 1, -36 },
  { 7747, 15, 36, 14, 1, -36 },
  { 7815, 40, 27, 43, 1, -27 },
  { 7950, 26, 27, 29, 1, -27 },
  { 8038, 24, 27, 28, 2, -27 },
  { 8119, 28, 39, 29, -2, -27 },
  { 8256, 26, 39, 29, 2, -27 },
  { 8383, 21, 27, 20, 1, -27 },
  { 8454, 21, 27, 23, 1, -27 },
  { 8525, 19, 32, 20, 2, -32 },
  { 8601, 25, 26, 29, 3, -26 },
  { 8683, 25, 26, 25, 2, -26 },
  { 8765, 37, 26, 38, 3, -26 },
  { 8886, 30, 26, 26, -2, -26 },
  { 8984, 30, 38, 25, -3, -26 },
  { 9127, 24, 26, 23, -1, -26 },
  { 9205, 20, 42, 17, 0, -34 },
  { 9310, 5, 47, 26, 11, -36 },
  { 9340, 19, 42, 17, -2, -34 },
  { 9440, 23, 8, 27, 3, -21 },
};

const GFXfont NotoSans_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_BOLDITALIC48PT7B_H_
