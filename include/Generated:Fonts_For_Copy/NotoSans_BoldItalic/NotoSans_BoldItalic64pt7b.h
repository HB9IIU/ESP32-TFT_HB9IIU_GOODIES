#ifndef _NOTOSANS_BOLDITALIC64PT7B_H_
#define _NOTOSANS_BOLDITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFE, 0x3F,
  0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F,
  0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E,
  0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF9,
  0xE1, 0xE0, 0x1F, 0xF1, 0xF0, 0x30, 0x0F, 0xF8, 0xF8, 0x00, 0x0F, 0xFC,
  0x78, 0x00, 0x07, 0xFE, 0x3C, 0x00, 0x03, 0xFF, 0x1E, 0x00, 0x00, 0xFF,
  0xDF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0x9F, 0xF8, 0x00, 0x03, 0xCF, 0xFC, 0x00, 0x03, 0xE3, 0xFE,
  0x00, 0x01, 0xF1, 0xFF, 0x10, 0x00, 0xF0, 0xFF, 0x8C, 0x00, 0x78, 0xFF,
  0xC7, 0x80, 0x3C, 0x7F, 0xE3, 0xFC, 0x3E, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xF8,
  0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFE, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF1, 0xFC, 0x3F, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0xFF,
  0xFC, 0xFF, 0x3F, 0xE7, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xE3, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xFE, 0x3F, 0x8F, 0xF0,
  0x7F, 0x0F, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x3F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xF0,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x0E, 0x01,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x87, 0xE0, 0x01, 0xFF, 0xCF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0xC0,
  0x10, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFE, 0x7F, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x1F, 0x03, 0xFC, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x08, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0x07, 0xF9, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF,
  0x7F, 0xC7, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7E,
  0x0F, 0xF8, 0x1C, 0x0F, 0xFC, 0x04, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x1E, 0x00,
  0x3F, 0xF0, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0x7F, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0x1F, 0xF8, 0x00,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x0C, 0x00, 0x00, 0xFF, 0xE1, 0xE0, 0x00, 0x3F,
  0xFC, 0x3F, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x3F, 0xFC, 0x3C, 0x00, 0x1F,
  0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0B, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x1E, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x7C, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0xF0, 0x0F, 0xF9,
  0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF8, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01,
  0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xEF, 0xFE, 0x07, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0x7F, 0xC0,
  0x3F, 0xF8, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x38, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0x3C, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0x1F, 0x00,
  0xFF, 0xC7, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0x83, 0xFC,
  0x01, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE7, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFC,
  0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x81, 0xFC, 0x07,
  0xF7, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x1F, 0xDF, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0xFE, 0x00,
  0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0xFE, 0x00, 0xFE, 0x03, 0xFD, 0xFC, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x1F, 0xE7, 0xF0,
  0x7F, 0x01, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x1F,
  0xC0, 0xFF, 0x1F, 0xFC, 0x7F, 0xC3, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0x83, 0xFF, 0xFB, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xFE, 0x7F, 0xFF,
  0x00, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0x80,
  0x7F, 0xF8, 0x00, 0x04, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x01, 0xFF, 0xF0, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x60, 0x1F, 0xFE, 0x00, 0x00, 0x40, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xFF,
  0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xFF,
  0xC7, 0xFE, 0x01, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF,
  0x80, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x1F,
  0xEF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFB, 0xFE,
  0x00, 0xFF, 0xBF, 0x80, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F,
  0xCF, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFC,
  0x00, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xF0, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0xCF, 0xE0, 0x1F, 0xE3, 0xFC,
  0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0xFF,
  0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFE,
  0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xF1, 0xFC, 0x0F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xFC,
  0x01, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE3, 0xF8,
  0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0xC0, 0xFE, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xF8,
  0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xDF,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC7,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x7F,
  0x80, 0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0xE0, 0x01,
  0x80, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x02, 0x00,
  0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF,
  0x01, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x9F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xCF, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE3,
  0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF1, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x1F,
  0xC3, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x0F, 0xE1, 0xFF, 0x00, 0x0F, 0xF1,
  0xFE, 0x07, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0xBF,
  0xC0, 0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xDF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01,
  0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC3, 0xFC, 0x03, 0xFF,
  0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xF1,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x20, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xFE, 0x00,
  0x7F, 0xDF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF,
  0xFF, 0xF8, 0x07, 0xF1, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0xFE, 0x00, 0xFF,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0xFF, 0xF0, 0x02, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x41, 0xFF, 0xC0,
  0x0C, 0x07, 0xFF, 0x83, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF7, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x3F, 0x80,
  0x01, 0xFF, 0xF1, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE,
  0x03, 0xFE, 0x3F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80,
  0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07,
  0xFF, 0x3F, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x06, 0x07, 0xFF, 0x00, 0x3C, 0x0F, 0xFF, 0xDF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xBC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE7, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xF9,
  0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFD, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xEF, 0xF8, 0x00,
  0xFF, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x08,
  0x00, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x30, 0x00, 0x1F, 0xF8, 0x7F,
  0xC0, 0x07, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0xDF,
  0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xCF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0xC1, 0xFF, 0xFC, 0x01, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x3F, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xE0, 0x07, 0xF8, 0xFF,
  0xFC, 0x01, 0xFC, 0x7F, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0xF0, 0x3F, 0xDF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x03,
  0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0xE0, 0x00,
  0x7F, 0x9F, 0xFF, 0x80, 0x03, 0xF9, 0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFB, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xFF, 0xC0, 0x07, 0xFE,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x07, 0xF0, 0x07, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0xF8, 0xFE, 0x01, 0xFF,
  0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x00, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xE0,
  0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xE3, 0xFF, 0x01, 0xFE, 0x7F, 0xF0,
  0x1F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xCC, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE1, 0xFC, 0x0F, 0xFC, 0x03, 0xC1, 0xFF, 0x80, 0x08, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x88, 0x00,
  0x1F, 0xF8, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x01, 0x68, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFB, 0xFC, 0x01, 0xFF,
  0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0xE1, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xEF, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x8F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF0,
  0xFF, 0x80, 0xFD, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x7F, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xDF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0xC0, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x7F, 0x0F,
  0xF8, 0x07, 0xF8, 0x7F, 0x1F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xC7, 0xF1,
  0xFF, 0x00, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xF8, 0x7F,
  0x3F, 0xE0, 0x07, 0xF9, 0xFE, 0x1F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0x07,
  0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xC1, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xE0,
  0x7F, 0x7F, 0xC0, 0x07, 0xFB, 0xF8, 0x1F, 0x9F, 0xE0, 0x01, 0xFE, 0xFE,
  0x07, 0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0x01, 0xFB, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x7E, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x23, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x3F, 0xFC, 0x00, 0x04,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFD, 0x80, 0x00, 0xFF, 0xF2, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_BoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 19, 47, 18, 1, -46 },
  { 113, 24, 17, 29, 6, -46 },
  { 164, 41, 46, 41, 1, -46 },
  { 400, 33, 53, 35, 2, -49 },
  { 619, 48, 47, 55, 4, -46 },
  { 901, 43, 47, 45, 2, -46 },
  { 1154, 11, 17, 16, 6, -46 },
  { 1178, 24, 56, 22, 2, -46 },
  { 1346, 23, 56, 22, -4, -46 },
  { 1507, 31, 31, 35, 5, -49 },
  { 1628, 31, 31, 37, 3, -38 },
  { 1749, 15, 15, 18, -3, -7 },
  { 1778, 18, 8, 21, 1, -21 },
  { 1796, 11, 11, 18, 1, -10 },
  { 1812, 35, 46, 27, -3, -46 },
  { 2014, 33, 47, 35, 2, -46 },
  { 2208, 25, 46, 35, 6, -46 },
  { 2352, 36, 46, 35, -2, -46 },
  { 2559, 35, 47, 35, 0, -46 },
  { 2765, 36, 46, 35, -1, -46 },
  { 2972, 34, 47, 35, 1, -46 },
  { 3172, 33, 47, 35, 3, -46 },
  { 3366, 36, 46, 35, 2, -46 },
  { 3573, 33, 47, 35, 2, -46 },
  { 3767, 31, 47, 35, 3, -46 },
  { 3950, 16, 37, 18, 1, -36 },
  { 4024, 20, 44, 18, -3, -36 },
  { 4134, 31, 34, 37, 3, -40 },
  { 4266, 31, 19, 37, 3, -32 },
  { 4340, 31, 34, 37, 3, -40 },
  { 4472, 26, 47, 29, 5, -46 },
  { 4625, 51, 52, 55, 3, -46 },
  { 4957, 40, 46, 40, -4, -46 },
  { 5187, 37, 46, 40, 2, -46 },
  { 5400, 38, 47, 39, 4, -46 },
  { 5624, 39, 46, 43, 2, -46 },
  { 5849, 35, 46, 35, 2, -46 },
  { 6051, 35, 46, 34, 2, -46 },
  { 6253, 39, 47, 44, 4, -46 },
  { 6483, 43, 46, 45, 2, -46 },
  { 6731, 30, 46, 25, -2, -46 },
  { 6904, 32, 60, 21, -10, -46 },
  { 7144, 43, 46, 39, 2, -46 },
  { 7392, 27, 46, 33, 2, -46 },
  { 7548, 55, 46, 56, 2, -46 },
  { 7865, 47, 46, 49, 2, -46 },
  { 8136, 41, 47, 47, 4, -46 },
  { 8377, 37, 46, 39, 2, -46 },
  { 8590, 41, 57, 47, 4, -46 },
  { 8883, 36, 46, 40, 2, -46 },
  { 9090, 34, 47, 34, 1, -46 },
  { 9290, 34, 46, 34, 5, -46 },
  { 9486, 41, 47, 44, 4, -46 },
  { 9727, 38, 46, 38, 6, -46 },
  { 9946, 57, 46, 57, 6, -46 },
  { 10274, 48, 46, 39, -4, -46 },
  { 10550, 36, 46, 36, 6, -46 },
  { 10757, 40, 46, 34, -2, -46 },
  { 10987, 27, 56, 21, -1, -46 },
  { 11176, 15, 46, 27, 7, -46 },
  { 11263, 26, 56, 21, -4, -46 },
  { 11445, 33, 30, 35, 1, -46 },
  { 11569, 27, 4, 26, -6, 6 },
  { 11583, 14, 10, 21, 9, -49 },
  { 11601, 34, 37, 38, 3, -36 },
  { 11759, 34, 50, 38, 1, -49 },
  { 11972, 29, 37, 31, 3, -36 },
  { 12107, 37, 50, 38, 3, -49 },
  { 12339, 31, 37, 36, 3, -36 },
  { 12483, 38, 64, 24, -7, -49 },
  { 12787, 36, 51, 38, 1, -36 },
  { 13017, 34, 49, 39, 1, -49 },
  { 13226, 20, 49, 19, 1, -49 },
  { 13349, 29, 64, 19, -8, -49 },
  { 13581, 38, 49, 36, 1, -49 },
  { 13814, 20, 49, 19, 1, -49 },
  { 13937, 54, 36, 58, 1, -36 },
  { 14180, 34, 36, 39, 1, -36 },
  { 14333, 32, 37, 37, 3, -36 },
  { 14481, 37, 51, 38, -2, -36 },
  { 14717, 34, 51, 38, 3, -36 },
  { 14934, 28, 36, 27, 1, -36 },
  { 15060, 28, 37, 30, 1, -36 },
  { 15190, 24, 43, 26, 3, -42 },
  { 15319, 35, 36, 39, 3, -35 },
  { 15477, 33, 35, 33, 3, -35 },
  { 15622, 50, 35, 50, 4, -35 },
  { 15841, 40, 35, 34, -3, -35 },
  { 16016, 41, 50, 33, -4, -35 },
  { 16273, 32, 35, 30, -1, -35 },
  { 16413, 27, 56, 23, 0, -46 },
  { 16602, 7, 63, 35, 14, -48 },
  { 16658, 26, 56, 23, -3, -46 },
  { 16840, 31, 11, 37, 3, -28 },
};

const GFXfont NotoSans_BoldItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_BOLDITALIC64PT7B_H_
