#ifndef _NOTOSANS_BOLDITALIC23PT7B_H_
#define _NOTOSANS_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xC0, 0x02,
  0x0E, 0x3C, 0x78, 0x77, 0xBB, 0x99, 0xCC, 0xEE, 0x66, 0x30, 0x03, 0x9C,
  0x06, 0x30, 0x0C, 0xE0, 0x39, 0x83, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x87,
  0x30, 0x0C, 0x60, 0xFF, 0xF9, 0xFF, 0xF4, 0xE6, 0x01, 0x9C, 0x03, 0x38,
  0x0E, 0x60, 0x19, 0xC0, 0x01, 0x80, 0x7C, 0x1F, 0xF3, 0xFE, 0x7B, 0x27,
  0xA0, 0x7A, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x5E, 0x8D, 0xCF,
  0xFC, 0xFF, 0x8F, 0xF0, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x0F, 0xC1, 0xC7,
  0xF0, 0xE1, 0xDC, 0x30, 0x67, 0x1C, 0x39, 0xCE, 0x0E, 0x77, 0x03, 0x9D,
  0xBE, 0xFE, 0xFF, 0xDF, 0x77, 0x73, 0xBB, 0x9C, 0x0C, 0xE7, 0x07, 0x39,
  0xC3, 0x8E, 0x61, 0xC3, 0xB8, 0x60, 0xFC, 0x38, 0x1E, 0x00, 0x03, 0x80,
  0x1F, 0xC0, 0x7F, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x78, 0x0F,
  0xE0, 0x1F, 0x0E, 0xFE, 0x3B, 0xDE, 0x77, 0x9F, 0xCE, 0x1F, 0x9E, 0x3E,
  0x3F, 0xFC, 0x7F, 0xFC, 0x3F, 0x3C, 0x77, 0x66, 0xEC, 0x07, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x70, 0x70, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x1E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x00, 0x04, 0x00, 0xE0, 0x18, 0x33, 0x0F, 0xE0,
  0xFF, 0xC7, 0xF9, 0xF0, 0x77, 0x0E, 0x60, 0x8E, 0x01, 0x00, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0x39, 0xDC, 0xE6, 0x70, 0x7E, 0xFF, 0xF0, 0x2F, 0xFF, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0x01, 0xF8, 0xFF, 0x9E, 0x77, 0x8E, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1D, 0xC7, 0xBF, 0xE3, 0xF8, 0x3E,
  0x00, 0x07, 0x8F, 0xCF, 0xFF, 0xE7, 0x72, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x01, 0xC0, 0x3F, 0x87, 0xFE,
  0x1C, 0xF0, 0x83, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xCF, 0xFE, 0xFF, 0xE0, 0x03,
  0x81, 0xFE, 0x3F, 0xF1, 0x8F, 0x00, 0x70, 0x07, 0x00, 0xF0, 0xFE, 0x0F,
  0x00, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE8, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F,
  0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0xEE, 0x1C, 0xE3,
  0x9E, 0x79, 0xE7, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x03, 0x80,
  0x38, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xFF,
  0x07, 0xFC, 0x11, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC8, 0x1E, 0x7F, 0xE3,
  0xFF, 0x0F, 0xE0, 0x01, 0xE0, 0x7F, 0x1F, 0xF1, 0xE0, 0x3C, 0x07, 0x80,
  0x73, 0x07, 0xFC, 0xFF, 0xEF, 0x9E, 0xF1, 0xEE, 0x1E, 0xE1, 0xEF, 0x1C,
  0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3,
  0x8F, 0x38, 0xF3, 0x8E, 0x3D, 0xE1, 0xFC, 0x1F, 0x07, 0xF8, 0xF3, 0xCE,
  0x1E, 0xE1, 0xEE, 0x1C, 0xF3, 0xCF, 0xF8, 0x3F, 0x00, 0x07, 0x03, 0xF8,
  0xFF, 0xBC, 0xF7, 0x0E, 0xE1, 0xFC, 0x3F, 0x8F, 0x7B, 0xEF, 0xDC, 0xFF,
  0x80, 0xE0, 0x3C, 0x0F, 0x3F, 0xE7, 0xF8, 0xFC, 0x00, 0x1C, 0xF3, 0xC7,
  0x00, 0x00, 0x00, 0x00, 0x8F, 0x3C, 0xF0, 0x0E, 0x3C, 0x78, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0x00, 0x20, 0x1C,
  0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x01,
  0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0xF8, 0x7E, 0x3F,
  0x1F, 0x03, 0x80, 0x40, 0x00, 0x1C, 0x7F, 0xBF, 0xEC, 0x70, 0x38, 0x1C,
  0x3E, 0x3E, 0x3C, 0x1C, 0x1C, 0x0E, 0x00, 0x01, 0x03, 0xC1, 0xE0, 0xE0,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xE0, 0x38, 0xE0, 0x07, 0x30, 0xFC,
  0xDC, 0xFF, 0x36, 0x39, 0xCF, 0x9C, 0x63, 0xE6, 0x38, 0xFB, 0x8E, 0x7E,
  0xE3, 0x9F, 0x9D, 0xEE, 0xE7, 0xDF, 0x18, 0xE3, 0x07, 0x00, 0x00, 0xF0,
  0x20, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x7F, 0xE1,
  0xFF, 0xCF, 0xFF, 0x78, 0x3D, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0x1F, 0xF0,
  0xFF, 0xCF, 0x3E, 0x78, 0xF3, 0x87, 0x9C, 0x38, 0xFF, 0xCF, 0xF0, 0x7F,
  0xE3, 0x87, 0x9C, 0x3C, 0xE1, 0xEF, 0x0F, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0,
  0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0xC7, 0xC6, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC3, 0xCF, 0x8F,
  0x0F, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0xE7,
  0x07, 0x9C, 0x1E, 0xF1, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1,
  0xFF, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x3F, 0xE7, 0xFC, 0x7F, 0xC7,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1,
  0xFF, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0xFC, 0x7F, 0xC7,
  0xFC, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0xF8, 0xE3, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x71, 0xFD, 0xE3, 0xF3, 0xC7, 0xE7, 0x81, 0xCF, 0x07, 0x8F, 0x0F,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1E, 0x0E, 0x38, 0x3C, 0xF0, 0x79,
  0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8F, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xE0,
  0x71, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x78,
  0x0F, 0xE3, 0xFC, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x7C, 0x1F, 0xC7, 0xF8, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0xFE, 0x0F, 0xE0, 0xF8, 0x00, 0x1E, 0x3E, 0x38, 0x78, 0xF1, 0xE1,
  0xE7, 0x83, 0x9E, 0x07, 0x78, 0x0E, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7,
  0x01, 0xCF, 0x03, 0x9E, 0x0F, 0x1C, 0x1E, 0x3C, 0x38, 0x78, 0x70, 0x78,
  0x1E, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC,
  0x1F, 0x9F, 0x83, 0x73, 0xF0, 0xFC, 0x7E, 0x1B, 0x8F, 0xC7, 0x73, 0xB8,
  0xCE, 0x73, 0x3B, 0x8E, 0x66, 0x71, 0xCD, 0xCE, 0x39, 0xB1, 0xCE, 0x3E,
  0x79, 0xC7, 0x8E, 0x38, 0xF1, 0xC7, 0x1C, 0x38, 0x1E, 0x07, 0x8F, 0x83,
  0x8F, 0xC1, 0xC7, 0xE0, 0xE3, 0xF8, 0xF1, 0xDC, 0x70, 0xEE, 0x38, 0xF7,
  0x9C, 0x71, 0xCE, 0x38, 0xEE, 0x1C, 0x7F, 0x0E, 0x1F, 0x8E, 0x0F, 0xC7,
  0x07, 0xE3, 0x81, 0xE1, 0xC0, 0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xF1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xCF, 0x0F, 0x1F, 0xFE, 0x1F, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x8F, 0x3E, 0x78, 0x73, 0x83, 0x9C, 0x1C,
  0xE1, 0xEF, 0xFE, 0x7F, 0xE3, 0xFE, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xE3,
  0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xEF, 0x03, 0xCF, 0x0F, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1F, 0xE0, 0xFF, 0x8F,
  0x3C, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xE3, 0xCF, 0xFC, 0x7F, 0xC3, 0xFC,
  0x1C, 0xF0, 0xE3, 0x8F, 0x1E, 0x78, 0xF3, 0x83, 0x9C, 0x1E, 0x03, 0xC0,
  0xFF, 0x1F, 0xF1, 0xE3, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE8, 0x1C, 0xFF, 0xCF, 0xF8, 0x7F, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x38, 0x3C, 0xE0, 0xF7, 0x83, 0x9E, 0x0E, 0x70, 0x39, 0xC1, 0xEF, 0x07,
  0xBC, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x3C, 0xE1, 0xE3, 0xFF,
  0x87, 0xFC, 0x0F, 0xC0, 0xE0, 0x3F, 0x81, 0xEF, 0x07, 0x3C, 0x3C, 0xF0,
  0xE1, 0xC7, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x70, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xE0, 0xF0, 0x7F, 0x07,
  0x87, 0xB8, 0x3C, 0x39, 0xC3, 0xE1, 0xCE, 0x1F, 0x1E, 0x71, 0xF8, 0xE3,
  0x8F, 0xCF, 0x1C, 0xEE, 0x70, 0xE7, 0x73, 0x87, 0x73, 0xB8, 0x3B, 0x9D,
  0xC1, 0xD8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x87, 0x87, 0x03, 0xC7, 0x80, 0xE7, 0x80, 0x7F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xBC, 0x03, 0xCE, 0x03, 0xC7, 0x01, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0x78,
  0xF0, 0x7B, 0x87, 0x9C, 0x78, 0xE3, 0x87, 0xBC, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0x0F, 0x8F, 0xC7, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0,
  0xE0, 0x7C, 0x3E, 0x1F, 0x00, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x0C, 0x38,
  0xE3, 0x8E, 0x38, 0x61, 0xC7, 0x1C, 0x07, 0xC3, 0xF0, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x1F, 0x07, 0xC3, 0xF0, 0x01, 0x80, 0x18, 0x03, 0xC0,
  0x7C, 0x06, 0xC0, 0xEC, 0x1C, 0xE1, 0x86, 0x38, 0x67, 0x07, 0xF0, 0x70,
  0xFF, 0xFF, 0xC0, 0xF3, 0x8E, 0x70, 0x0E, 0x31, 0xF7, 0x3F, 0xF7, 0x8F,
  0x78, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xFC,
  0x7D, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xCE, 0x0F, 0xF8,
  0x7F, 0xC7, 0x8F, 0x3C, 0x79, 0xC3, 0xCE, 0x1E, 0x70, 0xE7, 0x8F, 0x3C,
  0x79, 0xFF, 0x8F, 0xF8, 0xE7, 0x80, 0x07, 0x87, 0xF3, 0xFD, 0xE1, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xF1, 0xFC, 0x3F, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0xE7, 0x0F, 0xB8, 0xFF, 0xCF, 0x1E,
  0x70, 0xE7, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x1E, 0x78, 0xE3, 0xFF, 0x0F,
  0xF8, 0x7D, 0xC0, 0x07, 0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0F, 0xE7, 0xFF,
  0xF7, 0xF8, 0xE0, 0x1E, 0x03, 0xE6, 0x3F, 0xC3, 0xF8, 0x00, 0x70, 0x0F,
  0xC0, 0x7E, 0x07, 0x80, 0x38, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x0B, 0xC0, 0x7C, 0x03, 0xE0, 0x08, 0x00,
  0x07, 0x18, 0x7D, 0xC7, 0xFE, 0x78, 0xF3, 0xC7, 0x3C, 0x39, 0xE1, 0xCF,
  0x0E, 0x78, 0xF3, 0xCF, 0x1F, 0xF8, 0x7F, 0xC3, 0xDE, 0x00, 0xF0, 0x07,
  0x18, 0x78, 0xFF, 0x87, 0xF8, 0x02, 0x00, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xCE, 0x0E, 0xF8, 0x7F, 0xE7, 0xCF, 0x3C, 0x79, 0xE3, 0xCE,
  0x1C, 0x70, 0xE7, 0x87, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0xF0, 0xE0, 0x04,
  0x1C, 0x38, 0x70, 0x03, 0xC7, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1E,
  0x38, 0x71, 0xE0, 0x00, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x38,
  0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0xBC, 0x3F, 0x0F, 0x81, 0x00, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x3C, 0x71, 0xE1, 0xCF, 0x0F, 0x78, 0x3F,
  0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xC1, 0xE7, 0x07, 0x1E, 0x1C,
  0x78, 0xF0, 0xF0, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x1C, 0xE1, 0xC1, 0xDF,
  0x3E, 0x1B, 0xF7, 0xE3, 0xE7, 0xCF, 0x3C, 0x78, 0xF3, 0xC7, 0x8E, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0xF1, 0xE1, 0xC0, 0x1C, 0xE0, 0xEF, 0x86, 0xFE, 0x7C, 0xF3,
  0xC7, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0xC7, 0x9C, 0x38, 0xE1,
  0xCF, 0x0E, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0F, 0xE1, 0xFC,
  0x3F, 0x07, 0xE1, 0xFE, 0x3F, 0xFF, 0x3F, 0xC3, 0xF0, 0x0E, 0x70, 0x3F,
  0xE0, 0xFF, 0x87, 0x8F, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0xC7, 0x0E, 0x3C,
  0x78, 0xF1, 0xE3, 0xFF, 0x0F, 0xF8, 0x3B, 0xC1, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0E, 0x31, 0xFF, 0x3F, 0xF7,
  0x8F, 0x70, 0xEF, 0x0E, 0xF0, 0xEE, 0x0E, 0xE1, 0xEF, 0x1C, 0xFF, 0xC7,
  0xFC, 0x7F, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x1C, 0xE3, 0xB8, 0x7F, 0x1F, 0xA3, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x0F, 0x87, 0xF3, 0xFC, 0xE1, 0x38,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xEE, 0x7B, 0xFE, 0xFE, 0x00, 0x0C,
  0x0E, 0x0F, 0xFF, 0xFF, 0xF1, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E,
  0x0F, 0xE7, 0xF1, 0xF8, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0xF1, 0xE7, 0x0F,
  0x38, 0x71, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3F, 0xF0, 0xFF, 0x87,
  0xDC, 0x00, 0xE0, 0xFF, 0x0F, 0xF1, 0xE7, 0x1C, 0x73, 0xC7, 0x38, 0x77,
  0x87, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x3C, 0x00, 0xF1, 0xE1,
  0xFC, 0x78, 0xF7, 0x3E, 0x39, 0xCD, 0x9E, 0x73, 0x67, 0x1D, 0xD9, 0xC7,
  0x66, 0xE1, 0xF9, 0xB8, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1,
  0xE0, 0x78, 0x78, 0x00, 0x1C, 0x3C, 0x78, 0xF0, 0xE7, 0x83, 0xBC, 0x0F,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x03, 0xDE, 0x1E,
  0x38, 0xF0, 0xF0, 0x1C, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x71, 0xE0, 0xE7,
  0x81, 0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x81, 0xE0, 0x78, 0x1E, 0x03,
  0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x07, 0xC1, 0xE0,
  0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0xF8, 0x3C, 0x0F, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1F, 0x03, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x0F, 0x83, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0F, 0x81, 0xC3, 0xE3, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x7C, 0x3C, 0x18, 0x00, 0x7C, 0x3F, 0xFF, 0x3F, 0xC0, 0xE0,
};

const GFXglyph NotoSans_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 16, 7, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 15, 16, 15, 0, -16 },
  { 52, 12, 18, 13, 1, -17 },
  { 79, 18, 17, 20, 1, -17 },
  { 118, 15, 17, 16, 1, -17 },
  { 150, 4, 6, 6, 2, -16 },
  { 153, 8, 20, 8, 1, -16 },
  { 173, 9, 21, 8, -2, -17 },
  { 197, 11, 12, 13, 2, -18 },
  { 214, 11, 11, 13, 1, -14 },
  { 230, 5, 6, 7, -1, -3 },
  { 234, 7, 3, 7, 0, -8 },
  { 237, 4, 4, 7, 0, -4 },
  { 239, 12, 17, 10, -1, -17 },
  { 265, 11, 17, 13, 1, -17 },
  { 289, 9, 16, 13, 2, -16 },
  { 307, 13, 17, 13, -1, -17 },
  { 335, 12, 17, 13, 0, -17 },
  { 361, 12, 16, 13, 0, -16 },
  { 385, 13, 16, 13, 0, -16 },
  { 411, 12, 17, 13, 1, -17 },
  { 437, 13, 16, 13, 1, -16 },
  { 463, 12, 17, 13, 1, -17 },
  { 489, 11, 17, 13, 1, -17 },
  { 513, 6, 13, 7, 0, -13 },
  { 523, 7, 16, 7, -1, -13 },
  { 537, 11, 12, 13, 1, -14 },
  { 554, 11, 7, 13, 1, -12 },
  { 564, 11, 12, 13, 1, -14 },
  { 581, 9, 17, 11, 2, -17 },
  { 601, 18, 18, 20, 1, -16 },
  { 642, 14, 16, 14, -1, -16 },
  { 670, 13, 16, 14, 1, -16 },
  { 696, 14, 17, 14, 1, -17 },
  { 726, 14, 16, 16, 1, -16 },
  { 754, 12, 16, 12, 1, -16 },
  { 778, 12, 16, 12, 1, -16 },
  { 802, 15, 17, 16, 1, -17 },
  { 834, 15, 16, 16, 1, -16 },
  { 864, 11, 16, 9, -1, -16 },
  { 886, 12, 21, 8, -4, -16 },
  { 918, 15, 16, 14, 1, -16 },
  { 948, 9, 16, 12, 1, -16 },
  { 966, 19, 16, 20, 1, -16 },
  { 1004, 17, 16, 17, 1, -16 },
  { 1038, 15, 17, 17, 1, -17 },
  { 1070, 13, 16, 14, 1, -16 },
  { 1096, 15, 21, 17, 1, -17 },
  { 1136, 13, 16, 14, 1, -16 },
  { 1162, 12, 17, 12, 0, -17 },
  { 1188, 12, 16, 12, 2, -16 },
  { 1212, 14, 16, 16, 2, -16 },
  { 1240, 14, 16, 14, 2, -16 },
  { 1268, 21, 16, 21, 2, -16 },
  { 1310, 17, 16, 14, -1, -16 },
  { 1344, 13, 16, 13, 2, -16 },
  { 1370, 14, 16, 12, -1, -16 },
  { 1398, 9, 20, 8, 0, -16 },
  { 1421, 6, 17, 10, 2, -17 },
  { 1434, 10, 20, 8, -2, -16 },
  { 1459, 12, 11, 13, 0, -17 },
  { 1476, 9, 2, 9, -2, 2 },
  { 1479, 5, 4, 7, 3, -18 },
  { 1482, 12, 13, 14, 1, -13 },
  { 1502, 13, 17, 14, 0, -17 },
  { 1530, 10, 13, 11, 1, -13 },
  { 1547, 13, 17, 14, 1, -17 },
  { 1575, 11, 13, 13, 1, -13 },
  { 1593, 13, 24, 9, -2, -18 },
  { 1632, 13, 19, 14, 0, -13 },
  { 1663, 13, 17, 14, 0, -17 },
  { 1691, 7, 18, 7, 0, -18 },
  { 1707, 10, 24, 7, -3, -18 },
  { 1737, 14, 17, 13, 0, -17 },
  { 1767, 8, 17, 7, 0, -17 },
  { 1784, 20, 13, 21, 0, -13 },
  { 1817, 13, 13, 14, 0, -13 },
  { 1839, 11, 13, 13, 1, -13 },
  { 1857, 14, 19, 14, -1, -13 },
  { 1891, 12, 19, 14, 1, -13 },
  { 1920, 11, 13, 10, 0, -13 },
  { 1938, 10, 13, 11, 0, -13 },
  { 1955, 9, 15, 9, 1, -15 },
  { 1972, 13, 13, 14, 1, -13 },
  { 1994, 12, 13, 12, 1, -13 },
  { 2014, 18, 13, 18, 1, -13 },
  { 2044, 14, 13, 12, -1, -13 },
  { 2067, 15, 19, 12, -2, -13 },
  { 2103, 11, 13, 11, 0, -13 },
  { 2121, 10, 20, 8, 0, -16 },
  { 2146, 3, 22, 13, 5, -17 },
  { 2155, 9, 20, 8, -1, -16 },
  { 2178, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_BOLDITALIC23PT7B_H_
