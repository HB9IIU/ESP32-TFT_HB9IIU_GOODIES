#ifndef _NOTOSANS_BOLDITALIC39PT7B_H_
#define _NOTOSANS_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x7C, 0x7D, 0xF1,
  0xF7, 0xC7, 0xDF, 0x3E, 0x78, 0xFB, 0xE3, 0xEF, 0x8F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC7, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x01, 0xE3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00,
  0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xDC, 0xE1, 0xF9, 0x80, 0x1F, 0x98, 0x01, 0xFB, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x06, 0xFE, 0x00, 0xE7, 0xE0, 0x0E, 0x7E, 0xC0, 0xE7,
  0xCF, 0x0D, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0xE0, 0x01, 0xF0, 0x3F, 0xC0, 0x0F, 0x81, 0xFF, 0x80, 0x7C, 0x0F, 0xFE,
  0x01, 0xE0, 0x3E, 0x7C, 0x0F, 0x01, 0xF1, 0xF0, 0x7C, 0x07, 0xC7, 0xC3,
  0xE0, 0x1E, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x78, 0x03, 0xE3, 0xE3, 0xE0,
  0x0F, 0x8F, 0x9F, 0x00, 0x3E, 0x3E, 0x78, 0xF8, 0xF9, 0xF3, 0xCF, 0xFB,
  0xFF, 0xDF, 0x7F, 0xE7, 0xFE, 0xFB, 0xFF, 0xDF, 0xF3, 0xCF, 0x9F, 0x1F,
  0x9F, 0x7C, 0x7C, 0x00, 0xF9, 0xF1, 0xF0, 0x07, 0xC7, 0xC7, 0xC0, 0x1E,
  0x1F, 0x1F, 0x00, 0xF8, 0x78, 0x7C, 0x07, 0xC1, 0xE1, 0xE0, 0x3E, 0x07,
  0x8F, 0x80, 0xF0, 0x1E, 0x3E, 0x07, 0xC0, 0x7F, 0xF0, 0x3E, 0x01, 0xFF,
  0x80, 0xF0, 0x03, 0xFE, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF3, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3,
  0xF0, 0x00, 0xF9, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xF0, 0xFF, 0xC0, 0xFC, 0x7F, 0xF8, 0x7E,
  0x3F, 0xBF, 0x1F, 0x9F, 0xCF, 0xEF, 0xC7, 0xE1, 0xFB, 0xE3, 0xF0, 0x3F,
  0xF8, 0xFC, 0x0F, 0xFC, 0x3F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xFE,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF1, 0xFC, 0x7D, 0xF7, 0xDF, 0x7B, 0xEF, 0xBC, 0xF3, 0xC0, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x02, 0x07, 0x80, 0xF1, 0xE0, 0x1F, 0xBC, 0x03,
  0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xF8, 0xF0,
  0xFF, 0x80, 0x3E, 0xF0, 0x1F, 0xDF, 0x01, 0xF1, 0xE0, 0x1C, 0x3E, 0x00,
  0x87, 0xC0, 0x00, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8,
  0x78, 0x7C, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x3C, 0xFF,
  0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x83,
  0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC1, 0xFC, 0x7E, 0x1F, 0x87, 0xF7, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0xFF, 0xFE, 0x7F, 0x7C, 0x3E, 0x7C, 0x38,
  0xFC, 0x10, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0x07, 0xF0, 0x18, 0x0F, 0xC0, 0x40, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF3, 0x00, 0x3F, 0x9F, 0x8F, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0xFD,
  0xF8, 0x07, 0xCF, 0xC0, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0x07,
  0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7C, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF4, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF3, 0x00, 0x7F, 0x1F, 0x9F,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFE,
  0xE0, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x7E, 0x07, 0xDF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xBF, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0xCF,
  0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xFC, 0x1F, 0x8F, 0xE7, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xEF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x9F, 0xC7, 0xE0, 0xFC,
  0x7C, 0x07, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F,
  0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFE, 0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFE, 0xFE, 0x7F, 0x9F, 0xFF,
  0xF1, 0xFF, 0xBE, 0x3F, 0xEF, 0xC1, 0xF9, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x86, 0x1F, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0x80, 0xF8, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE0, 0xF8, 0x04, 0x00, 0x00, 0x60, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x7E, 0xFF, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x3E, 0x07,
  0xFE, 0x3E, 0x78, 0x3F, 0xFC, 0x7D, 0xF0, 0xFF, 0xF8, 0x7B, 0xC3, 0xF1,
  0xF0, 0xF7, 0x87, 0xC3, 0xC1, 0xFF, 0x1F, 0x07, 0x83, 0xFC, 0x3C, 0x0F,
  0x07, 0xF8, 0x78, 0x3E, 0x1F, 0xF1, 0xF0, 0x78, 0x3D, 0xE3, 0xE0, 0xF0,
  0x7B, 0xC7, 0xC3, 0xE1, 0xF7, 0x8F, 0x87, 0xC7, 0xCF, 0x1F, 0xBF, 0xFF,
  0x1E, 0x1F, 0xFF, 0xFE, 0x3E, 0x3F, 0xCF, 0xF0, 0x3C, 0x1F, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x00,
  0xFE, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x80,
  0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFC, 0x1F,
  0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8,
  0x3F, 0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x81,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x03, 0x87, 0xF0, 0x01,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x10, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE1, 0xFE, 0x07, 0xC0, 0x7F, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00,
  0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xF0, 0x0E, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xFE, 0x7E,
  0x0F, 0xFE, 0xFE, 0x0F, 0xFE, 0xFC, 0x0F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC,
  0x10, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0xE0, 0x7C, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3E, 0x7F,
  0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xC0, 0x7B, 0xC0, 0x3F, 0xF0, 0x3E, 0xF0, 0x0F, 0x7C, 0x0F, 0xBC, 0x07,
  0xDF, 0x03, 0xEF, 0x01, 0xEF, 0xC0, 0xFB, 0xC0, 0xFB, 0xE0, 0x7E, 0xF0,
  0x3C, 0xF8, 0x1F, 0x3C, 0x1F, 0x3E, 0x07, 0xCF, 0x07, 0x9F, 0x81, 0xF3,
  0xC3, 0xE7, 0xC0, 0x7C, 0xF0, 0xF1, 0xF0, 0x3F, 0x3E, 0x7C, 0x7C, 0x0F,
  0x8F, 0x9E, 0x3F, 0x03, 0xE3, 0xEF, 0x8F, 0xC0, 0xF8, 0xFB, 0xC3, 0xE0,
  0x3E, 0x3F, 0xF0, 0xF8, 0x1F, 0x8F, 0xF8, 0x3E, 0x07, 0xC3, 0xFE, 0x1F,
  0x81, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x1F, 0xC1, 0xF0, 0x1F, 0x07, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0x81, 0xFE, 0x00, 0x7C, 0x0F, 0xF8, 0x03,
  0xE0, 0x7F, 0xC0, 0x3F, 0x03, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x0F, 0x81,
  0xF7, 0xC0, 0x7C, 0x0F, 0xBE, 0x03, 0xE0, 0x7D, 0xF8, 0x3F, 0x03, 0xE7,
  0xC1, 0xF8, 0x3F, 0x3E, 0x0F, 0x81, 0xF9, 0xF8, 0x7C, 0x0F, 0x8F, 0xC3,
  0xE0, 0x7C, 0x3E, 0x3F, 0x03, 0xE1, 0xF9, 0xF8, 0x3F, 0x0F, 0xCF, 0x81,
  0xF8, 0x3E, 0x7C, 0x0F, 0x81, 0xFB, 0xE0, 0x7C, 0x0F, 0xDF, 0x03, 0xE0,
  0x3F, 0xF0, 0x3F, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0x80, 0x3F,
  0xE0, 0x7C, 0x01, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0x81,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x7F,
  0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF,
  0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC,
  0x1F, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8,
  0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F,
  0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0,
  0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x87, 0xF0,
  0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x87, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFC, 0x04, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x88, 0x01, 0xF8, 0xC0, 0x3F, 0x8F, 0xDF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF,
  0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xC3,
  0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C,
  0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xFF, 0x00, 0x7E, 0x01, 0xFB, 0xE0, 0x1F, 0xC0, 0x3F, 0x7C, 0x03,
  0xF8, 0x0F, 0xCF, 0x80, 0xFF, 0x01, 0xF9, 0xF0, 0x1F, 0xE0, 0x7E, 0x3E,
  0x07, 0xFC, 0x0F, 0xC7, 0xC0, 0xFF, 0x81, 0xF0, 0xF8, 0x1F, 0xF0, 0x7E,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xE0, 0xF7, 0xC3, 0xF0, 0x7C, 0x3E, 0xF8,
  0x7E, 0x0F, 0x87, 0xDF, 0x0F, 0x81, 0xF1, 0xF3, 0xE3, 0xF0, 0x3E, 0x3E,
  0x7C, 0x7C, 0x07, 0xCF, 0x8F, 0x9F, 0x80, 0xF9, 0xF1, 0xF3, 0xE0, 0x1F,
  0x3E, 0x3E, 0xFC, 0x03, 0xEF, 0x87, 0xDF, 0x00, 0x7D, 0xF0, 0xFB, 0xE0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80,
  0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF,
  0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x7C, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1,
  0xF8, 0x1F, 0x8F, 0xE0, 0x3E, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xC7, 0x80, 0x7C,
  0x78, 0x07, 0x87, 0x80, 0xF8, 0x7C, 0x1F, 0x03, 0xC1, 0xE0, 0x3C, 0x3E,
  0x03, 0xC7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0xE0, 0x08, 0x1F,
  0xC7, 0x83, 0xFF, 0x7C, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC7, 0xF9,
  0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01,
  0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xF3, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xDF,
  0x07, 0xFC, 0xF0, 0x1F, 0xCF, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC3, 0x00, 0xFD, 0xFC, 0x0F, 0xBF, 0xE0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x01,
  0xF3, 0xF0, 0x1F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xF9, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFB, 0xFF, 0x0F, 0x1F, 0xC0, 0x00, 0x7C, 0x01,
  0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF1, 0xFC, 0x19, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x04, 0x7F, 0x9E, 0x1F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xE1, 0xF8, 0x0F, 0xE7, 0xC0,
  0xFF, 0xDF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x3F, 0x87, 0xF0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C,
  0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF9, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xEF, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0x0F, 0xDF, 0xC1, 0xFB,
  0xF0, 0x3F, 0x7E, 0x0F, 0xDF, 0x9F, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0x1F,
  0xC0, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x02, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x04, 0x07, 0xF1, 0xE0, 0x7F,
  0xEF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F,
  0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xEF, 0x80, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x02, 0x00, 0xFC, 0x0E, 0x0F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0x80, 0x7E, 0xFF, 0x03, 0xEF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07,
  0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x07, 0xE0, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x09, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x02, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x9F,
  0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x0F, 0x9F, 0xC1, 0xFE, 0x0F,
  0x3F, 0xE3, 0xFE, 0x0F, 0x7F, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xE3, 0xFE, 0x3F, 0x1F, 0xC1, 0xFC, 0x3F, 0x1F, 0x81, 0xF8, 0x1F, 0x1F,
  0x83, 0xF8, 0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x3F,
  0x03, 0xF0, 0x3F, 0x3E, 0x03, 0xE0, 0x3E, 0x7E, 0x07, 0xE0, 0x7E, 0x7E,
  0x07, 0xE0, 0x7E, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x07, 0xE0, 0x7E, 0x7C,
  0x07, 0xC0, 0x7C, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC,
  0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0xFF,
  0x03, 0xCF, 0xFC, 0x1E, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x7F,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x1F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0x9F, 0xCF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x0F, 0x9F, 0xC0, 0x3C, 0xFF, 0x80, 0xF7, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x03,
  0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0x9F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x7F, 0xC0, 0xF8, 0xFC, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x08, 0x1F, 0xC7, 0x83, 0xFF, 0x7C, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xF3, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0x87, 0xCF, 0xC3, 0xEF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xE0, 0x41, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x80, 0x3F, 0x38,
  0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFC, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC4, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x7F, 0x1F, 0x87, 0xF8, 0xFE, 0x7F, 0x87, 0xFF, 0xFC, 0x1F,
  0xFB, 0xE0, 0xFF, 0x9F, 0x03, 0xF8, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC1, 0xF8, 0x7C,
  0x1F, 0x87, 0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07,
  0xCF, 0xC0, 0x3C, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0xF8, 0x3F, 0x81, 0xF9, 0xF0, 0x7F, 0x03,
  0xE3, 0xE0, 0xFE, 0x0F, 0xC7, 0xC3, 0xFC, 0x1F, 0x0F, 0x87, 0xF8, 0x7E,
  0x1F, 0x1F, 0xF0, 0xFC, 0x3E, 0x3D, 0xE3, 0xF0, 0x7C, 0xFB, 0xC7, 0xE0,
  0xF9, 0xE7, 0x8F, 0x81, 0xF3, 0xCF, 0x3F, 0x03, 0xEF, 0x9E, 0x7C, 0x07,
  0xDE, 0x3D, 0xF8, 0x0F, 0xFC, 0x7B, 0xE0, 0x1F, 0xF0, 0xF7, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x7F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8,
  0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x47,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7E,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x2F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xA0, 0x00,
  0x00,
};

const GFXglyph NotoSans_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 29, 11, 0, -28 },
  { 45, 14, 10, 18, 4, -28 },
  { 63, 24, 28, 25, 1, -28 },
  { 147, 20, 32, 21, 1, -30 },
  { 227, 30, 28, 33, 2, -28 },
  { 332, 26, 28, 28, 1, -28 },
  { 423, 6, 10, 10, 4, -28 },
  { 431, 15, 34, 13, 1, -28 },
  { 495, 15, 34, 13, -3, -28 },
  { 559, 19, 19, 21, 3, -30 },
  { 605, 19, 19, 22, 2, -23 },
  { 651, 9, 10, 11, -2, -5 },
  { 663, 11, 5, 13, 1, -13 },
  { 670, 7, 7, 11, 0, -6 },
  { 677, 21, 28, 17, -2, -28 },
  { 751, 20, 28, 21, 1, -28 },
  { 821, 16, 28, 21, 3, -28 },
  { 877, 22, 28, 21, -1, -28 },
  { 954, 21, 28, 21, 0, -28 },
  { 1028, 21, 28, 21, 0, -28 },
  { 1102, 21, 28, 21, 0, -28 },
  { 1176, 20, 28, 21, 2, -28 },
  { 1246, 22, 28, 21, 1, -28 },
  { 1323, 20, 28, 21, 1, -28 },
  { 1393, 19, 28, 21, 2, -28 },
  { 1460, 11, 23, 11, 0, -22 },
  { 1492, 13, 27, 11, -2, -22 },
  { 1536, 19, 20, 22, 2, -24 },
  { 1584, 19, 12, 22, 2, -20 },
  { 1613, 19, 20, 22, 2, -24 },
  { 1661, 16, 29, 18, 3, -28 },
  { 1719, 31, 32, 33, 2, -28 },
  { 1843, 24, 28, 24, -2, -28 },
  { 1927, 23, 28, 24, 1, -28 },
  { 2008, 23, 28, 24, 2, -28 },
  { 2089, 24, 28, 26, 1, -28 },
  { 2173, 22, 28, 21, 1, -28 },
  { 2250, 21, 28, 21, 1, -28 },
  { 2324, 24, 28, 27, 2, -28 },
  { 2408, 27, 28, 27, 1, -28 },
  { 2503, 18, 28, 15, -1, -28 },
  { 2566, 19, 36, 13, -6, -28 },
  { 2652, 27, 28, 24, 1, -28 },
  { 2747, 17, 28, 20, 1, -28 },
  { 2807, 34, 28, 34, 1, -28 },
  { 2926, 29, 28, 30, 1, -28 },
  { 3028, 25, 28, 29, 2, -28 },
  { 3116, 23, 28, 24, 1, -28 },
  { 3197, 25, 35, 29, 2, -28 },
  { 3307, 22, 28, 24, 1, -28 },
  { 3384, 20, 28, 21, 1, -28 },
  { 3454, 21, 28, 21, 3, -28 },
  { 3528, 24, 28, 27, 3, -28 },
  { 3612, 23, 28, 23, 4, -28 },
  { 3693, 35, 28, 35, 4, -28 },
  { 3816, 29, 28, 24, -2, -28 },
  { 3918, 22, 28, 22, 4, -28 },
  { 3995, 24, 28, 21, -1, -28 },
  { 4079, 17, 34, 13, -1, -28 },
  { 4152, 10, 28, 17, 4, -28 },
  { 4187, 17, 34, 13, -3, -28 },
  { 4260, 20, 18, 21, 1, -28 },
  { 4305, 17, 2, 16, -4, 4 },
  { 4310, 8, 6, 13, 6, -30 },
  { 4316, 21, 22, 23, 2, -22 },
  { 4374, 20, 30, 23, 1, -30 },
  { 4449, 17, 22, 19, 2, -22 },
  { 4496, 22, 30, 23, 2, -30 },
  { 4579, 19, 22, 22, 2, -22 },
  { 4632, 23, 39, 15, -4, -30 },
  { 4745, 22, 31, 23, 1, -22 },
  { 4831, 21, 30, 24, 1, -30 },
  { 4910, 12, 30, 12, 1, -30 },
  { 4955, 18, 39, 12, -5, -30 },
  { 5043, 23, 30, 22, 1, -30 },
  { 5130, 12, 30, 12, 1, -30 },
  { 5175, 32, 22, 35, 1, -22 },
  { 5263, 21, 22, 24, 1, -22 },
  { 5321, 19, 22, 23, 2, -22 },
  { 5374, 22, 31, 23, -1, -22 },
  { 5460, 21, 31, 23, 2, -22 },
  { 5542, 17, 22, 16, 1, -22 },
  { 5589, 18, 22, 19, 0, -22 },
  { 5639, 15, 26, 16, 2, -26 },
  { 5688, 21, 21, 24, 2, -21 },
  { 5744, 20, 21, 20, 2, -21 },
  { 5797, 31, 21, 31, 2, -21 },
  { 5879, 25, 21, 21, -2, -21 },
  { 5945, 25, 30, 20, -3, -21 },
  { 6039, 20, 21, 18, -1, -21 },
  { 6092, 16, 34, 14, 0, -28 },
  { 6160, 4, 39, 21, 9, -30 },
  { 6180, 16, 34, 14, -2, -28 },
  { 6248, 19, 7, 22, 2, -17 },
};

const GFXfont NotoSans_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_BOLDITALIC39PT7B_H_
