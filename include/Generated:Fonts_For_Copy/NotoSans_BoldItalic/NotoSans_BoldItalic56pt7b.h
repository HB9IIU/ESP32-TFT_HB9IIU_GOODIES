#ifndef _NOTOSANS_BOLDITALIC56PT7B_H_
#define _NOTOSANS_BOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFD, 0xFC, 0x07, 0xFC,
  0xF0, 0x60, 0x1F, 0xE3, 0xC0, 0x00, 0x7F, 0x8E, 0x00, 0x01, 0xFE, 0x78,
  0x00, 0x07, 0xF9, 0xE0, 0x00, 0x1F, 0xF7, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xEF, 0xF8, 0x00, 0x07,
  0x9F, 0xE0, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0xF1, 0xFE, 0x20, 0x03, 0xC7,
  0xF8, 0xE0, 0x0F, 0x3F, 0xE3, 0xF0, 0x39, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F,
  0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC3, 0xF0,
  0x30, 0x1F, 0xC3, 0xF8, 0xFC, 0x3F, 0xE3, 0xF8, 0xFF, 0x3F, 0x9F, 0xFE,
  0x7F, 0x3F, 0xCF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF1, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0x9F, 0xCF, 0xF3, 0xF9, 0xFF, 0xE7,
  0xF3, 0xFC, 0x7F, 0x0F, 0xF0, 0xFC, 0x7F, 0x0F, 0xE0, 0x20, 0x3F, 0x0F,
  0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x03,
  0xF0, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0xFF,
  0xC0, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xF7, 0xFC, 0x1F, 0xE3,
  0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xF0, 0x7F, 0xDF, 0xF1, 0xFF, 0x03, 0xFE,
  0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0x83, 0xFC,
  0x01, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x40, 0x1F, 0x80, 0x0C, 0x03, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xFB, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xC0, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xF3, 0xF0, 0x03, 0xFC, 0x7E, 0x00, 0xFF, 0x8F, 0xC0,
  0x07, 0xE1, 0xFC, 0x00, 0x78, 0x1F, 0x80, 0x07, 0x03, 0xF8, 0x00, 0x40,
  0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x06, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFE, 0x7F, 0x87, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F,
  0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00,
  0x3F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFC,
  0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF,
  0x1F, 0xF3, 0xFC, 0x3F, 0x0F, 0xF0, 0xF8, 0x7F, 0x81, 0x81, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x01,
  0xC0, 0x0F, 0xF8, 0x01, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0x87, 0xFF, 0x00, 0x70, 0x07, 0xFC, 0x01, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x80,
  0x00, 0x3F, 0xE3, 0x80, 0x01, 0xFF, 0x8F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x20, 0x00, 0x3F, 0xF0,
  0xE0, 0x01, 0xFF, 0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x0C, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0xC7,
  0xFE, 0x00, 0xFF, 0x7F, 0xFC, 0x03, 0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x03, 0xFE,
  0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F,
  0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80,
  0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xFC,
  0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xF3, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F,
  0xC0, 0x3F, 0xF3, 0xFE, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xBF, 0xC0,
  0x7F, 0xF3, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x81, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x0E, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0x83, 0xFE, 0x1E, 0x01, 0xFE, 0x10, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0xFF, 0xC3, 0xF3, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0x3F, 0x01, 0xFF, 0xFF, 0x83, 0xF7, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0x7E, 0x07, 0xF8, 0x3F, 0x03, 0xF7, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0xFC,
  0x1F, 0xC0, 0x7E, 0x03, 0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x1F,
  0x80, 0x7E, 0x03, 0xFF, 0xC3, 0xF8, 0x0F, 0xE0, 0x7E, 0xFC, 0x3F, 0x80,
  0xFC, 0x07, 0xEF, 0xC3, 0xF8, 0x0F, 0xC0, 0xFE, 0xFC, 0x3F, 0x81, 0xFC,
  0x0F, 0xCF, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0xFC, 0x3F, 0x83, 0xFC, 0x3F,
  0x8F, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xE0, 0xFF, 0xF7, 0xFF, 0xE0, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xE0,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x1E, 0x01,
  0xFF, 0xC0, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x40, 0x0F, 0xFE, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFE,
  0x3F, 0xE0, 0x1F, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0xFF,
  0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x80,
  0x7F, 0xFF, 0x1F, 0xF0, 0x10, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xC0,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F,
  0xCF, 0xF0, 0x07, 0xF3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xF8, 0x07,
  0xE7, 0xF8, 0x03, 0xFC, 0xFC, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0x7E, 0x03,
  0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x81,
  0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xC1, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xE0,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x3F, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xBF, 0x83, 0xFC, 0x01, 0xFC, 0x1F,
  0xDF, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xFE,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xF8, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x9F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF0, 0x07,
  0xF8, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x83,
  0xF8, 0x03, 0xFC, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x7F, 0x80,
  0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8,
  0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0xDF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFE,
  0x00, 0xE0, 0x3F, 0xE0, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0xC0, 0x00, 0xFF, 0x07, 0x80, 0x0F, 0xF8, 0x3F, 0xE7, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xE3,
  0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x1F,
  0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xCF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xDF, 0x80, 0xFF, 0x01, 0xFC, 0x0F,
  0xE7, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF9, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x7E, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x1F, 0x83, 0xFC, 0x01, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFF, 0x00, 0x7F, 0x0F, 0xE1, 0xF8, 0x7F, 0x80, 0x1F,
  0xC3, 0xF8, 0x7E, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x1F, 0x87, 0xF0, 0x01,
  0xFC, 0x7F, 0x07, 0xE3, 0xFC, 0x00, 0x7F, 0x3F, 0xC1, 0xF8, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x7E, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x1F, 0x9F, 0xE0,
  0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x01, 0xFB, 0xFC,
  0x00, 0x1F, 0xDF, 0x80, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xBF,
  0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80,
  0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xFF, 0xC7,
  0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x01,
  0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0x7F, 0x00, 0x7F, 0xF9, 0xFC, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x3F, 0xDF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F,
  0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F,
  0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7E,
  0x7F, 0xFE, 0x03, 0xF8, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0x08, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x60, 0x7F, 0xF0, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0xCF, 0xF0,
  0x03, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0x3F, 0x00, 0x07,
  0xFF, 0x1F, 0x80, 0x01, 0xFF, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F,
  0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x20,
  0x7F, 0xE0, 0x1E, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x67, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0xF1, 0xFC, 0x01, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xE7, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xF7, 0xF8, 0x01,
  0xFF, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x0C, 0x00, 0x3F, 0xE0, 0x1F, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x0F,
  0xF1, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x47, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0x83, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xC0,
  0x01, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0,
  0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xE7, 0xFF, 0xC3, 0xFF, 0xE0,
  0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0x00, 0xFC, 0xFF, 0xFE,
  0x03, 0xF3, 0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x1F, 0xF0,
  0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F,
  0x80, 0x7F, 0xC7, 0xFC, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x3F, 0x8F, 0xFC, 0x00, 0x1F, 0xCF, 0xFF, 0x00, 0x0F,
  0xEF, 0xFF, 0xC0, 0x07, 0xEF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFD, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0x3F,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0,
  0x7F, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFE, 0x7F,
  0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x20, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0xC0, 0x7F, 0x7F, 0xE0, 0x3F, 0xBF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xF0, 0x3E, 0x1F, 0xE0, 0x04, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x80, 0x07, 0xFC, 0xF0, 0x0F,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x08, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x40, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00,
  0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xC3, 0xFC, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0x83,
  0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xDF, 0xC0, 0x7F,
  0xFE, 0x7F, 0x00, 0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07,
  0xFD, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE1,
  0xFC, 0x01, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x83, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7F,
  0x3F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0xC0, 0x1F, 0xE7,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0xC7, 0xF0,
  0x1F, 0xFC, 0x07, 0xFC, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0x87, 0xF0, 0x3F,
  0x7C, 0x0F, 0xF8, 0x7F, 0x03, 0xF7, 0xC0, 0xFF, 0x07, 0xF0, 0x7F, 0xFC,
  0x0F, 0xF0, 0x7F, 0x07, 0xEF, 0xC1, 0xFE, 0x07, 0xF0, 0x7E, 0xFC, 0x1F,
  0xE0, 0x7F, 0x0F, 0xCF, 0xC3, 0xFC, 0x07, 0xF0, 0xFC, 0xFC, 0x3F, 0xC0,
  0x7F, 0x1F, 0xCF, 0xC7, 0xF8, 0x07, 0xF1, 0xF8, 0xFC, 0x7F, 0x80, 0x7F,
  0x3F, 0x8F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0xFC, 0xFF, 0x00, 0x7F, 0x3F,
  0x0F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0xFC, 0xFE, 0x00, 0x7F, 0x7E, 0x0F,
  0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xDF,
  0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x2F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_BoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 41, 16, 1, -40 },
  { 89, 21, 14, 25, 5, -40 },
  { 126, 35, 40, 36, 1, -40 },
  { 301, 30, 46, 31, 1, -43 },
  { 474, 43, 42, 48, 3, -41 },
  { 700, 37, 42, 40, 2, -41 },
  { 895, 10, 14, 14, 5, -40 },
  { 913, 21, 49, 19, 2, -40 },
  { 1042, 21, 50, 19, -4, -41 },
  { 1174, 27, 27, 31, 5, -43 },
  { 1266, 27, 27, 32, 3, -33 },
  { 1358, 14, 14, 16, -3, -7 },
  { 1383, 16, 6, 18, 1, -18 },
  { 1395, 10, 10, 16, 0, -9 },
  { 1408, 31, 40, 24, -3, -40 },
  { 1563, 28, 42, 31, 2, -41 },
  { 1710, 22, 40, 31, 5, -40 },
  { 1820, 31, 41, 31, -1, -41 },
  { 1979, 30, 42, 31, 0, -41 },
  { 2137, 31, 40, 31, -1, -40 },
  { 2292, 30, 41, 31, 1, -40 },
  { 2446, 30, 42, 31, 2, -41 },
  { 2604, 31, 40, 31, 2, -40 },
  { 2759, 29, 42, 31, 2, -41 },
  { 2912, 28, 42, 31, 2, -41 },
  { 3059, 15, 32, 16, 0, -31 },
  { 3119, 18, 38, 16, -3, -31 },
  { 3205, 27, 29, 32, 3, -35 },
  { 3303, 27, 17, 32, 3, -28 },
  { 3361, 27, 29, 32, 3, -35 },
  { 3459, 24, 42, 26, 4, -41 },
  { 3585, 44, 45, 48, 3, -40 },
  { 3833, 35, 40, 35, -3, -40 },
  { 4008, 33, 40, 35, 1, -40 },
  { 4173, 34, 42, 34, 3, -41 },
  { 4352, 35, 40, 38, 1, -40 },
  { 4527, 31, 40, 30, 1, -40 },
  { 4682, 31, 40, 30, 1, -40 },
  { 4837, 35, 42, 39, 3, -41 },
  { 5021, 38, 40, 39, 1, -40 },
  { 5211, 27, 40, 21, -2, -40 },
  { 5346, 28, 52, 19, -9, -40 },
  { 5528, 38, 40, 34, 1, -40 },
  { 5718, 24, 40, 29, 1, -40 },
  { 5838, 49, 40, 49, 1, -40 },
  { 6083, 42, 40, 42, 1, -40 },
  { 6293, 36, 42, 41, 3, -41 },
  { 6482, 33, 40, 34, 1, -40 },
  { 6647, 36, 51, 41, 3, -41 },
  { 6877, 32, 40, 35, 1, -40 },
  { 7037, 29, 42, 30, 1, -41 },
  { 7190, 29, 40, 30, 5, -40 },
  { 7335, 35, 41, 39, 4, -40 },
  { 7515, 33, 40, 33, 5, -40 },
  { 7680, 50, 40, 50, 5, -40 },
  { 7930, 42, 40, 34, -3, -40 },
  { 8140, 32, 40, 32, 5, -40 },
  { 8300, 35, 40, 30, -2, -40 },
  { 8475, 23, 49, 19, -1, -40 },
  { 8616, 13, 40, 24, 6, -40 },
  { 8681, 24, 49, 19, -4, -40 },
  { 8828, 28, 26, 31, 1, -40 },
  { 8919, 23, 4, 22, -5, 5 },
  { 8931, 12, 9, 18, 8, -43 },
  { 8945, 30, 32, 33, 2, -31 },
  { 9065, 30, 44, 33, 1, -43 },
  { 9230, 26, 32, 27, 2, -31 },
  { 9334, 33, 44, 33, 2, -43 },
  { 9516, 28, 32, 31, 2, -31 },
  { 9628, 33, 56, 21, -6, -43 },
  { 9859, 31, 44, 33, 1, -31 },
  { 10030, 30, 43, 34, 1, -43 },
  { 10192, 17, 43, 17, 1, -43 },
  { 10284, 25, 56, 17, -7, -43 },
  { 10459, 34, 43, 32, 1, -43 },
  { 10642, 17, 43, 17, 1, -43 },
  { 10734, 47, 31, 51, 1, -31 },
  { 10917, 30, 31, 34, 1, -31 },
  { 11034, 28, 32, 33, 2, -31 },
  { 11146, 33, 44, 33, -2, -31 },
  { 11328, 30, 44, 33, 2, -31 },
  { 11493, 25, 31, 24, 1, -31 },
  { 11590, 24, 32, 27, 1, -31 },
  { 11686, 21, 38, 23, 3, -37 },
  { 11786, 30, 32, 34, 3, -31 },
  { 11906, 29, 31, 29, 3, -31 },
  { 12019, 44, 31, 44, 3, -31 },
  { 12190, 36, 31, 30, -3, -31 },
  { 12330, 36, 44, 29, -4, -31 },
  { 12528, 28, 31, 26, -1, -31 },
  { 12637, 23, 49, 20, 0, -40 },
  { 12778, 6, 55, 31, 12, -42 },
  { 12820, 23, 49, 20, -3, -40 },
  { 12961, 27, 9, 32, 3, -24 },
};

const GFXfont NotoSans_BoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_BOLDITALIC56PT7B_H_
