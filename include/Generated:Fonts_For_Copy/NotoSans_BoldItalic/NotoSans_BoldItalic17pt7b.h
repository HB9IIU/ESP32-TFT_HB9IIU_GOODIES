#ifndef _NOTOSANS_BOLDITALIC17PT7B_H_
#define _NOTOSANS_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x19, 0xCC, 0x03, 0x39, 0xC0, 0xEF, 0x6D, 0xB6,
  0x06, 0xC1, 0x98, 0x32, 0x3F, 0xF7, 0xFE, 0x32, 0x06, 0xC7, 0xFE, 0xFF,
  0xC6, 0xC0, 0xD8, 0x33, 0x00, 0x02, 0x03, 0x87, 0xE7, 0xB3, 0x41, 0xE0,
  0xF8, 0x1E, 0x0B, 0xC5, 0xFF, 0xDF, 0xC1, 0x00, 0x80, 0x78, 0x73, 0x63,
  0x33, 0x31, 0x9B, 0x0D, 0x90, 0x6D, 0xFF, 0xDB, 0x61, 0xB3, 0x0D, 0x98,
  0xCD, 0xCC, 0x7C, 0xC1, 0xC0, 0x1F, 0x07, 0xE0, 0xCC, 0x19, 0x83, 0xF0,
  0x79, 0xDF, 0x37, 0x7E, 0xC7, 0x98, 0xE3, 0xFE, 0x3E, 0xE0, 0xFB, 0x60,
  0x1C, 0xE3, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x06, 0x00,
  0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x8C, 0x31, 0x8C, 0x00,
  0x0C, 0x06, 0x1B, 0x1F, 0xF1, 0xF9, 0xE1, 0x90, 0x4C, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x37, 0x6E, 0x7F, 0xFE, 0x7F, 0x80, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C,
  0x00, 0x3E, 0x7F, 0x73, 0xE3, 0xE3, 0xC3, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC,
  0x78, 0x1C, 0xFF, 0xF7, 0x98, 0x63, 0x8E, 0x30, 0xC7, 0x1C, 0x1F, 0x1F,
  0xCC, 0xE0, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0xDF, 0xE0,
  0x3F, 0x1F, 0xC8, 0x60, 0x30, 0x30, 0xF0, 0x7C, 0x06, 0x03, 0x43, 0xBF,
  0xDF, 0x80, 0x03, 0x83, 0xC3, 0xE1, 0xE1, 0xB1, 0x99, 0x9D, 0xFF, 0xFF,
  0x83, 0x03, 0x81, 0xC0, 0x1F, 0x8F, 0xCE, 0x06, 0x03, 0xC3, 0xF8, 0x9C,
  0x06, 0x03, 0x43, 0xBF, 0xDF, 0x80, 0x1F, 0x9F, 0x9C, 0x0C, 0x0E, 0xE7,
  0xF3, 0x9D, 0x8E, 0xC7, 0x63, 0x3F, 0x8F, 0x80, 0x7F, 0xBF, 0xC1, 0xC0,
  0xE0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x00, 0x1F, 0x9F,
  0xCC, 0x66, 0x33, 0xB8, 0xF0, 0xFC, 0xC6, 0xE3, 0xF1, 0x9F, 0xC7, 0xC0,
  0x3E, 0x7F, 0xE7, 0xE3, 0xE7, 0xE7, 0xFF, 0x36, 0x06, 0x0E, 0xFC, 0xF8,
  0x39, 0x80, 0x00, 0x01, 0x9C, 0xE0, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x71, 0x8C, 0x00, 0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xF0, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x07, 0x0F,
  0x3C, 0xF0, 0xC0, 0xFE, 0xFD, 0x18, 0x31, 0xE7, 0x0C, 0x30, 0x00, 0xC3,
  0x87, 0x00, 0x0F, 0xE0, 0xF3, 0x8C, 0x06, 0xC7, 0xBC, 0xFC, 0xE6, 0x67,
  0x66, 0x7B, 0x33, 0xDB, 0xB6, 0x77, 0xB0, 0x00, 0xE0, 0x83, 0xFC, 0x03,
  0x00, 0x03, 0xC0, 0xF8, 0x1B, 0x07, 0x60, 0xCC, 0x39, 0x86, 0x31, 0xFE,
  0x3F, 0xCE, 0x19, 0x83, 0xF0, 0x70, 0x1F, 0x87, 0xF3, 0x8C, 0xE3, 0x39,
  0xCF, 0xC3, 0xF9, 0xC6, 0x71, 0xDC, 0xE7, 0xFB, 0xF8, 0x1F, 0xCF, 0xF7,
  0x89, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x47, 0xF0, 0xFC,
  0x1F, 0x83, 0xF8, 0xE3, 0x9C, 0x73, 0x8E, 0x61, 0xCC, 0x3B, 0x87, 0x71,
  0xCE, 0x79, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xE3, 0x80, 0xE0, 0x38, 0x8F,
  0xC3, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xE3, 0x80,
  0xE0, 0x38, 0x0F, 0xC3, 0xF1, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x0F,
  0xE7, 0xF9, 0xE1, 0x38, 0x0E, 0x01, 0xCF, 0xB9, 0xF7, 0x0C, 0xE1, 0x9C,
  0x71, 0xFE, 0x1F, 0xC0, 0x1C, 0x71, 0x87, 0x38, 0x63, 0x86, 0x38, 0xE3,
  0xFE, 0x3F, 0xE7, 0x0C, 0x70, 0xC7, 0x1C, 0x61, 0xCE, 0x1C, 0x1F, 0x1F,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x7C, 0xFC, 0x03, 0x81,
  0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x81,
  0xC7, 0xE3, 0xE0, 0xC0, 0x1C, 0xF1, 0x8E, 0x39, 0xC3, 0xB8, 0x3F, 0x03,
  0xE0, 0x3E, 0x07, 0x70, 0x77, 0x06, 0x38, 0x63, 0x8E, 0x38, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x7F, 0xFE, 0x1C, 0x1E,
  0x38, 0x3C, 0xF8, 0xF1, 0xB1, 0xE3, 0x66, 0xC6, 0xCD, 0x8D, 0xB7, 0x3B,
  0x6C, 0x67, 0x98, 0xCF, 0x31, 0x9C, 0xE7, 0x39, 0xC0, 0x1C, 0x18, 0xE1,
  0xCF, 0x8C, 0x6C, 0x63, 0x63, 0x1B, 0xB8, 0xCD, 0xCE, 0x6C, 0x63, 0xE3,
  0x0F, 0x18, 0x79, 0xC3, 0xC0, 0x1F, 0x87, 0xF9, 0xC3, 0xB8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x06, 0xE1, 0xDC, 0x79, 0xFE, 0x1F, 0x00, 0x1F, 0x87,
  0xF3, 0x8C, 0xE3, 0x38, 0xCC, 0xF3, 0xF9, 0xF8, 0x70, 0x18, 0x06, 0x03,
  0x80, 0x1F, 0x87, 0xF9, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x06,
  0xE1, 0xDC, 0x71, 0xFE, 0x1F, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1F, 0x87,
  0xF3, 0x9C, 0xE3, 0x39, 0xCF, 0xE3, 0xF1, 0xDC, 0x73, 0x1C, 0xE6, 0x3B,
  0x87, 0x1F, 0x9F, 0xCE, 0x06, 0x03, 0x81, 0xE0, 0x38, 0x0E, 0x07, 0x43,
  0xBF, 0x9F, 0x80, 0x7F, 0xFF, 0xC7, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x0C, 0x0E, 0x00, 0x30, 0xE6, 0x1D, 0xC3, 0x38, 0x66, 0x1C,
  0xC3, 0xB8, 0x67, 0x0C, 0xE3, 0x9C, 0x71, 0xFC, 0x1F, 0x00, 0xC1, 0xF0,
  0xEC, 0x33, 0x1C, 0xC6, 0x33, 0x8C, 0xC3, 0x70, 0xD8, 0x3E, 0x0F, 0x01,
  0xC0, 0xC3, 0x0F, 0x8E, 0x1B, 0x1C, 0x76, 0x78, 0xCC, 0xF3, 0x9B, 0xE6,
  0x36, 0xDC, 0x6D, 0xB0, 0xF3, 0x61, 0xE7, 0xC3, 0x87, 0x07, 0x0E, 0x00,
  0x1C, 0x78, 0xE3, 0x03, 0x38, 0x1F, 0x80, 0xF8, 0x03, 0x80, 0x3C, 0x03,
  0xF0, 0x19, 0x81, 0xCE, 0x1C, 0x71, 0xC3, 0x80, 0xC3, 0xE3, 0xB9, 0x9D,
  0xC7, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x00, 0x1F, 0xE3,
  0xFC, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0xFE, 0x7F, 0xC0, 0x1E, 0x38, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1,
  0x87, 0x0C, 0x1E, 0x3C, 0x00, 0xCC, 0xCE, 0x66, 0x66, 0x66, 0x73, 0x1E,
  0x3C, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x1E, 0x3C,
  0x00, 0x06, 0x07, 0x03, 0x83, 0x63, 0x31, 0x99, 0x87, 0x83, 0xFF, 0xE7,
  0x30, 0x3D, 0xBF, 0xB8, 0xDC, 0x6C, 0x76, 0x3B, 0x39, 0xFC, 0x76, 0x00,
  0x1C, 0x0C, 0x06, 0x07, 0x03, 0x79, 0xFC, 0xC6, 0xE3, 0x71, 0xB1, 0xDC,
  0xEF, 0xED, 0xE0, 0x3E, 0xFF, 0x87, 0x0C, 0x18, 0x39, 0x7E, 0x7C, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x3F, 0x9F, 0xCE, 0x33, 0x8C, 0xC7, 0x31, 0xCC,
  0x63, 0xF8, 0x76, 0x00, 0x3F, 0x77, 0xE3, 0xEF, 0xFE, 0xC0, 0xC0, 0xFE,
  0x7E, 0x03, 0xC1, 0xF0, 0x70, 0x18, 0x1F, 0x87, 0xE0, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x83, 0xE0, 0xF0, 0x00, 0x1E,
  0xCF, 0xE7, 0x19, 0xC6, 0x63, 0x98, 0xE6, 0x71, 0xFC, 0x3B, 0x01, 0xC8,
  0x63, 0xF8, 0xFC, 0x00, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x79, 0xFC, 0xE6,
  0xE3, 0x71, 0xB9, 0xD8, 0xEC, 0x6E, 0x30, 0x18, 0xC6, 0x03, 0x98, 0xCE,
  0x73, 0x98, 0xCE, 0x00, 0x06, 0x0C, 0x18, 0x00, 0xE1, 0x83, 0x06, 0x1C,
  0x38, 0x60, 0xC3, 0x87, 0x0E, 0x78, 0xE0, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x39, 0xCC, 0xE3, 0x71, 0xF8, 0x7E, 0x1F, 0x86, 0x71, 0x9C, 0xE3, 0x80,
  0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC6, 0x18, 0xE0, 0x37, 0xBC,
  0x7F, 0xF8, 0xE7, 0x3B, 0x8C, 0x67, 0x38, 0xCE, 0x73, 0x98, 0xE7, 0x31,
  0x8E, 0xE3, 0x18, 0x37, 0x9F, 0xCE, 0x6E, 0x37, 0x1B, 0x9D, 0x8E, 0xC6,
  0xE3, 0x00, 0x3E, 0x7F, 0xE3, 0xE3, 0xC3, 0xC7, 0xC7, 0xFE, 0x7C, 0x1B,
  0xC7, 0xF1, 0x8C, 0xE3, 0x38, 0xCC, 0x73, 0x9C, 0xFE, 0x7F, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x00, 0x3D, 0xBF, 0xB8, 0xDC, 0x6C, 0x76, 0x3B, 0x19,
  0xFC, 0x76, 0x07, 0x03, 0x81, 0x81, 0xC0, 0x37, 0x3E, 0x38, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0x3F, 0x72, 0x70, 0x78, 0x3C, 0x0E, 0x0E, 0xFE,
  0xFC, 0x30, 0xCF, 0xFF, 0x61, 0x8E, 0x38, 0xE3, 0xEF, 0x80, 0x73, 0xB1,
  0xD8, 0xDC, 0x6E, 0x76, 0x3B, 0x3D, 0xFC, 0x76, 0x00, 0xC3, 0xE3, 0xB9,
  0x9D, 0xCE, 0xC3, 0xE1, 0xE0, 0xE0, 0x70, 0x00, 0xC7, 0x3E, 0x79, 0xB3,
  0xDD, 0x96, 0xCD, 0xB6, 0x6D, 0xF3, 0xCF, 0x1E, 0x78, 0xE3, 0x80, 0x39,
  0xE3, 0xB0, 0x7E, 0x07, 0x80, 0xE0, 0x3E, 0x0F, 0xC3, 0x98, 0xE3, 0x80,
  0x30, 0xE6, 0x38, 0xE6, 0x1D, 0xC1, 0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xE0, 0x78, 0x0E, 0x00, 0x3F, 0x7F, 0x0E, 0x1C, 0x38, 0x30,
  0x70, 0xFE, 0xFC, 0x0E, 0x3C, 0x60, 0xC1, 0x87, 0x3C, 0x70, 0x70, 0x61,
  0xC3, 0x06, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x38,
  0x30, 0x61, 0xC3, 0x03, 0x87, 0x18, 0x70, 0xC1, 0x87, 0x1C, 0x30, 0x00,
  0xF9, 0x9F,
};

const GFXglyph NotoSans_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 5, 0, -12 },
  { 9, 6, 4, 8, 2, -12 },
  { 12, 11, 12, 11, 0, -12 },
  { 29, 9, 14, 9, 0, -13 },
  { 45, 13, 12, 15, 1, -12 },
  { 65, 11, 12, 12, 1, -12 },
  { 82, 3, 4, 4, 2, -12 },
  { 84, 6, 15, 6, 1, -12 },
  { 96, 6, 15, 6, -1, -12 },
  { 108, 9, 8, 9, 1, -13 },
  { 117, 8, 8, 10, 1, -10 },
  { 125, 4, 4, 5, -1, -2 },
  { 127, 5, 3, 5, 0, -6 },
  { 129, 3, 3, 5, 0, -3 },
  { 131, 9, 12, 7, -1, -12 },
  { 145, 8, 12, 9, 1, -12 },
  { 157, 6, 12, 9, 2, -12 },
  { 166, 9, 12, 9, 0, -12 },
  { 180, 9, 12, 9, 0, -12 },
  { 194, 9, 12, 9, 0, -12 },
  { 208, 9, 12, 9, 0, -12 },
  { 222, 9, 12, 9, 1, -12 },
  { 236, 9, 12, 9, 1, -12 },
  { 250, 9, 12, 9, 0, -12 },
  { 264, 8, 12, 9, 1, -12 },
  { 276, 5, 9, 5, 0, -9 },
  { 282, 6, 11, 5, -1, -9 },
  { 291, 8, 9, 10, 1, -11 },
  { 300, 8, 6, 10, 1, -9 },
  { 306, 8, 9, 10, 1, -11 },
  { 315, 7, 12, 8, 1, -12 },
  { 326, 13, 14, 15, 1, -12 },
  { 349, 11, 12, 11, -1, -12 },
  { 366, 10, 12, 11, 0, -12 },
  { 381, 10, 12, 10, 1, -12 },
  { 396, 11, 12, 12, 0, -12 },
  { 413, 10, 12, 9, 0, -12 },
  { 428, 10, 12, 9, 0, -12 },
  { 443, 11, 12, 12, 1, -12 },
  { 460, 12, 12, 12, 0, -12 },
  { 478, 8, 12, 7, -1, -12 },
  { 490, 9, 16, 6, -3, -12 },
  { 508, 12, 12, 10, 0, -12 },
  { 526, 8, 12, 9, 0, -12 },
  { 538, 15, 12, 15, 0, -12 },
  { 561, 13, 12, 13, 0, -12 },
  { 581, 11, 12, 12, 1, -12 },
  { 598, 10, 12, 10, 0, -12 },
  { 613, 11, 15, 12, 1, -12 },
  { 634, 10, 12, 11, 0, -12 },
  { 649, 9, 12, 9, 0, -12 },
  { 663, 9, 12, 9, 1, -12 },
  { 677, 11, 12, 12, 1, -12 },
  { 694, 10, 12, 10, 2, -12 },
  { 709, 15, 12, 15, 2, -12 },
  { 732, 13, 12, 10, -1, -12 },
  { 752, 9, 12, 10, 2, -12 },
  { 766, 11, 12, 9, -1, -12 },
  { 783, 7, 15, 6, 0, -12 },
  { 797, 4, 12, 7, 2, -12 },
  { 803, 7, 15, 6, -1, -12 },
  { 817, 9, 8, 9, 0, -12 },
  { 826, 8, 1, 7, -2, 2 },
  { 827, 4, 3, 6, 2, -13 },
  { 829, 9, 9, 10, 1, -9 },
  { 840, 9, 13, 10, 0, -13 },
  { 855, 7, 9, 8, 1, -9 },
  { 863, 10, 13, 10, 1, -13 },
  { 880, 8, 9, 9, 1, -9 },
  { 889, 10, 17, 6, -2, -13 },
  { 911, 10, 13, 10, 0, -9 },
  { 928, 9, 13, 10, 0, -13 },
  { 943, 5, 13, 5, 0, -13 },
  { 952, 7, 17, 5, -2, -13 },
  { 967, 10, 13, 10, 0, -13 },
  { 984, 6, 13, 5, 0, -13 },
  { 994, 15, 9, 15, 0, -9 },
  { 1011, 9, 9, 10, 0, -9 },
  { 1022, 8, 9, 10, 1, -9 },
  { 1031, 10, 13, 10, -1, -9 },
  { 1048, 9, 13, 10, 1, -9 },
  { 1063, 8, 9, 7, 0, -9 },
  { 1072, 8, 9, 8, 0, -9 },
  { 1081, 6, 11, 7, 1, -11 },
  { 1090, 9, 9, 10, 1, -9 },
  { 1101, 9, 9, 9, 1, -9 },
  { 1112, 13, 9, 13, 1, -9 },
  { 1127, 11, 9, 9, -1, -9 },
  { 1140, 11, 13, 9, -1, -9 },
  { 1158, 8, 9, 8, 0, -9 },
  { 1167, 7, 15, 6, 0, -12 },
  { 1181, 2, 17, 9, 4, -13 },
  { 1186, 7, 15, 6, -1, -12 },
  { 1200, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_BOLDITALIC17PT7B_H_
