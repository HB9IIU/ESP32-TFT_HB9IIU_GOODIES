#ifndef _NOTOSANS_BOLDITALIC52PT7B_H_
#define _NOTOSANS_BOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x38, 0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F,
  0xBF, 0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7C, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x83, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F,
  0x83, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFC,
  0xE1, 0xC0, 0xFF, 0x1C, 0x00, 0x1F, 0xE7, 0x80, 0x03, 0xFC, 0xF0, 0x00,
  0x7F, 0x9E, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xDF,
  0xF0, 0x00, 0x39, 0xFE, 0x00, 0x07, 0x1F, 0xC0, 0x01, 0xE3, 0xF9, 0x00,
  0x3C, 0xFF, 0x3C, 0x07, 0x1F, 0xE7, 0xF0, 0xEF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0xFC,
  0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x8F,
  0xC0, 0x00, 0xFC, 0x3F, 0x8F, 0xC3, 0xE0, 0xFC, 0x3F, 0x1F, 0x8F, 0xF8,
  0xFC, 0x7F, 0x3F, 0x3F, 0xFC, 0xFF, 0xFE, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0xFC, 0xFF, 0xFE, 0x3F, 0xF9, 0xF9, 0xFC,
  0x7F, 0x1F, 0xF3, 0xF1, 0xFC, 0x7F, 0x07, 0x03, 0xF1, 0xF8, 0x7F, 0x00,
  0x07, 0xE3, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x03, 0xF1, 0xFC, 0x01, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x0F, 0xFF,
  0xE0, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xE3, 0xFE, 0xFF, 0x07, 0xF1, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xFD, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0x8F,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7,
  0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0x80, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0x00, 0xFC, 0x00, 0xE0,
  0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7F, 0x9F, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0x07, 0xFF, 0x80, 0x07, 0xF7, 0xE0,
  0x07, 0xFB, 0xF0, 0x07, 0xF8, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3F,
  0x00, 0x1C, 0x1F, 0xC0, 0x04, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0x00, 0x1F, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xBF, 0xE7,
  0xF9, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE,
  0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFD, 0xFC, 0x7F, 0x9F,
  0xC7, 0xE3, 0xFC, 0x3C, 0x3F, 0xC1, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0x83, 0xFF, 0x00,
  0xF0, 0x0F, 0xF8, 0x07, 0x00, 0x3F, 0xC0, 0x10, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xC0, 0x00, 0xFF,
  0x8F, 0x80, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x08, 0x00, 0x3F, 0xF0, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF1, 0xFC, 0x01,
  0xFC, 0xFF, 0xE0, 0x3F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x3F,
  0xE0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F,
  0xF3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xF0,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF,
  0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F,
  0x9F, 0xF0, 0x3F, 0xE7, 0xFE, 0x3F, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xF0, 0x1F, 0xF9, 0xFC, 0x01,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x82, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0x7F, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0x81, 0xFE, 0x10, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x01,
  0xFF, 0xC1, 0xF8, 0x7F, 0x01, 0xFF, 0xFC, 0x3F, 0x1F, 0x80, 0xFF, 0xFF,
  0x0F, 0xCF, 0xC0, 0x7F, 0xFF, 0x83, 0xF3, 0xF0, 0x3F, 0xEF, 0xE0, 0xFC,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xDF, 0x83,
  0xF0, 0x1F, 0x03, 0xF7, 0xE1, 0xF8, 0x0F, 0xC0, 0xFD, 0xF0, 0x7E, 0x03,
  0xF0, 0x3F, 0x7C, 0x1F, 0x80, 0xFC, 0x0F, 0xBF, 0x07, 0xC0, 0x3E, 0x07,
  0xEF, 0xC3, 0xF0, 0x1F, 0x81, 0xFB, 0xF0, 0xFC, 0x07, 0xE0, 0x7C, 0xFC,
  0x3F, 0x03, 0xF8, 0x3F, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0xCF, 0xC1, 0xF8,
  0x7F, 0x8F, 0xE1, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7E, 0x1F, 0xFE, 0xFF,
  0xF8, 0x1F, 0x83, 0xFF, 0xBF, 0xFC, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x00,
  0xFC, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x30, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0x80, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07,
  0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x7C, 0x07, 0xFE, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xC0, 0x3F, 0xFC, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0xF8, 0x03, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC,
  0x01, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x00, 0x0C, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0xFC, 0xFF, 0x80,
  0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x01,
  0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0xFF,
  0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F,
  0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7F, 0x00, 0xFE, 0x7C, 0x07, 0xF3, 0xF8,
  0x07, 0xF3, 0xE0, 0x3F, 0x3F, 0xC0, 0x7F, 0x1F, 0x03, 0xF9, 0xFC, 0x03,
  0xF8, 0xFC, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE1, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x0F, 0xC7, 0xF8, 0x07, 0xF1, 0xF8, 0xFE, 0x3F, 0x80, 0x7F, 0x0F,
  0xC7, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF3,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xBF, 0x87, 0xF8, 0x07, 0xF0, 0xFD, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFF, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F, 0x80, 0x7F, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xFC,
  0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x07, 0xF1, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0xFF,
  0x00, 0xFE, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x0F, 0xE3, 0xF8, 0x07, 0xF0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xE0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC0, 0x3F, 0x9F,
  0x80, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFC,
  0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7F,
  0x00, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x2F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x01,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF0, 0x3C, 0x07, 0xF8, 0x00, 0x80, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE1, 0x00, 0x03, 0xFC, 0x38, 0x00, 0xFF, 0x87, 0xC0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x03, 0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xE3, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFD, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF7, 0xE0, 0x7F,
  0x83, 0xF8, 0x1F, 0xDF, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0,
  0x3F, 0x83, 0xF9, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE7, 0xE0, 0xFE, 0x03,
  0xF8, 0x3F, 0x1F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x7E, 0x1F, 0xC0, 0x3F,
  0x87, 0xE1, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x87, 0xE3, 0xF8, 0x03, 0xF8,
  0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x7E, 0x7F, 0x00, 0x3F, 0x9F,
  0x81, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0xC7, 0xF8,
  0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xE7, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0xC0,
  0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0x87,
  0xE0, 0xFC, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0x01, 0xFF,
  0xE7, 0xF0, 0x3F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFC, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x87, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0xFE, 0x01, 0xFF, 0xCF, 0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x3F, 0xBF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE3, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF,
  0xC0, 0xFC, 0x7F, 0xF0, 0x0F, 0xC3, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFC, 0x7C, 0x1F, 0xF0, 0x04,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x7F, 0xC0, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xC3, 0xFC, 0x00, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xBF, 0xC0, 0x3F,
  0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF3,
  0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x7E,
  0x00, 0xFF, 0xFB, 0xF8, 0x01, 0xFF, 0xCF, 0xC0, 0x03, 0xFE, 0x3F, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0x9F, 0xFF, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0x81, 0xFF, 0x83, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC2, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x0F, 0xC0,
  0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8,
  0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0xC0, 0x1F, 0xF9, 0xFC, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x04, 0x00, 0x1F, 0xE0, 0x38, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x83, 0xE0, 0x03, 0xF8, 0xFF, 0x80, 0x3F, 0xBF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x7E, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x10,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xCF, 0xFF, 0x0F, 0xFF,
  0x03, 0xFB, 0xFF, 0xE3, 0xFF, 0xE0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F,
  0xDF, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF, 0xCF, 0xF8, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xE1, 0xFF, 0x01, 0xFF,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x0F,
  0xF1, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x0F, 0xF8, 0x03, 0xF3, 0xFF, 0xC0, 0x7F, 0x7F, 0xFE, 0x07, 0xEF,
  0xFF, 0xE0, 0x7E, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xCF,
  0xF8, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x7F, 0xC0,
  0x01, 0xF9, 0xFF, 0xC0, 0x07, 0xF7, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0xC1, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFE,
  0x00, 0xFF, 0x3F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0x08, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFC, 0x3F, 0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFD, 0xFE, 0x01, 0xFF, 0x9F, 0xC0, 0x0F, 0xF1, 0xFC,
  0x00, 0x18, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE1,
  0xFC, 0x0F, 0xCF, 0xF0, 0x3F, 0xBF, 0xE0, 0x7F, 0x7F, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xEC, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xF8, 0x0E, 0x0F, 0xE0, 0x04, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x10, 0x01, 0xFE, 0x30, 0x03,
  0xFC, 0x7E, 0x3F, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE8, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x10, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xEF, 0xC0, 0x7F, 0xFE, 0xFC, 0x07, 0xFF, 0xCF, 0xC0, 0x3F, 0xF8, 0xFC,
  0x01, 0xFE, 0x0F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFB, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xCF, 0xE0, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0x7F,
  0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF8,
  0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x01, 0xF9,
  0xFE, 0x00, 0x3F, 0x3F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x00,
  0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xCF, 0xE0, 0x3F, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0xF8,
  0x1F, 0xE3, 0xF8, 0x1F, 0x7C, 0x0F, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F, 0xF0,
  0x7E, 0x0F, 0xDF, 0x07, 0xF0, 0x3F, 0x07, 0xCF, 0x87, 0xF8, 0x1F, 0x87,
  0xE7, 0xC3, 0xF8, 0x0F, 0xC3, 0xF3, 0xE1, 0xFC, 0x07, 0xE3, 0xF1, 0xF1,
  0xFE, 0x03, 0xF1, 0xF8, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x7C, 0xFF, 0x00,
  0xFC, 0xFC, 0x3E, 0x7F, 0x00, 0x7E, 0x7E, 0x1F, 0x3F, 0x80, 0x3F, 0x7E,
  0x0F, 0xBF, 0x80, 0x1F, 0xBF, 0x07, 0xDF, 0xC0, 0x0F, 0xDF, 0x03, 0xEF,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x9F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x80, 0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_BoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 38, 15, 1, -37 },
  { 77, 19, 13, 24, 5, -37 },
  { 108, 33, 37, 34, 1, -37 },
  { 261, 27, 43, 29, 1, -40 },
  { 407, 40, 38, 45, 3, -38 },
  { 597, 34, 39, 37, 2, -38 },
  { 763, 9, 13, 13, 5, -37 },
  { 778, 19, 45, 18, 2, -37 },
  { 885, 20, 46, 18, -4, -38 },
  { 1000, 25, 25, 28, 4, -40 },
  { 1079, 25, 25, 30, 3, -31 },
  { 1158, 13, 13, 15, -3, -6 },
  { 1180, 15, 6, 17, 1, -17 },
  { 1192, 10, 9, 15, 0, -8 },
  { 1204, 28, 37, 22, -2, -37 },
  { 1334, 26, 39, 29, 2, -38 },
  { 1461, 20, 37, 29, 5, -37 },
  { 1554, 29, 38, 29, -1, -38 },
  { 1692, 28, 39, 29, 0, -38 },
  { 1829, 29, 37, 29, -1, -37 },
  { 1964, 28, 38, 29, 1, -37 },
  { 2097, 27, 39, 29, 2, -38 },
  { 2229, 29, 37, 29, 2, -37 },
  { 2364, 28, 39, 29, 1, -38 },
  { 2501, 26, 39, 29, 2, -38 },
  { 2628, 14, 30, 15, 0, -29 },
  { 2681, 17, 36, 15, -3, -29 },
  { 2758, 25, 28, 30, 3, -33 },
  { 2846, 25, 15, 30, 3, -26 },
  { 2893, 25, 28, 30, 3, -33 },
  { 2981, 22, 39, 24, 4, -38 },
  { 3089, 42, 42, 45, 2, -37 },
  { 3310, 33, 37, 33, -3, -37 },
  { 3463, 31, 37, 32, 1, -37 },
  { 3607, 31, 39, 32, 3, -38 },
  { 3759, 33, 37, 35, 1, -37 },
  { 3912, 29, 37, 28, 1, -37 },
  { 4047, 29, 37, 28, 1, -37 },
  { 4182, 32, 39, 36, 3, -38 },
  { 4338, 36, 37, 36, 1, -37 },
  { 4505, 25, 37, 20, -2, -37 },
  { 4621, 26, 48, 17, -8, -37 },
  { 4777, 36, 37, 32, 1, -37 },
  { 4944, 22, 37, 27, 1, -37 },
  { 5046, 45, 37, 46, 1, -37 },
  { 5255, 39, 37, 39, 1, -37 },
  { 5436, 33, 39, 38, 3, -38 },
  { 5597, 31, 37, 32, 1, -37 },
  { 5741, 33, 47, 38, 3, -38 },
  { 5935, 30, 37, 32, 1, -37 },
  { 6074, 27, 39, 28, 1, -38 },
  { 6206, 27, 37, 28, 4, -37 },
  { 6331, 32, 38, 36, 4, -37 },
  { 6483, 30, 37, 31, 5, -37 },
  { 6622, 46, 37, 46, 5, -37 },
  { 6835, 39, 37, 32, -3, -37 },
  { 7016, 29, 37, 29, 5, -37 },
  { 7151, 32, 37, 28, -2, -37 },
  { 7299, 22, 45, 17, -1, -37 },
  { 7423, 12, 37, 22, 6, -37 },
  { 7479, 21, 45, 17, -3, -37 },
  { 7598, 26, 24, 29, 1, -37 },
  { 7676, 22, 3, 21, -5, 5 },
  { 7685, 10, 8, 17, 8, -40 },
  { 7695, 28, 30, 31, 2, -29 },
  { 7800, 28, 41, 31, 1, -40 },
  { 7944, 24, 30, 25, 2, -29 },
  { 8034, 30, 41, 31, 2, -40 },
  { 8188, 26, 30, 29, 2, -29 },
  { 8286, 31, 52, 19, -6, -40 },
  { 8488, 29, 41, 31, 1, -29 },
  { 8637, 28, 40, 31, 1, -40 },
  { 8777, 16, 40, 16, 1, -40 },
  { 8857, 24, 52, 16, -7, -40 },
  { 9013, 31, 40, 30, 1, -40 },
  { 9168, 16, 40, 16, 1, -40 },
  { 9248, 43, 29, 47, 1, -29 },
  { 9404, 28, 29, 31, 1, -29 },
  { 9506, 26, 30, 30, 2, -29 },
  { 9604, 31, 41, 31, -2, -29 },
  { 9763, 28, 41, 31, 2, -29 },
  { 9907, 23, 29, 22, 1, -29 },
  { 9991, 23, 30, 25, 1, -29 },
  { 10078, 20, 35, 21, 2, -34 },
  { 10166, 28, 29, 31, 3, -28 },
  { 10268, 27, 28, 27, 3, -28 },
  { 10363, 41, 28, 41, 3, -28 },
  { 10507, 33, 28, 28, -3, -28 },
  { 10623, 34, 40, 27, -4, -28 },
  { 10793, 26, 28, 24, -1, -28 },
  { 10884, 22, 45, 18, 0, -37 },
  { 11008, 5, 51, 29, 12, -39 },
  { 11040, 22, 45, 18, -3, -37 },
  { 11164, 25, 9, 30, 3, -23 },
};

const GFXfont NotoSans_BoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_BOLDITALIC52PT7B_H_
