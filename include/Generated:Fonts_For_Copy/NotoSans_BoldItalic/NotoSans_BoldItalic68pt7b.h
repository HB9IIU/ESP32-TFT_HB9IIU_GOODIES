#ifndef _NOTOSANS_BOLDITALIC68PT7B_H_
#define _NOTOSANS_BOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xE1, 0xFF, 0x9F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xF8,
  0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xC7, 0x83, 0xC0, 0x3F, 0xF0, 0xF0, 0x18, 0x07, 0xFE, 0x3E, 0x00,
  0x00, 0xFF, 0xC7, 0xC0, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x03, 0xFF, 0x1E,
  0x00, 0x00, 0x7F, 0xF3, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3C, 0xFF, 0xE0, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x01, 0xF1, 0xFF, 0x80,
  0x00, 0x3E, 0x3F, 0xF0, 0x00, 0x07, 0xC7, 0xFE, 0x30, 0x00, 0xF0, 0xFF,
  0xC7, 0x80, 0x1E, 0x3F, 0xF8, 0xFE, 0x07, 0xCF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x81,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0xFF,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F,
  0x80, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF1,
  0xFF, 0xF8, 0xFF, 0x0F, 0xF9, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xF1, 0xFF, 0x9F, 0xF3, 0xFF,
  0xF8, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xFF, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xDF, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xE1, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x38, 0x03, 0xFC,
  0x00, 0x3E, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0xE3, 0xF8,
  0x00, 0x7F, 0xFB, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xF9,
  0xFF, 0x01, 0xFF, 0xF8, 0x01, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xFC,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xC0, 0x7F,
  0x80, 0x03, 0x80, 0x7F, 0x80, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x02, 0x03, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF,
  0xC1, 0xFE, 0x1F, 0xF8, 0x1F, 0x83, 0xFF, 0x03, 0xC0, 0x7F, 0xE0, 0x30,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xF8, 0x01, 0xFF,
  0xC0, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0xC0,
  0x06, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC2, 0x00, 0x00, 0x0F,
  0xFE, 0x1C, 0x00, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x3C, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x80, 0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0xFC, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xF8, 0x03, 0xFE,
  0x7F, 0xFF, 0x80, 0x7F, 0xDF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xBF, 0xF0,
  0x3F, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0xFE, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC0, 0x7F, 0xF1, 0xF0, 0x03, 0xFF, 0x0C, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0x07, 0xF8,
  0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFC,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xFE,
  0x07, 0xF1, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xFC,
  0x07, 0xF0, 0x1F, 0xE7, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0x00, 0x7F, 0x00, 0xFE,
  0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFB, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF7, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xEF, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE3, 0xFC, 0x1F, 0xE0,
  0x7F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x9F, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x38, 0x07, 0xFF,
  0xC0, 0x00, 0x08, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x0E, 0x00, 0x3F,
  0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x3F, 0xFF,
  0x00, 0x00, 0x60, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x8F, 0xFE, 0x00,
  0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x0E, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0x7F, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xDF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x07,
  0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFD, 0xFF, 0x80, 0x3F, 0xE7, 0xF8,
  0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x03,
  0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xF3,
  0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE,
  0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x1F, 0xE1,
  0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F,
  0x83, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x83, 0xF8, 0x7F, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xE3, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xF9, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x7F, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xEF, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF3, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x78, 0x03, 0xFF, 0xC0, 0x01, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xC0, 0x00, 0x1F, 0xFC, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0xFE, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFD, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x7F, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF3, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x9F, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x83, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xF0, 0x00, 0x1F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0x00, 0x3F, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0xFF,
  0x9F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xFC, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x7F, 0x80,
  0x3F, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xFF,
  0xC0, 0x1F, 0xF7, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0xBF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x9F, 0xFF, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0xC0,
  0x0F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFE, 0x00,
  0x60, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x08, 0x0F, 0xFF, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x3F, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x7F, 0xE0, 0x03, 0xFF,
  0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xFF,
  0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0x03, 0xFF, 0x80, 0x03, 0x81, 0xFF, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x3F,
  0xC0, 0x0F, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xFF, 0xE7, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFB, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xF0,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFC,
  0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF3,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x04, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF,
  0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x1F, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x07, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xC3,
  0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0xFE, 0x00,
  0xFF, 0x3F, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0x83, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x0F, 0xFD,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xFF, 0x80, 0x00, 0xFE, 0x3F,
  0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xFD, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0xFC, 0x00, 0x7F, 0xCF, 0xFF,
  0xF0, 0x00, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xF9, 0xFF,
  0x00, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xFD, 0xFF, 0x80,
  0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x70, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF,
  0x01, 0xFF, 0x3F, 0xF8, 0x07, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xF0, 0x3F, 0xF0, 0x01, 0x80, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0xFF, 0xC3, 0x80, 0x07, 0xFF,
  0x0F, 0xC0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x10, 0x1F,
  0xFE, 0x78, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0xFC,
  0x7F, 0x80, 0x3F, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0x00, 0x0F,
  0xFC, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xE3, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0x7F, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFD, 0xFE,
  0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFE,
  0x7F, 0x83, 0xFF, 0x01, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x9F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xF8, 0xFF, 0x1F, 0xF8, 0x03,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFC,
  0x00, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x0F, 0xF3,
  0xFE, 0x00, 0x3F, 0xE7, 0xF0, 0x7F, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0x83,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xF8, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x07, 0xF7, 0xFC, 0x00, 0x1F,
  0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x01, 0xFD, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF3,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x8F, 0xFF, 0x00,
  0x00, 0xDF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x60, 0x00, 0xFF, 0xFF, 0x20, 0x00,
  0x1F, 0xFE, 0x10, 0x00, 0x00, 0xB8, 0x00,
};

const GFXglyph NotoSans_BoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 21, 50, 20, 1, -49 },
  { 133, 25, 18, 31, 7, -49 },
  { 190, 43, 49, 44, 1, -49 },
  { 454, 35, 56, 37, 2, -52 },
  { 699, 52, 50, 58, 4, -49 },
  { 1024, 45, 50, 48, 2, -49 },
  { 1306, 11, 18, 17, 7, -49 },
  { 1331, 26, 60, 23, 2, -49 },
  { 1526, 26, 60, 23, -5, -49 },
  { 1721, 32, 33, 37, 6, -52 },
  { 1853, 33, 33, 39, 4, -41 },
  { 1990, 16, 17, 20, -3, -8 },
  { 2024, 19, 8, 22, 1, -22 },
  { 2043, 11, 12, 20, 1, -11 },
  { 2060, 37, 49, 29, -3, -49 },
  { 2287, 35, 50, 37, 2, -49 },
  { 2506, 27, 49, 37, 6, -49 },
  { 2672, 38, 49, 37, -2, -49 },
  { 2905, 37, 50, 37, 0, -49 },
  { 3137, 38, 49, 37, -1, -49 },
  { 3370, 36, 50, 37, 1, -49 },
  { 3595, 35, 50, 37, 3, -49 },
  { 3814, 37, 49, 37, 3, -49 },
  { 4041, 35, 50, 37, 2, -49 },
  { 4260, 33, 50, 37, 3, -49 },
  { 4467, 18, 39, 20, 1, -38 },
  { 4555, 23, 47, 20, -4, -38 },
  { 4691, 33, 36, 39, 4, -43 },
  { 4840, 33, 20, 39, 4, -34 },
  { 4923, 33, 36, 39, 4, -43 },
  { 5072, 28, 50, 31, 5, -49 },
  { 5247, 55, 55, 58, 3, -49 },
  { 5626, 43, 49, 43, -4, -49 },
  { 5890, 40, 49, 42, 2, -49 },
  { 6135, 40, 50, 42, 4, -49 },
  { 6385, 42, 49, 46, 2, -49 },
  { 6643, 37, 49, 37, 2, -49 },
  { 6870, 37, 49, 36, 2, -49 },
  { 7097, 42, 50, 47, 4, -49 },
  { 7360, 46, 49, 48, 2, -49 },
  { 7642, 32, 49, 26, -2, -49 },
  { 7838, 34, 63, 23, -11, -49 },
  { 8106, 46, 49, 42, 2, -49 },
  { 8388, 29, 49, 35, 2, -49 },
  { 8566, 58, 49, 60, 2, -49 },
  { 8922, 50, 49, 52, 2, -49 },
  { 9229, 44, 50, 50, 4, -49 },
  { 9504, 40, 49, 41, 2, -49 },
  { 9749, 44, 61, 50, 4, -49 },
  { 10085, 38, 49, 42, 2, -49 },
  { 10318, 36, 50, 36, 1, -49 },
  { 10543, 35, 49, 36, 6, -49 },
  { 10758, 43, 50, 47, 5, -49 },
  { 11027, 40, 49, 40, 6, -49 },
  { 11272, 61, 49, 61, 6, -49 },
  { 11646, 51, 49, 41, -4, -49 },
  { 11959, 39, 49, 38, 6, -49 },
  { 12198, 42, 49, 36, -2, -49 },
  { 12456, 28, 60, 23, -1, -49 },
  { 12666, 17, 49, 29, 7, -49 },
  { 12771, 29, 60, 23, -5, -49 },
  { 12989, 35, 32, 37, 1, -49 },
  { 13129, 28, 5, 27, -6, 6 },
  { 13147, 14, 11, 22, 10, -52 },
  { 13167, 36, 39, 40, 3, -38 },
  { 13343, 36, 53, 40, 1, -52 },
  { 13582, 31, 39, 33, 3, -38 },
  { 13734, 39, 53, 40, 3, -52 },
  { 13993, 33, 39, 38, 3, -38 },
  { 14154, 40, 68, 25, -7, -52 },
  { 14494, 38, 54, 41, 1, -38 },
  { 14751, 37, 52, 41, 1, -52 },
  { 14992, 21, 52, 20, 1, -52 },
  { 15129, 31, 68, 20, -9, -52 },
  { 15393, 41, 52, 39, 1, -52 },
  { 15660, 21, 52, 20, 1, -52 },
  { 15797, 57, 38, 62, 1, -38 },
  { 16068, 37, 38, 41, 1, -38 },
  { 16244, 34, 39, 40, 3, -38 },
  { 16410, 39, 54, 40, -2, -38 },
  { 16674, 36, 54, 40, 3, -38 },
  { 16917, 30, 38, 29, 1, -38 },
  { 17060, 30, 39, 32, 1, -38 },
  { 17207, 26, 46, 28, 3, -45 },
  { 17357, 36, 38, 41, 4, -37 },
  { 17528, 36, 37, 35, 3, -37 },
  { 17695, 53, 37, 54, 4, -37 },
  { 17941, 43, 37, 36, -3, -37 },
  { 18140, 44, 53, 35, -5, -37 },
  { 18432, 34, 37, 32, -1, -37 },
  { 18590, 28, 60, 24, 0, -49 },
  { 18800, 7, 66, 37, 15, -51 },
  { 18858, 27, 60, 24, -3, -49 },
  { 19061, 33, 12, 39, 4, -30 },
};

const GFXfont NotoSans_BoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_BOLDITALIC68PT7B_H_
