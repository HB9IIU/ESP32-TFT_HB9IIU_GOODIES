#ifndef _NOTOSANS_BOLDITALIC30PT7B_H_
#define _NOTOSANS_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x0F,
  0xC3, 0xE0, 0x78, 0x00, 0x79, 0xEF, 0x39, 0xC7, 0x79, 0xEF, 0x3D, 0xC7,
  0x38, 0xE0, 0x01, 0xE7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE7, 0x80,
  0x38, 0xE0, 0x07, 0x1C, 0x5F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0,
  0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x1C, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x9E, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x07, 0x9E, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x3F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xCF, 0xB3, 0x1E, 0x60, 0x3C, 0xC0, 0x7D, 0x80, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0x9E, 0x03, 0x3D,
  0x86, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x07, 0xF0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x08, 0x7F, 0x00, 0xE0, 0xFF, 0x03, 0x83,
  0xDE, 0x0F, 0x0F, 0x3C, 0x3C, 0x1E, 0x78, 0x70, 0x3C, 0xF1, 0xC0, 0x71,
  0xE7, 0x80, 0xE3, 0xDE, 0x01, 0xCF, 0x39, 0xF3, 0xFE, 0xE7, 0xF7, 0xFB,
  0xDF, 0xE7, 0xEF, 0x79, 0xE3, 0x1C, 0xF3, 0xC0, 0x71, 0xC7, 0x81, 0xE7,
  0x8E, 0x07, 0x8F, 0x1C, 0x0E, 0x1E, 0x78, 0x3C, 0x3C, 0xF0, 0xF0, 0x7F,
  0xC3, 0xC0, 0x7F, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E,
  0x00, 0xF3, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x01, 0xFE,
  0x1F, 0x3F, 0xF1, 0xE7, 0xDF, 0x3E, 0xF8, 0xFF, 0xCF, 0x87, 0xF8, 0xF8,
  0x7F, 0x8F, 0x83, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xFC, 0x7C, 0x7B, 0xDD, 0xEF, 0x73, 0x80, 0x01, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x03, 0x80, 0x78, 0x0F, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x38, 0x10, 0xE0, 0xF3, 0x83, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0x1F,
  0xFC, 0xFE, 0x07, 0xFC, 0x3E, 0x70, 0x31, 0xE0, 0x47, 0x80, 0x10, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x3E, 0x79, 0xE3, 0xC7, 0x1E, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x33, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7,
  0xC3, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0x78, 0x3E, 0xF0, 0x7D, 0xF1, 0xF3,
  0xF7, 0xE3, 0xFF, 0x87, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x1F,
  0xE3, 0xFE, 0xFF, 0xEF, 0xBC, 0x73, 0xC4, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF0, 0x70, 0xF8, 0x30, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE7, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0E,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x80, 0x3E, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xDE, 0x07, 0xBC, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x7C, 0x78,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x80, 0x1F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x80, 0x7C, 0x7D, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7D, 0xF0, 0x7B, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFC, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C,
  0x78, 0x7C, 0x7D, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF,
  0x9F, 0xFF, 0x8F, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x1E, 0x1E, 0x1F, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F,
  0x7C, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x7C, 0xF8,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F,
  0xF0, 0x1F, 0xE0, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3,
  0xEF, 0x87, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x7D, 0xF1, 0xFB,
  0xFF, 0xF3, 0xFF, 0xC3, 0xF7, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE3, 0x1F, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x06, 0x1F, 0x1F,
  0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8,
  0xF8, 0xF8, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x41, 0xE0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F,
  0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x7C, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x03,
  0xE0, 0x0E, 0x00, 0x20, 0x00, 0x07, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xE3,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1E, 0x01,
  0xF8, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x07,
  0xF0, 0xFC, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x0F, 0x1C, 0x07, 0x0F, 0x3C,
  0x3F, 0xE7, 0x38, 0xFF, 0xC7, 0x78, 0xF1, 0xC7, 0x71, 0xE3, 0xC7, 0x71,
  0xC3, 0x87, 0xF3, 0xC3, 0x87, 0xF3, 0xC3, 0x8F, 0xF3, 0x87, 0x8E, 0xF3,
  0xCF, 0x9E, 0xF3, 0xFF, 0xFC, 0x71, 0xFB, 0xF8, 0x78, 0xF1, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x01, 0xE7, 0x00, 0x3C, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF0, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x1E, 0x0F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xE3, 0xE3, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x3E, 0x3C, 0x1E,
  0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0x78, 0x3E, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0x83, 0x0F, 0xC0, 0x47, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7C, 0x7E, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xDF,
  0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x7E, 0x78, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xC3, 0x8F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x87, 0xFB, 0xE1, 0xFE, 0xF0, 0x7F, 0xBC,
  0x3F, 0xEF, 0x00, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3F, 0x07, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x81, 0xF0, 0xF0,
  0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1E,
  0x03, 0xE1, 0xE0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0x80, 0xF8,
  0x78, 0x0F, 0x87, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x6F, 0xE0, 0xFF,
  0x81, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0xF0, 0x7E, 0x0F, 0x0F,
  0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1E, 0x7C, 0x01, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3E,
  0xF0, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07,
  0x83, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x1F, 0x00, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xE0,
  0x77, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E, 0xF0, 0x7F, 0x87, 0xBC, 0x3D,
  0xE1, 0xCF, 0x0F, 0x78, 0xF7, 0x83, 0xDE, 0x39, 0xE0, 0xF3, 0x9E, 0x78,
  0x3C, 0xE7, 0x1E, 0x1E, 0x3B, 0xCF, 0x87, 0x8E, 0xE3, 0xC1, 0xE3, 0xF8,
  0xF0, 0x78, 0xFC, 0x3C, 0x1E, 0x3F, 0x0F, 0x0F, 0x0F, 0x87, 0xC3, 0xC3,
  0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x0F, 0xC0, 0x3C, 0x3F, 0x01, 0xF0,
  0xFC, 0x07, 0x87, 0xF8, 0x1E, 0x1F, 0xE0, 0x78, 0x7F, 0x83, 0xE1, 0xEF,
  0x0F, 0x07, 0xBC, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xE3, 0xC3, 0xC7, 0x9F,
  0x0F, 0x1E, 0x78, 0x3C, 0x7D, 0xE1, 0xE0, 0xF7, 0x87, 0x83, 0xDE, 0x1E,
  0x0F, 0xF8, 0x78, 0x1F, 0xC3, 0xE0, 0x7F, 0x0F, 0x01, 0xFC, 0x3C, 0x03,
  0xF0, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xF8, 0xFC, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x78,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xBC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x83, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xE3, 0xE3, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x3E, 0x0F, 0x9F, 0x3F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0xFC, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0,
  0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x83,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x78, 0x3E, 0x3C, 0x1F, 0x3E, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x03, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF8, 0xFF, 0xE3, 0xF0, 0xC7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF9, 0x01, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x83, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xE3, 0xC0,
  0x7C, 0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x8F, 0x01,
  0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07,
  0x8F, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x3E,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x0F,
  0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1,
  0xF1, 0xE0, 0xF0, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07,
  0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xFE, 0x07,
  0xC0, 0xFB, 0xC0, 0xF8, 0x1E, 0x78, 0x3F, 0x07, 0xCF, 0x07, 0xE0, 0xF1,
  0xE1, 0xFC, 0x1E, 0x3C, 0x3F, 0x87, 0xC7, 0x87, 0x70, 0xF0, 0xF1, 0xEE,
  0x3E, 0x1E, 0x39, 0xC7, 0x83, 0xCF, 0x38, 0xF0, 0x79, 0xE7, 0x3C, 0x0F,
  0x78, 0xE7, 0x81, 0xEF, 0x1D, 0xE0, 0x3D, 0xC3, 0xBC, 0x07, 0xF8, 0x77,
  0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x07, 0xC1, 0xF0,
  0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00,
  0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF3,
  0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0x1E,
  0x0F, 0x8F, 0x0F, 0x87, 0x87, 0x83, 0xE7, 0xC0, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x00, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xF1, 0xE3,
  0xC7, 0x8F, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xDC, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xF3, 0xC0, 0xE7, 0x01,
  0xDE, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0,
  0x03, 0x80, 0x0F, 0xEF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x3F, 0x7C, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xFD, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0x78, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x30,
  0x1E, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x1E, 0x3E, 0x1F, 0x3C, 0x1F,
  0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x7C,
  0xFC, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xE7, 0xE0, 0x01, 0xE0, 0x1F, 0xF1,
  0xFF, 0x87, 0xFE, 0x3E, 0x09, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x11, 0xFB, 0x87, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x18, 0xF0, 0x3F, 0xBC, 0x1F, 0xEF, 0x07, 0xFF,
  0xC3, 0xE3, 0xE1, 0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xE3,
  0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x87, 0xC1, 0xF3, 0xF0, 0x7F,
  0xF8, 0x1F, 0xEE, 0x03, 0xF7, 0x80, 0x00, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xF3, 0xE1, 0xEF, 0x83, 0xDF, 0x0F, 0xBD, 0xFE, 0xFF, 0xF9, 0xFF,
  0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x87, 0x1F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x0B, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0xEF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x3F, 0x7C, 0x1E, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xFD, 0xFC, 0x7F, 0xF8, 0x7F, 0x78, 0x3E, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x80, 0xF0, 0xE3, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x38,
  0x1E, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E,
  0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C,
  0xF8, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0x07, 0x07, 0xC3, 0xE1,
  0xE0, 0x20, 0x00, 0x04, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1,
  0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC0, 0x00, 0x38,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x0B, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x04, 0x78, 0x3E, 0x1E, 0x1F, 0x0F,
  0x8F, 0x83, 0xE7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x0F, 0x8F, 0x03, 0xE3, 0xE0,
  0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x07, 0xC0, 0x0F, 0x87, 0xC3, 0xC1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0,
  0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC0, 0x00, 0x38, 0x0C,
  0x0E, 0x7E, 0x3F, 0x87, 0x7F, 0xBF, 0xC7, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8,
  0xF9, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x3C, 0x78, 0x3C, 0x1E, 0x7C, 0x1E,
  0x0F, 0x3E, 0x1F, 0x0F, 0x9E, 0x0F, 0x87, 0xCF, 0x07, 0x83, 0xEF, 0x83,
  0xC1, 0xE7, 0xC3, 0xE0, 0xF3, 0xC1, 0xF0, 0xF9, 0xE0, 0xF0, 0x7C, 0xF0,
  0x78, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0xFC, 0x1D, 0xFE, 0x3F, 0xFE, 0x3F,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78,
  0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0,
  0x78, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xEF, 0x83,
  0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF,
  0x87, 0xCF, 0x9F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x0C, 0x01,
  0xCF, 0xC0, 0x77, 0xF8, 0x3F, 0xFE, 0x0F, 0xC7, 0x83, 0xE1, 0xF0, 0xF0,
  0x7C, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0x78, 0x3E,
  0x3E, 0x1F, 0x0F, 0xCF, 0xC3, 0xFF, 0xE0, 0xF7, 0xF0, 0x3D, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x01, 0x80, 0x0F, 0xE7, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E,
  0x3F, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8,
  0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0x7C, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3E,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x00, 0x38, 0xF7, 0xC7, 0x7C, 0x7F, 0xE3, 0xFF, 0x1F,
  0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFE, 0x3E, 0x08, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF3, 0x07, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F,
  0x80, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x3F, 0xF7, 0xFE, 0xFF, 0xE3,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x7C, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x3C, 0x1F, 0x7C, 0x1E, 0x7C,
  0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF,
  0x70, 0x7E, 0x70, 0xF8, 0x1F, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x7C, 0x78,
  0x78, 0x78, 0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x39, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF0,
  0x7C, 0x3F, 0xE1, 0xF8, 0x7B, 0xC3, 0xF1, 0xF7, 0x8E, 0xE3, 0xCF, 0x1D,
  0xCF, 0x9E, 0x7B, 0x9E, 0x3C, 0xEF, 0x3C, 0x79, 0xDE, 0xF0, 0xF7, 0xBD,
  0xE1, 0xEE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8,
  0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0xF8, 0xF8, 0x1F, 0x3E, 0x01, 0xE7, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xDE, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x87, 0xC7, 0xE0, 0xF8, 0x1F,
  0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x1E,
  0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x5F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC1, 0xFC, 0x0F, 0x80, 0x7E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0xC0, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x07,
  0x80, 0x00, 0x7C, 0x07, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0x80, 0xF0,
};

const GFXglyph NotoSans_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 21, 9, 0, -21 },
  { 28, 11, 7, 14, 3, -21 },
  { 38, 19, 21, 19, 1, -21 },
  { 88, 15, 25, 17, 1, -23 },
  { 135, 23, 22, 26, 2, -22 },
  { 199, 20, 22, 21, 1, -22 },
  { 254, 5, 7, 8, 3, -21 },
  { 259, 11, 26, 10, 1, -21 },
  { 295, 11, 27, 10, -2, -22 },
  { 333, 14, 15, 16, 3, -23 },
  { 360, 14, 15, 17, 2, -18 },
  { 387, 7, 7, 9, -1, -3 },
  { 394, 8, 4, 10, 1, -10 },
  { 398, 5, 5, 9, 0, -5 },
  { 402, 16, 22, 13, -1, -22 },
  { 446, 15, 22, 17, 1, -22 },
  { 488, 12, 21, 17, 3, -21 },
  { 520, 17, 22, 17, -1, -22 },
  { 567, 16, 22, 17, 0, -22 },
  { 611, 16, 21, 17, 0, -21 },
  { 653, 17, 21, 17, 0, -21 },
  { 698, 16, 22, 17, 1, -22 },
  { 742, 17, 21, 17, 1, -21 },
  { 787, 16, 22, 17, 1, -22 },
  { 831, 15, 22, 17, 1, -22 },
  { 873, 8, 17, 9, 0, -17 },
  { 890, 10, 21, 9, -2, -17 },
  { 917, 14, 16, 17, 2, -19 },
  { 945, 14, 9, 17, 2, -15 },
  { 961, 14, 16, 17, 2, -19 },
  { 989, 13, 22, 14, 2, -22 },
  { 1025, 24, 24, 26, 1, -21 },
  { 1097, 19, 21, 19, -2, -21 },
  { 1147, 17, 21, 19, 1, -21 },
  { 1192, 18, 22, 18, 2, -22 },
  { 1242, 18, 21, 20, 1, -21 },
  { 1290, 16, 21, 16, 1, -21 },
  { 1332, 16, 21, 16, 1, -21 },
  { 1374, 18, 22, 21, 2, -22 },
  { 1424, 20, 21, 21, 1, -21 },
  { 1477, 14, 21, 11, -1, -21 },
  { 1514, 15, 27, 10, -5, -21 },
  { 1565, 20, 21, 18, 1, -21 },
  { 1618, 13, 21, 16, 1, -21 },
  { 1653, 26, 21, 26, 1, -21 },
  { 1722, 22, 21, 23, 1, -21 },
  { 1780, 19, 22, 22, 2, -22 },
  { 1833, 17, 21, 18, 1, -21 },
  { 1878, 19, 27, 22, 2, -22 },
  { 1943, 17, 21, 19, 1, -21 },
  { 1988, 15, 22, 16, 1, -22 },
  { 2030, 16, 21, 16, 2, -21 },
  { 2072, 19, 21, 21, 2, -21 },
  { 2122, 17, 21, 18, 3, -21 },
  { 2167, 27, 21, 27, 3, -21 },
  { 2238, 23, 21, 18, -2, -21 },
  { 2299, 17, 21, 17, 3, -21 },
  { 2344, 19, 21, 16, -1, -21 },
  { 2394, 13, 26, 10, -1, -21 },
  { 2437, 7, 22, 13, 3, -22 },
  { 2457, 12, 26, 10, -2, -21 },
  { 2496, 15, 14, 17, 1, -22 },
  { 2523, 13, 2, 12, -3, 3 },
  { 2527, 7, 5, 10, 4, -23 },
  { 2532, 16, 17, 18, 1, -17 },
  { 2566, 16, 23, 18, 1, -23 },
  { 2612, 14, 17, 15, 1, -17 },
  { 2642, 18, 23, 18, 1, -23 },
  { 2694, 15, 17, 17, 1, -17 },
  { 2726, 18, 30, 11, -3, -23 },
  { 2794, 16, 24, 18, 1, -17 },
  { 2842, 16, 23, 18, 1, -23 },
  { 2888, 9, 23, 9, 1, -23 },
  { 2914, 14, 30, 9, -4, -23 },
  { 2967, 18, 23, 17, 1, -23 },
  { 3019, 9, 23, 9, 1, -23 },
  { 3045, 25, 17, 27, 1, -17 },
  { 3099, 16, 17, 18, 1, -17 },
  { 3133, 15, 17, 18, 1, -17 },
  { 3165, 18, 24, 18, -1, -17 },
  { 3219, 16, 24, 18, 1, -17 },
  { 3267, 13, 17, 13, 1, -17 },
  { 3295, 14, 17, 14, 0, -17 },
  { 3325, 12, 20, 12, 1, -20 },
  { 3355, 16, 16, 18, 2, -16 },
  { 3387, 16, 16, 15, 1, -16 },
  { 3419, 23, 16, 24, 2, -16 },
  { 3465, 19, 16, 16, -2, -16 },
  { 3503, 19, 23, 16, -2, -16 },
  { 3558, 15, 16, 14, -1, -16 },
  { 3588, 13, 26, 11, 0, -21 },
  { 3631, 3, 30, 17, 7, -23 },
  { 3643, 13, 26, 11, -2, -21 },
  { 3686, 14, 5, 17, 2, -13 },
};

const GFXfont NotoSans_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_BOLDITALIC30PT7B_H_
