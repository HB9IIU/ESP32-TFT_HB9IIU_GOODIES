#ifndef _NOTOSANS_BOLDITALIC44PT7B_H_
#define _NOTOSANS_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x04, 0x00, 0x3F, 0x3F, 0x9F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE7, 0x38,
  0x1F, 0x9C, 0x10, 0x7F, 0x38, 0x00, 0xFE, 0x70, 0x01, 0xFC, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0x7F, 0x00, 0x0E, 0x7E, 0x00, 0x38, 0xFC, 0xC0, 0x73, 0xF9, 0xF0, 0xEF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0x80, 0xFF, 0xE0, 0x07, 0xC0, 0x7F, 0xF8, 0x03, 0xE0, 0x3F,
  0xFE, 0x01, 0xF0, 0x0F, 0xCF, 0xC0, 0x7C, 0x03, 0xE3, 0xF0, 0x3E, 0x01,
  0xF8, 0xFC, 0x1F, 0x00, 0x7C, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x83, 0xE0,
  0x07, 0xC3, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0xF8, 0x00, 0xFC, 0x7E, 0x7E,
  0x00, 0x3F, 0x1F, 0x1F, 0x3F, 0x87, 0xCF, 0xCF, 0x9F, 0xF9, 0xFF, 0xF7,
  0xCF, 0xFE, 0x7F, 0xFB, 0xF7, 0xFF, 0xCF, 0xFC, 0xF9, 0xFB, 0xF3, 0xFE,
  0x7C, 0xFC, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x87, 0xC0,
  0x07, 0xC7, 0xE1, 0xF0, 0x03, 0xE1, 0xF8, 0xFC, 0x01, 0xF0, 0x7C, 0x3F,
  0x00, 0x7C, 0x1F, 0x0F, 0x80, 0x3E, 0x07, 0xC3, 0xE0, 0x1F, 0x01, 0xF1,
  0xF8, 0x0F, 0x80, 0x7E, 0xFC, 0x03, 0xE0, 0x1F, 0xFF, 0x01, 0xF0, 0x03,
  0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x07, 0xFF,
  0x01, 0xF8, 0x3F, 0xFE, 0x0F, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xE7, 0xF1,
  0xFC, 0x7F, 0x0F, 0xE7, 0xE1, 0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0x7F, 0xFC,
  0x3F, 0x80, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0x83, 0xF8, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x38, 0x3E, 0x01, 0xE1,
  0xE0, 0x1F, 0xCF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFE, 0x0C, 0x7E, 0xF0, 0x07, 0xF7,
  0x80, 0x7F, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x18, 0x3F, 0x00,
  0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0x1C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x30, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0x7E, 0x07, 0xF0, 0xFC, 0x1F,
  0xE1, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0x7E, 0x7F,
  0x7F, 0x3E, 0x3F, 0x0E, 0x1F, 0x84, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0x80,
  0x7F, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xC0,
  0xFF, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x80, 0x03, 0xF8, 0xF0, 0x0F,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x80, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0E, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x80, 0x0F, 0xF1, 0xC0, 0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xF3, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF3, 0xF8,
  0x0F, 0xDF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0x0F, 0xE3, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F,
  0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFC,
  0x0F, 0xC3, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xBF, 0xC1, 0xFC,
  0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x00,
  0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x0F, 0xE3, 0xFE, 0xFF,
  0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xF7, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x01,
  0xFD, 0xFC, 0x1F, 0xEF, 0xF1, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x3F, 0xF7, 0xE0, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x20, 0x3F, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0,
  0x30, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x7F, 0x8E, 0x03, 0xF9,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0xFF, 0x03, 0xE3, 0xE0, 0x7F, 0xFC, 0x7C, 0xF8, 0x1F,
  0xFF, 0x0F, 0x9F, 0x07, 0xFF, 0xE1, 0xF7, 0xC1, 0xF8, 0x7C, 0x3E, 0xF8,
  0x7E, 0x0F, 0x87, 0xDE, 0x0F, 0x81, 0xE0, 0xFF, 0xC3, 0xE0, 0x7C, 0x1F,
  0xF8, 0x7C, 0x0F, 0x83, 0xFF, 0x0F, 0x81, 0xF0, 0x7F, 0xE3, 0xE0, 0x7C,
  0x1F, 0x7C, 0x7C, 0x0F, 0x83, 0xEF, 0x8F, 0x83, 0xF0, 0xFD, 0xF0, 0xF8,
  0x7E, 0x1F, 0x3E, 0x1F, 0xBF, 0xEF, 0xC7, 0xC3, 0xFF, 0xFF, 0xF8, 0xFC,
  0x3F, 0xEF, 0xFE, 0x0F, 0x83, 0xF8, 0xFF, 0x01, 0xF0, 0x0C, 0x03, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0x00, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x81,
  0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0xF0, 0x7F, 0x80, 0x08, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x04, 0x07, 0xFC, 0x1F, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xE0, 0xFF, 0x81, 0xFC,
  0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xF8, 0x07, 0xF8, 0x3F,
  0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0x00, 0xE0, 0xFF, 0x80, 0x04, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0xE7, 0xF0, 0x3F, 0xFC, 0xFE,
  0x07, 0xFF, 0x9F, 0xC0, 0xFF, 0xF3, 0xF0, 0x3F, 0xFC, 0x7E, 0x07, 0xFF,
  0x8F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF0, 0xFF, 0x00, 0x7E, 0x1F, 0xE0, 0x1F, 0xC1, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x07,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0C, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x07,
  0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x8F, 0xF0, 0x00,
  0xFE, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0xFD, 0xF0, 0x1F,
  0xBF, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0x3F,
  0x7C, 0x0F, 0x9F, 0x80, 0xFD, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xC1, 0xF1,
  0xF8, 0x1F, 0x9F, 0x0F, 0xCF, 0xC0, 0x7E, 0x3E, 0x3E, 0x3F, 0x01, 0xF8,
  0xF9, 0xF8, 0xFC, 0x07, 0xC3, 0xE7, 0xC3, 0xF0, 0x3F, 0x0F, 0xBF, 0x1F,
  0xC0, 0xFC, 0x3E, 0xF8, 0x7E, 0x03, 0xF0, 0xFF, 0xE1, 0xF8, 0x0F, 0xC3,
  0xFF, 0x07, 0xE0, 0x3E, 0x0F, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xE0, 0xFC,
  0x07, 0xE0, 0xFF, 0x83, 0xF0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0x80,
  0x0F, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x3F, 0xF8,
  0x03, 0xF0, 0x1F, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x07, 0xDF,
  0x80, 0x7E, 0x03, 0xEF, 0xE0, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x01, 0xF9,
  0xF8, 0x1F, 0x80, 0xFC, 0xFE, 0x0F, 0xC0, 0x7E, 0x3F, 0x07, 0xE0, 0x3F,
  0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xE3, 0xF0, 0x1F, 0x83, 0xF1, 0xF8, 0x0F,
  0xC1, 0xF8, 0xFC, 0x07, 0xE0, 0xFE, 0x7E, 0x03, 0xF0, 0x3F, 0x7E, 0x03,
  0xF0, 0x1F, 0xBF, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0,
  0x7E, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x3F, 0xF0,
  0x1F, 0x80, 0x1F, 0xF8, 0x0F, 0xC0, 0x0F, 0xFC, 0x07, 0xE0, 0x03, 0xFC,
  0x07, 0xE0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xEF, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x1F, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xF1,
  0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x06, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1,
  0x80, 0x1F, 0xC3, 0xC0, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x83,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x87, 0xE0,
  0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF8,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x8F,
  0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x0F,
  0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0xC0,
  0x7F, 0x3F, 0x00, 0xFF, 0x80, 0xFC, 0x7E, 0x03, 0xFF, 0x01, 0xF8, 0xFC,
  0x07, 0xFE, 0x07, 0xF1, 0xF8, 0x1F, 0x7C, 0x0F, 0xC3, 0xF0, 0x3E, 0xF8,
  0x3F, 0x87, 0xE0, 0xFD, 0xF0, 0x7E, 0x0F, 0xC1, 0xF3, 0xE1, 0xFC, 0x1F,
  0x87, 0xE7, 0xC3, 0xF0, 0x3F, 0x0F, 0xCF, 0x87, 0xE0, 0x7E, 0x1F, 0x1F,
  0x1F, 0x80, 0xFC, 0x7E, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x7C, 0xFE, 0x01,
  0xF3, 0xF0, 0xF9, 0xF8, 0x03, 0xE7, 0xC1, 0xF3, 0xF0, 0x07, 0xDF, 0x83,
  0xEF, 0xC0, 0x0F, 0xBE, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x0F, 0xBE, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x9F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F,
  0x87, 0xF0, 0x3F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xE0,
  0x07, 0xCF, 0x80, 0x3F, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0xF8, 0x0F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03,
  0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x01, 0xFE, 0x3E, 0x07, 0xFE, 0x7C, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0x8F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE,
  0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF,
  0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xF8, 0x0F, 0xE3, 0xE0, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xCF, 0xE0, 0x1F, 0xBF, 0xE0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0,
  0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0xFE, 0x03,
  0xF9, 0xFC, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7C, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFE, 0x0C,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x08, 0xFF, 0x03, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0x9F, 0x80, 0xFF, 0xEF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x7F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0x80, 0x7F, 0xE7,
  0xC0, 0x1F, 0xE7, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0x3F, 0x8F, 0xE0, 0xFC, 0xFE, 0x07, 0xEF,
  0xE0, 0x3F, 0x7F, 0x03, 0xFB, 0xF0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x30, 0xFF, 0xBF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFE, 0x60, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x1F, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFB, 0xF0, 0x1F, 0xF7, 0xF0, 0x0F, 0xE7, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xC0,
  0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xCF,
  0xF0, 0x1F, 0xBF, 0xF0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0x3F, 0x1F, 0xE0, 0x7E, 0x3F, 0x80, 0xFC,
  0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xF0,
  0x7E, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xF0, 0xFF,
  0x00, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xE7,
  0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0,
  0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F,
  0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFC,
  0x03, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xC7, 0xF8,
  0x1F, 0xC0, 0x3E, 0x7F, 0xE3, 0xFF, 0x03, 0xF7, 0xFF, 0x3F, 0xFC, 0x1F,
  0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0xE1,
  0xFC, 0x7F, 0x83, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFF, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x80, 0xFC,
  0x7F, 0x01, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x80, 0xFC, 0x7F,
  0x01, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x81, 0xFC, 0x7F, 0x01,
  0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x07, 0xC7, 0xF8, 0x0F, 0x9F, 0xF8, 0x3F, 0x7F, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xC7, 0xF8, 0x1F, 0x8F, 0xF0, 0x3F, 0x1F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF,
  0x0F, 0xE3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xF0,
  0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0xF9, 0xFF, 0x00, 0xFD, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07,
  0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFB, 0xFF, 0xC0,
  0xFC, 0xFF, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3E, 0x07, 0xFE, 0x7C, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x07,
  0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFC,
  0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xFC, 0x3F, 0x87,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0xFC, 0x0F, 0xFB, 0xF8, 0x0F,
  0xE7, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC7,
  0xE0, 0xF9, 0xFC, 0x3F, 0x7F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xE3, 0xE1, 0xFC, 0x04, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x10, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFB, 0xE0,
  0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xC3, 0xE0, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F,
  0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x7E, 0x01, 0xF1, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF,
  0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x03,
  0xFC, 0x07, 0xEF, 0xC0, 0xFF, 0x03, 0xFB, 0xF0, 0x7F, 0xC0, 0xFC, 0xFC,
  0x1F, 0xF0, 0x7F, 0x3F, 0x07, 0xFC, 0x1F, 0x8F, 0xC3, 0xFF, 0x0F, 0xE3,
  0xF0, 0xFF, 0xC3, 0xF0, 0xFC, 0x7D, 0xF0, 0xFC, 0x3F, 0x1F, 0x7C, 0x7E,
  0x0F, 0xCF, 0xDF, 0x1F, 0x83, 0xF3, 0xE7, 0xCF, 0xC0, 0xFC, 0xF9, 0xF3,
  0xF0, 0x3F, 0x7C, 0x7D, 0xFC, 0x0F, 0xDF, 0x1F, 0x7E, 0x03, 0xF7, 0x87,
  0xDF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0x87, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC1,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xC0, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xE8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 32, 13, 0, -31 },
  { 57, 17, 11, 20, 4, -31 },
  { 81, 28, 31, 28, 1, -31 },
  { 190, 23, 36, 24, 1, -33 },
  { 294, 34, 32, 38, 2, -32 },
  { 430, 30, 32, 31, 1, -32 },
  { 550, 8, 11, 11, 4, -31 },
  { 561, 16, 38, 15, 2, -31 },
  { 637, 16, 39, 15, -3, -32 },
  { 715, 21, 22, 24, 4, -34 },
  { 773, 22, 21, 25, 2, -26 },
  { 831, 10, 11, 13, -2, -5 },
  { 845, 12, 6, 14, 1, -15 },
  { 854, 8, 8, 13, 0, -7 },
  { 862, 24, 32, 19, -2, -32 },
  { 958, 23, 32, 24, 1, -32 },
  { 1050, 17, 31, 24, 4, -31 },
  { 1116, 25, 32, 24, -1, -32 },
  { 1216, 24, 32, 24, 0, -32 },
  { 1312, 25, 31, 24, -1, -31 },
  { 1409, 23, 31, 24, 1, -31 },
  { 1499, 23, 32, 24, 2, -32 },
  { 1591, 24, 31, 24, 2, -31 },
  { 1684, 23, 32, 24, 1, -32 },
  { 1776, 21, 32, 24, 2, -32 },
  { 1860, 12, 25, 13, 0, -24 },
  { 1898, 14, 30, 13, -2, -24 },
  { 1951, 22, 24, 25, 2, -28 },
  { 2017, 22, 13, 25, 2, -22 },
  { 2053, 22, 24, 25, 2, -28 },
  { 2119, 19, 33, 20, 3, -32 },
  { 2198, 35, 35, 38, 2, -31 },
  { 2352, 28, 31, 28, -3, -31 },
  { 2461, 26, 31, 27, 1, -31 },
  { 2562, 26, 32, 27, 3, -32 },
  { 2666, 27, 31, 30, 1, -31 },
  { 2771, 24, 31, 24, 1, -31 },
  { 2864, 24, 31, 23, 1, -31 },
  { 2957, 27, 32, 30, 3, -32 },
  { 3065, 30, 31, 31, 1, -31 },
  { 3182, 20, 31, 17, -1, -31 },
  { 3260, 22, 40, 15, -7, -31 },
  { 3370, 30, 31, 27, 1, -31 },
  { 3487, 19, 31, 23, 1, -31 },
  { 3561, 38, 31, 39, 1, -31 },
  { 3709, 33, 31, 33, 1, -31 },
  { 3837, 28, 32, 32, 3, -32 },
  { 3949, 26, 31, 27, 1, -31 },
  { 4050, 28, 39, 32, 3, -32 },
  { 4187, 25, 31, 27, 1, -31 },
  { 4284, 23, 32, 23, 1, -32 },
  { 4376, 23, 31, 23, 4, -31 },
  { 4466, 28, 31, 30, 3, -31 },
  { 4575, 26, 31, 26, 4, -31 },
  { 4676, 39, 31, 39, 4, -31 },
  { 4828, 33, 31, 27, -3, -31 },
  { 4956, 25, 31, 25, 4, -31 },
  { 5053, 27, 31, 24, -1, -31 },
  { 5158, 19, 38, 15, -1, -31 },
  { 5249, 10, 32, 19, 5, -32 },
  { 5289, 18, 38, 15, -3, -31 },
  { 5375, 22, 21, 24, 1, -32 },
  { 5433, 18, 3, 18, -4, 4 },
  { 5440, 10, 7, 14, 6, -34 },
  { 5449, 23, 24, 26, 2, -24 },
  { 5518, 23, 33, 26, 1, -33 },
  { 5613, 20, 24, 21, 2, -24 },
  { 5673, 25, 33, 26, 2, -33 },
  { 5777, 21, 24, 25, 2, -24 },
  { 5840, 26, 45, 16, -5, -34 },
  { 5987, 24, 35, 26, 1, -24 },
  { 6092, 23, 33, 27, 1, -33 },
  { 6187, 13, 33, 13, 1, -33 },
  { 6241, 20, 44, 13, -6, -33 },
  { 6351, 26, 33, 25, 1, -33 },
  { 6459, 13, 33, 13, 1, -33 },
  { 6513, 37, 24, 40, 1, -24 },
  { 6624, 23, 24, 27, 1, -24 },
  { 6693, 22, 24, 26, 2, -24 },
  { 6759, 25, 35, 26, -1, -24 },
  { 6869, 23, 35, 26, 2, -24 },
  { 6970, 19, 24, 19, 1, -24 },
  { 7027, 20, 24, 21, 0, -24 },
  { 7087, 17, 29, 18, 2, -29 },
  { 7149, 24, 24, 27, 2, -24 },
  { 7221, 23, 24, 23, 2, -24 },
  { 7290, 34, 24, 35, 3, -24 },
  { 7392, 28, 24, 24, -2, -24 },
  { 7476, 28, 35, 23, -3, -24 },
  { 7599, 22, 24, 21, -1, -24 },
  { 7665, 18, 38, 16, 0, -31 },
  { 7751, 4, 43, 24, 10, -33 },
  { 7773, 18, 38, 16, -2, -31 },
  { 7859, 22, 7, 25, 2, -19 },
};

const GFXfont NotoSans_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_BOLDITALIC44PT7B_H_
