#ifndef _NOTOSANS_BOLDITALIC43PT7B_H_
#define _NOTOSANS_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x04, 0x00, 0x3F, 0x3F, 0x3E,
  0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x78,
  0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0,
  0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x78,
  0x3C, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x03, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x01, 0xE1, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0x9C, 0x70, 0x7F, 0x38, 0x00,
  0xFE, 0x70, 0x01, 0xFD, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0x7F, 0x00, 0x1C, 0xFE, 0x00, 0x39,
  0xFC, 0x80, 0x73, 0xF9, 0xE0, 0xEF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x3E,
  0x03, 0xFF, 0xC0, 0x3E, 0x03, 0xF3, 0xE0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x01, 0xF8, 0xF8, 0x1F, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x0F,
  0x80, 0x3E, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x8F, 0x80, 0x1F, 0x8F, 0xCF,
  0x80, 0x0F, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7, 0xCF, 0xF1, 0xF3, 0xE7,
  0xCF, 0xFC, 0xFF, 0xF7, 0xCF, 0xFF, 0x7F, 0xF3, 0xEF, 0xFF, 0x9F, 0xF3,
  0xE7, 0xC7, 0xC7, 0xF3, 0xE7, 0xE3, 0xE0, 0x03, 0xE3, 0xE1, 0xF0, 0x01,
  0xF1, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x3E, 0x01,
  0xF0, 0x7E, 0x3F, 0x00, 0xF8, 0x3F, 0x1F, 0x00, 0xF8, 0x1F, 0x8F, 0x80,
  0xF8, 0x07, 0xCF, 0xC0, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0xC0,
  0x7C, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0x0F, 0xFF, 0x03, 0xF0, 0xFF, 0xFC,
  0x3F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFE, 0x3F, 0x9F, 0xC7, 0xF0, 0xFE, 0xFC,
  0x3F, 0x03, 0xFF, 0xC3, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0x7F, 0xE0, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xE0, 0x3F, 0xF8, 0x7F,
  0x80, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x40, 0x7C, 0x07, 0x07, 0x80, 0x7C,
  0x78, 0x0F, 0xF7, 0x80, 0xFF, 0xF7, 0xF7, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFB, 0xF0, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF3, 0xC0,
  0x7E, 0x3E, 0x03, 0xE3, 0xE0, 0x0C, 0x3F, 0x00, 0x81, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x0C, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7E, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03,
  0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xF7,
  0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0x7E, 0x3F, 0x3F, 0x0E, 0x1F, 0x86, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0xFF, 0x01,
  0xE0, 0x7F, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7C, 0x3F, 0xC0, 0x40, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x80,
  0x03, 0xF9, 0xC0, 0x1F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF1, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x80, 0x0F, 0xF1, 0xC0, 0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xF0, 0x10, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x7E, 0x7F, 0xC1, 0xFB,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x87, 0xF3, 0xFC, 0x1F,
  0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0,
  0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x0F,
  0xE1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xE3, 0xF8, 0xFE, 0x0F, 0xEF, 0xE0,
  0x7F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0xBF, 0x03, 0xFD, 0xFC, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x87, 0xFE, 0xFC, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x84, 0x07, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x07, 0xE0, 0x30, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x07, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0x87, 0xF3,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x07,
  0xC7, 0xC0, 0x7F, 0xF1, 0xF3, 0xE0, 0x7F, 0xFC, 0x7C, 0xF8, 0x3F, 0xFF,
  0x0F, 0x7C, 0x1F, 0xCF, 0x83, 0xDF, 0x0F, 0xC3, 0xE0, 0xF7, 0x83, 0xE0,
  0xF8, 0x3F, 0xE1, 0xF0, 0x3E, 0x0F, 0xF8, 0x7C, 0x0F, 0x07, 0xFE, 0x3E,
  0x07, 0xC1, 0xFF, 0x8F, 0x81, 0xF0, 0x7F, 0xE3, 0xE0, 0x7C, 0x3E, 0xF8,
  0xF8, 0x3E, 0x0F, 0xBE, 0x3E, 0x0F, 0x87, 0xCF, 0x8F, 0xCF, 0xF3, 0xF3,
  0xE1, 0xFF, 0xFF, 0xF8, 0xF8, 0x7F, 0xEF, 0xFC, 0x1F, 0x0F, 0xF3, 0xFE,
  0x07, 0xC0, 0x70, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x20, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF8,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x83,
  0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7E, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x83, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xE1, 0xF0, 0x7F, 0xC0, 0x18, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x3F, 0xC0, 0x70, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80,
  0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xE1, 0xF8, 0x07, 0xF8, 0x7F,
  0x03, 0xFE, 0x0F, 0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x87,
  0xE1, 0xFF, 0x00, 0x30, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xFB, 0xF8, 0x1F, 0xFC, 0xFC, 0x0F, 0xFF,
  0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0xFF, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFF,
  0x00, 0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0C, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x1F, 0xE0, 0x03,
  0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFF,
  0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0xC0, 0xFD, 0xF0,
  0x3E, 0x7C, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x3E, 0x7C, 0x1F, 0x3F, 0x03,
  0xF3, 0xE0, 0xF9, 0xF8, 0x1F, 0x9F, 0x0F, 0x8F, 0xC0, 0xFC, 0xF8, 0x7C,
  0xFC, 0x07, 0xE7, 0xC7, 0xC7, 0xE0, 0x3E, 0x3E, 0x3E, 0x3F, 0x03, 0xF1,
  0xF3, 0xE1, 0xF8, 0x1F, 0x8F, 0x9F, 0x0F, 0xC0, 0xFC, 0x3D, 0xF0, 0xFC,
  0x07, 0xC1, 0xFF, 0x87, 0xE0, 0x7E, 0x0F, 0xF8, 0x3F, 0x03, 0xF0, 0x7F,
  0xC1, 0xF8, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xE0, 0xFC, 0x07,
  0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xFE,
  0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x07, 0xFF,
  0x00, 0x7E, 0x07, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xDF,
  0x80, 0xFC, 0x07, 0xDF, 0x80, 0xFC, 0x0F, 0xDF, 0x80, 0xFC, 0x0F, 0xCF,
  0xC0, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F, 0x87,
  0xE1, 0xF8, 0x1F, 0x87, 0xE1, 0xF8, 0x1F, 0x87, 0xE3, 0xF0, 0x1F, 0x83,
  0xF3, 0xF0, 0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x01,
  0xFB, 0xF0, 0x3F, 0x01, 0xFB, 0xE0, 0x3F, 0x01, 0xFB, 0xE0, 0x3F, 0x01,
  0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00,
  0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0xFC, 0x00,
  0x7F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xF9, 0xFF, 0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x0F,
  0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8,
  0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xFC, 0x3F,
  0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF,
  0x87, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03,
  0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x8F, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F,
  0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xE3, 0xE0, 0xFE, 0x01, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x80, 0x0F, 0xE3, 0xC0,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00,
  0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0,
  0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0,
  0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0x00, 0x7E, 0xFC, 0x03, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xF0, 0x0F,
  0xCF, 0xC0, 0x7F, 0xC0, 0x7F, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0xFC, 0x07,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF, 0xC0, 0xFC,
  0x3F, 0x07, 0xDF, 0x07, 0xF0, 0xFC, 0x1F, 0x7C, 0x1F, 0x83, 0xF0, 0xFD,
  0xF0, 0x7E, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0x3F, 0x1F, 0x9F, 0x0F, 0xC0,
  0xFC, 0x7C, 0x7C, 0x7E, 0x03, 0xF1, 0xF1, 0xF1, 0xF8, 0x0F, 0xCF, 0xC7,
  0xCF, 0xC0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0xFD, 0xF8, 0x7C, 0xFC, 0x01,
  0xF7, 0xC1, 0xF7, 0xE0, 0x07, 0xDF, 0x07, 0xDF, 0x80, 0x1F, 0xF8, 0x1F,
  0x7C, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x07,
  0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F,
  0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0xC1,
  0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF0, 0x7C, 0x1E, 0x00,
  0xF8, 0x00, 0x07, 0xFC, 0xFC, 0x1F, 0xFD, 0xF0, 0x7F, 0xFB, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFC, 0x7F, 0x01,
  0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFE, 0xF8, 0x0F, 0xF9, 0xF0, 0x0F, 0xE3, 0xE0, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC7,
  0x80, 0x1F, 0xBF, 0xC0, 0x7E, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC,
  0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xE3, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7C, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xC7, 0x8F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x0C, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x3F, 0x00,
  0xFF, 0xBF, 0x80, 0xFF, 0xDF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0x9F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0x80, 0x1F, 0xC7, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xE0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x03, 0xFB,
  0xF0, 0x3F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x20, 0xFF, 0x1F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x20, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0x3F, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xBE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0xFC, 0x3F,
  0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF7, 0xE0, 0x0F, 0xC7, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xC0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x1F, 0xBF,
  0xE0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F,
  0x8F, 0xF8, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFE, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x03,
  0xF8, 0xFC, 0x07, 0xF0, 0x00, 0x60, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x10, 0x7E, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x0F, 0xC1, 0xFE, 0x03, 0xF0, 0xFF, 0x00, 0xFC, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xFB, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xE1,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x43, 0xE0, 0x1F, 0x00, 0x78, 0xFF, 0x87,
  0xFC, 0x0F, 0x9F, 0xF8, 0xFF, 0xE0, 0xFB, 0xFF, 0xDF, 0xFE, 0x0F, 0xBF,
  0xFD, 0xFF, 0xE0, 0xFF, 0x9F, 0xFC, 0xFF, 0x1F, 0xE0, 0xFF, 0x87, 0xF1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE0,
  0x7E, 0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC0, 0x7E, 0x3F, 0x81,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x81,
  0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x3F, 0x8F,
  0xC0, 0x7E, 0x03, 0xF8, 0x00, 0x43, 0xE0, 0x0F, 0x1F, 0xF0, 0x3E, 0x7F,
  0xF0, 0x7D, 0xFF, 0xE0, 0xFB, 0xFF, 0xE1, 0xFF, 0x3F, 0xC7, 0xFC, 0x3F,
  0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF1,
  0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xF3, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0x7F, 0x01,
  0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFC, 0x07, 0xF7, 0xF0, 0x3F,
  0xBF, 0x83, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x10, 0xF0, 0x00, 0xF1, 0xFE, 0x00, 0xF9,
  0xFF, 0x80, 0x7D, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF8, 0x7F, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFB, 0xFF,
  0x80, 0xFC, 0xFF, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x7C, 0x1F, 0xFD, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0x1F,
  0xC0, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0,
  0x0F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03,
  0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0xF9, 0xFC, 0x3F, 0x7F,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFE, 0x10, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFC, 0x0C, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0xC0,
  0x3F, 0x8F, 0xEF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0,
  0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x0F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8,
  0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC,
  0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x07, 0xFF, 0x3E, 0x07, 0xFC,
  0x7C, 0x07, 0xF1, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF1, 0xF8,
  0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFE,
  0x01, 0xF1, 0xF8, 0x03, 0xE7, 0xF0, 0x07, 0xCF, 0xC0, 0x0F, 0xBF, 0x00,
  0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xBF, 0x07, 0xFC, 0x1F,
  0xDF, 0x83, 0xFE, 0x0F, 0xCF, 0xC3, 0xFF, 0x0F, 0xE7, 0xE1, 0xFF, 0x87,
  0xE3, 0xF0, 0xF7, 0xC3, 0xF1, 0xF8, 0xFB, 0xE3, 0xF0, 0xFC, 0x7D, 0xF1,
  0xF8, 0x7E, 0x7C, 0xF9, 0xF8, 0x3F, 0x3E, 0x7C, 0xFC, 0x1F, 0xBE, 0x3E,
  0xFC, 0x0F, 0xDF, 0x1F, 0x7E, 0x07, 0xEF, 0x8F, 0xBE, 0x03, 0xFF, 0x87,
  0xBF, 0x01, 0xFF, 0xC3, 0xDF, 0x80, 0xFB, 0xC1, 0xEF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0xCF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x8F, 0xC0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01,
  0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x09, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 32, 12, 0, -31 },
  { 57, 16, 11, 19, 4, -31 },
  { 79, 27, 31, 28, 1, -31 },
  { 184, 23, 36, 24, 1, -33 },
  { 288, 33, 31, 37, 2, -31 },
  { 416, 29, 31, 30, 1, -31 },
  { 529, 8, 11, 11, 4, -31 },
  { 540, 16, 38, 15, 2, -31 },
  { 616, 16, 38, 15, -3, -31 },
  { 692, 20, 21, 23, 4, -33 },
  { 745, 21, 21, 25, 2, -26 },
  { 801, 10, 11, 12, -2, -5 },
  { 815, 12, 5, 14, 1, -14 },
  { 823, 8, 8, 12, 0, -7 },
  { 831, 23, 31, 18, -2, -31 },
  { 921, 22, 31, 24, 1, -31 },
  { 1007, 17, 31, 24, 4, -31 },
  { 1073, 24, 31, 24, -1, -31 },
  { 1166, 23, 31, 24, 0, -31 },
  { 1256, 24, 31, 24, -1, -31 },
  { 1349, 23, 31, 24, 1, -31 },
  { 1439, 22, 31, 24, 2, -31 },
  { 1525, 24, 31, 24, 2, -31 },
  { 1618, 23, 31, 24, 1, -31 },
  { 1708, 21, 31, 24, 2, -31 },
  { 1790, 12, 25, 12, 0, -24 },
  { 1828, 14, 30, 12, -2, -24 },
  { 1881, 21, 23, 25, 2, -27 },
  { 1942, 21, 13, 25, 2, -22 },
  { 1977, 21, 23, 25, 2, -27 },
  { 2038, 18, 32, 20, 3, -31 },
  { 2110, 34, 35, 37, 2, -31 },
  { 2259, 27, 31, 27, -3, -31 },
  { 2364, 25, 31, 27, 1, -31 },
  { 2461, 25, 31, 26, 3, -31 },
  { 2558, 27, 31, 29, 1, -31 },
  { 2663, 24, 31, 23, 1, -31 },
  { 2756, 24, 31, 23, 1, -31 },
  { 2849, 26, 31, 30, 3, -31 },
  { 2950, 29, 31, 30, 1, -31 },
  { 3063, 20, 31, 16, -1, -31 },
  { 3141, 22, 40, 14, -7, -31 },
  { 3251, 29, 31, 26, 1, -31 },
  { 3364, 18, 31, 22, 1, -31 },
  { 3434, 37, 31, 38, 1, -31 },
  { 3578, 32, 31, 33, 1, -31 },
  { 3702, 27, 31, 31, 3, -31 },
  { 3807, 25, 31, 26, 1, -31 },
  { 3904, 27, 38, 31, 3, -31 },
  { 4033, 25, 31, 27, 1, -31 },
  { 4130, 22, 31, 23, 1, -31 },
  { 4216, 23, 31, 23, 3, -31 },
  { 4306, 27, 31, 30, 3, -31 },
  { 4411, 25, 31, 25, 4, -31 },
  { 4508, 38, 31, 38, 4, -31 },
  { 4656, 32, 31, 26, -2, -31 },
  { 4780, 24, 31, 24, 4, -31 },
  { 4873, 26, 31, 23, -1, -31 },
  { 4974, 18, 38, 14, -1, -31 },
  { 5060, 10, 31, 18, 5, -31 },
  { 5099, 18, 38, 14, -3, -31 },
  { 5185, 22, 20, 24, 1, -31 },
  { 5240, 18, 3, 17, -4, 4 },
  { 5247, 9, 7, 14, 6, -33 },
  { 5255, 23, 24, 25, 2, -24 },
  { 5324, 23, 33, 26, 1, -33 },
  { 5419, 19, 24, 21, 2, -24 },
  { 5476, 25, 33, 26, 2, -33 },
  { 5580, 21, 24, 24, 2, -24 },
  { 5643, 26, 43, 16, -5, -33 },
  { 5783, 24, 34, 26, 1, -24 },
  { 5885, 23, 33, 26, 1, -33 },
  { 5980, 13, 33, 13, 1, -33 },
  { 6034, 20, 43, 13, -6, -33 },
  { 6142, 26, 33, 24, 1, -33 },
  { 6250, 13, 33, 13, 1, -33 },
  { 6304, 36, 24, 39, 1, -24 },
  { 6412, 23, 24, 26, 1, -24 },
  { 6481, 21, 24, 25, 2, -24 },
  { 6544, 25, 34, 26, -1, -24 },
  { 6651, 23, 34, 26, 2, -24 },
  { 6749, 19, 24, 18, 1, -24 },
  { 6806, 20, 24, 20, 0, -24 },
  { 6866, 16, 28, 18, 2, -28 },
  { 6922, 23, 23, 26, 2, -23 },
  { 6989, 23, 23, 22, 2, -23 },
  { 7056, 33, 23, 34, 3, -23 },
  { 7151, 27, 23, 23, -2, -23 },
  { 7229, 28, 33, 22, -3, -23 },
  { 7345, 22, 23, 20, -1, -23 },
  { 7409, 18, 38, 15, 0, -31 },
  { 7495, 4, 43, 24, 10, -33 },
  { 7517, 17, 38, 15, -2, -31 },
  { 7598, 21, 7, 25, 2, -19 },
};

const GFXfont NotoSans_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_BOLDITALIC43PT7B_H_
