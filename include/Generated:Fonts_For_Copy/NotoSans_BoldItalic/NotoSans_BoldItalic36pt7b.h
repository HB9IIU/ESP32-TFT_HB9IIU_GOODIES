#ifndef _NOTOSANS_BOLDITALIC36PT7B_H_
#define _NOTOSANS_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xF8, 0x1F, 0x87, 0xF0, 0xFC, 0x0F,
  0x80, 0x7C, 0xFB, 0xC7, 0xBE, 0x3D, 0xF3, 0xEF, 0x1F, 0x78, 0xF3, 0xC7,
  0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E,
  0x1E, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC0, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03, 0xC7,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01,
  0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xF9,
  0x84, 0x1F, 0x30, 0x03, 0xE6, 0x00, 0x7D, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1B,
  0xF0, 0x03, 0x3E, 0x40, 0xE7, 0xCC, 0x1D, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x07, 0x81, 0xFE, 0x00, 0xF0, 0x3F, 0xF0,
  0x0F, 0x03, 0xFF, 0x01, 0xE0, 0x7C, 0xF0, 0x3C, 0x07, 0x8F, 0x07, 0x80,
  0xF8, 0xF0, 0x78, 0x0F, 0x8F, 0x0F, 0x00, 0xF8, 0xF1, 0xE0, 0x0F, 0x1F,
  0x3E, 0x00, 0xF1, 0xF3, 0xC7, 0x0F, 0x1E, 0x79, 0xFC, 0xFF, 0xEF, 0x3F,
  0xE7, 0xFD, 0xF7, 0xFE, 0x7F, 0x9E, 0xF9, 0xE3, 0xF3, 0xCF, 0x9F, 0x00,
  0x78, 0xF1, 0xE0, 0x0F, 0x9F, 0x1E, 0x00, 0xF1, 0xF1, 0xE0, 0x1E, 0x1F,
  0x1E, 0x03, 0xC1, 0xE3, 0xE0, 0x7C, 0x1E, 0x3C, 0x07, 0x81, 0xF7, 0xC0,
  0xF0, 0x1F, 0xF8, 0x1E, 0x00, 0xFF, 0x83, 0xE0, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xE3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7,
  0xC0, 0x07, 0xDF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0x0F, 0xF8, 0x3F, 0x3F, 0xFC, 0x3E, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x0F, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD,
  0xF8, 0x1F, 0xF0, 0xFC, 0x7D, 0xEF, 0xBE, 0xF3, 0xCF, 0x3C, 0xE3, 0x80,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x06, 0x0F, 0x03, 0xC7, 0x01, 0xFB, 0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFC, 0x01, 0xFF, 0x03, 0xF7, 0x80, 0xF1, 0xE0,
  0x30, 0xF0, 0x08, 0x7C, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x8F, 0x87, 0xC7,
  0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0xFF, 0x80, 0x18, 0xF9, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC,
  0xFC, 0x3F, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xEF, 0xC0,
  0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7E, 0x0F,
  0x8F, 0xC3, 0xF0, 0xF8, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x3F, 0xFE, 0x3F, 0x7C, 0x78, 0xF8, 0x63, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x38, 0x3F, 0x03, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7C, 0xFE, 0x04, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE8, 0x00, 0xF9, 0xC0,
  0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x08, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x80, 0x1F, 0x8F, 0x07, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x0C, 0x07, 0xDF, 0xE3, 0xEF, 0xF8, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xC1, 0xF3, 0xE0, 0x7E, 0xF8, 0x1F, 0xBE, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3F, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x7E, 0x3F, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x87, 0xC1, 0xF1, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF9, 0xF8,
  0x7C, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF8, 0x3F, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3, 0xFB, 0xF0,
  0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xE7, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xBE, 0x0F, 0x9F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC4, 0x1F, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0x83, 0xF0, 0xFC,
  0x7F, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x81, 0xF0, 0x7E, 0x3F, 0x8F, 0xC1, 0xF0, 0x01, 0xE0, 0x3F,
  0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0xFF,
  0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0x8F, 0xE4, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF3, 0xE0,
  0x7E, 0x0F, 0x3C, 0x1F, 0xF8, 0xF7, 0x83, 0xFF, 0x8F, 0x78, 0x7E, 0x78,
  0x7F, 0x0F, 0x87, 0x87, 0xF0, 0xF0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xF1,
  0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xF1, 0xE1, 0xE1, 0xEF, 0x1E, 0x1E,
  0x1E, 0xF1, 0xE3, 0xE3, 0xCF, 0x1F, 0xFF, 0xFC, 0xF1, 0xFE, 0xFF, 0x8F,
  0x0F, 0xC7, 0xE0, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x08, 0x03, 0xF8, 0x07, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00,
  0x0F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E,
  0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00,
  0x7F, 0xF0, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0,
  0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xE0, 0x18, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x08, 0x3F, 0xC3, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x7E,
  0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3,
  0xE0, 0x3F, 0x9F, 0x81, 0xFC, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x80,
  0x61, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0xFB, 0xF0, 0x7F, 0xEF, 0xC1,
  0xFF, 0xBF, 0x0F, 0xFC, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xE1, 0xFE, 0x1F, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC,
  0x03, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFE,
  0x07, 0xC1, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0,
  0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xBF, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03,
  0xFF, 0x07, 0xBC, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF8, 0x3E, 0xF0, 0x3D,
  0xF0, 0x7D, 0xE0, 0xFB, 0xE0, 0xFB, 0xC1, 0xE7, 0xC1, 0xF7, 0x87, 0xDF,
  0x03, 0xCF, 0x0F, 0x3E, 0x0F, 0x9E, 0x3E, 0x7C, 0x1F, 0x3C, 0x78, 0xF8,
  0x3E, 0x79, 0xF3, 0xE0, 0x7C, 0xF3, 0xC7, 0xC0, 0xF1, 0xFF, 0x8F, 0x83,
  0xE1, 0xFE, 0x1F, 0x07, 0xC3, 0xFC, 0x3E, 0x0F, 0x87, 0xF0, 0xF8, 0x1F,
  0x0F, 0xE1, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xC1, 0xFC, 0x01, 0xF0, 0x7F, 0x00,
  0x7C, 0x1F, 0xE0, 0x1F, 0x0F, 0xF8, 0x07, 0xC3, 0xFE, 0x03, 0xE0, 0xFF,
  0xC0, 0xF8, 0x3D, 0xF0, 0x3E, 0x0F, 0x7C, 0x0F, 0x87, 0xCF, 0x83, 0xE1,
  0xF3, 0xE1, 0xF0, 0x7C, 0xF8, 0x7C, 0x1F, 0x3F, 0x1F, 0x07, 0x87, 0xC7,
  0xC3, 0xE1, 0xF1, 0xE0, 0xF8, 0x7E, 0xF8, 0x3E, 0x0F, 0xBE, 0x0F, 0x83,
  0xEF, 0x87, 0xC0, 0xFF, 0xE1, 0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xFC, 0x1F,
  0x01, 0xFF, 0x07, 0xC0, 0x3F, 0xC3, 0xE0, 0x0F, 0xF0, 0xF8, 0x03, 0xF8,
  0x3E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3E, 0x07, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xF3, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF8,
  0x1F, 0x1F, 0x83, 0xF1, 0xF0, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xF0, 0x3E, 0x1F, 0x07,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC0, 0xFC, 0x7C, 0x0F, 0xCF, 0xC0, 0x7C,
  0xFC, 0x07, 0xEF, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFE, 0xF8, 0x3F, 0x01, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x88, 0x03, 0xE1, 0xC1, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E,
  0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3,
  0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0xFE, 0x0F, 0xE3, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0,
  0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83,
  0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x3F,
  0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0xF8, 0x01, 0xE7, 0xC0, 0x0F,
  0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x0F, 0xDF, 0x01, 0xFC,
  0x07, 0xCF, 0x80, 0xFE, 0x07, 0xE7, 0xC0, 0x7F, 0x03, 0xE3, 0xE0, 0x7F,
  0x81, 0xF1, 0xF0, 0x3F, 0xC1, 0xF0, 0xF8, 0x3F, 0xE0, 0xF8, 0x3C, 0x1E,
  0xF0, 0xFC, 0x1E, 0x1F, 0x78, 0x7C, 0x0F, 0x0F, 0x3C, 0x7E, 0x07, 0x8F,
  0x9E, 0x3E, 0x03, 0xC7, 0xCF, 0x1F, 0x01, 0xE3, 0xC7, 0x9F, 0x00, 0xF3,
  0xE3, 0xCF, 0x80, 0x79, 0xE1, 0xEF, 0x80, 0x3D, 0xF0, 0xF7, 0xC0, 0x1E,
  0xF0, 0x7B, 0xE0, 0x0F, 0x78, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x03, 0xFB, 0xE0, 0x1F, 0x9F, 0x01, 0xF8, 0xF8, 0x0F, 0x87,
  0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3F, 0x7E,
  0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xF0, 0xF8,
  0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x8E, 0x03, 0xE3, 0xC0, 0xF0,
  0xF0, 0x78, 0x1C, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x0F,
  0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xFC, 0x7C, 0x7C,
  0x3E, 0x1E, 0x0F, 0x03, 0xE3, 0xE1, 0xFE, 0x7C, 0x7F, 0xEF, 0x1F, 0xFF,
  0xE3, 0xFB, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF7, 0xE0, 0x7C, 0xFC, 0x0F,
  0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E,
  0x3E, 0x0F, 0xC7, 0xE3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFB, 0xC1, 0xFE, 0x78,
  0x1F, 0x9F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0xF8, 0x0F, 0xBF,
  0x83, 0xEF, 0xF8, 0x7F, 0xFF, 0x0F, 0xE7, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xFD, 0xF0, 0x1F,
  0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xFC, 0x3F, 0x1F, 0x8F, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1E, 0xFF, 0x83, 0xC7, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x8C, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x18, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x3E, 0x0F, 0xF7, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xF9, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC,
  0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFD, 0xE0, 0x3F, 0x1E, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFD, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x08, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0x9F, 0x0F, 0xFD,
  0xE1, 0xFF, 0xFE, 0x1F, 0xDF, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE7, 0xE0,
  0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xDF, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x08, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0xF8, 0x0F, 0xBF, 0xC3, 0xEF, 0xF8, 0x7F, 0xFF, 0x8F, 0xF3, 0xF1, 0xF8,
  0x7E, 0x7F, 0x07, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xC7, 0xC0,
  0xF9, 0xF8, 0x1F, 0x3F, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03,
  0xE7, 0xE0, 0x7C, 0xF8, 0x1F, 0x9F, 0x03, 0xF3, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x3F, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC3, 0xF0, 0x3E,
  0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0xBF, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xE7,
  0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07,
  0xC0, 0xFC, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x1F, 0x03, 0xE0, 0x3C,
  0xFE, 0x1F, 0xE1, 0xF7, 0xFC, 0xFF, 0x87, 0xFF, 0xF7, 0xFE, 0x1F, 0xE7,
  0xFC, 0xFC, 0x7E, 0x1F, 0xC3, 0xF1, 0xF8, 0x7F, 0x0F, 0xCF, 0xC1, 0xF8,
  0x3F, 0x3F, 0x07, 0xE0, 0xF8, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F,
  0x9F, 0x83, 0xF0, 0x7E, 0x7E, 0x0F, 0xC1, 0xF9, 0xF0, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x7C, 0xFC, 0x1F, 0x83, 0xF3, 0xE0,
  0x7E, 0x0F, 0xCF, 0x81, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x1F,
  0x01, 0xE7, 0xF8, 0x7D, 0xFF, 0x0F, 0xFF, 0xF1, 0xFE, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F,
  0x3F, 0x03, 0xE7, 0xE0, 0xFC, 0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C,
  0xFC, 0x0F, 0x9F, 0x03, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x80, 0x01, 0xF8,
  0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFB, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xC7, 0xC0, 0x1E, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3E, 0x03,
  0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xBF, 0xC0, 0x7C, 0xFC, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE1,
  0xE1, 0xFE, 0x7C, 0x7F, 0xEF, 0x0F, 0xFF, 0xE3, 0xF9, 0xFC, 0xFC, 0x1F,
  0x9F, 0x83, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xE3, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFE, 0xF8, 0x1F, 0x9F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0x1F, 0x0F, 0x3E, 0x1F,
  0x7E, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x06, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0xC0, 0x7C, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x8F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8,
  0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0,
  0x7E, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0x81,
  0xF9, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xE3, 0xF8, 0xFF, 0xFF, 0x1F, 0xFB,
  0xE1, 0xFE, 0x78, 0x1F, 0x8F, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0,
  0x3E, 0x7C, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x7E, 0x1E, 0x0F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8,
  0x3F, 0xF8, 0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x7E, 0xF8, 0x7F, 0x87, 0xCF,
  0x87, 0xF8, 0x7C, 0xF8, 0xF7, 0x8F, 0x87, 0x8F, 0x78, 0xF8, 0x78, 0xF7,
  0x9F, 0x07, 0x9E, 0x79, 0xF0, 0x79, 0xE7, 0xBE, 0x07, 0xBC, 0x7B, 0xE0,
  0x7B, 0xC7, 0xBC, 0x07, 0xBC, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x87,
  0xE0, 0x1F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xE0, 0x07,
  0xE7, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x1F, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE3,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC,
  0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x3F, 0x00,
  0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xBF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFC, 0x03, 0xF8,
};

const GFXglyph NotoSans_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 13, 10, 16, 4, -26 },
  { 54, 22, 26, 23, 1, -26 },
  { 126, 19, 29, 20, 1, -27 },
  { 195, 28, 26, 31, 2, -26 },
  { 286, 24, 26, 25, 1, -26 },
  { 364, 6, 10, 9, 4, -26 },
  { 372, 14, 32, 12, 1, -26 },
  { 428, 14, 32, 12, -3, -26 },
  { 484, 17, 18, 20, 3, -28 },
  { 523, 17, 17, 21, 2, -21 },
  { 560, 9, 9, 10, -2, -4 },
  { 571, 10, 5, 12, 1, -12 },
  { 578, 7, 6, 10, 0, -6 },
  { 584, 20, 26, 15, -2, -26 },
  { 649, 19, 26, 20, 1, -26 },
  { 711, 15, 26, 20, 3, -26 },
  { 760, 20, 26, 20, -1, -26 },
  { 825, 19, 26, 20, 0, -26 },
  { 887, 19, 26, 20, 0, -26 },
  { 949, 20, 26, 20, 0, -26 },
  { 1014, 18, 26, 20, 2, -26 },
  { 1073, 20, 26, 20, 1, -26 },
  { 1138, 19, 26, 20, 1, -26 },
  { 1200, 17, 26, 20, 2, -26 },
  { 1256, 10, 20, 10, 0, -20 },
  { 1281, 12, 25, 10, -2, -20 },
  { 1319, 17, 19, 21, 2, -23 },
  { 1360, 17, 11, 21, 2, -18 },
  { 1384, 17, 19, 21, 2, -23 },
  { 1425, 15, 26, 17, 3, -26 },
  { 1474, 28, 29, 31, 2, -26 },
  { 1576, 22, 26, 23, -2, -26 },
  { 1648, 21, 26, 22, 1, -26 },
  { 1717, 21, 26, 22, 2, -26 },
  { 1786, 22, 26, 24, 1, -26 },
  { 1858, 20, 26, 20, 1, -26 },
  { 1923, 20, 26, 19, 1, -26 },
  { 1988, 22, 26, 25, 2, -26 },
  { 2060, 24, 26, 25, 1, -26 },
  { 2138, 17, 26, 14, -1, -26 },
  { 2194, 18, 34, 12, -6, -26 },
  { 2271, 24, 26, 22, 1, -26 },
  { 2349, 15, 26, 19, 1, -26 },
  { 2398, 31, 26, 32, 1, -26 },
  { 2499, 26, 26, 27, 1, -26 },
  { 2584, 23, 26, 26, 2, -26 },
  { 2659, 21, 26, 22, 1, -26 },
  { 2728, 23, 32, 26, 2, -26 },
  { 2820, 20, 26, 22, 1, -26 },
  { 2885, 19, 26, 19, 1, -26 },
  { 2947, 19, 26, 19, 3, -26 },
  { 3009, 23, 26, 25, 2, -26 },
  { 3084, 21, 26, 21, 3, -26 },
  { 3153, 33, 26, 32, 3, -26 },
  { 3261, 27, 26, 22, -2, -26 },
  { 3349, 21, 26, 20, 3, -26 },
  { 3418, 22, 26, 19, -1, -26 },
  { 3490, 15, 32, 12, -1, -26 },
  { 3550, 8, 26, 15, 4, -26 },
  { 3576, 15, 32, 12, -2, -26 },
  { 3636, 18, 17, 20, 1, -26 },
  { 3675, 15, 3, 14, -3, 3 },
  { 3681, 8, 6, 12, 5, -28 },
  { 3687, 19, 20, 21, 2, -20 },
  { 3735, 19, 27, 21, 1, -27 },
  { 3800, 16, 20, 17, 2, -20 },
  { 3840, 20, 27, 21, 2, -27 },
  { 3908, 17, 20, 20, 2, -20 },
  { 3951, 21, 37, 13, -4, -28 },
  { 4049, 20, 29, 21, 1, -20 },
  { 4122, 19, 27, 22, 1, -27 },
  { 4187, 11, 27, 11, 1, -27 },
  { 4225, 17, 36, 11, -5, -27 },
  { 4302, 21, 27, 20, 1, -27 },
  { 4373, 11, 27, 11, 1, -27 },
  { 4411, 30, 20, 33, 1, -20 },
  { 4486, 19, 20, 22, 1, -20 },
  { 4534, 17, 20, 21, 2, -20 },
  { 4577, 21, 29, 21, -1, -20 },
  { 4654, 19, 29, 21, 2, -20 },
  { 4723, 16, 20, 15, 1, -20 },
  { 4763, 16, 20, 17, 0, -20 },
  { 4803, 13, 24, 15, 2, -24 },
  { 4842, 19, 20, 22, 2, -20 },
  { 4890, 19, 20, 18, 2, -20 },
  { 4938, 28, 20, 28, 2, -20 },
  { 5008, 23, 20, 19, -2, -20 },
  { 5066, 23, 29, 19, -2, -20 },
  { 5150, 18, 20, 17, -1, -20 },
  { 5195, 15, 32, 13, 0, -26 },
  { 5255, 4, 35, 20, 8, -27 },
  { 5273, 15, 32, 13, -2, -26 },
  { 5333, 17, 6, 21, 2, -16 },
};

const GFXfont NotoSans_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_BOLDITALIC36PT7B_H_
