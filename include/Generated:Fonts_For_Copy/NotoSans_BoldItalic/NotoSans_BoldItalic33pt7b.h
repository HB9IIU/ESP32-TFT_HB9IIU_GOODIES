#ifndef _NOTOSANS_BOLDITALIC33PT7B_H_
#define _NOTOSANS_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x7C, 0xF7,
  0xCF, 0x78, 0xF7, 0x9F, 0x79, 0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0xF1, 0xC0,
  0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0x80, 0x1C, 0x38, 0x01, 0xC7, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x47, 0x8F, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xE3, 0xC0, 0x1E, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0x8F, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xBC, 0x7C, 0xC2, 0x3E, 0x60, 0x1F, 0x30, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0x9F,
  0x00, 0xCF, 0xA0, 0x67, 0xDE, 0x77, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE0, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80,
  0x1E, 0x0F, 0xE0, 0x1E, 0x0F, 0xF8, 0x0F, 0x0F, 0xFC, 0x0F, 0x07, 0x9E,
  0x0F, 0x07, 0xCF, 0x0F, 0x03, 0xC7, 0x87, 0x81, 0xE3, 0xC7, 0x80, 0xF1,
  0xE7, 0x80, 0x79, 0xF3, 0x80, 0x3C, 0xF3, 0xDF, 0xDF, 0xFB, 0xDF, 0xEF,
  0xFB, 0xDF, 0xFB, 0xF9, 0xCF, 0x3C, 0xF1, 0xEF, 0x9E, 0x01, 0xE7, 0x8F,
  0x01, 0xE3, 0xC7, 0x80, 0xE1, 0xE3, 0xC0, 0xF0, 0xF3, 0xE0, 0xF0, 0x79,
  0xE0, 0xF0, 0x3D, 0xF0, 0x70, 0x1F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07,
  0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x1F, 0x1F, 0xF0,
  0x7C, 0xFF, 0xE3, 0xE7, 0xEF, 0x8F, 0x9F, 0x1F, 0x7C, 0xF8, 0x7F, 0xE3,
  0xE0, 0xFF, 0x8F, 0x81, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xBE, 0x07, 0xF8, 0xFC, 0x7D, 0xF7, 0x9E, 0x79, 0xC7,
  0x3C, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x41, 0xC0, 0x71, 0xC0, 0xFD, 0xC0, 0xFF, 0xFF,
  0x1F, 0xFF, 0x07, 0xFE, 0x0F, 0xC6, 0x3F, 0xE0, 0x7D, 0xE0, 0x7C, 0xF0,
  0x38, 0xF0, 0x10, 0xF0, 0x00, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0xF8, 0xFF, 0xFF,
  0xFF, 0xDF, 0xE0, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF9, 0xF8, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7C, 0x1F,
  0x3E, 0x1F, 0x9F, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x1F, 0xE3, 0xFF, 0x3F, 0xFB, 0xFF,
  0xCF, 0x3E, 0x71, 0xE1, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7C, 0xFE, 0x0E, 0x0F, 0xC0, 0x80, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0x0F,
  0xC1, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF3, 0x00, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xBC, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x1E, 0x1E,
  0x0F, 0x0F, 0x87, 0xC3, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0x81, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x02, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF3, 0x01, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x3F, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0x87, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC7,
  0x83, 0xE1, 0xF0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0x80, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x07, 0xDF, 0x83, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xE1, 0xF9, 0xF9, 0xF8, 0x7C, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0x07, 0xCF, 0xEF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1,
  0xF0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x07,
  0xCF, 0xC7, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0x7C, 0x0E, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x0F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xF1, 0xF8, 0xFC, 0x3C,
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x0F, 0xC3, 0xFF, 0xBF, 0xFD, 0xFF, 0xF7, 0x0F,
  0xA0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x03,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x7E, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x7F, 0xCF, 0x3C, 0x3F,
  0xF1, 0xE7, 0x0F, 0xFE, 0x3D, 0xE3, 0xE3, 0xC7, 0xBC, 0x78, 0x78, 0xF7,
  0x1E, 0x0E, 0x1E, 0xE3, 0xC3, 0xC3, 0xDC, 0x78, 0x78, 0x77, 0x8F, 0x0F,
  0x1E, 0xF1, 0xE3, 0xC3, 0x8E, 0x3C, 0xFD, 0xF1, 0xC7, 0xFF, 0xFC, 0x3C,
  0x7E, 0x7F, 0x07, 0x83, 0x83, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x07, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x3C,
  0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x3E,
  0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00,
  0x7D, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE3, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xCF, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xE3, 0xC1, 0xF8, 0x04, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x60, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7E,
  0x7C, 0x0F, 0xC7, 0xC7, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x41, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xF1, 0xE1, 0xF8, 0x02, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xFE, 0xF8, 0x3F, 0xEF,
  0x83, 0xFE, 0xF8, 0x7F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xFC, 0x07, 0xC7, 0xE0, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x8F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x3F,
  0x00, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF7,
  0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3D, 0xE1, 0xFF, 0x03, 0xFE,
  0x1E, 0xF0, 0x7B, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3, 0xEF,
  0x0F, 0x7C, 0x3E, 0xF1, 0xE7, 0xC3, 0xEF, 0x1E, 0x78, 0x3C, 0xF3, 0xC7,
  0x83, 0xCF, 0x3C, 0xF8, 0x7C, 0x77, 0x8F, 0x87, 0xC7, 0x78, 0xF8, 0x78,
  0x7F, 0x0F, 0x07, 0x87, 0xF0, 0xF0, 0x78, 0x7E, 0x1F, 0x0F, 0x87, 0xE1,
  0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x07, 0xC1, 0xE0, 0x07, 0xE0, 0x0F, 0x07,
  0xE0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x1E, 0x0F,
  0xF0, 0x1E, 0x0F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1E, 0x78, 0x3C, 0x1E,
  0x78, 0x3C, 0x1E, 0x7C, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x3C, 0x7C, 0x3E,
  0x3E, 0x78, 0x3C, 0x3E, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0xF8,
  0x07, 0xF0, 0xF8, 0x07, 0xF0, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFE, 0x7F, 0x0F, 0xC0, 0xFC,
  0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0xFC, 0x1F,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x1F, 0x9F, 0x1F, 0xE3, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFE, 0x7F, 0x0F, 0xC0, 0xFC,
  0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0xFC, 0x3F,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xF3, 0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x7E,
  0x00, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xF8, 0xF0, 0xF8,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x20, 0x1F, 0x18, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E,
  0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE1, 0xF0, 0x3C,
  0x3E, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x3E,
  0x03, 0xEF, 0x80, 0xF8, 0x0F, 0xBE, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x81,
  0xF3, 0xE0, 0xFE, 0x07, 0x8F, 0x83, 0xF8, 0x3E, 0x3E, 0x1F, 0xE0, 0xF0,
  0xF8, 0x7F, 0x87, 0xC3, 0xE3, 0xFE, 0x1F, 0x0F, 0x8F, 0x78, 0xF8, 0x3E,
  0x3D, 0xE3, 0xE0, 0xF9, 0xE7, 0x8F, 0x03, 0xE7, 0x9E, 0x7C, 0x0F, 0xBC,
  0x79, 0xE0, 0x3E, 0xF1, 0xEF, 0x80, 0xFF, 0xC7, 0xBE, 0x01, 0xFE, 0x1E,
  0xF0, 0x07, 0x78, 0x7F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0xC1,
  0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xFF, 0x01, 0xF9, 0xE0, 0x3E, 0x3E, 0x0F,
  0xC7, 0xC1, 0xF0, 0xF8, 0x7C, 0x0F, 0x1F, 0x81, 0xF3, 0xE0, 0x3E, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xF8, 0x1F,
  0xC0, 0xFF, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xBC, 0x07, 0x9C, 0x0F, 0x1C, 0x0E, 0x1E, 0x1E,
  0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0xF1, 0xF1, 0xE1, 0xE0, 0x03, 0xF3, 0xC3, 0xFE,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x1F, 0x8F, 0x83, 0xE7, 0xE0, 0xF9,
  0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC,
  0x3E, 0x1F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xCF,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0x78, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF1, 0xEF, 0xF0, 0xF3, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xE3, 0xF0, 0x47, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x81, 0x1F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E,
  0x7C, 0x0F, 0xF7, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0x3E,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFD, 0xE0, 0x1F, 0x9C, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xF3, 0xE3, 0xF0, 0xF9, 0xF0, 0x79, 0xF0, 0x7C, 0xFB,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x21, 0xF8, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF3,
  0xC3, 0xFC, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x1F, 0x8F, 0x83, 0xE7,
  0xE0, 0xF9, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0,
  0x7C, 0xFC, 0x3E, 0x1F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xBE,
  0x07, 0xCF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x30, 0x7E, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x7C, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0xF1, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0x81, 0xF7, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3E, 0x03, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x3F, 0x1F, 0x0F, 0xC3, 0xE3,
  0xF0, 0x7C, 0xFC, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F, 0x7C,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFB, 0xE0, 0x3E, 0x7C,
  0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3F,
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x1E, 0x3E, 0x0F,
  0x83, 0xDF, 0xE7, 0xF8, 0x7F, 0xFE, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xF8,
  0xFE, 0x3E, 0x7E, 0x1F, 0x87, 0xCF, 0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x1F,
  0x3E, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0x79, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F,
  0x83, 0xE7, 0xC1, 0xF0, 0x7C, 0xF0, 0x3E, 0x0F, 0xBE, 0x0F, 0x81, 0xE7,
  0xC1, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xC1, 0xF0, 0x1E, 0x3E,
  0x0F, 0x7F, 0x87, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0xF9, 0xF8, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7,
  0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xFB,
  0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBC, 0x07, 0xFE, 0x07,
  0xDF, 0x03, 0xE7, 0x81, 0xF3, 0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x07, 0xF0, 0x00, 0x07, 0x9F, 0x80, 0xF7, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x0F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0x9F, 0x81, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF3, 0xC3, 0xFE, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0x1F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C,
  0x7C, 0x0F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x1F,
  0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xBE, 0x07, 0xCF, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1E, 0x3C, 0x7B, 0xF1, 0xEF, 0xC7, 0xFE,
  0x3F, 0xC8, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0xE3, 0xE0, 0x47, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0,
  0x0F, 0x90, 0x1F, 0x3E, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0x07,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x3E, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7,
  0xC7, 0xF3, 0xFF, 0xF1, 0xFF, 0x78, 0x7F, 0xBC, 0x1F, 0x1E, 0x00, 0xF0,
  0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3,
  0xE3, 0xE0, 0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0xF8, 0x0F, 0x7C,
  0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x0F, 0xFE, 0x1F, 0x83, 0xEF, 0x87, 0xE0, 0xFB,
  0xE3, 0xF8, 0x7C, 0xF8, 0xFE, 0x1F, 0x3E, 0x3B, 0x8F, 0x8F, 0x9E, 0xE3,
  0xE3, 0xE7, 0xB9, 0xF0, 0xFB, 0xCE, 0x7C, 0x3E, 0xF3, 0x9E, 0x07, 0xB8,
  0xEF, 0x81, 0xFE, 0x3B, 0xC0, 0x7F, 0x0E, 0xF0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x3E, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xCF, 0x80,
  0x3E, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xCF, 0x80, 0x7E, 0x7C, 0x07, 0xE3, 0xF0, 0x3E, 0x0F, 0x87, 0xF0, 0x7E,
  0x00, 0x0F, 0x01, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x9F,
  0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC,
  0x00, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x1F, 0x00,
  0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x7F,
  0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0xFC,
};

const GFXglyph NotoSans_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 24, 9, 0, -24 },
  { 34, 12, 9, 15, 3, -24 },
  { 48, 20, 24, 21, 1, -24 },
  { 108, 17, 27, 18, 1, -25 },
  { 166, 25, 24, 28, 2, -24 },
  { 241, 22, 24, 23, 1, -24 },
  { 307, 6, 9, 8, 3, -24 },
  { 314, 13, 29, 11, 1, -24 },
  { 362, 12, 29, 11, -2, -24 },
  { 406, 16, 16, 18, 3, -25 },
  { 438, 16, 16, 19, 2, -20 },
  { 470, 8, 8, 9, -2, -4 },
  { 478, 9, 4, 11, 1, -11 },
  { 483, 6, 5, 9, 0, -5 },
  { 487, 17, 24, 14, -1, -24 },
  { 538, 17, 24, 18, 1, -24 },
  { 589, 13, 24, 18, 3, -24 },
  { 628, 19, 24, 18, -1, -24 },
  { 685, 18, 24, 18, 0, -24 },
  { 739, 18, 24, 18, 0, -24 },
  { 793, 18, 24, 18, 0, -24 },
  { 847, 18, 24, 18, 1, -24 },
  { 901, 19, 24, 18, 1, -24 },
  { 958, 17, 24, 18, 1, -24 },
  { 1009, 17, 24, 18, 1, -24 },
  { 1060, 9, 18, 9, 0, -18 },
  { 1081, 11, 22, 9, -2, -18 },
  { 1112, 16, 18, 19, 2, -21 },
  { 1148, 16, 10, 19, 2, -17 },
  { 1168, 16, 18, 19, 2, -21 },
  { 1204, 13, 24, 15, 3, -24 },
  { 1243, 27, 27, 28, 1, -24 },
  { 1335, 21, 24, 21, -2, -24 },
  { 1398, 19, 24, 20, 1, -24 },
  { 1455, 20, 24, 20, 2, -24 },
  { 1515, 20, 24, 22, 1, -24 },
  { 1575, 18, 24, 18, 1, -24 },
  { 1629, 18, 24, 18, 1, -24 },
  { 1683, 20, 24, 23, 2, -24 },
  { 1743, 22, 24, 23, 1, -24 },
  { 1809, 15, 24, 13, -1, -24 },
  { 1854, 16, 31, 11, -5, -24 },
  { 1916, 22, 24, 20, 1, -24 },
  { 1982, 14, 24, 17, 1, -24 },
  { 2024, 28, 24, 29, 1, -24 },
  { 2108, 24, 24, 25, 1, -24 },
  { 2180, 21, 24, 24, 2, -24 },
  { 2243, 19, 24, 20, 1, -24 },
  { 2300, 21, 30, 24, 2, -24 },
  { 2379, 19, 24, 20, 1, -24 },
  { 2436, 17, 24, 17, 1, -24 },
  { 2487, 17, 24, 18, 3, -24 },
  { 2538, 21, 24, 23, 2, -24 },
  { 2601, 19, 24, 19, 3, -24 },
  { 2658, 30, 24, 30, 3, -24 },
  { 2748, 25, 24, 20, -2, -24 },
  { 2823, 19, 24, 19, 3, -24 },
  { 2880, 20, 24, 18, -1, -24 },
  { 2940, 14, 29, 11, -1, -24 },
  { 2991, 7, 24, 14, 4, -24 },
  { 3012, 14, 29, 11, -2, -24 },
  { 3063, 16, 16, 18, 1, -24 },
  { 3095, 14, 2, 13, -3, 3 },
  { 3099, 7, 5, 11, 5, -25 },
  { 3104, 18, 18, 20, 1, -18 },
  { 3145, 17, 25, 20, 1, -25 },
  { 3199, 15, 18, 16, 1, -18 },
  { 3233, 20, 25, 20, 1, -25 },
  { 3296, 17, 18, 18, 1, -18 },
  { 3335, 20, 33, 12, -4, -25 },
  { 3418, 18, 26, 20, 1, -18 },
  { 3477, 17, 25, 20, 1, -25 },
  { 3531, 10, 25, 10, 1, -25 },
  { 3563, 15, 33, 10, -4, -25 },
  { 3625, 19, 25, 19, 1, -25 },
  { 3685, 10, 25, 10, 1, -25 },
  { 3717, 27, 18, 30, 1, -18 },
  { 3778, 17, 18, 20, 1, -18 },
  { 3817, 17, 18, 19, 1, -18 },
  { 3856, 19, 26, 20, -1, -18 },
  { 3918, 18, 26, 20, 1, -18 },
  { 3977, 14, 18, 14, 1, -18 },
  { 4009, 15, 18, 16, 0, -18 },
  { 4043, 12, 22, 14, 2, -22 },
  { 4076, 17, 18, 20, 2, -18 },
  { 4115, 17, 18, 17, 2, -18 },
  { 4154, 26, 18, 26, 2, -18 },
  { 4213, 21, 18, 18, -2, -18 },
  { 4261, 21, 26, 17, -2, -18 },
  { 4330, 17, 18, 15, -1, -18 },
  { 4369, 14, 29, 12, 0, -24 },
  { 4420, 4, 32, 18, 7, -25 },
  { 4436, 14, 29, 12, -2, -24 },
  { 4487, 16, 5, 19, 2, -14 },
};

const GFXfont NotoSans_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_BOLDITALIC33PT7B_H_
