#ifndef _NOTOSANS_BOLDITALIC31PT7B_H_
#define _NOTOSANS_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x07,
  0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xEF, 0x1D,
  0xE7, 0xB8, 0xF7, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x1E, 0x00,
  0xE3, 0x80, 0x3C, 0x70, 0x07, 0x1E, 0x0F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0xE3, 0xC0, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE3, 0xC5, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0xF1,
  0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E,
  0xC2, 0x3E, 0xC0, 0x3E, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xBE, 0x83, 0x3E, 0xC3, 0x7C, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1F, 0x80, 0x7C, 0x7F, 0x80, 0xE1, 0xFF, 0x03, 0xC3, 0xCE, 0x0F,
  0x0F, 0x1C, 0x1C, 0x1E, 0x38, 0x70, 0x3C, 0xF1, 0xE0, 0x79, 0xE7, 0x80,
  0xE3, 0xCE, 0x31, 0xEF, 0x39, 0xFB, 0xFE, 0xF7, 0xFF, 0xFB, 0xDF, 0xF7,
  0xE7, 0x3C, 0xE0, 0x1C, 0xF1, 0xC0, 0x79, 0xE3, 0x81, 0xE3, 0xCF, 0x03,
  0x87, 0x9E, 0x0E, 0x0E, 0x3C, 0x3C, 0x1E, 0xF0, 0xF0, 0x3F, 0xE1, 0xC0,
  0x7F, 0x8F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01,
  0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x3E, 0x3F, 0xC3,
  0xE7, 0xFF, 0x1F, 0x3E, 0x7D, 0xF3, 0xE1, 0xFF, 0x1F, 0x0F, 0xF8, 0xF8,
  0x3F, 0x87, 0xC0, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xF3, 0xF0, 0x7B, 0xDE, 0xEF, 0x7B, 0x9C, 0x01, 0xF0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C,
  0x00, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x00, 0x01, 0x00, 0x07, 0x80, 0x0F, 0x02, 0x1E, 0x0E,
  0x38, 0x1F, 0x70, 0x3F, 0xFF, 0x9F, 0xFE, 0x0F, 0xFC, 0x3F, 0x18, 0xF7,
  0x07, 0xEE, 0x07, 0x9E, 0x06, 0x3C, 0x00, 0x34, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x3E, 0x7C, 0xF3, 0xE7, 0x8F, 0x3C, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBE, 0x3E, 0x1F, 0x3E,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0xFC, 0xFD, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xF0, 0x3F,
  0x0F, 0xF3, 0xFE, 0x7F, 0xEF, 0xDE, 0x7B, 0xE6, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0x7E, 0x07, 0x07, 0xC0, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xC1, 0xE3, 0xF0, 0x40, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x40, 0x1F, 0x3E, 0x7F,
  0x9F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xBC,
  0x07, 0x9E, 0x07, 0x9F, 0x07, 0x8F, 0x07, 0xC7, 0x87, 0xC3, 0xC3, 0xC3,
  0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x40, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xE1, 0x1F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7D, 0xF8, 0x7B,
  0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x1F, 0x1F, 0x1E, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x7E, 0xFC, 0x7C, 0x7C, 0xF8, 0x3C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF8, 0x3C,
  0xFC, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xFC,
  0x1F, 0xFE, 0x3F, 0x7E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F,
  0x78, 0x1E, 0x7C, 0x3E, 0x7E, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xBE,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0xEF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x7C, 0xFC, 0xFC, 0x78, 0x03, 0xC1, 0xF0,
  0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x1F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x1F, 0xE3, 0xFF, 0x9F, 0xFE,
  0x7B, 0xF2, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0xF0, 0x7F, 0x9E, 0x78, 0xFF, 0xC7, 0x78, 0xFF, 0xE3, 0xBC,
  0x78, 0xF1, 0xDC, 0x78, 0x70, 0xEE, 0x38, 0x38, 0x7F, 0x3C, 0x3C, 0x7F,
  0x9E, 0x1C, 0x3F, 0xCF, 0x1E, 0x3D, 0xE7, 0x8F, 0x1E, 0x71, 0xFF, 0xFE,
  0x38, 0xFE, 0xFE, 0x1E, 0x1C, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x0E, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xC0, 0x0F, 0x3C, 0x01, 0xF3,
  0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xE0, 0x1E, 0x3E,
  0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1E, 0x1E, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF8,
  0x3C, 0x3F, 0x0F, 0x07, 0xC7, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x1E,
  0x0F, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x00, 0x8F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x01, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0,
  0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0x07, 0xE1, 0xFF, 0xFC, 0x7F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x02, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xF8, 0x08, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE1, 0xFF, 0x7C, 0x3F, 0xEF, 0x87, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x81, 0xE1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x03, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xE0, 0x3C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x9F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0x30, 0x00, 0x0F,
  0x81, 0xF8, 0x7C, 0x1F, 0x03, 0xE1, 0xF8, 0x1E, 0x1F, 0x81, 0xF0, 0xF8,
  0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x1E, 0xFC, 0x01, 0xF7,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC1, 0xF0, 0x1E, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xE0,
  0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xEE, 0x07, 0x78, 0x7B, 0x83, 0xDE, 0x1E,
  0xE0, 0xEF, 0x8F, 0xB8, 0x7B, 0xC3, 0xCE, 0x1C, 0xF0, 0xF3, 0x8F, 0x3C,
  0x3C, 0xE3, 0x9F, 0x0F, 0x39, 0xE7, 0xC7, 0xCE, 0x71, 0xE1, 0xE3, 0xFC,
  0x78, 0x78, 0xFE, 0x1E, 0x1E, 0x3F, 0x8F, 0x87, 0x8F, 0xC3, 0xE3, 0xC3,
  0xF0, 0xF0, 0xF0, 0xF8, 0x3C, 0x3C, 0x3E, 0x1F, 0x00, 0x0F, 0xC0, 0x3E,
  0x1F, 0x80, 0x78, 0x3F, 0x80, 0xF0, 0x7F, 0x01, 0xE1, 0xFE, 0x07, 0xC3,
  0xFE, 0x0F, 0x07, 0xBC, 0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0xF8, 0x78, 0x7C,
  0xF1, 0xF0, 0xF1, 0xE3, 0xC1, 0xE3, 0xE7, 0x83, 0xC3, 0xCF, 0x07, 0x87,
  0x9E, 0x1F, 0x0F, 0xFC, 0x3C, 0x0F, 0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x3F,
  0xC1, 0xE0, 0x7F, 0x87, 0xC0, 0x7F, 0x0F, 0x00, 0xFC, 0x1E, 0x01, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1E, 0x07, 0xCF, 0x83, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x03, 0xE3, 0xE0,
  0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F, 0x1E,
  0x0F, 0x9F, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC1,
  0xF1, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x1F, 0x1E, 0x0F, 0x9F, 0x03,
  0xCF, 0x81, 0xF7, 0xC0, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3E, 0x02, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x80, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF1,
  0xF0, 0x1E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0x87, 0xC0, 0x78, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xFB, 0xC0,
  0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0x78, 0x7C,
  0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x07,
  0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0,
  0x3E, 0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x7C, 0xF0, 0x7F, 0x07, 0xCF,
  0x07, 0xF0, 0x78, 0xF0, 0x7F, 0x0F, 0x8F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF,
  0x1F, 0x0F, 0x1E, 0xF1, 0xE0, 0xF1, 0xEF, 0x1E, 0x0F, 0x3C, 0xF3, 0xC0,
  0xF3, 0xCF, 0x3C, 0x0F, 0x38, 0xF7, 0xC0, 0xF7, 0x8F, 0x78, 0x0F, 0x78,
  0xF7, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0xC0, 0x1F,
  0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x3E, 0x1F,
  0x80, 0x7C, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0x9E, 0x0F, 0xCF, 0x07, 0xC7,
  0xC7, 0xC3, 0xE3, 0xC0, 0xF3, 0xE0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0x03,
  0xF8, 0x3F, 0xC0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E,
  0x0F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xE0, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xF7, 0x03, 0xCE, 0x07, 0x1C,
  0x1E, 0x3C, 0x38, 0x38, 0xF0, 0x73, 0xC0, 0xF7, 0x01, 0xFE, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF8, 0xF0, 0xE1, 0xE0, 0x07, 0xE7, 0x87,
  0xFB, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0x78, 0x3F, 0x38, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x7C, 0x1E, 0xFE, 0x1F, 0xFE, 0x3F, 0xBF, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x3E,
  0x7C, 0x7E, 0xFE, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xE7, 0xE0, 0x03, 0xFC,
  0x3F, 0xF1, 0xFF, 0xCF, 0xEE, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x11, 0xFB, 0xC7, 0xFF,
  0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x1F, 0xBE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xE1,
  0xF0, 0x7D, 0xFC, 0x1F, 0xFF, 0x07, 0xFB, 0xC0, 0xFC, 0xE0, 0x03, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF9, 0xF8, 0xF3, 0xE1, 0xEF, 0x83, 0xDF, 0x0F, 0xBF,
  0xFE, 0x7F, 0xF9, 0xFF, 0xC3, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x83,
  0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x02, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE7, 0x87, 0xFB, 0xC7, 0xFF, 0xC7, 0xFF,
  0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x78, 0x1E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3E, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x0C, 0x1F,
  0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x7C, 0x1E,
  0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x1F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x03, 0x07, 0xC3, 0xE1, 0xF0,
  0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x00, 0x10,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x27, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x1E,
  0x0F, 0x87, 0x87, 0xC3, 0xE3, 0xE0, 0xF9, 0xF0, 0x3C, 0xF8, 0x0F, 0x7C,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x01,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x07, 0xC3, 0xC0, 0xF8, 0x07,
  0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87,
  0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0x1E, 0x7C, 0x3F, 0x0E, 0x7F, 0x3F, 0xC7, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFD, 0xF3, 0xF1, 0xF8, 0x79, 0xF0, 0xFC, 0x3C, 0xF8, 0x7C, 0x1E,
  0x78, 0x3E, 0x0F, 0x7C, 0x1E, 0x0F, 0xBE, 0x0F, 0x07, 0xDF, 0x0F, 0x83,
  0xCF, 0x07, 0xC1, 0xE7, 0x83, 0xE1, 0xF7, 0xC1, 0xE0, 0xFB, 0xE0, 0xF0,
  0x7D, 0xE0, 0xF8, 0x3C, 0xF0, 0x7C, 0x1E, 0x00, 0x1E, 0x7C, 0x1C, 0xFE,
  0x1D, 0xFF, 0x3F, 0xFF, 0x3F, 0x1F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0x78, 0x7E, 0x7E, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0x9F, 0x01, 0xDF, 0xE0, 0x77, 0xF8, 0x3F,
  0xBF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x1F, 0x07,
  0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1F, 0x1F, 0x8F, 0xEF, 0xC3,
  0xFF, 0xE0, 0xF7, 0xF0, 0x3C, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xE7,
  0x87, 0xFB, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F,
  0x87, 0xC3, 0xEF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x1E, 0x78, 0xF7, 0xC7, 0xFE, 0x7F, 0xE3, 0xF8, 0x1F, 0x80, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xF1, 0xFF, 0xCF, 0x86,
  0x3E, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3E, 0x80, 0xFB, 0x87, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x1F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0xC8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x3E, 0x0F, 0x3C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0x78, 0x7E, 0x78, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0,
  0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF0, 0xF9, 0xF0, 0x79, 0xE0, 0x7B,
  0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x3E,
  0xF0, 0xFC, 0x3C, 0xF1, 0xFC, 0x7C, 0xF1, 0xDC, 0x78, 0xF3, 0xDC, 0x78,
  0xF3, 0xDC, 0xF8, 0xF3, 0x9C, 0xF0, 0xF7, 0x9D, 0xF0, 0xF7, 0x1D, 0xE0,
  0xF7, 0x1D, 0xE0, 0xFF, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x7C, 0x3E, 0x07,
  0xC7, 0xC0, 0x3C, 0xF8, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0xFC, 0x1F,
  0x80, 0x0F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F,
  0x07, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00,
  0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0xFE, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0xFC, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xD0, 0x0C, 0x00,
};

const GFXglyph NotoSans_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 22, 9, 0, -22 },
  { 29, 11, 8, 14, 3, -22 },
  { 40, 19, 22, 20, 1, -22 },
  { 93, 16, 26, 17, 1, -24 },
  { 145, 23, 22, 27, 2, -22 },
  { 209, 21, 22, 22, 1, -22 },
  { 267, 5, 8, 8, 3, -22 },
  { 272, 12, 27, 11, 1, -22 },
  { 313, 11, 28, 11, -2, -23 },
  { 352, 15, 15, 17, 3, -24 },
  { 381, 15, 15, 18, 2, -18 },
  { 410, 7, 8, 9, -1, -4 },
  { 417, 8, 4, 10, 1, -10 },
  { 421, 6, 5, 9, 0, -5 },
  { 425, 16, 22, 13, -1, -22 },
  { 469, 16, 22, 17, 1, -22 },
  { 513, 12, 22, 17, 3, -22 },
  { 546, 18, 22, 17, -1, -22 },
  { 596, 17, 22, 17, 0, -22 },
  { 643, 17, 22, 17, 0, -22 },
  { 690, 17, 22, 17, 0, -22 },
  { 737, 16, 22, 17, 1, -22 },
  { 781, 17, 22, 17, 1, -22 },
  { 828, 16, 22, 17, 1, -22 },
  { 872, 16, 22, 17, 1, -22 },
  { 916, 8, 17, 9, 0, -17 },
  { 933, 10, 21, 9, -2, -17 },
  { 960, 15, 16, 18, 2, -19 },
  { 990, 15, 10, 18, 2, -16 },
  { 1009, 15, 16, 18, 2, -19 },
  { 1039, 13, 22, 14, 2, -22 },
  { 1075, 25, 25, 27, 1, -22 },
  { 1154, 20, 22, 19, -2, -22 },
  { 1209, 18, 22, 19, 1, -22 },
  { 1259, 18, 22, 19, 2, -22 },
  { 1309, 19, 22, 21, 1, -22 },
  { 1362, 17, 22, 17, 1, -22 },
  { 1409, 17, 22, 17, 1, -22 },
  { 1456, 19, 22, 21, 2, -22 },
  { 1509, 21, 22, 22, 1, -22 },
  { 1567, 15, 22, 12, -1, -22 },
  { 1609, 16, 29, 10, -5, -22 },
  { 1667, 21, 22, 19, 1, -22 },
  { 1725, 13, 22, 16, 1, -22 },
  { 1761, 26, 22, 27, 1, -22 },
  { 1833, 23, 22, 24, 1, -22 },
  { 1897, 20, 22, 23, 2, -22 },
  { 1952, 18, 22, 19, 1, -22 },
  { 2002, 20, 27, 23, 2, -22 },
  { 2070, 17, 22, 19, 1, -22 },
  { 2117, 16, 22, 16, 1, -22 },
  { 2161, 16, 22, 16, 3, -22 },
  { 2205, 20, 22, 21, 2, -22 },
  { 2260, 18, 22, 18, 3, -22 },
  { 2310, 28, 22, 28, 3, -22 },
  { 2387, 23, 22, 19, -2, -22 },
  { 2451, 17, 22, 17, 3, -22 },
  { 2498, 19, 22, 17, -1, -22 },
  { 2551, 13, 27, 10, -1, -22 },
  { 2595, 8, 22, 13, 3, -22 },
  { 2617, 13, 27, 10, -2, -22 },
  { 2661, 15, 14, 17, 1, -22 },
  { 2688, 13, 2, 12, -3, 3 },
  { 2692, 7, 5, 10, 4, -24 },
  { 2697, 17, 17, 18, 1, -17 },
  { 2734, 16, 24, 18, 1, -24 },
  { 2782, 14, 17, 15, 1, -17 },
  { 2812, 18, 24, 18, 1, -24 },
  { 2866, 15, 17, 17, 1, -17 },
  { 2898, 18, 31, 12, -3, -24 },
  { 2968, 17, 24, 18, 1, -17 },
  { 3019, 16, 24, 19, 1, -24 },
  { 3067, 9, 24, 9, 1, -24 },
  { 3094, 14, 31, 9, -4, -24 },
  { 3149, 18, 24, 18, 1, -24 },
  { 3203, 9, 24, 9, 1, -24 },
  { 3230, 25, 17, 28, 1, -17 },
  { 3284, 16, 17, 19, 1, -17 },
  { 3318, 16, 17, 18, 1, -17 },
  { 3352, 18, 24, 18, -1, -17 },
  { 3406, 17, 24, 18, 1, -17 },
  { 3457, 13, 17, 13, 1, -17 },
  { 3485, 14, 17, 15, 0, -17 },
  { 3515, 12, 21, 13, 1, -21 },
  { 3547, 16, 17, 19, 2, -17 },
  { 3581, 16, 17, 16, 2, -17 },
  { 3615, 24, 17, 24, 2, -17 },
  { 3666, 20, 17, 17, -2, -17 },
  { 3709, 20, 24, 16, -2, -17 },
  { 3769, 16, 17, 15, -1, -17 },
  { 3803, 13, 27, 11, 0, -22 },
  { 3847, 3, 30, 17, 7, -23 },
  { 3859, 13, 27, 11, -2, -22 },
  { 3903, 15, 6, 18, 2, -14 },
};

const GFXfont NotoSans_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_BOLDITALIC31PT7B_H_
