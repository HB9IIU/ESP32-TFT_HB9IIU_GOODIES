#ifndef _JETBRAINSMONO_SEMIBOLD36PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9C, 0x71, 0xC0, 0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xE0, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xE0, 0x03, 0xC1, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x03, 0x83, 0x80, 0x78, 0x38, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xE0,
  0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC1, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03,
  0x83, 0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFE,
  0x7E, 0xDF, 0x3C, 0x67, 0xDE, 0x31, 0xEF, 0x18, 0xF7, 0x8C, 0x03, 0xE6,
  0x01, 0xF3, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x0D, 0xF8, 0x06, 0x7C, 0x03, 0x1E, 0x01, 0x8F, 0xF0, 0xC7,
  0xFC, 0x63, 0xDE, 0x33, 0xEF, 0xDF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x3F, 0x80, 0x3D, 0xFF, 0x01, 0xC7, 0x9E, 0x0F, 0x1C, 0x38, 0x38, 0xF0,
  0xE1, 0xC3, 0xC3, 0x8F, 0x0F, 0x0E, 0x38, 0x3C, 0x39, 0xC0, 0x71, 0xEE,
  0x01, 0xFF, 0x38, 0x03, 0xF9, 0xC0, 0x01, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x7B, 0xFC, 0x01, 0xDF, 0xF8, 0x0E,
  0x70, 0xE0, 0x71, 0xC3, 0x81, 0xC7, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0x70,
  0xE3, 0xC1, 0xC3, 0x8E, 0x07, 0xFE, 0x70, 0x0F, 0xF3, 0xC0, 0x1F, 0x80,
  0x01, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xC3, 0xE0,
  0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0xF7,
  0x9E, 0x1E, 0xF1, 0xE7, 0x9E, 0x3F, 0xF3, 0xC3, 0xFC, 0x78, 0x3F, 0x8F,
  0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0xC7, 0xF8, 0x7F, 0xF7, 0x8F,
  0xFC, 0xF8, 0x7F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x60, 0x3C, 0x0F, 0x87, 0xF1, 0xFC, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x01, 0xE0, 0x0C, 0xC0, 0x1E,
  0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x7E, 0x3F, 0x87, 0xE0, 0xF8, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xC1, 0xC1, 0x9F,
  0x38, 0xFF, 0xF3, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x3B, 0xC0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0x78, 0x1E,
  0x0F, 0x81, 0xC0, 0xE0, 0x10, 0x10, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3F, 0x3E, 0x3E, 0x7C,
  0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF1, 0x0F, 0xF3, 0xCF, 0xF7, 0xCF, 0xF3,
  0xCF, 0xF3, 0x8F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xDE, 0x07,
  0x8F, 0x03, 0x87, 0x81, 0x83, 0xC0, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x79, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x0F, 0x3E, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xEF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x87, 0xEF, 0x80, 0xFB, 0xE0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF8, 0x07, 0x9F, 0x03,
  0xE7, 0xE3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xBE, 0x03, 0xEF,
  0x80, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xE0, 0x3E,
  0xF0, 0x0F, 0x78, 0x0F, 0xBE, 0x07, 0x8F, 0x87, 0xC3, 0xE7, 0xC0, 0xFF,
  0xC0, 0x3F, 0x80, 0x3F, 0xF0, 0x7E, 0x7C, 0x3C, 0x1F, 0x3C, 0x07, 0xDE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xFC, 0x3E,
  0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x1E, 0x03, 0xEF, 0x80, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x1E, 0x7C, 0x0F,
  0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0x9E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x3E, 0xFF, 0xFF, 0xFE, 0x1E,
  0x3F, 0x7F, 0x3F, 0x3F, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0,
  0xF0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xF8, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xEF, 0xE3, 0xE0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0x1F, 0xC1, 0xFB, 0xF8, 0x7F, 0xFF,
  0x0F, 0x1F, 0xE3, 0xC1, 0xFC, 0x78, 0x3F, 0x8F, 0x07, 0xF1, 0xE0, 0xFE,
  0x3C, 0x1F, 0xC7, 0x83, 0xF8, 0xF0, 0x7F, 0x1E, 0x0F, 0xE1, 0xC3, 0xFC,
  0x3F, 0xFF, 0x83, 0xF7, 0xF0, 0x3C, 0xEE, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1E,
  0x03, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1F, 0x78,
  0x01, 0xFF, 0x00, 0x3C, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x0F,
  0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78,
  0x0F, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xF9,
  0xE0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00,
  0x01, 0x80, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7E, 0x7E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xFF, 0xF1, 0xFF,
  0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7B, 0xE0, 0x7D, 0xFC, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7,
  0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xC7, 0xC1, 0xE1, 0xF0, 0xF0,
  0xF8, 0x78, 0x3C, 0x3C, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xE7, 0x80, 0xF3,
  0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFD, 0x83, 0xFE, 0xE1, 0xFF, 0x70, 0xFF, 0xF8,
  0xEF, 0xEE, 0x77, 0xF7, 0x3B, 0xFB, 0xB9, 0xFC, 0xFC, 0xFE, 0x7E, 0x7F,
  0x3E, 0x3F, 0x8F, 0x1F, 0xC7, 0x9F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xEE, 0x0F, 0xEE, 0x0F, 0xEF, 0x0F, 0xE7, 0x0F,
  0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF,
  0xF1, 0xCF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0x80,
  0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7E, 0x7E, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1,
  0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x7E,
  0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9E, 0x0F, 0xEF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x0F, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3,
  0xFF, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x8F, 0x03, 0xC7, 0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x3E, 0xF0, 0x0F, 0x78,
  0x07, 0xC0, 0x01, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1,
  0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x3D, 0xE0, 0x3E, 0xFE, 0x7F, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xF0, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE1, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0x80, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x70,
  0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xE0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF1, 0xF0, 0xEF, 0x1F, 0x0E, 0xF1, 0xF0, 0xEF, 0x1B,
  0x8E, 0x71, 0xB8, 0xE7, 0x19, 0x9E, 0x71, 0x99, 0xE7, 0x19, 0x9E, 0x7B,
  0x99, 0xE7, 0xB9, 0x9C, 0x7B, 0x99, 0xC7, 0xB1, 0x9C, 0x7B, 0x1D, 0xC3,
  0xB1, 0xDC, 0x3B, 0x1D, 0xC3, 0xB0, 0xDC, 0x3B, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x03,
  0xEF, 0x80, 0x78, 0xF8, 0x1F, 0x0F, 0x03, 0xC1, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xF7, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x81, 0xF0, 0xF0,
  0x3C, 0x1F, 0x0F, 0x81, 0xF3, 0xE0, 0x3E, 0x78, 0x03, 0xFF, 0x00, 0x7C,
  0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF9,
  0xE0, 0x07, 0x9E, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0x70,
  0x1E, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0x70, 0x1E,
  0xF0, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xE7, 0xE7, 0xC0, 0xFB, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x07, 0xFF, 0x8F, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xBF, 0xFB, 0xCF, 0xFD, 0xE3,
  0xF8, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF3, 0xF0, 0xF7, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x7E,
  0xFF, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFE,
  0x7F, 0xFE, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x1F, 0x8F,
  0x3F, 0xCF, 0x7F, 0xEF, 0xFF, 0xEF, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x6F, 0x7F, 0xEF, 0x3F, 0xEF,
  0x1F, 0xCF, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0x7C, 0x3E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x1F, 0x8F, 0x3F, 0xCF, 0x7F, 0xEF, 0xFF, 0xEF, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xEF, 0x7F, 0xEF,
  0x3F, 0xCF, 0x0F, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x3F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x3F, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x0F, 0x8F,
  0x07, 0x87, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0xC7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0,
  0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0xE7, 0x8F, 0x3B, 0xF7,
  0xEE, 0xFF, 0xFB, 0xC7, 0x9E, 0xF1, 0xC3, 0xFC, 0x70, 0xFF, 0x1C, 0x3F,
  0xC7, 0x0F, 0xF1, 0xC3, 0xFC, 0x70, 0xFF, 0x1C, 0x3F, 0xC7, 0x0F, 0xF1,
  0xC3, 0xFC, 0x70, 0xFF, 0x1C, 0x3F, 0xC7, 0x0F, 0xF1, 0xC3, 0xFC, 0x70,
  0xFF, 0x1C, 0x3F, 0xC7, 0x0F, 0xF3, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x0F, 0xE0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF0, 0xF3, 0xF0, 0xF7, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x7E, 0xFF,
  0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x8F, 0x3F, 0xCF, 0x7F, 0xEF, 0xFF,
  0xEF, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x6F, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF3, 0xF0, 0xF7,
  0xFC, 0xFF, 0xFE, 0xFE, 0xFE, 0xF8, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F,
  0xFE, 0x7F, 0xFE, 0x1F, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xF0, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x0F, 0x9F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0xE0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xEF, 0x0F, 0x0E, 0x71, 0xF0,
  0xE7, 0x1F, 0x0E, 0x71, 0xB1, 0xE7, 0x1B, 0x9E, 0x79, 0x99, 0xC7, 0x99,
  0x9C, 0x7B, 0x99, 0xC3, 0xB9, 0x9C, 0x3B, 0x19, 0xC3, 0xB1, 0xFC, 0x3B,
  0x1F, 0x83, 0xB0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xE0, 0xF8, 0x7C, 0x03, 0xE7, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC0,
  0xF1, 0xF0, 0x1F, 0x3C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x7C, 0x03,
  0xE7, 0x80, 0xF8, 0xF8, 0x1E, 0x0F, 0x87, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E,
  0x01, 0xF0, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x79, 0xE0, 0x3E, 0x7C,
  0x0F, 0x8F, 0x03, 0xC3, 0xC1, 0xF0, 0xF8, 0x78, 0x1E, 0x1E, 0x07, 0xCF,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x0F, 0xF1,
  0xE3, 0xFC, 0x7F, 0xEF, 0x0F, 0xFB, 0xC1, 0xFC,
};

const GFXglyph JetBrainsMono_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 12, 11, 22, 5, -26 },
  { 38, 20, 26, 22, 1, -26 },
  { 103, 17, 36, 22, 2, -31 },
  { 180, 22, 26, 22, 0, -26 },
  { 252, 19, 27, 22, 2, -27 },
  { 317, 4, 11, 22, 9, -26 },
  { 323, 11, 34, 22, 6, -30 },
  { 370, 11, 34, 22, 4, -30 },
  { 417, 19, 19, 22, 1, -22 },
  { 463, 17, 17, 22, 2, -20 },
  { 500, 8, 11, 22, 6, -5 },
  { 511, 12, 4, 22, 5, -14 },
  { 517, 6, 6, 22, 8, -6 },
  { 522, 17, 34, 22, 2, -30 },
  { 595, 16, 27, 22, 3, -27 },
  { 649, 17, 26, 22, 3, -26 },
  { 705, 17, 27, 22, 2, -27 },
  { 763, 17, 26, 22, 2, -26 },
  { 819, 16, 26, 22, 2, -26 },
  { 871, 16, 26, 22, 3, -26 },
  { 923, 18, 26, 22, 2, -26 },
  { 982, 18, 26, 22, 2, -26 },
  { 1041, 17, 27, 22, 2, -27 },
  { 1099, 18, 27, 22, 2, -27 },
  { 1160, 6, 20, 22, 8, -20 },
  { 1175, 8, 26, 22, 6, -20 },
  { 1201, 16, 20, 22, 3, -22 },
  { 1241, 16, 12, 22, 3, -18 },
  { 1265, 16, 20, 22, 3, -22 },
  { 1305, 14, 26, 22, 4, -26 },
  { 1351, 19, 33, 22, 1, -27 },
  { 1430, 19, 26, 22, 1, -26 },
  { 1492, 17, 26, 22, 3, -26 },
  { 1548, 16, 27, 22, 3, -27 },
  { 1602, 16, 26, 22, 3, -26 },
  { 1654, 16, 26, 22, 3, -26 },
  { 1706, 16, 26, 22, 3, -26 },
  { 1758, 16, 27, 22, 3, -27 },
  { 1812, 16, 26, 22, 3, -26 },
  { 1864, 15, 26, 22, 3, -26 },
  { 1913, 17, 26, 22, 1, -26 },
  { 1969, 17, 26, 22, 3, -26 },
  { 2025, 15, 26, 22, 4, -26 },
  { 2074, 17, 26, 22, 2, -26 },
  { 2130, 16, 26, 22, 3, -26 },
  { 2182, 16, 27, 22, 3, -27 },
  { 2236, 17, 26, 22, 3, -26 },
  { 2292, 16, 33, 22, 3, -27 },
  { 2358, 17, 26, 22, 3, -26 },
  { 2414, 17, 27, 22, 2, -27 },
  { 2472, 18, 26, 22, 2, -26 },
  { 2531, 16, 26, 22, 3, -26 },
  { 2583, 19, 26, 22, 1, -26 },
  { 2645, 20, 26, 22, 1, -26 },
  { 2710, 19, 26, 22, 1, -26 },
  { 2772, 20, 26, 22, 1, -26 },
  { 2837, 16, 26, 22, 3, -26 },
  { 2889, 10, 34, 22, 7, -30 },
  { 2932, 17, 34, 22, 2, -30 },
  { 3005, 10, 34, 22, 5, -30 },
  { 3048, 16, 14, 22, 3, -26 },
  { 3076, 17, 4, 22, 2, 1 },
  { 3085, 9, 5, 22, 6, -28 },
  { 3091, 17, 20, 22, 2, -20 },
  { 3134, 16, 26, 22, 3, -26 },
  { 3186, 16, 20, 22, 3, -20 },
  { 3226, 16, 26, 22, 3, -26 },
  { 3278, 16, 20, 22, 3, -20 },
  { 3318, 17, 26, 22, 2, -26 },
  { 3374, 16, 26, 22, 3, -20 },
  { 3426, 16, 26, 22, 3, -26 },
  { 3478, 17, 28, 22, 3, -28 },
  { 3538, 14, 34, 22, 3, -28 },
  { 3598, 17, 26, 22, 3, -26 },
  { 3654, 19, 26, 22, 1, -26 },
  { 3716, 18, 20, 22, 2, -20 },
  { 3761, 16, 20, 22, 3, -20 },
  { 3801, 16, 20, 22, 3, -20 },
  { 3841, 16, 26, 22, 3, -20 },
  { 3893, 16, 26, 22, 3, -20 },
  { 3945, 16, 20, 22, 4, -20 },
  { 3985, 16, 20, 22, 3, -20 },
  { 4025, 17, 25, 22, 2, -25 },
  { 4079, 16, 20, 22, 3, -20 },
  { 4119, 18, 20, 22, 2, -20 },
  { 4164, 20, 20, 22, 1, -20 },
  { 4214, 19, 20, 22, 1, -20 },
  { 4262, 18, 26, 22, 2, -20 },
  { 4321, 16, 20, 22, 3, -20 },
  { 4361, 16, 34, 22, 3, -30 },
  { 4429, 4, 34, 22, 9, -30 },
  { 4446, 16, 34, 22, 3, -30 },
  { 4514, 18, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_SEMIBOLD36PT7B_H_
