#ifndef _JETBRAINSMONO_SEMIBOLD41PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x80, 0x00, 0x00, 0x00, 0xFB,
  0xF7, 0xFF, 0xEF, 0x80, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xF7, 0x87, 0xDE, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0F, 0x01, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x3C,
  0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xE0, 0x70, 0x07, 0x81,
  0xC0, 0x1E, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0xC0,
  0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x3C,
  0x01, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0x77, 0xE7, 0xC7, 0x3E, 0x7C, 0x71, 0xF7, 0xC7, 0x1F, 0x7C,
  0x70, 0x07, 0xC7, 0x00, 0x7E, 0x70, 0x03, 0xF7, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x77, 0xE0, 0x07, 0x3F, 0x00, 0x71, 0xF0, 0x07, 0x1F, 0xF8, 0x71,
  0xF7, 0x87, 0x1F, 0x7C, 0x71, 0xF7, 0xE7, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x07,
  0x9F, 0xF0, 0x07, 0x9F, 0xFC, 0x07, 0x8F, 0x1E, 0x03, 0x87, 0x07, 0x03,
  0x83, 0x83, 0x83, 0xC1, 0xC1, 0xC3, 0xC0, 0xE0, 0xE1, 0xC0, 0x70, 0x71,
  0xE0, 0x38, 0x79, 0xE0, 0x1F, 0x7C, 0xE0, 0x07, 0xFC, 0xF0, 0x01, 0xFC,
  0xF0, 0x00, 0x10, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x60, 0x00, 0x39, 0xFE, 0x00, 0x3D, 0xFF, 0x80, 0x3C, 0xFF, 0xE0,
  0x1C, 0xF0, 0xF0, 0x1E, 0x78, 0x38, 0x1E, 0x3C, 0x1C, 0x0E, 0x1E, 0x0E,
  0x0E, 0x0F, 0x07, 0x0F, 0x07, 0x87, 0x8F, 0x03, 0xC3, 0xC7, 0x00, 0xFF,
  0xC7, 0x80, 0x3F, 0xE7, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF0,
  0x1F, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x1F, 0xF9, 0xF0, 0xFF, 0xC7, 0xCF, 0xBC, 0x3E, 0x7D, 0xE0, 0xFF, 0xCF,
  0x03, 0xFC, 0x78, 0x1F, 0xE3, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F,
  0xC7, 0xC1, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFB, 0xE3, 0xFF, 0x8F, 0x0F,
  0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xE0, 0x00, 0x38,
  0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x60, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC,
  0x0F, 0x80, 0x78, 0x02, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x01, 0xE0, 0x27, 0x83,
  0x83, 0x9F, 0x8E, 0x3F, 0x7F, 0x3B, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xB8, 0x00, 0x3E, 0xF0, 0x00,
  0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xC0,
  0x78, 0x06, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xC0, 0xFD, 0xF0, 0x0F,
  0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x0C, 0x3F, 0xE3, 0xE7, 0xFC, 0x7C, 0xFF, 0x8F, 0x9F,
  0xF1, 0xF3, 0xFE, 0x08, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xCF, 0x81, 0xF9,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xEF,
  0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xE0, 0xF8, 0x08, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xE0,
  0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xF7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC1, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x3C, 0xFF, 0x07, 0xBF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xC7, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xC0, 0x1E, 0xF8, 0x07, 0xCF, 0x81, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x7F, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF8, 0xFE, 0x7E, 0x03, 0xE7,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF3, 0xE0, 0x7E, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x1E, 0xF8, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x07,
  0xC3, 0xFB, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0x0F, 0xC3, 0xF1, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xF9, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x07, 0xE7, 0xC0, 0x3F, 0x7C,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7,
  0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x3F, 0x8F, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFB, 0xE0, 0xFF, 0x7C, 0x01, 0x8F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x79,
  0xFB, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x1E, 0x1F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C,
  0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xE0, 0xFE, 0x3E,
  0x00, 0xF8, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xFF, 0x81, 0xF3, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xDF,
  0xE1, 0xF1, 0xFF, 0x87, 0x83, 0xFE, 0x3E, 0x0F, 0xF8, 0xF0, 0x3F, 0xE3,
  0xC0, 0xFF, 0x8F, 0x03, 0xFE, 0x3C, 0x0F, 0xF8, 0xF0, 0x3F, 0xE3, 0xC0,
  0xFF, 0x87, 0x83, 0xFE, 0x1E, 0x0F, 0xF8, 0x7C, 0x7F, 0xE1, 0xFF, 0x7F,
  0x83, 0xF9, 0xDE, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0xFB, 0xC0, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x01, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0,
  0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x00,
  0x7C, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x81,
  0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7B, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xF8, 0xF8, 0x3F, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x01, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE0,
  0xFD, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xCF, 0xC1, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x87,
  0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F,
  0xDF, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xCF, 0xC1, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x87, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x7F, 0x70, 0x7F, 0xF7, 0x0F,
  0xFF, 0x78, 0xEF, 0xF3, 0x8E, 0xFF, 0x38, 0xEF, 0xFB, 0xDE, 0xFF, 0xBD,
  0xCF, 0xF9, 0xDC, 0xFF, 0x9F, 0xCF, 0xF9, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8,
  0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xDE, 0x0F, 0xF7, 0x83, 0xFD, 0xE0, 0xFF, 0x3C, 0x3F, 0xCF,
  0x0F, 0xF3, 0xC3, 0xFE, 0x78, 0xFF, 0x9E, 0x3F, 0xE3, 0x8F, 0xF8, 0xF3,
  0xFE, 0x3C, 0xFF, 0x87, 0x3F, 0xE1, 0xEF, 0xF8, 0x7B, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xFC, 0x07, 0xDF, 0x83, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xF8, 0x1F, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xCF, 0xC1, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xCF, 0x80, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x81, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F,
  0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x07,
  0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xE0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x83, 0xF7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3D, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C,
  0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0xFF, 0x83, 0xE1,
  0xEF, 0x07, 0xC3, 0xDE, 0x0D, 0x87, 0xBE, 0x1B, 0x0F, 0x3C, 0x76, 0x1E,
  0x78, 0xEC, 0x3C, 0xF1, 0xDC, 0x79, 0xE3, 0xB8, 0xF3, 0xC7, 0x71, 0xE7,
  0x8C, 0xE3, 0xCF, 0x19, 0xCF, 0x1E, 0x33, 0x9E, 0x3C, 0xE3, 0x3C, 0x79,
  0xC6, 0x78, 0x7B, 0x8C, 0xF0, 0xF7, 0x1D, 0xE1, 0xEE, 0x3B, 0xC3, 0xD8,
  0x77, 0x87, 0xB0, 0xEF, 0x0F, 0x61, 0xDC, 0x1F, 0xC3, 0xB8, 0x3F, 0x83,
  0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xFF,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC1, 0xE0, 0xF8,
  0x3C, 0x1E, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x9E, 0x00, 0xF7, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7C, 0x07, 0xDF, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7D, 0xF0, 0x1F, 0xBF, 0x87, 0xF7, 0xFF, 0xDE, 0x7F, 0xF3, 0xC3,
  0xFC, 0x78, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0xF9, 0xFF, 0x1F,
  0x7F, 0xF3, 0xFF, 0xFE, 0x7F, 0x8F, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xFC,
  0x07, 0xDF, 0xC1, 0xFB, 0xFF, 0xFF, 0x7D, 0xFF, 0xCF, 0xBF, 0xF1, 0xF3,
  0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7,
  0xF1, 0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x1F, 0x0F, 0x1F, 0xF3, 0xCF, 0xFE, 0xF7, 0xFF, 0xBD, 0xF8, 0x6F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x03, 0xF7, 0xFF, 0xBC, 0xFF, 0xEF,
  0x3F, 0xF3, 0xC3, 0xF8, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x79,
  0xF0, 0x1F, 0x3F, 0xDF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x07, 0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD, 0xFF, 0xEF,
  0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x7C, 0x0F, 0xDF, 0xFE, 0xF7, 0xFF, 0xBC, 0xFF, 0xEF,
  0x1F, 0xF3, 0xC0, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE3, 0xF0, 0xF9, 0xFF, 0x3E, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F,
  0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0xF3,
  0xC3, 0xCF, 0x7E, 0x7E, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xFF,
  0x8F, 0x0F, 0xF8, 0x70, 0xFF, 0x87, 0x0F, 0xF8, 0x70, 0xFF, 0x87, 0x0F,
  0xF8, 0x70, 0xFF, 0x87, 0x0F, 0xF8, 0x70, 0xFF, 0x87, 0x0F, 0xF8, 0x70,
  0xFF, 0x87, 0x0F, 0xF8, 0x70, 0xFF, 0x87, 0x0F, 0xF8, 0x70, 0xFF, 0x87,
  0x0F, 0xF8, 0x70, 0xFF, 0x87, 0x0F, 0xF8, 0x70, 0xF0, 0xF8, 0xFC, 0x3E,
  0x7F, 0xCF, 0xBF, 0xFB, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3C, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1,
  0xFC, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0xFC, 0x1F, 0x3F,
  0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xCF, 0xF1, 0xFD, 0xF8, 0x0F, 0xBF, 0x01,
  0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xDF, 0x80, 0xFB, 0xF8, 0x3F, 0x7F, 0xFF, 0xEF, 0xBF, 0xF9, 0xF7, 0xFE,
  0x3E, 0x7F, 0x87, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xC7, 0xFC,
  0xF3, 0xFF, 0xBD, 0xFF, 0xEF, 0x7E, 0x1B, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xF7, 0xE0, 0xFD, 0xFF, 0xEF, 0x3F, 0xFB, 0xCF, 0xFC, 0xF0, 0xFE, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0xF8, 0xFC, 0x1F, 0x7F, 0xE3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xE1, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xC0, 0xFC, 0xF0,
  0x07, 0xDE, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBF, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xDF, 0x01, 0xF7,
  0xE0, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x3B, 0xC1, 0xF0, 0xF7, 0x83, 0xE1, 0xE7,
  0x87, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x3B, 0x0F, 0x3C, 0x76, 0x1E, 0x78,
  0xEC, 0x38, 0xF1, 0xDC, 0xF0, 0xE3, 0x39, 0xE1, 0xE6, 0x73, 0xC3, 0xDC,
  0x67, 0x87, 0xB8, 0xCF, 0x0F, 0x71, 0x9C, 0x1E, 0xE3, 0xB8, 0x3D, 0x87,
  0xF0, 0x3B, 0x0F, 0xE0, 0x76, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E,
  0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x1F,
  0x9F, 0x80, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0xFC, 0x07, 0xC7, 0xC0, 0x3E,
  0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB,
  0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0x7C, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0xC7,
  0xE0, 0x3E, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x0F, 0x7F, 0xE0, 0xFF,
  0xFF, 0x0F, 0xF8, 0xF8, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFE,
  0xF0, 0x0F, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 30, 25, 9, -30 },
  { 28, 14, 12, 25, 5, -30 },
  { 49, 22, 30, 25, 1, -30 },
  { 132, 20, 42, 25, 2, -36 },
  { 237, 25, 30, 25, 0, -30 },
  { 331, 21, 30, 25, 2, -30 },
  { 410, 5, 12, 25, 10, -30 },
  { 418, 13, 39, 25, 7, -34 },
  { 482, 13, 39, 25, 5, -34 },
  { 546, 22, 21, 25, 1, -25 },
  { 604, 20, 19, 25, 2, -23 },
  { 652, 10, 13, 25, 6, -6 },
  { 669, 13, 5, 25, 6, -16 },
  { 678, 7, 7, 25, 9, -7 },
  { 685, 19, 39, 25, 3, -34 },
  { 778, 19, 30, 25, 3, -30 },
  { 850, 20, 30, 25, 3, -30 },
  { 925, 19, 30, 25, 3, -30 },
  { 997, 18, 30, 25, 3, -30 },
  { 1065, 18, 30, 25, 3, -30 },
  { 1133, 19, 30, 25, 3, -30 },
  { 1205, 20, 30, 25, 2, -30 },
  { 1280, 19, 30, 25, 3, -30 },
  { 1352, 19, 30, 25, 3, -30 },
  { 1424, 20, 30, 25, 2, -30 },
  { 1499, 7, 23, 25, 9, -23 },
  { 1520, 9, 30, 25, 7, -23 },
  { 1554, 18, 23, 25, 3, -25 },
  { 1606, 18, 15, 25, 3, -21 },
  { 1640, 18, 23, 25, 3, -25 },
  { 1692, 16, 30, 25, 5, -30 },
  { 1752, 22, 37, 25, 1, -30 },
  { 1854, 21, 30, 25, 2, -30 },
  { 1933, 19, 30, 25, 3, -30 },
  { 2005, 19, 30, 25, 3, -30 },
  { 2077, 19, 30, 25, 3, -30 },
  { 2149, 17, 30, 25, 4, -30 },
  { 2213, 19, 30, 25, 3, -30 },
  { 2285, 19, 30, 25, 3, -30 },
  { 2357, 18, 30, 25, 3, -30 },
  { 2425, 17, 30, 25, 4, -30 },
  { 2489, 20, 30, 25, 1, -30 },
  { 2564, 20, 30, 25, 3, -30 },
  { 2639, 18, 30, 25, 4, -30 },
  { 2707, 20, 30, 25, 2, -30 },
  { 2782, 18, 30, 25, 3, -30 },
  { 2850, 18, 30, 25, 3, -30 },
  { 2918, 20, 30, 25, 3, -30 },
  { 2993, 19, 37, 25, 3, -30 },
  { 3081, 20, 30, 25, 3, -30 },
  { 3156, 20, 30, 25, 2, -30 },
  { 3231, 21, 30, 25, 2, -30 },
  { 3310, 18, 30, 25, 3, -30 },
  { 3378, 21, 30, 25, 2, -30 },
  { 3457, 23, 30, 25, 1, -30 },
  { 3544, 22, 30, 25, 1, -30 },
  { 3627, 23, 30, 25, 1, -30 },
  { 3714, 18, 30, 25, 3, -30 },
  { 3782, 11, 39, 25, 8, -34 },
  { 3836, 19, 39, 25, 3, -34 },
  { 3929, 11, 39, 25, 6, -34 },
  { 3983, 19, 16, 25, 3, -30 },
  { 4021, 20, 4, 25, 2, 1 },
  { 4031, 10, 6, 25, 7, -32 },
  { 4039, 19, 23, 25, 2, -23 },
  { 4094, 19, 30, 25, 3, -30 },
  { 4166, 19, 23, 25, 3, -23 },
  { 4221, 18, 30, 25, 3, -30 },
  { 4289, 19, 23, 25, 3, -23 },
  { 4344, 20, 30, 25, 2, -30 },
  { 4419, 18, 30, 25, 3, -23 },
  { 4487, 18, 30, 25, 3, -30 },
  { 4555, 20, 32, 25, 3, -32 },
  { 4635, 16, 39, 25, 3, -32 },
  { 4713, 20, 30, 25, 3, -30 },
  { 4788, 22, 30, 25, 1, -30 },
  { 4871, 20, 23, 25, 2, -23 },
  { 4929, 18, 23, 25, 3, -23 },
  { 4981, 19, 23, 25, 3, -23 },
  { 5036, 19, 30, 25, 3, -23 },
  { 5108, 18, 30, 25, 3, -23 },
  { 5176, 19, 23, 25, 4, -23 },
  { 5231, 19, 23, 25, 3, -23 },
  { 5286, 20, 29, 25, 2, -29 },
  { 5359, 18, 23, 25, 3, -23 },
  { 5411, 21, 23, 25, 2, -23 },
  { 5472, 23, 23, 25, 1, -23 },
  { 5539, 21, 23, 25, 2, -23 },
  { 5600, 21, 30, 25, 2, -23 },
  { 5679, 18, 23, 25, 3, -23 },
  { 5731, 18, 39, 25, 3, -34 },
  { 5819, 5, 39, 25, 10, -34 },
  { 5844, 18, 39, 25, 3, -34 },
  { 5932, 20, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_SEMIBOLD41PT7B_H_
