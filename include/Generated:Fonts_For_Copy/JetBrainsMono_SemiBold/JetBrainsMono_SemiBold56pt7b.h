#ifndef _JETBRAINSMONO_SEMIBOLD56PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0x00,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7C, 0x07, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x1F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7C, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xF3, 0xCF, 0xF1, 0xFC, 0x78, 0xFE, 0x7F, 0x0F, 0x0F,
  0xCF, 0xE1, 0xE1, 0xFD, 0xFC, 0x3C, 0x3F, 0xBF, 0x87, 0x80, 0x07, 0xF0,
  0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x0F, 0xE3, 0xC0, 0x01, 0xFE, 0x78, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xE7, 0xF8, 0x00, 0x3C,
  0x7F, 0x80, 0x07, 0x87, 0xF0, 0x00, 0xF0, 0xFE, 0x00, 0x1E, 0x0F, 0xFF,
  0x83, 0xC1, 0xFF, 0xF0, 0x78, 0x3F, 0x7E, 0x0F, 0x0F, 0xEF, 0xE1, 0xE1,
  0xFD, 0xFE, 0x3C, 0x7F, 0x1F, 0xF7, 0xBF, 0xE3, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC7, 0xFF, 0x00, 0x03,
  0xE3, 0xFF, 0xE0, 0x01, 0xF0, 0xFF, 0xFC, 0x00, 0xF8, 0x7E, 0x1F, 0x00,
  0x3C, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x07, 0x80,
  0xF8, 0x7C, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0x7C, 0x0F, 0x8F, 0x80, 0x1F,
  0x07, 0xE7, 0xC0, 0x07, 0xFF, 0xF1, 0xE0, 0x00, 0xFF, 0xFC, 0xF8, 0x00,
  0x1F, 0xFE, 0x7C, 0x00, 0x03, 0xFE, 0x3E, 0x00, 0x00, 0x0C, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xE0, 0x00, 0x0F,
  0x1F, 0xFE, 0x00, 0x07, 0xCF, 0xFF, 0x80, 0x03, 0xE7, 0xFF, 0xF0, 0x01,
  0xF1, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x0F, 0x80, 0x3E, 0x1F, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xF0,
  0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x0F, 0x80, 0x0F, 0xFF, 0xC3, 0xE0, 0x03,
  0xFF, 0xE1, 0xF0, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF9, 0xFC, 0x1F, 0xDF, 0x87,
  0xF0, 0xFC, 0xFC, 0x1F, 0x8F, 0xE7, 0xE0, 0xFE, 0x7E, 0x3F, 0x03, 0xFF,
  0xF1, 0xF8, 0x0F, 0xFF, 0x0F, 0xC0, 0x7F, 0xF8, 0x7E, 0x01, 0xFF, 0x83,
  0xF0, 0x07, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0xF0, 0xFE,
  0x07, 0xFE, 0x03, 0xF8, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0x00,
  0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x04, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x08, 0x03,
  0xE0, 0x04, 0x78, 0x0F, 0x80, 0xF1, 0xFC, 0x1E, 0x0F, 0xE7, 0xF8, 0x78,
  0xFF, 0xBF, 0xF9, 0xC7, 0xFE, 0xFF, 0xF7, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x80, 0x04, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x1F, 0xCF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0xC0, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xF8, 0x07, 0xF9, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0x87, 0xFF, 0xC3,
  0xF1, 0xFF, 0xF1, 0xFC, 0x7F, 0xFC, 0x7F, 0x1F, 0xFF, 0x1F, 0xC7, 0xFF,
  0xC3, 0xF1, 0xFF, 0xF0, 0x78, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFD, 0xF8, 0x03, 0xFC, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0x01, 0xF8, 0x03, 0x80, 0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x20,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF7, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x03, 0xF8, 0xFF, 0x83, 0xFE, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x03,
  0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x7F, 0xF0, 0x7E, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xFB, 0xF8, 0x01,
  0xFD, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x03, 0xFB, 0xFF, 0x80, 0xFE, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0x0F, 0xF3, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE,
  0x00, 0xFF, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xA0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFC, 0x1F, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x0F,
  0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xE1,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xFC, 0x01,
  0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xE0, 0x0F, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFC, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x81,
  0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x20, 0x0F,
  0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC1, 0xFE,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF,
  0x01, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0xFC, 0x1F, 0x80, 0xFF, 0xF0, 0x7C,
  0x03, 0xFF, 0xC1, 0xF0, 0x0F, 0xFF, 0x07, 0xC0, 0x3F, 0xFC, 0x1F, 0x00,
  0xFF, 0xF0, 0x7C, 0x03, 0xFF, 0xC1, 0xF0, 0x0F, 0xFF, 0x07, 0xC0, 0x3F,
  0xFC, 0x1F, 0x00, 0xFF, 0xF0, 0x7C, 0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xFF,
  0x07, 0xE0, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0x8F, 0xFF, 0xC0,
  0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFE, 0x7F, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xF0, 0x07, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x01, 0xFC, 0xFC, 0x01,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0xF9, 0xF8, 0x01, 0xFE, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF,
  0xC7, 0xF8, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xBF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF,
  0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xF3, 0xF8, 0x01, 0xFE,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xEF, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xC7, 0xF8, 0x07, 0xF9, 0xFC,
  0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F,
  0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x03, 0xF9,
  0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xDF, 0xFF, 0x80, 0x7B, 0xFE, 0xF0,
  0x1F, 0xFF, 0xDF, 0x03, 0xFF, 0xFB, 0xE0, 0x7B, 0xFF, 0xBC, 0x1F, 0x7F,
  0xF7, 0xC3, 0xEF, 0xFE, 0xF8, 0x79, 0xFF, 0xCF, 0x0F, 0x3F, 0xF9, 0xE3,
  0xE7, 0xFF, 0x3E, 0x7C, 0xFF, 0xE7, 0xCF, 0x1F, 0xFC, 0x79, 0xE3, 0xFF,
  0x8F, 0xFC, 0xFF, 0xF1, 0xFF, 0x1F, 0xFE, 0x1F, 0xE3, 0xFF, 0xC3, 0xFC,
  0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0x7C, 0x07, 0xFF, 0xBE, 0x03, 0xFF, 0xDF,
  0x81, 0xFF, 0xE7, 0xC0, 0xFF, 0xF3, 0xE0, 0x7F, 0xF9, 0xF8, 0x3F, 0xFC,
  0x7C, 0x1F, 0xFE, 0x3E, 0x0F, 0xFF, 0x1F, 0x87, 0xFF, 0x87, 0xC3, 0xFF,
  0xC3, 0xE1, 0xFF, 0xE1, 0xF8, 0xFF, 0xF0, 0x7C, 0x7F, 0xF8, 0x3F, 0x3F,
  0xFC, 0x0F, 0x9F, 0xFE, 0x07, 0xCF, 0xFF, 0x03, 0xF7, 0xFF, 0x80, 0xF9,
  0xFF, 0xC0, 0x7C, 0xFF, 0xE0, 0x3F, 0x7F, 0xF0, 0x0F, 0xBF, 0xF8, 0x07,
  0xDF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0x9F,
  0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xE0, 0x1F, 0xE7, 0xFC, 0x3F, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x05, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xF8, 0x07, 0xF9,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFF, 0x87, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0xE7, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80,
  0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF3,
  0xF8, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xE0, 0x1F, 0xC7, 0xFC, 0x3F,
  0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3E, 0xFC, 0x07, 0xE0,
  0x3E, 0xFC, 0x07, 0xE0, 0x3E, 0xFC, 0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0,
  0x7E, 0x7C, 0x0F, 0xE0, 0x7E, 0x7C, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0,
  0x7E, 0x7E, 0x0E, 0xF0, 0x7E, 0x7E, 0x0E, 0xF0, 0x7C, 0x7E, 0x0E, 0xF0,
  0x7C, 0x7E, 0x0E, 0x70, 0x7C, 0x7E, 0x1E, 0x70, 0x7C, 0x3E, 0x1E, 0x70,
  0x7C, 0x3E, 0x1E, 0x70, 0x7C, 0x3E, 0x1E, 0x78, 0xFC, 0x3E, 0x1E, 0x78,
  0xFC, 0x3E, 0x1C, 0x78, 0xFC, 0x3F, 0x1C, 0x78, 0xF8, 0x3F, 0x1C, 0x78,
  0xF8, 0x3F, 0x3C, 0x38, 0xF8, 0x3F, 0x3C, 0x38, 0xF8, 0x3F, 0x3C, 0x38,
  0xF8, 0x1F, 0x3C, 0x3C, 0xF8, 0x1F, 0x3C, 0x3C, 0xF8, 0x1F, 0x38, 0x3C,
  0xF8, 0x1F, 0x38, 0x3D, 0xF8, 0x1F, 0x38, 0x3D, 0xF0, 0x1F, 0x38, 0x3D,
  0xF0, 0x1F, 0x78, 0x1D, 0xF0, 0x1F, 0xF8, 0x1D, 0xF0, 0x1F, 0xF8, 0x1D,
  0xF0, 0x0F, 0xF8, 0x1D, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x9F,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xF8,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x1F,
  0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xDF, 0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0xBF,
  0x3F, 0xFF, 0xCF, 0xC3, 0xFF, 0xE3, 0xF0, 0x7F, 0xF0, 0xFC, 0x00, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xFC, 0x1F,
  0xCF, 0xFF, 0x0F, 0xEF, 0xFF, 0xC7, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD,
  0xFF, 0xE7, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xF7, 0xF7, 0xFF, 0xF3,
  0xFB, 0xFF, 0xF9, 0xFC, 0xFF, 0xF0, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xC7, 0xF8, 0x07, 0xF9,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xF8,
  0x7F, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xE1, 0xFF, 0xE3, 0xF1, 0xFF,
  0xF9, 0xF9, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0x7E, 0xFF, 0xC7, 0xBF, 0x7F,
  0x80, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF8,
  0x3F, 0xF3, 0xFF, 0xFD, 0xF9, 0xFF, 0xFE, 0xFC, 0x7F, 0xFE, 0x7E, 0x1F,
  0xFE, 0x3F, 0x03, 0xFE, 0x1F, 0x80, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFC, 0x07, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x3F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x87,
  0xFF, 0x8F, 0xC7, 0xFF, 0xE7, 0xE7, 0xFF, 0xFB, 0xF3, 0xFF, 0xFD, 0xFB,
  0xFF, 0x1F, 0xFD, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xBF, 0x3F,
  0xFF, 0xDF, 0x8F, 0xFF, 0xEF, 0xC7, 0xFF, 0xE7, 0xE0, 0xFF, 0xE3, 0xF0,
  0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x87, 0xFC, 0x1F, 0xCF, 0xFF, 0x0F, 0xEF, 0xFF, 0xC7, 0xF7, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xEF, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xFC,
  0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xF8, 0x00,
  0xFF, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFE, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0xFC, 0xFC, 0x3F, 0x0F, 0xDF, 0xE7, 0xFC,
  0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0xCF, 0xEF, 0xC1,
  0xF8, 0x7E, 0xFC, 0x1F, 0x03, 0xEF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03,
  0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC,
  0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0,
  0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xFF,
  0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F,
  0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F,
  0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0xC1,
  0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xF0, 0xFE, 0x1F, 0xF0, 0x7F, 0x3F, 0xFC,
  0x3F, 0xBF, 0xFF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0x9F,
  0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xBF, 0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x80,
  0x7F, 0xBF, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xFE,
  0x1F, 0xF0, 0x7F, 0x3F, 0xFC, 0x3F, 0xBF, 0xFF, 0x1F, 0xDF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xDF, 0xFF, 0xCF, 0xEF, 0xFF, 0xE7, 0xF3, 0xFF, 0xE3, 0xF8, 0x7F, 0xC1,
  0xFC, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x87,
  0xFF, 0x8F, 0xC7, 0xFF, 0xE7, 0xE7, 0xFF, 0xFB, 0xF3, 0xFF, 0xFD, 0xFB,
  0xFF, 0x1E, 0xFD, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F,
  0x80, 0x7F, 0xBF, 0xE0, 0xEF, 0xCF, 0xFF, 0xF7, 0xE7, 0xFF, 0xFB, 0xF1,
  0xFF, 0xF9, 0xF8, 0x7F, 0xF8, 0xFC, 0x0F, 0xF8, 0x7E, 0x00, 0x40, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x1F, 0xF0, 0x3F, 0x9F, 0xFF, 0x0F,
  0xEF, 0xFF, 0xE3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x7F,
  0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xE7, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x1F, 0xE7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x7F,
  0x1F, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xFE, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0xF8, 0x0F, 0xC0, 0x7D, 0xF0,
  0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x01, 0xF7, 0xC0, 0xFE, 0x07, 0xEF, 0xC1,
  0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x1F, 0x3F, 0x07, 0x78, 0x3E, 0x3E, 0x0E,
  0xF0, 0x7C, 0x7C, 0x1D, 0xE0, 0xF8, 0xF8, 0x39, 0xC1, 0xF1, 0xF0, 0xF3,
  0x87, 0xC3, 0xF1, 0xE7, 0x0F, 0x87, 0xE3, 0xCE, 0x1F, 0x07, 0xC7, 0x1E,
  0x3E, 0x0F, 0x8E, 0x3C, 0x7C, 0x1F, 0x1C, 0x78, 0xF8, 0x3E, 0x78, 0x71,
  0xF0, 0x7C, 0xF0, 0xE7, 0xC0, 0xF9, 0xE1, 0xCF, 0x81, 0xFB, 0xC3, 0xDF,
  0x01, 0xF7, 0x07, 0xBE, 0x03, 0xEE, 0x0F, 0x7C, 0x07, 0xDC, 0x1E, 0xF8,
  0x0F, 0xF8, 0x1D, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80,
  0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0x3F, 0xFC, 0x03,
  0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xE7, 0xF8, 0x3F, 0xFC,
  0x3F, 0xC3, 0xEF, 0xC1, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xEF, 0xC0, 0x7F,
  0xFC, 0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 9, 41, 34, 12, -41 },
  { 48, 19, 17, 34, 7, -41 },
  { 89, 30, 41, 34, 2, -41 },
  { 243, 27, 57, 34, 3, -49 },
  { 436, 34, 41, 34, 0, -41 },
  { 611, 29, 42, 34, 3, -41 },
  { 764, 7, 17, 34, 13, -41 },
  { 779, 17, 54, 34, 10, -47 },
  { 894, 18, 54, 34, 6, -47 },
  { 1016, 30, 29, 34, 2, -34 },
  { 1125, 27, 27, 34, 3, -32 },
  { 1217, 13, 17, 34, 9, -8 },
  { 1245, 18, 5, 34, 8, -21 },
  { 1257, 10, 11, 34, 12, -10 },
  { 1271, 26, 52, 34, 4, -46 },
  { 1440, 26, 42, 34, 4, -41 },
  { 1577, 26, 41, 34, 5, -41 },
  { 1711, 27, 41, 34, 3, -41 },
  { 1850, 26, 42, 34, 3, -41 },
  { 1987, 25, 41, 34, 4, -41 },
  { 2116, 25, 42, 34, 4, -41 },
  { 2248, 27, 42, 34, 3, -41 },
  { 2390, 26, 41, 34, 4, -41 },
  { 2524, 26, 43, 34, 4, -42 },
  { 2664, 27, 41, 34, 3, -41 },
  { 2803, 10, 32, 34, 12, -31 },
  { 2843, 13, 40, 34, 9, -31 },
  { 2908, 25, 31, 34, 4, -34 },
  { 3005, 24, 19, 34, 5, -28 },
  { 3062, 25, 31, 34, 4, -34 },
  { 3159, 21, 41, 34, 7, -41 },
  { 3267, 30, 51, 34, 2, -41 },
  { 3459, 29, 41, 34, 2, -41 },
  { 3608, 25, 41, 34, 5, -41 },
  { 3737, 26, 42, 34, 4, -41 },
  { 3874, 26, 41, 34, 4, -41 },
  { 4008, 24, 41, 34, 5, -41 },
  { 4131, 25, 41, 34, 5, -41 },
  { 4260, 26, 42, 34, 4, -41 },
  { 4397, 24, 41, 34, 5, -41 },
  { 4520, 23, 41, 34, 5, -41 },
  { 4638, 26, 42, 34, 2, -41 },
  { 4775, 28, 41, 34, 4, -41 },
  { 4919, 24, 41, 34, 6, -41 },
  { 5042, 27, 41, 34, 3, -41 },
  { 5181, 25, 41, 34, 4, -41 },
  { 5310, 25, 42, 34, 4, -41 },
  { 5442, 27, 41, 34, 4, -41 },
  { 5581, 26, 51, 34, 4, -41 },
  { 5747, 27, 41, 34, 4, -41 },
  { 5886, 27, 43, 34, 3, -42 },
  { 6032, 28, 41, 34, 3, -41 },
  { 6176, 25, 42, 34, 4, -41 },
  { 6308, 29, 41, 34, 2, -41 },
  { 6457, 32, 41, 34, 1, -41 },
  { 6621, 30, 41, 34, 2, -41 },
  { 6775, 31, 41, 34, 1, -41 },
  { 6934, 24, 41, 34, 5, -41 },
  { 7057, 15, 52, 34, 11, -46 },
  { 7155, 26, 52, 34, 4, -46 },
  { 7324, 15, 52, 34, 8, -46 },
  { 7422, 26, 22, 34, 4, -41 },
  { 7494, 27, 6, 34, 3, 1 },
  { 7515, 14, 8, 34, 9, -44 },
  { 7529, 26, 32, 34, 3, -31 },
  { 7633, 25, 42, 34, 4, -41 },
  { 7765, 26, 32, 34, 4, -31 },
  { 7869, 25, 42, 34, 4, -41 },
  { 8001, 25, 32, 34, 4, -31 },
  { 8101, 27, 41, 34, 3, -41 },
  { 8240, 25, 41, 34, 4, -31 },
  { 8369, 25, 41, 34, 4, -41 },
  { 8498, 27, 44, 34, 4, -44 },
  { 8647, 21, 54, 34, 5, -44 },
  { 8789, 27, 41, 34, 5, -41 },
  { 8928, 29, 41, 34, 2, -41 },
  { 9077, 28, 31, 34, 3, -31 },
  { 9186, 25, 31, 34, 4, -31 },
  { 9283, 25, 32, 34, 4, -31 },
  { 9383, 25, 41, 34, 4, -31 },
  { 9512, 25, 41, 34, 4, -31 },
  { 9641, 26, 31, 34, 5, -31 },
  { 9742, 26, 32, 34, 4, -31 },
  { 9846, 27, 39, 34, 3, -39 },
  { 9978, 25, 32, 34, 4, -31 },
  { 10078, 29, 31, 34, 2, -31 },
  { 10191, 31, 31, 34, 1, -31 },
  { 10312, 29, 31, 34, 2, -31 },
  { 10425, 29, 41, 34, 2, -31 },
  { 10574, 24, 31, 34, 5, -31 },
  { 10667, 24, 52, 34, 5, -46 },
  { 10823, 6, 52, 34, 14, -46 },
  { 10862, 24, 52, 34, 5, -46 },
  { 11018, 28, 13, 34, 3, -26 },
};

const GFXfont JetBrainsMono_SemiBold56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_SEMIBOLD56PT7B_H_
