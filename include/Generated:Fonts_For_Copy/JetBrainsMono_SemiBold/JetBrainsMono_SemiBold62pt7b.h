#ifndef _JETBRAINSMONO_SEMIBOLD62PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x87, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8,
  0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xF8,
  0xF3, 0xFE, 0x7F, 0x87, 0x8F, 0xF3, 0xFC, 0x3C, 0x3F, 0x9F, 0xC1, 0xE1,
  0xFE, 0xFE, 0x0F, 0x0F, 0xF7, 0xF0, 0x78, 0x00, 0x3F, 0x83, 0xC0, 0x01,
  0xFC, 0x1E, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x7F, 0x87, 0x80, 0x01, 0xFE,
  0x3C, 0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x79, 0xFF, 0x00, 0x03, 0xC7, 0xFC, 0x00, 0x1E,
  0x1F, 0xE0, 0x00, 0xF0, 0x7F, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x3C, 0x1F,
  0xFF, 0x81, 0xE0, 0xFF, 0xFC, 0x0F, 0x07, 0xFF, 0xE0, 0x78, 0x3F, 0xFF,
  0x83, 0xC3, 0xFD, 0xFE, 0x1E, 0x3F, 0xEF, 0xFC, 0xF3, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xC3, 0xFF, 0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xC3,
  0xFF, 0xFC, 0x00, 0x7E, 0x3F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC0, 0xF8, 0xFC, 0x00, 0x3F, 0xBF, 0xC7, 0xC0, 0x01,
  0xFF, 0xFC, 0x7C, 0x00, 0x07, 0xFF, 0xE7, 0xE0, 0x00, 0x1F, 0xFE, 0x3E,
  0x00, 0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x0F,
  0x8F, 0xFF, 0x80, 0x00, 0xFC, 0xFF, 0xFE, 0x00, 0x07, 0xC7, 0xFF, 0xF0,
  0x00, 0x7C, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xE0, 0x7E, 0x00, 0x7E, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x7C, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0xFC, 0x00, 0xFF, 0x7F, 0x8F, 0xC0, 0x03, 0xFF, 0xF8,
  0x7C, 0x00, 0x1F, 0xFF, 0x87, 0xE0, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0xFF, 0x3F, 0xC0, 0xFE, 0xFE, 0x1F,
  0xE0, 0xFE, 0xFE, 0x0F, 0xE1, 0xFC, 0xFE, 0x07, 0xF3, 0xFC, 0xFE, 0x07,
  0xFB, 0xF8, 0xFE, 0x03, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x01,
  0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x20, 0x03, 0xF0, 0x02, 0x1C, 0x01, 0xF0, 0x07, 0x1F, 0xC0, 0xF8, 0x1F,
  0xCF, 0xF8, 0x7C, 0x3F, 0xE7, 0xFE, 0x1E, 0x3F, 0xFF, 0xFF, 0xCE, 0x7F,
  0xFF, 0xFF, 0xF7, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x02, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x7F, 0x80,
  0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x0E, 0x07, 0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0x0F, 0xE1,
  0xFF, 0xF8, 0x7F, 0x8F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF,
  0xF0, 0xFE, 0x1F, 0xFF, 0x83, 0xE0, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFE,
  0x00, 0x3F, 0xC7, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFC,
  0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01,
  0xF0, 0x1F, 0xC0, 0x0F, 0x00, 0xFE, 0x00, 0x60, 0x07, 0xF0, 0x02, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x1F,
  0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x7F, 0x3F, 0xFC, 0x07, 0xF7, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0x80, 0x3F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F,
  0xC0, 0x7F, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE,
  0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x3F, 0xC7, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x87, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xBF,
  0x80, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xCF, 0xFC, 0x03, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xE7, 0xFE,
  0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xBF, 0x80, 0x7F, 0xFD, 0xFE, 0x00, 0xFF, 0xEF, 0xF0, 0x00, 0x3C, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x02, 0x00, 0x01, 0xC0, 0x1F, 0xE0, 0xFF,
  0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0x1F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xC0, 0x7F, 0x87, 0xFF, 0xE0, 0x3F,
  0x81, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xF8, 0x1F, 0xC0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0xFF, 0x03, 0xF0, 0x07, 0xFF, 0x81,
  0xF8, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xF0,
  0x3F, 0x00, 0x7F, 0xF8, 0x1F, 0x80, 0x3F, 0xFC, 0x0F, 0xC0, 0x1F, 0xFE,
  0x07, 0xE0, 0x0F, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0xFC, 0x03, 0xFF,
  0xC0, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xC7,
  0xFF, 0x80, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0x9F, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03,
  0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFE, 0x3F, 0x80, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFE, 0x03, 0xFF, 0xC7, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x07, 0xF9, 0xFC,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xFB, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x1F,
  0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x07,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFE,
  0x03, 0xFF, 0xCF, 0xE0, 0x07, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01,
  0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xEF,
  0xE0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x7F, 0xBF, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFE, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE,
  0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xEF,
  0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xEF, 0x80, 0x7F, 0xFF, 0x7C, 0x07, 0xDF, 0xFB, 0xE0, 0x3E, 0xFF, 0xDF,
  0x81, 0xF7, 0xFE, 0x7C, 0x1F, 0x3F, 0xFB, 0xE0, 0xF9, 0xFF, 0xDF, 0x07,
  0xCF, 0xFE, 0x7C, 0x3E, 0xFF, 0xF3, 0xE3, 0xE7, 0xFF, 0x9F, 0x1F, 0x3F,
  0xFC, 0x7C, 0xF9, 0xFF, 0xE3, 0xEF, 0x8F, 0xFF, 0x1F, 0x7C, 0x7F, 0xF8,
  0xFB, 0xE3, 0xFF, 0xC3, 0xFF, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF,
  0x87, 0xFF, 0x83, 0xFC, 0x3F, 0xFC, 0x1F, 0xC1, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xC0, 0x1F, 0xFE,
  0xFC, 0x03, 0xFF, 0xDF, 0x80, 0x7F, 0xF9, 0xF0, 0x0F, 0xFF, 0x3F, 0x01,
  0xFF, 0xE7, 0xE0, 0x3F, 0xFC, 0x7E, 0x07, 0xFF, 0x8F, 0xC0, 0xFF, 0xF1,
  0xF8, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x0F,
  0xFF, 0x07, 0xE1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFC, 0x1F, 0x87, 0xFF, 0x81,
  0xF8, 0xFF, 0xF0, 0x3F, 0x1F, 0xFE, 0x07, 0xE3, 0xFF, 0xC0, 0x7E, 0x7F,
  0xF8, 0x0F, 0xCF, 0xFF, 0x01, 0xF9, 0xFF, 0xE0, 0x1F, 0xBF, 0xFC, 0x03,
  0xF7, 0xFF, 0x80, 0x3E, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0x3F,
  0x80, 0x07, 0xFC, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFC,
  0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xF8,
  0x03, 0xFF, 0x9F, 0xC0, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFD, 0xFC, 0x00,
  0x7F, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03,
  0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0x87, 0xF8,
  0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xF8, 0x0F,
  0xE0, 0x1F, 0xBF, 0x01, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x80, 0xFE, 0xFC,
  0x07, 0xF8, 0x1F, 0x9F, 0x80, 0xFF, 0x03, 0xF3, 0xF0, 0x1D, 0xE0, 0x7E,
  0x7E, 0x07, 0xBC, 0x0F, 0xCF, 0xC0, 0xF7, 0x81, 0xF9, 0xF8, 0x1E, 0xF0,
  0x3F, 0x3F, 0x83, 0xDE, 0x07, 0xE7, 0xF0, 0x7B, 0xC0, 0xFC, 0x7E, 0x0F,
  0x78, 0x1F, 0x8F, 0xC1, 0xE7, 0x87, 0xE1, 0xF8, 0x3C, 0xF0, 0xFC, 0x3F,
  0x07, 0x1E, 0x1F, 0x87, 0xE1, 0xE3, 0xC3, 0xF0, 0xFC, 0x3C, 0x78, 0x7E,
  0x1F, 0x87, 0x8F, 0x0F, 0xC3, 0xF0, 0xF1, 0xE1, 0xF8, 0x7E, 0x1E, 0x3C,
  0x3F, 0x07, 0xE3, 0xC7, 0x87, 0xE0, 0xFC, 0x78, 0x78, 0xF8, 0x1F, 0x8F,
  0x0F, 0x1F, 0x03, 0xF3, 0xC1, 0xE7, 0xE0, 0x7E, 0x78, 0x3C, 0xFC, 0x0F,
  0xCF, 0x07, 0x9F, 0x81, 0xF9, 0xE0, 0xF3, 0xF0, 0x3F, 0x3C, 0x1E, 0x7E,
  0x07, 0xE7, 0x83, 0xCF, 0xC0, 0xFC, 0xF0, 0x79, 0xF8, 0x0F, 0x9E, 0x07,
  0xBE, 0x01, 0xFF, 0xC0, 0xF7, 0xC0, 0x3F, 0xF0, 0x1E, 0xF8, 0x07, 0xFE,
  0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x7B, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x9F, 0xE0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFC, 0x01,
  0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0x3F, 0xFF, 0xE7, 0xF1, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0x87, 0xF0,
  0x07, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xE1, 0xFF, 0xC0, 0xFE, 0x3F, 0xFE,
  0x0F, 0xE7, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0xFC, 0xFE,
  0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0x0F, 0xE3, 0xFF,
  0xE0, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x03, 0xE0, 0x3F, 0x81, 0xFF, 0x87, 0xF0, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF,
  0x9F, 0xCF, 0xFF, 0xFB, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xF0,
  0x1F, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xE7, 0xFF, 0xFD, 0xFC,
  0x7F, 0xFF, 0x3F, 0x87, 0xFF, 0xC7, 0xF0, 0x3F, 0xF0, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFE, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xE1, 0xFC, 0x3F, 0xFF, 0x3F, 0x8F, 0xFF, 0xE7, 0xF3, 0xFF,
  0xFE, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x0F,
  0xFD, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x3F,
  0xFF, 0xDF, 0xC3, 0xFF, 0xF3, 0xF8, 0x3F, 0xFC, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x7F, 0x0F,
  0xFE, 0x0F, 0xE3, 0xFF, 0xE1, 0xFC, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xE7,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x3F, 0xCF, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC0,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F,
  0x80, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0xFF, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1C, 0x01, 0xC1, 0xF8, 0xFE, 0x1F, 0xE3,
  0xF3, 0xFE, 0x7F, 0xE7, 0xEF, 0xFC, 0xFF, 0xEF, 0xDF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xC3, 0xF8, 0x3F, 0xFF, 0x03, 0xF0, 0x7F, 0xFE,
  0x07, 0xC0, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xF0,
  0x3E, 0x07, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0xFF, 0x81,
  0xF0, 0x3F, 0xFF, 0x03, 0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0xFF, 0xFC, 0x0F,
  0x81, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x7C,
  0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0xFF, 0x81, 0xF0, 0x3F, 0xFF, 0x03, 0xE0,
  0x7F, 0xFE, 0x07, 0xC0, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0x03,
  0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F,
  0xFF, 0x81, 0xF0, 0x3F, 0xFF, 0x03, 0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0xFF,
  0xFC, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0xC3, 0xFF, 0x83, 0xF8, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0x8F, 0xEF, 0xFF,
  0xF9, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x7F,
  0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE1, 0xFF, 0xC0, 0xFE, 0x3F, 0xFE, 0x0F,
  0xE7, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF,
  0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0xFC, 0xFE, 0xFF,
  0xFF, 0xCF, 0xEF, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0x0F, 0xE3, 0xFF, 0xE0,
  0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x18, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE1,
  0xFC, 0x3F, 0xFE, 0x3F, 0x8F, 0xFF, 0xE7, 0xF3, 0xFF, 0xFE, 0xFE, 0x7F,
  0xFF, 0xDF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFB, 0xF9, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xCF, 0xE1, 0xFF, 0xF1,
  0xFC, 0x0F, 0xFC, 0x3F, 0x80, 0x1C, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xE1, 0xFF,
  0xC0, 0xFE, 0x3F, 0xFF, 0x0F, 0xE7, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xCF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xF9, 0xFF, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xF8,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x2F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0xBF, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xEF, 0xC0, 0x7F, 0x00, 0xF9, 0xF8, 0x0F, 0xE0, 0x1F, 0x3F, 0x01, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0xFC, 0x07, 0xF0, 0x1F, 0x9F, 0x80,
  0xEF, 0x03, 0xF1, 0xF8, 0x1D, 0xE0, 0x7E, 0x3F, 0x07, 0xBC, 0x0F, 0x87,
  0xE0, 0xF7, 0x81, 0xF0, 0xFC, 0x1E, 0xF0, 0x7E, 0x1F, 0x83, 0xDE, 0x0F,
  0xC3, 0xF0, 0x79, 0xC1, 0xF8, 0x3E, 0x0E, 0x3C, 0x3F, 0x07, 0xE3, 0xC7,
  0x87, 0xC0, 0xFC, 0x78, 0xF0, 0xF8, 0x1F, 0x8F, 0x1E, 0x3F, 0x03, 0xF1,
  0xE3, 0xC7, 0xE0, 0x7E, 0x3C, 0x78, 0xFC, 0x0F, 0xC7, 0x87, 0x9F, 0x80,
  0xF9, 0xE0, 0xF3, 0xE0, 0x1F, 0xBC, 0x1E, 0x7C, 0x03, 0xF7, 0x83, 0xCF,
  0x80, 0x7E, 0xF0, 0x7B, 0xF0, 0x0F, 0xDE, 0x0F, 0x7E, 0x01, 0xFB, 0xC0,
  0xEF, 0xC0, 0x1F, 0x70, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFC,
  0x7F, 0xFC, 0x01, 0xF9, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xF8, 0x07, 0xEF,
  0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0x07, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0,
  0x0F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 10, 45, 37, 14, -45 },
  { 58, 21, 18, 37, 8, -45 },
  { 106, 33, 45, 37, 2, -45 },
  { 292, 29, 63, 37, 4, -54 },
  { 521, 37, 46, 37, 0, -46 },
  { 734, 32, 47, 37, 3, -46 },
  { 922, 7, 18, 37, 15, -45 },
  { 938, 19, 59, 37, 11, -52 },
  { 1079, 20, 59, 37, 7, -52 },
  { 1227, 33, 32, 37, 2, -38 },
  { 1359, 29, 29, 37, 4, -35 },
  { 1465, 14, 19, 37, 10, -9 },
  { 1499, 20, 7, 37, 9, -24 },
  { 1517, 11, 12, 37, 13, -11 },
  { 1534, 29, 58, 37, 4, -51 },
  { 1745, 29, 47, 37, 4, -46 },
  { 1916, 29, 45, 37, 5, -45 },
  { 2080, 29, 46, 37, 4, -46 },
  { 2247, 28, 46, 37, 4, -45 },
  { 2408, 28, 45, 37, 4, -45 },
  { 2566, 28, 46, 37, 5, -45 },
  { 2727, 30, 46, 37, 4, -45 },
  { 2900, 30, 45, 37, 4, -45 },
  { 3069, 29, 47, 37, 4, -46 },
  { 3240, 30, 46, 37, 4, -46 },
  { 3413, 11, 36, 37, 13, -35 },
  { 3463, 14, 45, 37, 10, -35 },
  { 3542, 27, 33, 37, 5, -37 },
  { 3654, 27, 21, 37, 5, -31 },
  { 3725, 27, 33, 37, 5, -37 },
  { 3837, 23, 45, 37, 8, -45 },
  { 3967, 33, 57, 37, 2, -46 },
  { 4203, 33, 45, 37, 2, -45 },
  { 4389, 29, 45, 37, 5, -45 },
  { 4553, 28, 47, 37, 5, -46 },
  { 4718, 28, 45, 37, 5, -45 },
  { 4876, 26, 45, 37, 6, -45 },
  { 5023, 28, 45, 37, 5, -45 },
  { 5181, 28, 47, 37, 5, -46 },
  { 5346, 27, 45, 37, 5, -45 },
  { 5498, 25, 45, 37, 6, -45 },
  { 5639, 29, 46, 37, 2, -45 },
  { 5806, 30, 45, 37, 5, -45 },
  { 5975, 26, 45, 37, 7, -45 },
  { 6122, 29, 45, 37, 4, -45 },
  { 6286, 27, 45, 37, 5, -45 },
  { 6438, 27, 47, 37, 5, -46 },
  { 6597, 30, 45, 37, 5, -45 },
  { 6766, 29, 57, 37, 4, -46 },
  { 6973, 29, 45, 37, 5, -45 },
  { 7137, 29, 47, 37, 4, -46 },
  { 7308, 31, 45, 37, 3, -45 },
  { 7483, 27, 46, 37, 5, -45 },
  { 7639, 33, 45, 37, 2, -45 },
  { 7825, 35, 45, 37, 1, -45 },
  { 8022, 33, 45, 37, 2, -45 },
  { 8208, 34, 45, 37, 2, -45 },
  { 8400, 27, 45, 37, 5, -45 },
  { 8552, 17, 58, 37, 12, -51 },
  { 8676, 29, 58, 37, 4, -51 },
  { 8887, 16, 58, 37, 9, -51 },
  { 9003, 29, 24, 37, 4, -45 },
  { 9090, 29, 6, 37, 4, 2 },
  { 9112, 15, 9, 37, 10, -49 },
  { 9129, 28, 36, 37, 4, -35 },
  { 9255, 28, 46, 37, 5, -45 },
  { 9416, 28, 36, 37, 5, -35 },
  { 9542, 27, 46, 37, 5, -45 },
  { 9698, 28, 36, 37, 5, -35 },
  { 9824, 30, 45, 37, 3, -45 },
  { 9993, 27, 46, 37, 5, -35 },
  { 10149, 27, 45, 37, 5, -45 },
  { 10301, 30, 49, 37, 5, -49 },
  { 10485, 24, 60, 37, 5, -49 },
  { 10665, 30, 45, 37, 5, -45 },
  { 10834, 33, 45, 37, 2, -45 },
  { 11020, 31, 35, 37, 3, -35 },
  { 11156, 27, 35, 37, 5, -35 },
  { 11275, 28, 36, 37, 5, -35 },
  { 11401, 28, 46, 37, 5, -35 },
  { 11562, 27, 46, 37, 5, -35 },
  { 11718, 28, 35, 37, 6, -35 },
  { 11841, 29, 36, 37, 4, -35 },
  { 11972, 30, 44, 37, 3, -44 },
  { 12137, 27, 35, 37, 5, -34 },
  { 12256, 32, 34, 37, 3, -34 },
  { 12392, 35, 34, 37, 1, -34 },
  { 12541, 33, 34, 37, 2, -34 },
  { 12682, 32, 45, 37, 3, -34 },
  { 12862, 27, 34, 37, 5, -34 },
  { 12977, 27, 58, 37, 5, -51 },
  { 13173, 7, 58, 37, 15, -51 },
  { 13224, 27, 58, 37, 5, -51 },
  { 13420, 31, 14, 37, 3, -29 },
};

const GFXfont JetBrainsMono_SemiBold62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_SEMIBOLD62PT7B_H_
