#ifndef _JETBRAINSMONO_SEMIBOLD24PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x60, 0x07, 0xF7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0x0C, 0x70, 0x63, 0x03, 0x18, 0x38,
  0xC1, 0x86, 0x7F, 0xFF, 0xFF, 0xE3, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x30,
  0x61, 0x8F, 0xFF, 0x7F, 0xF9, 0xC6, 0x0C, 0x30, 0x61, 0x83, 0x1C, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x3F, 0xC3, 0xFE, 0x76, 0xE7, 0x67,
  0x76, 0x07, 0x60, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x06, 0xF0, 0x67,
  0xE6, 0x77, 0x67, 0x7E, 0xE3, 0xFE, 0x1F, 0xC0, 0x60, 0x06, 0x00, 0x60,
  0x18, 0x0D, 0xF0, 0x3E, 0x61, 0xB1, 0x8C, 0xC6, 0x73, 0x19, 0x86, 0xEC,
  0x1F, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x67, 0x01, 0xBF, 0x0D, 0x8C, 0x66,
  0x33, 0x98, 0xCC, 0x63, 0x60, 0xFF, 0x03, 0xE0, 0x0F, 0x01, 0xFC, 0x0F,
  0xF0, 0xE1, 0x87, 0x0E, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x7C, 0x07, 0xF1,
  0xFB, 0x9D, 0xCE, 0xCE, 0x3E, 0x70, 0xE3, 0x87, 0x1E, 0x7C, 0x7F, 0x71,
  0xF1, 0xC0, 0xFF, 0xFF, 0xB6, 0x03, 0x0F, 0x1F, 0x3C, 0x78, 0x70, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x78,
  0x3C, 0x1F, 0x0F, 0x03, 0xC1, 0xC3, 0xE1, 0xC1, 0xC1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x73, 0xCF, 0x1C, 0x20,
  0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0E, 0x67, 0x7D, 0x7D, 0xFF,
  0x80, 0xC0, 0x0F, 0x80, 0xEE, 0x0E, 0x70, 0xE1, 0xC1, 0x08, 0x00, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x3B, 0xDC, 0xE7, 0x73, 0x98, 0xFF, 0xFF,
  0x7F, 0xFF, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x0F,
  0xF3, 0xFF, 0x70, 0xEE, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xCE, 0xF9, 0xDF,
  0x13, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x8E, 0x7F, 0xC7, 0xE0, 0x0E,
  0x03, 0xC1, 0xF8, 0x7B, 0x0E, 0x61, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC,
  0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0x60, 0x6E, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x7E, 0x07,
  0x70, 0xE7, 0x8E, 0x3F, 0xC1, 0xF8, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E,
  0x07, 0x03, 0x80, 0xE0, 0x71, 0xF8, 0x7E, 0x1F, 0x07, 0xFF, 0xFF, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x87, 0xFC, 0xFF, 0xDC, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xF8, 0x37, 0x8E, 0x7F, 0xC7, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0xB8, 0x7F, 0xE7, 0x9E, 0x70, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x70, 0x77, 0x8E, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7C, 0x0D, 0x83, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x1E, 0x0F,
  0xF3, 0xFF, 0x70, 0xEE, 0x0D, 0xC1, 0xB8, 0x73, 0x9C, 0x3F, 0x07, 0xE1,
  0xCF, 0x70, 0xEE, 0x0F, 0x81, 0xF8, 0x3F, 0x8E, 0x7F, 0xC7, 0xE0, 0x0F,
  0x03, 0xFC, 0x7F, 0xE7, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70,
  0xF7, 0xFE, 0x3E, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x01, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x7B, 0xDE, 0x00,
  0x00, 0x00, 0x01, 0xDE, 0xF7, 0x3B, 0x9C, 0xC0, 0x00, 0x60, 0x7C, 0x3F,
  0x1F, 0x8F, 0xC1, 0xC0, 0x38, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x70, 0x02, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x78, 0x3F, 0x1F,
  0x0F, 0x83, 0xC0, 0x60, 0x08, 0x00, 0xE0, 0x7F, 0x3F, 0xC0, 0xF0, 0x38,
  0x1C, 0x0E, 0x0F, 0x3F, 0x1F, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00, 0xF0,
  0x78, 0x3C, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xC0, 0xEE, 0x03, 0x60,
  0x1F, 0x0E, 0xF8, 0xFB, 0xC6, 0x3E, 0x31, 0xF1, 0x8F, 0x8C, 0x7C, 0x63,
  0xE3, 0x1F, 0x18, 0xF8, 0xFB, 0xC1, 0x87, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x1D, 0x81, 0xD8,
  0x19, 0xC1, 0x9C, 0x39, 0xC3, 0x8C, 0x38, 0xE3, 0xFE, 0x7F, 0xE7, 0xFE,
  0x70, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0xEE,
  0x0F, 0xC1, 0xF8, 0x37, 0x1E, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x1E, 0xFF, 0xDF, 0xE0, 0x1E, 0x0F, 0xF1, 0xFF, 0x70,
  0xEE, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC1, 0xF8, 0x3F, 0x8E, 0x7F, 0xC7, 0xE0, 0xFC, 0x1F, 0xF3, 0xFF,
  0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0xFE, 0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB,
  0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E,
  0x0F, 0xF1, 0xFF, 0x70, 0xEE, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0xFF, 0x9F, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8E, 0x7F, 0xC7, 0xE0,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x30, 0xFF,
  0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0x0F, 0xE1,
  0xFC, 0x3F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x8E, 0x70, 0xFF,
  0x0F, 0xF0, 0xE7, 0x0E, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x7F, 0x0F, 0xD0, 0xFF, 0x8F, 0xF9, 0xBF, 0x9B, 0xED, 0xBE,
  0xF7, 0xEF, 0x7E, 0x77, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xB1,
  0xF6, 0x3E, 0xE7, 0xCC, 0xF9, 0x9F, 0x3B, 0xE3, 0x7C, 0x6F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x3C, 0x1E, 0x0F, 0xF1, 0xFF, 0x70, 0xEE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x77, 0x9E, 0x7F, 0x87, 0xE0, 0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0xFE,
  0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xE1, 0xFF, 0xFB, 0xFE, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x0F, 0xF1, 0xFF, 0x70,
  0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x8E, 0x7F, 0xC7, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xFF, 0xDF, 0xF3, 0xFC, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0x77, 0x0E,
  0xE1, 0xFC, 0x1C, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0x77, 0x00,
  0x70, 0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x7E, 0x07,
  0x70, 0x77, 0x8E, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0x8E, 0x7F, 0x87, 0xE0, 0xE0, 0x3E,
  0x07, 0xE0, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x70, 0xE3, 0x0E, 0x38, 0xC3,
  0x8C, 0x39, 0xC1, 0x9C, 0x1D, 0x81, 0xD8, 0x1F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0xE3, 0x0D, 0x8E, 0x76, 0x39, 0xD8, 0xE7, 0x63, 0x9D, 0x9A, 0x66,
  0x69, 0x9D, 0xA6, 0x76, 0x99, 0xD2, 0x67, 0x4D, 0x8D, 0x36, 0x34, 0xF8,
  0xF3, 0xE3, 0xCF, 0x0F, 0x1C, 0x3C, 0x70, 0xF1, 0xC0, 0xE0, 0x73, 0x83,
  0x9C, 0x38, 0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70,
  0x77, 0x03, 0xC0, 0xE0, 0x3F, 0x03, 0x98, 0x1C, 0xE0, 0xC7, 0x0E, 0x1C,
  0x60, 0xE7, 0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF,
  0xFF, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0xFF, 0xFF,
  0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFF, 0x80, 0x0E, 0x03, 0xC0, 0x78, 0x0D,
  0x83, 0xB0, 0x67, 0x1C, 0x63, 0x0E, 0xE0, 0xD8, 0x1C, 0xFF, 0xFF, 0xFF,
  0xE1, 0xC3, 0x87, 0x1F, 0xC3, 0xFE, 0x70, 0xE7, 0x06, 0x00, 0x71, 0xFF,
  0x7F, 0xF7, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xF7, 0xF7, 0x3F, 0x70, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7, 0x8E, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8E, 0xFF, 0xDD, 0xF0,
  0x3F, 0x8F, 0xFB, 0xC7, 0x70, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x1F, 0xC7, 0x3F, 0xE3, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xDF, 0xB7, 0xEF, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x1F, 0xCF, 0x7E, 0xCF, 0xB0, 0x3F, 0x8F, 0xFB, 0x87, 0x70, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x1C, 0x07, 0x87, 0x3F, 0xE3, 0xF0, 0x00,
  0xF0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x7E, 0xDF, 0xBF, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE1, 0xFC, 0xF7, 0xEC, 0xFB, 0x00, 0xC0, 0x30, 0x1C, 0xFF, 0x3F, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7, 0x8E, 0xE0,
  0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1C, 0x06, 0x01, 0xE0, 0x38, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x03, 0xC0, 0xE0, 0x20, 0x00, 0x01, 0xFE,
  0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x77, 0xFB, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x70, 0xFF, 0x0F, 0xF0,
  0xE7, 0x0E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xEE, 0x0F, 0xFE, 0x0F, 0xE0,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x07, 0xF0, 0x3F,
  0xFE, 0xEF, 0xFF, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63,
  0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x30, 0xEF, 0x9F, 0xFB, 0xC7,
  0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0E, 0x3F, 0x8F, 0xFB, 0xC7, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1B, 0xCF, 0x3F, 0xC3, 0xF0, 0xEF, 0x9F, 0xFB, 0xC7,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0x7F,
  0xEE, 0xF9, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x7E, 0xDF, 0xBF, 0x1F,
  0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7F, 0x3D, 0xFB, 0x3E,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xEF, 0xDF, 0xFB, 0xC7, 0xF0, 0x7E,
  0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x7F, 0x8F, 0xFB, 0x87, 0xF0, 0x0E, 0x00, 0xFE, 0x0F, 0xF0, 0x1E, 0x00,
  0xFC, 0x1F, 0x87, 0xFF, 0xE3, 0xF8, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0xCF, 0x3F,
  0xC3, 0xF0, 0xE0, 0x76, 0x07, 0x70, 0x67, 0x0E, 0x30, 0xE3, 0x8E, 0x39,
  0xC1, 0x9C, 0x1D, 0xC1, 0xD8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xC6, 0x3E,
  0x39, 0xF1, 0xCD, 0x9E, 0x6E, 0xD3, 0x76, 0x99, 0xB4, 0xCD, 0x3E, 0x69,
  0xE3, 0x4F, 0x1E, 0x78, 0xF1, 0xC3, 0x8E, 0x00, 0xF0, 0x77, 0x8E, 0x39,
  0xC1, 0xDC, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x83, 0x9C, 0x38,
  0xE7, 0x0E, 0xE0, 0x70, 0xE0, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x38, 0xE3,
  0x9C, 0x1D, 0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xC1, 0xF0, 0x7C, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x03, 0x8F,
  0xE3, 0xF0, 0xFE, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x07, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x3E, 0x0F, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xFC, 0x1F, 0x1F, 0xC7, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0xF8, 0x3E, 0x0E, 0x00, 0x7C, 0x37, 0xE3, 0xE7, 0x3E, 0x7F,
  0xE3, 0xE0,
};

const GFXglyph JetBrainsMono_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 18, 14, 5, -18 },
  { 10, 8, 8, 14, 3, -18 },
  { 18, 13, 18, 14, 1, -18 },
  { 48, 12, 24, 14, 1, -21 },
  { 84, 14, 18, 14, 0, -18 },
  { 116, 13, 18, 14, 1, -18 },
  { 146, 3, 8, 14, 6, -18 },
  { 149, 8, 23, 14, 4, -20 },
  { 172, 7, 23, 14, 3, -20 },
  { 193, 13, 13, 14, 1, -15 },
  { 215, 12, 12, 14, 1, -14 },
  { 233, 5, 8, 14, 4, -4 },
  { 238, 8, 2, 14, 3, -9 },
  { 240, 4, 4, 14, 5, -4 },
  { 242, 11, 23, 14, 2, -20 },
  { 274, 11, 18, 14, 2, -18 },
  { 299, 11, 18, 14, 2, -18 },
  { 324, 12, 18, 14, 1, -18 },
  { 351, 12, 18, 14, 1, -18 },
  { 378, 10, 18, 14, 2, -18 },
  { 401, 11, 18, 14, 2, -18 },
  { 426, 12, 18, 14, 1, -18 },
  { 453, 11, 18, 14, 2, -18 },
  { 478, 11, 18, 14, 2, -18 },
  { 503, 12, 18, 14, 1, -18 },
  { 530, 4, 13, 14, 5, -13 },
  { 537, 5, 17, 14, 4, -13 },
  { 548, 11, 13, 14, 2, -14 },
  { 566, 10, 8, 14, 2, -12 },
  { 576, 11, 13, 14, 2, -14 },
  { 594, 9, 18, 14, 3, -18 },
  { 615, 13, 22, 14, 1, -18 },
  { 651, 12, 18, 14, 1, -18 },
  { 678, 11, 18, 14, 2, -18 },
  { 703, 11, 18, 14, 2, -18 },
  { 728, 11, 18, 14, 2, -18 },
  { 753, 11, 18, 14, 2, -18 },
  { 778, 11, 18, 14, 2, -18 },
  { 803, 11, 18, 14, 2, -18 },
  { 828, 10, 18, 14, 2, -18 },
  { 851, 10, 18, 14, 2, -18 },
  { 874, 11, 18, 14, 1, -18 },
  { 899, 12, 18, 14, 2, -18 },
  { 926, 10, 18, 14, 3, -18 },
  { 949, 12, 18, 14, 1, -18 },
  { 976, 11, 18, 14, 2, -18 },
  { 1001, 11, 18, 14, 2, -18 },
  { 1026, 11, 18, 14, 2, -18 },
  { 1051, 11, 22, 14, 2, -18 },
  { 1082, 11, 18, 14, 2, -18 },
  { 1107, 12, 18, 14, 1, -18 },
  { 1134, 12, 18, 14, 1, -18 },
  { 1161, 11, 18, 14, 2, -18 },
  { 1186, 12, 18, 14, 1, -18 },
  { 1213, 14, 18, 14, 0, -18 },
  { 1245, 13, 18, 14, 1, -18 },
  { 1275, 13, 18, 14, 1, -18 },
  { 1305, 10, 18, 14, 2, -18 },
  { 1328, 6, 23, 14, 5, -20 },
  { 1346, 11, 23, 14, 2, -20 },
  { 1378, 7, 23, 14, 3, -20 },
  { 1399, 11, 10, 14, 2, -18 },
  { 1413, 12, 2, 14, 1, 1 },
  { 1416, 6, 4, 14, 4, -19 },
  { 1419, 12, 13, 14, 1, -13 },
  { 1439, 11, 18, 14, 2, -18 },
  { 1464, 11, 13, 14, 2, -13 },
  { 1482, 10, 18, 14, 2, -18 },
  { 1505, 11, 13, 14, 2, -13 },
  { 1523, 12, 18, 14, 1, -18 },
  { 1550, 10, 17, 14, 2, -13 },
  { 1572, 11, 18, 14, 2, -18 },
  { 1597, 11, 19, 14, 2, -19 },
  { 1624, 9, 23, 14, 2, -19 },
  { 1650, 12, 18, 14, 2, -18 },
  { 1677, 12, 18, 14, 1, -18 },
  { 1704, 12, 13, 14, 1, -13 },
  { 1724, 11, 13, 14, 2, -13 },
  { 1742, 11, 13, 14, 2, -13 },
  { 1760, 11, 17, 14, 2, -13 },
  { 1784, 10, 17, 14, 2, -13 },
  { 1806, 11, 13, 14, 2, -13 },
  { 1824, 11, 13, 14, 2, -13 },
  { 1842, 12, 17, 14, 1, -17 },
  { 1868, 11, 13, 14, 2, -13 },
  { 1886, 12, 13, 14, 1, -13 },
  { 1906, 13, 13, 14, 1, -13 },
  { 1928, 12, 13, 14, 1, -13 },
  { 1948, 12, 17, 14, 1, -13 },
  { 1974, 10, 13, 14, 2, -13 },
  { 1991, 10, 23, 14, 2, -20 },
  { 2020, 3, 23, 14, 6, -20 },
  { 2029, 10, 23, 14, 2, -20 },
  { 2058, 12, 5, 14, 1, -11 },
};

const GFXfont JetBrainsMono_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_SEMIBOLD24PT7B_H_
