#ifndef _JETBRAINSMONO_SEMIBOLD25PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x0E, 0xFB,
  0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1D, 0x8C, 0x0C, 0x30, 0x61,
  0x83, 0x1C, 0x38, 0xC7, 0xFF, 0xBF, 0xFC, 0x61, 0x83, 0x0C, 0x18, 0xE1,
  0xC6, 0x0C, 0x31, 0xFF, 0xEF, 0xFF, 0x18, 0xE0, 0xC6, 0x0E, 0x30, 0x61,
  0x83, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x03, 0xF8, 0xFF, 0xBD,
  0x7F, 0x27, 0xE4, 0x1C, 0x83, 0xD0, 0x3E, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x27, 0x04, 0xF8, 0x8F, 0x93, 0xFA, 0xF7, 0xFC, 0x7F, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x7C, 0x0E, 0xFC, 0x1B, 0x98, 0x66, 0x39, 0x8C, 0x77,
  0x1C, 0xCC, 0x1F, 0xB0, 0x1E, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x19, 0xE0,
  0x37, 0xE0, 0xCC, 0xE3, 0x38, 0xCE, 0x71, 0x98, 0x67, 0x60, 0xFD, 0xC0,
  0xF0, 0x02, 0x00, 0xFC, 0x0F, 0xF0, 0x71, 0xC7, 0x0E, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x8F, 0xCE, 0x6E, 0x3F, 0x71, 0xF3,
  0x87, 0x9C, 0x3C, 0xF3, 0xF3, 0xFF, 0x8F, 0xCE, 0xFF, 0xFF, 0xF8, 0x01,
  0x07, 0x1F, 0x3E, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x3E, 0x1F, 0x07, 0x01, 0x80,
  0xE0, 0xF8, 0x3C, 0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x7C, 0xF8, 0xE0, 0x80, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x8E, 0x2F, 0x27, 0xFF, 0xFC, 0x7F, 0x00, 0xE0,
  0x0D, 0x80, 0xEE, 0x0E, 0x38, 0x71, 0xC1, 0x04, 0x00, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x3D, 0xE7, 0x9C, 0x73, 0x8E, 0x38, 0xFF, 0xFF, 0xFF, 0xE0,
  0x77, 0xFE, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x04, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE4,
  0xFD, 0xDF, 0xBB, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEF,
  0xF8, 0xFE, 0x00, 0x1F, 0x03, 0xF0, 0x7F, 0x0E, 0x70, 0xC7, 0x08, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x07, 0xF1, 0xFF, 0x78, 0xFE,
  0x0F, 0xC1, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xF8,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xFC, 0x1F, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x0F, 0x81, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC7, 0x70, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFE, 0xFB, 0xFC,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0xF8, 0x7F, 0xE3, 0xC7, 0x9C, 0x1D, 0xC0, 0x6E, 0x03, 0xB0, 0x19, 0xC1,
  0xCF, 0x1E, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x0E,
  0xE0, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x04, 0x07, 0xF1,
  0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3B, 0x8E, 0x7F, 0xC3, 0xE0, 0xFE,
  0x38, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEF, 0xF8, 0xFE, 0x00,
  0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x70, 0x1B, 0x80, 0xEC,
  0x06, 0x70, 0x73, 0xC7, 0x8F, 0xFC, 0x3D, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x77, 0xFE, 0xE0, 0x00, 0x00,
  0x00, 0x1D, 0xFF, 0xB8, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xCE, 0x79, 0xC7, 0x1C, 0xE3, 0x80, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x38, 0x07, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x06,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x38, 0x0F, 0x07, 0xE3, 0xE1, 0xF0, 0x78, 0x0C, 0x01, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0xF8, 0x0E, 0x01, 0x80, 0x70, 0x38, 0x1E, 0x3F, 0x0F, 0x83,
  0x80, 0xE0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x0E, 0x00, 0x02, 0x00,
  0xFF, 0x0F, 0xFC, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x7B, 0xC7,
  0xFE, 0x30, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0xE3, 0x0F, 0x18, 0x78, 0xE7,
  0xC3, 0xDE, 0x0C, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x70, 0x0F, 0x80, 0x7C, 0x03, 0x60, 0x1B, 0x01, 0xDC, 0x0E, 0xE0, 0x77,
  0x03, 0x18, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x7F, 0xC7, 0xFF, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0xE0, 0x3F, 0x01, 0xC0, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEF, 0xFC, 0xFF, 0x0F, 0xFC, 0xE0, 0xEE,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x3E, 0xFF, 0xCF, 0xF8, 0x04, 0x07,
  0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0x07, 0xF9, 0xEF, 0xF8, 0xFE,
  0x00, 0xFF, 0x9F, 0xFB, 0x8F, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFE, 0xFF,
  0xDF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1,
  0xF8, 0x07, 0x00, 0xE0, 0x1C, 0xFF, 0x9F, 0xF3, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xF1, 0xEF, 0xF8, 0xFE, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0xEF, 0x9E, 0x7F, 0xC3, 0xF8,
  0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0xE3, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E,
  0xE0, 0xEE, 0x07, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x9F, 0xB6, 0xF6, 0xDE,
  0xDB, 0xCE, 0x79, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0C, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7D, 0x8F, 0xB9, 0xFF,
  0x3F, 0x67, 0xEE, 0xFC, 0xDF, 0x9B, 0xF3, 0xFE, 0x37, 0xC6, 0xF8, 0xFF,
  0x0F, 0xE1, 0xFC, 0x3C, 0x04, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xF1, 0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0x8F, 0xFE, 0xE1, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF, 0xFC, 0xFF, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x04, 0x07,
  0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEF, 0xF8, 0xFE,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF, 0x0E,
  0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0x04, 0x07,
  0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC0, 0x38, 0x07, 0x80, 0x7E, 0x07, 0xF0,
  0x7F, 0x01, 0xF0, 0x0E, 0x01, 0xF0, 0x1F, 0x07, 0xF1, 0xEF, 0xF8, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0xE0, 0x3F, 0x01, 0xDC,
  0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x38, 0xE1, 0x87, 0x1C, 0x38, 0xE1, 0xC7,
  0x07, 0x30, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x36, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x00, 0xE3, 0x8E, 0xC7, 0x19, 0x8A, 0x33, 0x14, 0x66, 0x28, 0xCE,
  0x53, 0x9D, 0xB7, 0x3B, 0x6E, 0x76, 0xDC, 0xED, 0xB0, 0xDB, 0x61, 0xA2,
  0xC3, 0x45, 0x86, 0x8B, 0x0D, 0x16, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0xF0, 0x7B, 0x83, 0x8E, 0x38, 0x71, 0xC1, 0xDC, 0x0E, 0xE0, 0x3E, 0x01,
  0xF0, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x3B, 0x81, 0xDC, 0x1C, 0x70, 0xE3,
  0x8E, 0x0E, 0x70, 0x77, 0x01, 0xC0, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0,
  0xE3, 0x8E, 0x1C, 0x70, 0x77, 0x03, 0xB8, 0x0D, 0x80, 0x7C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xF8, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0xE0, 0x6C, 0x1D, 0xC3, 0xB8, 0x63,
  0x1C, 0x73, 0x06, 0xE0, 0xF8, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3,
  0x87, 0x0F, 0x83, 0xFE, 0x3D, 0xF7, 0x07, 0x00, 0x70, 0x07, 0x1F, 0xF7,
  0xFF, 0x70, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x7F, 0xF3, 0xF7, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x79, 0xFF, 0xBF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0xFF, 0xDD, 0xF0, 0x1F,
  0x0F, 0xF9, 0xFF, 0xF0, 0x7E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x1F, 0x83, 0xF8, 0xF7, 0xFC, 0x7F, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x73, 0xEE, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xE7, 0xDC, 0x1F, 0x0F, 0xF9, 0xC7,
  0x70, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x83, 0xF8,
  0xF7, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC3, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3E, 0xEF,
  0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xEF, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x3F, 0xC7, 0xF0, 0xF0,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xF9, 0xFF, 0xBF, 0xFF, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1C, 0x04, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x7F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0xF0, 0x3C,
  0x0E, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x7F, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xEF,
  0xF3, 0xF8, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7E,
  0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0x8E, 0x78, 0xFF, 0x0F, 0xF0, 0xE7, 0x8E,
  0x38, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x07, 0xFE, 0x07, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0xEE, 0xE7, 0xF7, 0xB9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C,
  0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9C,
  0xEF, 0x9F, 0xFB, 0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x1F, 0x0F, 0xF9, 0xFF,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8,
  0xF7, 0xFC, 0x7F, 0x00, 0xE7, 0x9F, 0xFB, 0xFF, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xFF, 0xFD, 0xDF, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0xEF, 0xFF, 0xFF, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xF7,
  0xFE, 0x7D, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE7, 0x8E,
  0xFE, 0xFF, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3F, 0x8F, 0xFB, 0xEF, 0xF0,
  0x7E, 0x01, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xE0, 0x1F, 0x83, 0xF8, 0xF7,
  0xFE, 0x7F, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xE7, 0xFC,
  0x7F, 0x00, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x70,
  0xE3, 0x87, 0x1C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0xC7, 0x1E, 0x38, 0xF1, 0xC7, 0x8A, 0x3E, 0x53, 0xF6, 0x9D, 0xB6,
  0xCD, 0xB6, 0x6D, 0xB3, 0x45, 0x9A, 0x2C, 0xF1, 0xE7, 0x8E, 0x1C, 0x70,
  0xF0, 0x7B, 0x83, 0x8E, 0x38, 0x7B, 0xC1, 0xDC, 0x07, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0xEE, 0x0F, 0x78, 0x71, 0xC7, 0x07, 0x78, 0x3C, 0xE0,
  0x3B, 0x83, 0xDC, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0x73, 0x83, 0xB8,
  0x1D, 0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xE0, 0x7C, 0x1F, 0x83, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x7F, 0x0F, 0xE0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xC0, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0xF0, 0xFE, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC1, 0xF8, 0x3E, 0x07, 0x00, 0x18, 0x03, 0xF1, 0xDF, 0xCF, 0xCF, 0x7E,
  0x3F, 0x70, 0xF0,
};

const GFXglyph JetBrainsMono_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 9, 7, 15, 3, -18 },
  { 21, 13, 18, 15, 1, -18 },
  { 51, 11, 26, 15, 2, -22 },
  { 87, 15, 18, 15, 0, -18 },
  { 121, 13, 19, 15, 1, -19 },
  { 152, 3, 7, 15, 6, -18 },
  { 155, 8, 24, 15, 4, -21 },
  { 179, 8, 24, 15, 3, -21 },
  { 203, 13, 13, 15, 1, -15 },
  { 225, 11, 12, 15, 2, -14 },
  { 242, 6, 8, 15, 4, -4 },
  { 248, 9, 3, 15, 3, -10 },
  { 252, 5, 4, 15, 5, -4 },
  { 255, 11, 24, 15, 2, -21 },
  { 288, 11, 19, 15, 2, -19 },
  { 315, 12, 18, 15, 2, -18 },
  { 342, 11, 19, 15, 2, -19 },
  { 369, 11, 18, 15, 2, -18 },
  { 394, 11, 18, 15, 2, -18 },
  { 419, 11, 18, 15, 2, -18 },
  { 444, 13, 18, 15, 1, -18 },
  { 474, 12, 18, 15, 2, -18 },
  { 501, 11, 19, 15, 2, -19 },
  { 528, 13, 19, 15, 1, -19 },
  { 559, 5, 14, 15, 5, -14 },
  { 568, 6, 18, 15, 4, -14 },
  { 582, 11, 14, 15, 2, -15 },
  { 602, 11, 9, 15, 2, -13 },
  { 615, 11, 14, 15, 2, -15 },
  { 635, 10, 18, 15, 3, -18 },
  { 658, 13, 24, 15, 1, -19 },
  { 697, 13, 18, 15, 1, -18 },
  { 727, 12, 18, 15, 2, -18 },
  { 754, 11, 19, 15, 2, -19 },
  { 781, 11, 18, 15, 2, -18 },
  { 806, 11, 18, 15, 2, -18 },
  { 831, 11, 18, 15, 2, -18 },
  { 856, 11, 19, 15, 2, -19 },
  { 883, 11, 18, 15, 2, -18 },
  { 908, 11, 18, 15, 2, -18 },
  { 933, 12, 18, 15, 1, -18 },
  { 960, 12, 18, 15, 2, -18 },
  { 987, 10, 18, 15, 3, -18 },
  { 1010, 11, 18, 15, 2, -18 },
  { 1035, 11, 18, 15, 2, -18 },
  { 1060, 11, 19, 15, 2, -19 },
  { 1087, 12, 18, 15, 2, -18 },
  { 1114, 11, 24, 15, 2, -19 },
  { 1147, 12, 18, 15, 2, -18 },
  { 1174, 11, 19, 15, 2, -19 },
  { 1201, 13, 18, 15, 1, -18 },
  { 1231, 11, 18, 15, 2, -18 },
  { 1256, 13, 18, 15, 1, -18 },
  { 1286, 15, 18, 15, 0, -18 },
  { 1320, 13, 18, 15, 1, -18 },
  { 1350, 13, 18, 15, 1, -18 },
  { 1380, 11, 18, 15, 2, -18 },
  { 1405, 7, 24, 15, 5, -21 },
  { 1426, 11, 24, 15, 2, -21 },
  { 1459, 7, 24, 15, 3, -21 },
  { 1480, 11, 10, 15, 2, -18 },
  { 1494, 13, 2, 15, 1, 1 },
  { 1498, 6, 4, 15, 4, -20 },
  { 1501, 12, 14, 15, 1, -14 },
  { 1522, 11, 18, 15, 2, -18 },
  { 1547, 11, 14, 15, 2, -14 },
  { 1567, 11, 18, 15, 2, -18 },
  { 1592, 11, 14, 15, 2, -14 },
  { 1612, 13, 18, 15, 1, -18 },
  { 1642, 11, 19, 15, 2, -14 },
  { 1669, 11, 18, 15, 2, -18 },
  { 1694, 12, 20, 15, 2, -20 },
  { 1724, 10, 25, 15, 2, -20 },
  { 1756, 12, 18, 15, 2, -18 },
  { 1783, 13, 18, 15, 1, -18 },
  { 1813, 13, 14, 15, 1, -14 },
  { 1836, 11, 14, 15, 2, -14 },
  { 1856, 11, 14, 15, 2, -14 },
  { 1876, 11, 19, 15, 2, -14 },
  { 1903, 11, 19, 15, 2, -14 },
  { 1930, 12, 14, 15, 2, -14 },
  { 1951, 11, 14, 15, 2, -14 },
  { 1971, 12, 18, 15, 1, -18 },
  { 1998, 11, 14, 15, 2, -14 },
  { 2018, 13, 14, 15, 1, -14 },
  { 2041, 13, 14, 15, 1, -14 },
  { 2064, 13, 14, 15, 1, -14 },
  { 2087, 13, 19, 15, 1, -14 },
  { 2118, 11, 14, 15, 2, -14 },
  { 2138, 11, 24, 15, 2, -21 },
  { 2171, 3, 24, 15, 6, -21 },
  { 2180, 11, 24, 15, 2, -21 },
  { 2213, 13, 6, 15, 1, -12 },
};

const GFXfont JetBrainsMono_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_SEMIBOLD25PT7B_H_
