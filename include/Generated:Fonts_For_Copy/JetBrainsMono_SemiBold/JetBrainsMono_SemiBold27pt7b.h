#ifndef _JETBRAINSMONO_SEMIBOLD27PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x66, 0x66, 0x00, 0x0F, 0xFF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x8D, 0xC6, 0x06, 0x18, 0x38, 0x60,
  0xE3, 0x83, 0x0E, 0x0C, 0x31, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x18, 0x70,
  0x61, 0x81, 0x86, 0x06, 0x18, 0x38, 0x63, 0xFF, 0xFF, 0xFF, 0xCC, 0x30,
  0x30, 0xC0, 0xC3, 0x07, 0x0C, 0x1C, 0x70, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x3F, 0x03, 0xFE, 0x3F, 0xF3, 0xDB, 0xDC, 0xCE, 0xE6, 0x07, 0x30, 0x3D,
  0x80, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xDE, 0x06, 0x70, 0x33,
  0xF9, 0x9D, 0xCC, 0xEF, 0xFF, 0x3F, 0xF0, 0xFF, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x3C, 0x03, 0x7E, 0x06, 0x67, 0x0E, 0xE3, 0x0C, 0xE3,
  0x18, 0xE3, 0x38, 0xE3, 0x70, 0x7F, 0x60, 0x3E, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x3C, 0x07, 0x7E, 0x06, 0xE7, 0x0C, 0xC3, 0x1C, 0xC3, 0x38,
  0xC3, 0x30, 0xE7, 0x60, 0x7E, 0xE0, 0x3C, 0x0F, 0x80, 0x7F, 0x83, 0xFE,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x01, 0xF8,
  0x07, 0xF1, 0xF9, 0xC7, 0xE3, 0xBB, 0x87, 0xEE, 0x1F, 0x38, 0x3C, 0xF0,
  0xF1, 0xEF, 0xE7, 0xFB, 0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0x66, 0x01, 0x07,
  0x0F, 0x3F, 0x3C, 0x78, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3E, 0x1F, 0x0F, 0x03,
  0x80, 0x70, 0x3E, 0x1F, 0x83, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x81,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0,
  0xF0, 0xF1, 0xF0, 0xF0, 0x60, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x10,
  0xC3, 0xF3, 0x3F, 0xFF, 0xF3, 0xFF, 0x00, 0xC0, 0x07, 0xC0, 0x33, 0x81,
  0xCE, 0x0F, 0x1C, 0x38, 0x70, 0x20, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x3C, 0xF3, 0x9E, 0x79, 0xC7, 0x38, 0xFF, 0xFF, 0xFF,
  0x67, 0xBF, 0xEF, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE2, 0x7E, 0xF7, 0xEF, 0x7E, 0x67,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0xFF, 0x7F, 0xE1, 0xF8,
  0x07, 0x80, 0xFC, 0x0F, 0xE1, 0xFF, 0x0F, 0x78, 0x63, 0xC2, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFC,
  0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x7E, 0x07, 0xE0, 0xFF, 0xFE, 0x7F, 0xE3, 0xF8, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x87,
  0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x78, 0xFF, 0xEF, 0xFF, 0xF0, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xE1, 0xF8, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x77, 0xC7,
  0xFF, 0x3E, 0x7D, 0xC0, 0xEE, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x0E, 0xF0,
  0x73, 0xFF, 0x9F, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x07, 0x70, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07,
  0xF0, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0x3F, 0xC7, 0x9E, 0xF0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0xDF, 0x7F, 0xE1, 0xFC, 0x1F, 0x81, 0xFF,
  0x1F, 0xF9, 0xE1, 0xEE, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x77,
  0x87, 0x9F, 0xFC, 0x7F, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x00, 0xF7, 0xBF, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0x7F, 0xC0, 0x3C, 0x78, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x80, 0x00, 0x10, 0x0F,
  0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x07, 0x03, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC0, 0xF0, 0x0C, 0x00, 0xFC, 0x1F, 0xE3, 0xFE, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC7, 0xF8, 0xFE, 0x1F, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0x7F, 0xC3, 0xC7, 0x9C, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x7B,
  0xE3, 0xFF, 0x9C, 0x7E, 0x70, 0xF9, 0xC3, 0xE7, 0x0F, 0x9C, 0x3E, 0x70,
  0xF9, 0xC7, 0xE3, 0xFF, 0x8F, 0xBE, 0x08, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3B, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x71, 0x83,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xE7, 0xFF, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xFF, 0xE7, 0xFC, 0x3F, 0xF9, 0xC1,
  0xEE, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x77, 0xFF, 0xBF, 0xF9,
  0xFF, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x7E, 0x07, 0xF0, 0x77, 0xFF, 0x7F, 0xE1, 0xFC, 0xFF, 0x0F, 0xFC, 0xFF,
  0xEE, 0x1F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x77, 0xFF, 0x7F, 0xE1, 0xFC, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x73, 0xFF, 0x9F,
  0xF8, 0x3F, 0x80, 0xE0, 0x3F, 0x03, 0xF8, 0x1D, 0xC1, 0xEE, 0x0E, 0x70,
  0xF3, 0x87, 0x1C, 0x78, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xC7, 0x0E, 0x3C,
  0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0x70,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1,
  0xFD, 0x9F, 0xEC, 0xDF, 0x66, 0xFB, 0xB7, 0xCF, 0x3E, 0x79, 0xFB, 0xCF,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x70, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC7,
  0xEC, 0x7E, 0xC7, 0xEE, 0x7E, 0x67, 0xE7, 0x7E, 0x77, 0xE3, 0x7E, 0x3F,
  0xE3, 0xFE, 0x1B, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0x1F, 0x83, 0xFC,
  0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFE,
  0x7F, 0xE1, 0xF8, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xBF, 0xF9, 0xFF, 0x8E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xE1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC,
  0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81,
  0xDC, 0x0E, 0xF0, 0xF3, 0xFF, 0x9F, 0xF8, 0x3F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0xFF, 0x07, 0xFE, 0x3F, 0xFD, 0xC1, 0xEE,
  0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0xFF, 0xBF, 0xF9, 0xFF,
  0x0E, 0x38, 0x70, 0xE3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1D,
  0xC0, 0xF0, 0x1F, 0x81, 0xFF, 0x1F, 0xF9, 0xE1, 0xEE, 0x07, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xFC, 0x0E, 0xE0, 0x77, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7,
  0xFE, 0x7F, 0xE1, 0xF8, 0xE0, 0x1F, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x70,
  0x39, 0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xC7, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xE0, 0xE1, 0xC7, 0x61, 0xC7, 0x61, 0xC6, 0x73, 0xC6, 0x73,
  0xC6, 0x73, 0xCE, 0x73, 0x4E, 0x73, 0x4E, 0x73, 0x4E, 0x72, 0x6E, 0x32,
  0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x3E, 0x6C, 0x3E, 0x6C, 0x3E,
  0x2C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0xF0, 0x1D, 0xC0, 0xE7, 0x87,
  0x8E, 0x1C, 0x3C, 0xF0, 0x73, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xCE, 0x0F, 0x3C, 0x38,
  0x71, 0xE0, 0xE7, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x39, 0xC0, 0xE3,
  0x81, 0xC3, 0x87, 0x87, 0x0E, 0x07, 0x3C, 0x0E, 0x70, 0x0E, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xFE,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x19, 0x83, 0x9C, 0x38, 0xC7, 0x0E,
  0x70, 0xEE, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x87,
  0x1F, 0x83, 0xFE, 0x7F, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x1F, 0xF7, 0xFF,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF1, 0xFF, 0xFF, 0x7F, 0x70, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7C, 0xEF, 0xEF, 0xFF, 0xF0,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0xFF, 0xFF, 0xEF, 0xEE, 0x7C, 0x1F, 0x83, 0xFE, 0x7F, 0xFF, 0x0F, 0xE0,
  0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7F, 0x07, 0x7F,
  0xF7, 0xFE, 0x1F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x73,
  0xE7, 0x7F, 0x77, 0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0x73, 0xF7, 0x1F, 0x83,
  0xFE, 0x79, 0xEF, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x07, 0x79, 0xF7, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x77, 0xF7, 0x7F,
  0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0xF7, 0xFF, 0x7F, 0x71, 0xE7, 0x00, 0x70, 0x07, 0x00, 0xF3, 0xFE, 0x3F,
  0xE3, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7C, 0xEF,
  0xEF, 0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x07, 0x00, 0x7C, 0x01,
  0xE0, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x7C, 0x07, 0x80,
  0x40, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x7F, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x3F, 0x81, 0xDC, 0x1E, 0xE0, 0xE7, 0x0E, 0x38,
  0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0x8F, 0x1C, 0x3C, 0xE0, 0xE7, 0x07,
  0xB8, 0x1D, 0xC0, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xEE, 0x7B, 0xFF, 0xEF, 0x7B, 0xF8, 0xC7, 0xE3, 0x1F,
  0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7,
  0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xC0, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F,
  0xE7, 0xFE, 0x1F, 0x80, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xFF, 0xFE,
  0xFE, 0xE7, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3E, 0x77,
  0xF7, 0x7F, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xF7, 0xF7, 0x3F, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0xEF, 0x8F, 0xFE, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x1F, 0xC7, 0xFE, 0x7F, 0xFF, 0x07, 0xE0, 0x0F, 0x00,
  0x7F, 0x83, 0xFE, 0x07, 0xF0, 0x07, 0x00, 0x7E, 0x07, 0xF8, 0xF7, 0xFE,
  0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0xE0, 0x1D, 0xC0, 0xF7,
  0x03, 0x9C, 0x0E, 0x38, 0x78, 0xE1, 0xC3, 0x87, 0x07, 0x1C, 0x1C, 0xE0,
  0x73, 0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xC3,
  0x0F, 0x87, 0x1B, 0x9E, 0x37, 0x3C, 0x6E, 0x79, 0xDC, 0xD3, 0x99, 0xA7,
  0x32, 0x4C, 0x64, 0xD8, 0xF9, 0xB1, 0xF3, 0x63, 0xE7, 0xC3, 0xC7, 0x87,
  0x0E, 0x0E, 0x1C, 0x00, 0xF0, 0x3D, 0xE1, 0xE3, 0xC7, 0x07, 0x3C, 0x1F,
  0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xEE, 0x0F,
  0x3C, 0x38, 0x71, 0xE0, 0xEF, 0x03, 0xC0, 0xF0, 0x1D, 0xC0, 0xF7, 0x03,
  0x9E, 0x0E, 0x38, 0x70, 0xF1, 0xC1, 0xC7, 0x07, 0x38, 0x1E, 0xE0, 0x3B,
  0x80, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x78, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x0F, 0xF0, 0xFE,
  0x0F, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x7F, 0x07,
  0xF0, 0xFF, 0x0E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xF0, 0x00, 0x08, 0x01, 0xF8, 0x77, 0xF1,
  0xF9, 0xE7, 0xE3, 0xFB, 0x87, 0xE0, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 9, 8, 16, 4, -20 },
  { 20, 14, 20, 16, 1, -20 },
  { 55, 13, 27, 16, 2, -23 },
  { 99, 16, 20, 16, 0, -20 },
  { 139, 14, 20, 16, 1, -20 },
  { 174, 4, 8, 16, 6, -20 },
  { 178, 8, 26, 16, 5, -23 },
  { 204, 9, 26, 16, 3, -23 },
  { 234, 14, 14, 16, 1, -16 },
  { 259, 13, 12, 16, 2, -15 },
  { 279, 6, 8, 16, 4, -4 },
  { 285, 8, 3, 16, 4, -10 },
  { 288, 5, 5, 16, 6, -5 },
  { 292, 12, 25, 16, 2, -22 },
  { 330, 12, 20, 16, 2, -20 },
  { 360, 13, 20, 16, 2, -20 },
  { 393, 12, 20, 16, 2, -20 },
  { 423, 12, 20, 16, 2, -20 },
  { 453, 12, 20, 16, 2, -20 },
  { 483, 12, 20, 16, 2, -20 },
  { 513, 13, 20, 16, 2, -20 },
  { 546, 13, 20, 16, 2, -20 },
  { 579, 12, 20, 16, 2, -20 },
  { 609, 13, 20, 16, 2, -20 },
  { 642, 5, 15, 16, 6, -15 },
  { 652, 7, 19, 16, 4, -15 },
  { 669, 12, 14, 16, 2, -16 },
  { 690, 12, 10, 16, 2, -14 },
  { 705, 12, 14, 16, 2, -16 },
  { 726, 11, 20, 16, 3, -20 },
  { 754, 14, 25, 16, 1, -20 },
  { 798, 14, 20, 16, 1, -20 },
  { 833, 13, 20, 16, 2, -20 },
  { 866, 12, 20, 16, 2, -20 },
  { 896, 12, 20, 16, 2, -20 },
  { 926, 12, 20, 16, 2, -20 },
  { 956, 12, 20, 16, 2, -20 },
  { 986, 12, 20, 16, 2, -20 },
  { 1016, 12, 20, 16, 2, -20 },
  { 1046, 11, 20, 16, 3, -20 },
  { 1074, 13, 20, 16, 1, -20 },
  { 1107, 13, 20, 16, 2, -20 },
  { 1140, 12, 20, 16, 3, -20 },
  { 1170, 13, 20, 16, 2, -20 },
  { 1203, 12, 20, 16, 2, -20 },
  { 1233, 12, 20, 16, 2, -20 },
  { 1263, 13, 20, 16, 2, -20 },
  { 1296, 13, 25, 16, 2, -20 },
  { 1337, 13, 20, 16, 2, -20 },
  { 1370, 13, 20, 16, 2, -20 },
  { 1403, 14, 20, 16, 1, -20 },
  { 1438, 12, 20, 16, 2, -20 },
  { 1468, 14, 20, 16, 1, -20 },
  { 1503, 16, 20, 16, 0, -20 },
  { 1543, 14, 20, 16, 1, -20 },
  { 1578, 15, 20, 16, 1, -20 },
  { 1616, 12, 20, 16, 2, -20 },
  { 1646, 7, 25, 16, 5, -22 },
  { 1668, 12, 25, 16, 2, -22 },
  { 1706, 7, 25, 16, 4, -22 },
  { 1728, 12, 11, 16, 2, -20 },
  { 1745, 13, 2, 16, 2, 1 },
  { 1749, 6, 4, 16, 5, -21 },
  { 1752, 12, 15, 16, 2, -15 },
  { 1775, 12, 20, 16, 2, -20 },
  { 1805, 12, 15, 16, 2, -15 },
  { 1828, 12, 20, 16, 2, -20 },
  { 1858, 12, 15, 16, 2, -15 },
  { 1881, 14, 20, 16, 1, -20 },
  { 1916, 12, 20, 16, 2, -15 },
  { 1946, 12, 20, 16, 2, -20 },
  { 1976, 13, 21, 16, 2, -21 },
  { 2011, 11, 26, 16, 2, -21 },
  { 2047, 13, 20, 16, 2, -20 },
  { 2080, 14, 20, 16, 1, -20 },
  { 2115, 14, 15, 16, 1, -15 },
  { 2142, 12, 15, 16, 2, -15 },
  { 2165, 12, 15, 16, 2, -15 },
  { 2188, 12, 20, 16, 2, -15 },
  { 2218, 12, 20, 16, 2, -15 },
  { 2248, 12, 15, 16, 3, -15 },
  { 2271, 12, 15, 16, 2, -15 },
  { 2294, 13, 19, 16, 1, -19 },
  { 2325, 12, 15, 16, 2, -15 },
  { 2348, 14, 15, 16, 1, -15 },
  { 2375, 15, 15, 16, 1, -15 },
  { 2404, 14, 15, 16, 1, -15 },
  { 2431, 14, 20, 16, 1, -15 },
  { 2466, 12, 15, 16, 2, -15 },
  { 2489, 12, 25, 16, 2, -22 },
  { 2527, 3, 25, 16, 7, -22 },
  { 2537, 12, 25, 16, 2, -22 },
  { 2575, 14, 7, 16, 1, -13 },
};

const GFXfont JetBrainsMono_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_SEMIBOLD27PT7B_H_
