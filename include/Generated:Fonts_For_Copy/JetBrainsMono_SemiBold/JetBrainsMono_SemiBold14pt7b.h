#ifndef _JETBRAINSMONO_SEMIBOLD14PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xD4, 0xF0, 0xDE, 0xE5, 0x20, 0x12, 0x12, 0x7F, 0x7F, 0x24,
  0x24, 0xFF, 0x24, 0x64, 0x4C, 0x10, 0x21, 0xF6, 0xED, 0x1A, 0x1E, 0x0E,
  0x15, 0x2F, 0x73, 0xC1, 0x02, 0x00, 0xF1, 0x92, 0x94, 0xF4, 0x08, 0x16,
  0x3D, 0x29, 0x49, 0xC7, 0x79, 0x9B, 0x02, 0x0E, 0x16, 0xE7, 0x46, 0xDD,
  0xEC, 0xFF, 0x09, 0xD8, 0xC4, 0x63, 0x18, 0xC2, 0x18, 0xE3, 0x84, 0x8C,
  0x63, 0x33, 0x33, 0x33, 0x36, 0xC8, 0x18, 0x18, 0x49, 0xFF, 0x08, 0x3C,
  0x66, 0x24, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x00, 0x6D, 0x60, 0xF0,
  0xF0, 0x06, 0x18, 0x30, 0x41, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x82, 0x0C,
  0x18, 0x00, 0x7F, 0x3C, 0x71, 0xF7, 0x5C, 0x71, 0xCD, 0xE0, 0x39, 0xB2,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFC, 0x7F, 0x3C, 0x41, 0x0C, 0x63,
  0x18, 0xC3, 0xF0, 0xFC, 0x31, 0x8C, 0x3C, 0x30, 0x71, 0xCD, 0xE0, 0x1C,
  0x63, 0x18, 0x67, 0x1F, 0xFF, 0x04, 0x10, 0xFF, 0x0C, 0x36, 0xFC, 0x10,
  0x41, 0xCD, 0xE0, 0x18, 0x61, 0x83, 0x0F, 0xD8, 0xA1, 0xE3, 0xCC, 0xF0,
  0xFF, 0x8F, 0x30, 0x60, 0x83, 0x04, 0x18, 0x30, 0xC0, 0x7F, 0x3C, 0x73,
  0x79, 0xFC, 0x71, 0xCD, 0xE0, 0x7D, 0x9A, 0x1C, 0x3C, 0xCF, 0x82, 0x0C,
  0x30, 0xE0, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x58, 0x0C, 0xEE, 0x30, 0x70,
  0x70, 0x40, 0xFC, 0x00, 0x3F, 0xFC, 0xC1, 0xC1, 0xC1, 0x1F, 0xCC, 0x00,
  0xF0, 0xC6, 0x37, 0xB1, 0x00, 0x47, 0x00, 0x3E, 0x63, 0x41, 0x4D, 0xDB,
  0xD9, 0xD9, 0xD9, 0x4F, 0x40, 0x60, 0x3C, 0x0C, 0x30, 0x71, 0xE3, 0x44,
  0x89, 0xBF, 0x62, 0xC5, 0x0C, 0xFD, 0x9B, 0x16, 0x6F, 0x99, 0xB1, 0xE3,
  0xCD, 0xF0, 0x7F, 0x3C, 0x70, 0xC3, 0x0C, 0x31, 0xCD, 0xE0, 0xFB, 0x3C,
  0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xE0, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30,
  0xC3, 0xF0, 0xFF, 0x0C, 0x30, 0xFF, 0xFC, 0x30, 0xC3, 0x00, 0x7F, 0x3C,
  0x70, 0xC3, 0x7C, 0x71, 0xCD, 0xE0, 0xC7, 0x1C, 0x71, 0xFF, 0x1C, 0x71,
  0xC7, 0x10, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x1E, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xE3, 0x66, 0x78, 0xC7, 0x9B, 0x36, 0xCF, 0x9B,
  0x36, 0x66, 0xCD, 0x8C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0xFC, 0xCF, 0x9E, 0xBD, 0xFB, 0x76, 0xE1, 0xC3, 0x87, 0x0C, 0xC7, 0x9A,
  0x79, 0xF7, 0x5D, 0x77, 0xCF, 0x30, 0x7F, 0x3C, 0x71, 0xC7, 0x1C, 0x71,
  0xCD, 0xE0, 0xFD, 0x9F, 0x1E, 0x3C, 0xDF, 0x30, 0x60, 0xC1, 0x80, 0x7D,
  0x9B, 0x16, 0x2C, 0x58, 0xB1, 0x62, 0xCC, 0xF0, 0x20, 0x60, 0x60, 0xFD,
  0x9B, 0x1E, 0x3F, 0xDF, 0x36, 0x66, 0xCD, 0x8C, 0x7D, 0x9B, 0x06, 0x07,
  0x83, 0x81, 0x43, 0xCC, 0xF0, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCD, 0xE0, 0x87, 0x8B,
  0x16, 0x64, 0xCD, 0x1A, 0x1C, 0x38, 0x60, 0xD9, 0xD9, 0x5B, 0x5B, 0x57,
  0x57, 0x56, 0x56, 0x66, 0x66, 0x63, 0x26, 0x34, 0x1C, 0x18, 0x1C, 0x3C,
  0x36, 0x66, 0xC3, 0xC3, 0x62, 0x26, 0x34, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFC, 0x30, 0x86, 0x30, 0xC6, 0x10, 0xFF, 0xF0, 0xFE, 0x49, 0x24,
  0x92, 0x4F, 0xC0, 0xC1, 0x81, 0x03, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x30,
  0x20, 0x60, 0xC0, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x30,
  0xE6, 0x93, 0xC4, 0xFF, 0xFC, 0xE3, 0x3B, 0xF0, 0x4F, 0xFE, 0x1C, 0xFD,
  0xC3, 0x0D, 0xBF, 0xC7, 0x1C, 0x71, 0xCF, 0xF0, 0x3B, 0xFC, 0x70, 0xC3,
  0x1C, 0xDE, 0x04, 0x17, 0x7F, 0xC7, 0x1C, 0x71, 0xCD, 0xD0, 0x3B, 0xBC,
  0x7F, 0xFF, 0x0C, 0xDE, 0x3E, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30,
  0x60, 0x77, 0xFC, 0x71, 0xC7, 0x37, 0x49, 0x05, 0xF7, 0x00, 0xC3, 0x0D,
  0xBF, 0xC7, 0x1C, 0x71, 0xC7, 0x10, 0x30, 0x70, 0x07, 0x8F, 0x02, 0x04,
  0x08, 0x10, 0x23, 0xF8, 0x18, 0x70, 0x1E, 0x78, 0x20, 0x82, 0x08, 0x20,
  0x86, 0xFB, 0x00, 0xC1, 0x83, 0x1E, 0x6C, 0x9F, 0x3E, 0x64, 0xCD, 0x8C,
  0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0F, 0xAD, 0xEE,
  0x5C, 0xB9, 0x72, 0xE5, 0xCB, 0xDB, 0xFC, 0x71, 0xC7, 0x1C, 0x71, 0x3B,
  0xFC, 0x71, 0xC7, 0x1C, 0xDE, 0xDB, 0xFC, 0x71, 0xC7, 0x1C, 0xFF, 0xC3,
  0x0C, 0x00, 0x77, 0xFC, 0x71, 0xC7, 0x1C, 0xDD, 0x04, 0x10, 0x40, 0xD9,
  0xFB, 0x1E, 0x3C, 0x18, 0x30, 0x60, 0x7B, 0xFC, 0x3C, 0x3C, 0x1C, 0x5F,
  0x20, 0x8F, 0xFF, 0x20, 0x82, 0x08, 0x30, 0xF0, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xDE, 0x87, 0x8B, 0x32, 0x66, 0x8D, 0x0E, 0x18, 0xC9, 0x59, 0x5B,
  0x5B, 0x56, 0x56, 0x66, 0x66, 0xC6, 0x99, 0xE1, 0xC3, 0x0F, 0x13, 0x63,
  0x87, 0x8B, 0x33, 0x66, 0x87, 0x0E, 0x18, 0x30, 0x41, 0x80, 0xFF, 0xF0,
  0xC6, 0x31, 0x8C, 0x3F, 0x0C, 0x71, 0x04, 0x18, 0x6F, 0x3C, 0x18, 0x61,
  0x06, 0x1C, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x83, 0x0C, 0x20, 0x83,
  0xCF, 0x20, 0x83, 0x0C, 0xE3, 0x00, 0x41, 0xEE, 0x78, 0x60,
};

const GFXglyph JetBrainsMono_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 5, 4, 8, 2, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 14, 8, 1, -12 },
  { 30, 8, 10, 8, 0, -10 },
  { 40, 7, 10, 8, 1, -10 },
  { 49, 2, 4, 8, 3, -10 },
  { 50, 5, 14, 8, 2, -12 },
  { 59, 4, 14, 8, 2, -12 },
  { 66, 8, 8, 8, 0, -9 },
  { 74, 7, 7, 8, 1, -8 },
  { 81, 3, 4, 8, 2, -2 },
  { 83, 4, 1, 8, 2, -5 },
  { 84, 2, 2, 8, 3, -2 },
  { 85, 7, 14, 8, 1, -12 },
  { 98, 6, 10, 8, 1, -10 },
  { 106, 7, 10, 8, 1, -10 },
  { 115, 6, 10, 8, 1, -10 },
  { 123, 6, 10, 8, 1, -10 },
  { 131, 6, 10, 8, 1, -10 },
  { 139, 6, 10, 8, 1, -10 },
  { 147, 7, 10, 8, 1, -10 },
  { 156, 7, 10, 8, 1, -10 },
  { 165, 6, 10, 8, 1, -10 },
  { 173, 7, 10, 8, 1, -10 },
  { 182, 2, 8, 8, 3, -8 },
  { 184, 3, 10, 8, 2, -8 },
  { 188, 6, 7, 8, 1, -8 },
  { 194, 6, 5, 8, 1, -7 },
  { 198, 6, 7, 8, 1, -8 },
  { 204, 5, 10, 8, 2, -10 },
  { 211, 8, 13, 8, 0, -10 },
  { 224, 7, 10, 8, 1, -10 },
  { 233, 7, 10, 8, 1, -10 },
  { 242, 6, 10, 8, 1, -10 },
  { 250, 6, 10, 8, 1, -10 },
  { 258, 6, 10, 8, 1, -10 },
  { 266, 6, 10, 8, 1, -10 },
  { 274, 6, 10, 8, 1, -10 },
  { 282, 6, 10, 8, 1, -10 },
  { 290, 6, 10, 8, 1, -10 },
  { 298, 7, 10, 8, 0, -10 },
  { 307, 7, 10, 8, 1, -10 },
  { 316, 7, 10, 8, 1, -10 },
  { 325, 7, 10, 8, 1, -10 },
  { 334, 6, 10, 8, 1, -10 },
  { 342, 6, 10, 8, 1, -10 },
  { 350, 7, 10, 8, 1, -10 },
  { 359, 7, 13, 8, 1, -10 },
  { 371, 7, 10, 8, 1, -10 },
  { 380, 7, 10, 8, 1, -10 },
  { 389, 7, 10, 8, 1, -10 },
  { 398, 6, 10, 8, 1, -10 },
  { 406, 7, 10, 8, 1, -10 },
  { 415, 8, 10, 8, 0, -10 },
  { 425, 8, 10, 8, 0, -10 },
  { 435, 8, 10, 8, 0, -10 },
  { 445, 6, 10, 8, 1, -10 },
  { 453, 3, 14, 8, 3, -12 },
  { 459, 7, 14, 8, 1, -12 },
  { 472, 4, 14, 8, 2, -12 },
  { 479, 6, 5, 8, 1, -10 },
  { 483, 7, 2, 8, 1, 0 },
  { 485, 4, 2, 8, 2, -11 },
  { 486, 6, 8, 8, 1, -8 },
  { 492, 6, 10, 8, 1, -10 },
  { 500, 6, 8, 8, 1, -8 },
  { 506, 6, 10, 8, 1, -10 },
  { 514, 6, 8, 8, 1, -8 },
  { 520, 7, 10, 8, 1, -10 },
  { 529, 6, 11, 8, 1, -8 },
  { 538, 6, 10, 8, 1, -10 },
  { 546, 7, 11, 8, 1, -11 },
  { 556, 6, 14, 8, 1, -11 },
  { 567, 7, 10, 8, 1, -10 },
  { 576, 8, 10, 8, 0, -10 },
  { 586, 7, 8, 8, 1, -8 },
  { 593, 6, 8, 8, 1, -8 },
  { 599, 6, 8, 8, 1, -8 },
  { 605, 6, 11, 8, 1, -8 },
  { 614, 6, 11, 8, 1, -8 },
  { 623, 7, 8, 8, 1, -8 },
  { 630, 6, 8, 8, 1, -8 },
  { 636, 6, 10, 8, 1, -10 },
  { 644, 6, 8, 8, 1, -8 },
  { 650, 7, 8, 8, 1, -8 },
  { 657, 8, 8, 8, 0, -8 },
  { 665, 7, 8, 8, 1, -8 },
  { 672, 7, 11, 8, 1, -8 },
  { 682, 6, 8, 8, 1, -8 },
  { 688, 6, 14, 8, 1, -12 },
  { 699, 2, 14, 8, 3, -12 },
  { 703, 6, 14, 8, 1, -12 },
  { 714, 7, 4, 8, 1, -7 },
};

const GFXfont JetBrainsMono_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_SEMIBOLD14PT7B_H_
