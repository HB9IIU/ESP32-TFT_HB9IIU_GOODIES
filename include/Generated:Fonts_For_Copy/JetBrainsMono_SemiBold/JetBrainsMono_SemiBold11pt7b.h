#ifndef _JETBRAINSMONO_SEMIBOLD11PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x43, 0xDD, 0x50, 0x24, 0xA7, 0xCA, 0x4B, 0xF4, 0x94, 0x21,
  0x3D, 0x7A, 0x70, 0xE5, 0xBF, 0x88, 0x40, 0xE7, 0x4A, 0xA2, 0x82, 0xC6,
  0x95, 0x46, 0x79, 0x24, 0x18, 0x77, 0x64, 0x9D, 0xE0, 0x2B, 0x49, 0x24,
  0x44, 0xC6, 0x23, 0x33, 0x32, 0x6C, 0x10, 0x4F, 0xC4, 0x29, 0x20, 0x21,
  0x3E, 0x42, 0x00, 0x7A, 0xE0, 0xF0, 0x18, 0x84, 0x62, 0x31, 0x08, 0xC4,
  0x00, 0xF4, 0xE3, 0x5A, 0xC6, 0x6E, 0x67, 0x28, 0x42, 0x10, 0x9F, 0xF4,
  0xC6, 0x23, 0x33, 0x1F, 0xF0, 0x88, 0xE1, 0x8E, 0x7E, 0x31, 0x19, 0xB9,
  0xFC, 0x63, 0xFC, 0x21, 0xE1, 0x86, 0x7E, 0x33, 0x11, 0xE9, 0xC6, 0x6E,
  0xFC, 0x44, 0x23, 0x11, 0x88, 0xF4, 0xE6, 0xED, 0x46, 0x7E, 0xF4, 0xE3,
  0x3F, 0x18, 0x8C, 0xD0, 0x70, 0xD0, 0x7A, 0x09, 0xF9, 0x06, 0x0C, 0xFF,
  0xC1, 0xF0, 0x86, 0x0C, 0x37, 0x60, 0xF0, 0x86, 0xE6, 0x20, 0x0C, 0x79,
  0x1C, 0x67, 0x96, 0x59, 0xF0, 0x40, 0xC0, 0x30, 0xE2, 0x8A, 0x69, 0xF4,
  0x71, 0xF4, 0xE7, 0xE9, 0xC6, 0x7E, 0x74, 0xE1, 0x08, 0x42, 0x6E, 0xF4,
  0xE3, 0x18, 0xC6, 0x7E, 0xFC, 0x21, 0xE8, 0x42, 0x1F, 0xFC, 0x21, 0xFF,
  0xC2, 0x10, 0x74, 0xE1, 0x0B, 0xC6, 0x6E, 0x9C, 0xE7, 0xF9, 0xCE, 0x73,
  0xF9, 0x08, 0x42, 0x10, 0x9F, 0x3C, 0x30, 0xC3, 0x0C, 0x3C, 0x9E, 0x9C,
  0xA5, 0xCB, 0x4A, 0x71, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x9E, 0xF7, 0xDA,
  0xC6, 0x31, 0xCE, 0x73, 0x5A, 0xD6, 0x73, 0xF4, 0xE7, 0x39, 0xCE, 0x6E,
  0xF4, 0x63, 0x3F, 0x42, 0x10, 0xF4, 0xE3, 0x18, 0xC6, 0x6E, 0x10, 0xC0,
  0xF4, 0xE3, 0x3F, 0x4A, 0x53, 0xF4, 0xE1, 0xC3, 0x86, 0x7E, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x9C, 0xE7, 0x39, 0xCE, 0x6E, 0xC5, 0x14, 0xDA, 0x28,
  0xA3, 0x8C, 0x96, 0x5F, 0x5D, 0x6D, 0xB6, 0xDB, 0xCD, 0xA3, 0x8C, 0x30,
  0xA6, 0xB1, 0xC5, 0x36, 0x8E, 0x30, 0x41, 0x04, 0xF8, 0x8C, 0x46, 0x22,
  0x1F, 0xF2, 0x49, 0x24, 0x9C, 0x86, 0x10, 0x86, 0x10, 0xC2, 0x10, 0xC0,
  0xED, 0xB6, 0xDB, 0x7C, 0x62, 0x95, 0x30, 0xF8, 0x90, 0xF4, 0xDF, 0x39,
  0xFC, 0x84, 0x3D, 0x38, 0xC6, 0x7E, 0xF4, 0xE1, 0x09, 0xB8, 0x18, 0xFF,
  0x39, 0xCE, 0x7F, 0xF4, 0xFF, 0x09, 0xB8, 0x3B, 0x19, 0xF6, 0x31, 0x8C,
  0xFC, 0xE7, 0x3D, 0xBC, 0x6E, 0x84, 0x3D, 0x39, 0xCE, 0x73, 0x21, 0x01,
  0xC2, 0x10, 0x84, 0xF8, 0x13, 0x0F, 0x11, 0x11, 0x13, 0xE0, 0x84, 0x27,
  0x2F, 0x5A, 0x53, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x07, 0xFD, 0x6B, 0x5A,
  0xD4, 0xF4, 0xE7, 0x39, 0xCC, 0xF4, 0xE3, 0x19, 0xB8, 0xF4, 0xE3, 0x19,
  0xFA, 0x10, 0xFC, 0xE7, 0x39, 0xFC, 0x63, 0xBE, 0x63, 0x08, 0x40, 0xF4,
  0x78, 0x38, 0xF8, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x07, 0x9C, 0xE7, 0x39,
  0xB8, 0xC5, 0x36, 0x8A, 0x38, 0xC0, 0x95, 0x57, 0x5B, 0x6D, 0xA0, 0x4C,
  0xA3, 0x0C, 0x6B, 0x30, 0xC5, 0x36, 0x8A, 0x30, 0x43, 0x08, 0xF8, 0x88,
  0xCC, 0x7C, 0x39, 0x08, 0x4E, 0x70, 0x84, 0x21, 0xC0, 0xFF, 0xC0, 0xC3,
  0x18, 0x87, 0xBD, 0x0C, 0x66, 0x00, 0xCD, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 4, 3, 7, 1, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 12, 7, 1, -10 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 6, 8, 7, 0, -8 },
  { 32, 1, 3, 7, 3, -8 },
  { 33, 3, 10, 7, 2, -9 },
  { 37, 4, 10, 7, 1, -9 },
  { 42, 6, 6, 7, 0, -7 },
  { 47, 5, 5, 7, 1, -6 },
  { 51, 2, 4, 7, 2, -2 },
  { 52, 3, 1, 7, 2, -4 },
  { 53, 2, 2, 7, 2, -2 },
  { 54, 5, 10, 7, 1, -9 },
  { 61, 5, 8, 7, 1, -8 },
  { 66, 5, 8, 7, 1, -8 },
  { 71, 5, 8, 7, 1, -8 },
  { 76, 5, 8, 7, 1, -8 },
  { 81, 5, 8, 7, 1, -8 },
  { 86, 5, 8, 7, 1, -8 },
  { 91, 5, 8, 7, 1, -8 },
  { 96, 5, 8, 7, 1, -8 },
  { 101, 5, 8, 7, 1, -8 },
  { 106, 5, 8, 7, 1, -8 },
  { 111, 2, 6, 7, 2, -6 },
  { 113, 2, 8, 7, 2, -6 },
  { 115, 5, 6, 7, 1, -7 },
  { 119, 5, 4, 7, 1, -6 },
  { 122, 5, 6, 7, 1, -7 },
  { 126, 5, 8, 7, 1, -8 },
  { 131, 6, 10, 7, 0, -8 },
  { 139, 6, 8, 7, 0, -8 },
  { 145, 5, 8, 7, 1, -8 },
  { 150, 5, 8, 7, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 5, 8, 7, 1, -8 },
  { 185, 6, 8, 7, 0, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 5, 8, 7, 1, -8 },
  { 201, 5, 8, 7, 1, -8 },
  { 206, 5, 8, 7, 1, -8 },
  { 211, 5, 8, 7, 1, -8 },
  { 216, 5, 8, 7, 1, -8 },
  { 221, 5, 10, 7, 1, -8 },
  { 228, 5, 8, 7, 1, -8 },
  { 233, 5, 8, 7, 1, -8 },
  { 238, 5, 8, 7, 1, -8 },
  { 243, 5, 8, 7, 1, -8 },
  { 248, 6, 8, 7, 0, -8 },
  { 254, 6, 8, 7, 0, -8 },
  { 260, 6, 8, 7, 0, -8 },
  { 266, 6, 8, 7, 0, -8 },
  { 272, 5, 8, 7, 1, -8 },
  { 277, 3, 10, 7, 2, -9 },
  { 281, 5, 10, 7, 1, -9 },
  { 288, 3, 10, 7, 2, -9 },
  { 292, 5, 4, 7, 1, -8 },
  { 295, 5, 1, 7, 1, 0 },
  { 296, 2, 2, 7, 2, -9 },
  { 297, 5, 6, 7, 1, -6 },
  { 301, 5, 8, 7, 1, -8 },
  { 306, 5, 6, 7, 1, -6 },
  { 310, 5, 8, 7, 1, -8 },
  { 315, 5, 6, 7, 1, -6 },
  { 319, 5, 8, 7, 1, -8 },
  { 324, 5, 8, 7, 1, -6 },
  { 329, 5, 8, 7, 1, -8 },
  { 334, 5, 9, 7, 1, -9 },
  { 340, 4, 11, 7, 1, -9 },
  { 346, 5, 8, 7, 1, -8 },
  { 351, 6, 8, 7, 0, -8 },
  { 357, 5, 6, 7, 1, -6 },
  { 361, 5, 6, 7, 1, -6 },
  { 365, 5, 6, 7, 1, -6 },
  { 369, 5, 8, 7, 1, -6 },
  { 374, 5, 8, 7, 1, -6 },
  { 379, 5, 6, 7, 1, -6 },
  { 383, 5, 6, 7, 1, -6 },
  { 387, 6, 8, 7, 0, -8 },
  { 393, 5, 6, 7, 1, -6 },
  { 397, 6, 6, 7, 0, -6 },
  { 402, 6, 6, 7, 0, -6 },
  { 407, 6, 6, 7, 0, -6 },
  { 412, 6, 8, 7, 0, -6 },
  { 418, 5, 6, 7, 1, -6 },
  { 422, 5, 10, 7, 1, -9 },
  { 429, 1, 10, 7, 3, -9 },
  { 431, 5, 10, 7, 1, -9 },
  { 438, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_SemiBold11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_SEMIBOLD11PT7B_H_
