#ifndef _JETBRAINSMONO_SEMIBOLD16PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x01, 0xF0, 0xCE, 0x73, 0x9C, 0x80, 0x19, 0x08,
  0x84, 0x4F, 0xF7, 0xF9, 0x90, 0xC8, 0x44, 0xFF, 0x93, 0x09, 0x8C, 0x80,
  0x10, 0x10, 0x3C, 0x7E, 0xD6, 0xD0, 0xF0, 0x78, 0x3E, 0x16, 0x13, 0xD3,
  0xFE, 0x7C, 0x10, 0x10, 0x70, 0xF6, 0x6D, 0x93, 0x68, 0xFE, 0x09, 0x00,
  0x80, 0x7E, 0x34, 0x89, 0x24, 0x4B, 0x1E, 0x38, 0x7C, 0x46, 0x40, 0x60,
  0x70, 0xF3, 0xDA, 0xCE, 0xCC, 0xDE, 0x7B, 0xFF, 0xC0, 0x1B, 0x99, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x86, 0x1C, 0x20, 0xC7, 0x0C, 0x61, 0x8C, 0x63,
  0x18, 0xC6, 0x67, 0x72, 0x00, 0x0C, 0x06, 0x13, 0x3F, 0x73, 0xF0, 0xE0,
  0xD8, 0x66, 0x22, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x36, 0x66, 0xC0, 0xFF, 0xC0, 0x7D, 0x80, 0x07, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x3C, 0xFF,
  0x1E, 0x1C, 0x3B, 0x76, 0xE1, 0xC3, 0x85, 0xBB, 0xE0, 0x18, 0x78, 0xF8,
  0x98, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3C, 0x7E, 0xC6,
  0xC6, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0xFF, 0xFC, 0x30,
  0xC3, 0x07, 0x81, 0x83, 0x03, 0x8F, 0xBB, 0xE0, 0x0E, 0x18, 0x61, 0xC3,
  0x0C, 0xF1, 0xE3, 0xFF, 0xFC, 0x18, 0x30, 0x7E, 0xFF, 0x06, 0x0D, 0xDF,
  0xF1, 0x81, 0x03, 0x8D, 0xBB, 0xE0, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x7E,
  0xE6, 0xC3, 0xC3, 0xC3, 0x6E, 0x7C, 0xFF, 0xFF, 0xC3, 0xC6, 0x06, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x3C, 0x7E, 0xC6, 0xC6, 0x66, 0x3C,
  0x7C, 0xC6, 0xC2, 0xC3, 0xEE, 0x7C, 0x3C, 0x7E, 0xC6, 0xC3, 0xC3, 0xC6,
  0x7E, 0x16, 0x0C, 0x18, 0x18, 0x30, 0x7D, 0x80, 0x07, 0x60, 0x7D, 0x80,
  0x03, 0xDB, 0x40, 0x02, 0x0C, 0x7B, 0x8C, 0x1E, 0x0F, 0x07, 0x02, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC1, 0xE0, 0xF0, 0x61, 0xCF, 0x78,
  0x80, 0xF3, 0xE0, 0xC3, 0x0D, 0xF7, 0x98, 0x60, 0x06, 0x18, 0x3C, 0x7E,
  0xC3, 0x83, 0x8D, 0x9B, 0x91, 0x91, 0x91, 0x93, 0x9D, 0x80, 0xC0, 0x78,
  0x38, 0x18, 0x38, 0x3C, 0x2C, 0x2C, 0x64, 0x66, 0x66, 0x7E, 0xC6, 0xC3,
  0xC3, 0xF8, 0xFE, 0xC6, 0xC2, 0xC6, 0xFC, 0xFE, 0xC2, 0xC3, 0xC3, 0xFE,
  0xFC, 0x3C, 0x7E, 0xC6, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0xC2, 0x7E,
  0x3C, 0xF9, 0xFF, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C,
  0x7E, 0xC6, 0xC3, 0xC0, 0xC0, 0xCF, 0xC3, 0xC3, 0xC2, 0x6E, 0x3C, 0xC7,
  0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0xFF, 0xFC,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x3E, 0x7C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0x8F, 0xBB, 0xE0, 0xC3, 0xC6, 0xC6, 0xCC,
  0xCC, 0xF8, 0xFC, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xC7, 0xE7, 0xA7, 0xAF, 0xFB,
  0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xC7, 0x8F, 0x9F, 0x3A,
  0x76, 0xE5, 0xCB, 0x9F, 0x1E, 0x30, 0x3C, 0xFF, 0x1E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x8D, 0xFB, 0xE0, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xC6, 0xC2, 0xC2, 0xC2, 0xC2,
  0xC2, 0xC2, 0xC6, 0x7E, 0x7C, 0x0C, 0x06, 0x07, 0xF8, 0xFE, 0xC7, 0xC3,
  0xC3, 0xC6, 0xFC, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0x3C, 0x7E, 0xC6, 0xC0,
  0xE0, 0x78, 0x3E, 0x06, 0x03, 0xC3, 0xFE, 0x7C, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x8D, 0xBB, 0xE0, 0xC3, 0xC3, 0xC2, 0xC6, 0x66,
  0x66, 0x64, 0x6C, 0x2C, 0x3C, 0x38, 0x38, 0xCC, 0xE6, 0x53, 0x29, 0xB4,
  0xDA, 0xAD, 0x56, 0xEB, 0x73, 0x39, 0x9C, 0xCE, 0x60, 0x61, 0xB1, 0x8C,
  0xC6, 0xC1, 0xE0, 0xE0, 0x30, 0x3C, 0x36, 0x19, 0x98, 0xDC, 0x30, 0xC1,
  0xB0, 0xD8, 0xC6, 0x63, 0x60, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xFF, 0xFC, 0x18, 0x60, 0xC3, 0x0E, 0x18, 0x60, 0xC3, 0xFF, 0xF0,
  0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0xF8,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x18, 0x70, 0xF1,
  0x66, 0x68, 0xF0, 0x80, 0xFF, 0xFF, 0xCD, 0x80, 0x3C, 0xFF, 0x18, 0x37,
  0xF8, 0xF1, 0xE3, 0x7A, 0xC1, 0x83, 0x06, 0xEF, 0xF8, 0xF0, 0xE1, 0xC3,
  0x8F, 0xBE, 0xE0, 0x3C, 0xFF, 0x1E, 0x0C, 0x18, 0x30, 0xB7, 0x3C, 0x06,
  0x0C, 0x1B, 0xF7, 0xF8, 0xF1, 0xE3, 0xC7, 0x8D, 0xBB, 0xF0, 0x3C, 0xFF,
  0x1E, 0x1F, 0xF8, 0x30, 0x33, 0x3C, 0x0F, 0x1F, 0x30, 0x30, 0xFF, 0xFF,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E, 0xFF, 0x1E, 0x3C, 0x78, 0xF9,
  0xBF, 0x06, 0x0D, 0xFB, 0xE0, 0xC1, 0x83, 0x06, 0xEF, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x30, 0x08, 0x18, 0x18, 0x00, 0x78, 0x78, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x04, 0x30, 0xC0, 0x7D, 0xF0, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3F, 0xFE, 0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xCE, 0xCC,
  0xF8, 0xCC, 0xCE, 0xC6, 0xC3, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x03, 0xE1, 0xF0, 0xB6, 0xDB, 0xD3, 0xD3, 0xD3,
  0xD3, 0xD3, 0xD3, 0xD3, 0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6,
  0x3C, 0xFF, 0x1E, 0x1C, 0x38, 0x71, 0xBF, 0x3C, 0xDD, 0xFF, 0x1E, 0x1C,
  0x38, 0x71, 0xF7, 0xDD, 0x83, 0x06, 0x00, 0x7E, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xB7, 0x7E, 0x0C, 0x18, 0x30, 0xB9, 0xFB, 0x1C, 0x38, 0x10, 0x20,
  0x40, 0x80, 0x3C, 0x7E, 0xC0, 0x60, 0x7E, 0x06, 0x03, 0xE6, 0x7E, 0x30,
  0x63, 0xFF, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x7C, 0x78, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xB7, 0x3C, 0xC3, 0xC2, 0xC6, 0x66, 0x64, 0x6C, 0x3C,
  0x3C, 0x38, 0xCC, 0xA6, 0x53, 0x69, 0xB7, 0x5B, 0xA9, 0xCC, 0x66, 0x33,
  0x00, 0xC7, 0x66, 0x6C, 0x3C, 0x18, 0x3C, 0x6C, 0x66, 0xC3, 0xC3, 0xC2,
  0x66, 0x66, 0x6C, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x30, 0x30, 0xFF, 0xFC,
  0x38, 0x61, 0x86, 0x18, 0x7F, 0xFE, 0x0E, 0x38, 0x60, 0xC0, 0x81, 0x3E,
  0x78, 0x18, 0x10, 0x60, 0xC1, 0x81, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x60, 0xC1, 0x83, 0x06, 0x07, 0x8F, 0x30, 0x60, 0xC1, 0x83, 0x1E,
  0x38, 0x00, 0xF3, 0x9B, 0x8E,
};

const GFXglyph JetBrainsMono_SemiBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 5, 5, 10, 2, -12 },
  { 10, 9, 12, 10, 0, -12 },
  { 24, 8, 16, 10, 1, -14 },
  { 40, 10, 12, 10, 0, -12 },
  { 55, 8, 12, 10, 1, -12 },
  { 67, 2, 5, 10, 4, -12 },
  { 69, 5, 15, 10, 3, -13 },
  { 79, 5, 15, 10, 2, -13 },
  { 89, 9, 9, 10, 0, -10 },
  { 100, 8, 8, 10, 1, -9 },
  { 108, 4, 5, 10, 2, -2 },
  { 111, 5, 2, 10, 2, -6 },
  { 113, 3, 3, 10, 3, -3 },
  { 115, 8, 15, 10, 1, -13 },
  { 130, 7, 12, 10, 1, -12 },
  { 141, 8, 12, 10, 1, -12 },
  { 153, 8, 12, 10, 1, -12 },
  { 165, 7, 12, 10, 1, -12 },
  { 176, 7, 12, 10, 1, -12 },
  { 187, 7, 12, 10, 1, -12 },
  { 198, 8, 12, 10, 1, -12 },
  { 210, 8, 12, 10, 1, -12 },
  { 222, 8, 12, 10, 1, -12 },
  { 234, 8, 12, 10, 1, -12 },
  { 246, 3, 9, 10, 3, -9 },
  { 250, 3, 12, 10, 3, -9 },
  { 255, 7, 9, 10, 1, -10 },
  { 263, 7, 6, 10, 1, -8 },
  { 269, 7, 9, 10, 1, -10 },
  { 277, 6, 12, 10, 2, -12 },
  { 286, 8, 15, 10, 1, -12 },
  { 301, 8, 12, 10, 1, -12 },
  { 313, 8, 12, 10, 1, -12 },
  { 325, 8, 12, 10, 1, -12 },
  { 337, 7, 12, 10, 1, -12 },
  { 348, 7, 12, 10, 1, -12 },
  { 359, 8, 12, 10, 1, -12 },
  { 371, 8, 12, 10, 1, -12 },
  { 383, 7, 12, 10, 1, -12 },
  { 394, 7, 12, 10, 1, -12 },
  { 405, 7, 12, 10, 1, -12 },
  { 416, 8, 12, 10, 1, -12 },
  { 428, 7, 12, 10, 2, -12 },
  { 439, 8, 12, 10, 1, -12 },
  { 451, 7, 12, 10, 1, -12 },
  { 462, 7, 12, 10, 1, -12 },
  { 473, 8, 12, 10, 1, -12 },
  { 485, 8, 15, 10, 1, -12 },
  { 500, 8, 12, 10, 1, -12 },
  { 512, 8, 12, 10, 1, -12 },
  { 524, 8, 12, 10, 1, -12 },
  { 536, 7, 12, 10, 1, -12 },
  { 547, 8, 12, 10, 1, -12 },
  { 559, 9, 12, 10, 0, -12 },
  { 573, 9, 12, 10, 0, -12 },
  { 587, 9, 12, 10, 0, -12 },
  { 601, 7, 12, 10, 1, -12 },
  { 612, 4, 15, 10, 3, -13 },
  { 620, 8, 15, 10, 1, -13 },
  { 635, 5, 15, 10, 2, -13 },
  { 645, 7, 7, 10, 1, -12 },
  { 652, 8, 2, 10, 1, 0 },
  { 654, 3, 3, 10, 3, -13 },
  { 656, 7, 9, 10, 1, -9 },
  { 664, 7, 12, 10, 1, -12 },
  { 675, 7, 9, 10, 1, -9 },
  { 683, 7, 12, 10, 1, -12 },
  { 694, 7, 9, 10, 1, -9 },
  { 702, 8, 12, 10, 1, -12 },
  { 714, 7, 12, 10, 1, -9 },
  { 725, 7, 12, 10, 1, -12 },
  { 736, 8, 13, 10, 1, -13 },
  { 749, 6, 16, 10, 1, -13 },
  { 761, 8, 12, 10, 1, -12 },
  { 773, 9, 12, 10, 0, -12 },
  { 787, 8, 9, 10, 1, -9 },
  { 796, 7, 9, 10, 1, -9 },
  { 804, 7, 9, 10, 1, -9 },
  { 812, 7, 12, 10, 1, -9 },
  { 823, 7, 12, 10, 1, -9 },
  { 834, 7, 9, 10, 2, -9 },
  { 842, 8, 9, 10, 1, -9 },
  { 851, 7, 11, 10, 1, -11 },
  { 861, 7, 9, 10, 1, -9 },
  { 869, 8, 9, 10, 1, -9 },
  { 878, 9, 9, 10, 0, -9 },
  { 889, 8, 9, 10, 1, -9 },
  { 898, 8, 12, 10, 1, -9 },
  { 910, 7, 9, 10, 1, -9 },
  { 918, 7, 15, 10, 1, -13 },
  { 932, 2, 15, 10, 4, -13 },
  { 936, 7, 15, 10, 1, -13 },
  { 950, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_SemiBold16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_SEMIBOLD16PT7B_H_
