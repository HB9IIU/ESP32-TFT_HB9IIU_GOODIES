#ifndef _JETBRAINSMONO_SEMIBOLD34PT7B_H_
#define _JETBRAINSMONO_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xE3,
  0x8E, 0x38, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0x78, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x03,
  0x83, 0x80, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC1,
  0xC0, 0x70, 0x71, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0x83, 0x80, 0xE0, 0xE0,
  0x38, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x70, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7F, 0xBE, 0x79, 0x9F, 0x79, 0x8F, 0x79, 0x8F, 0x79, 0x80, 0x79, 0x80,
  0x7D, 0x80, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFE,
  0x01, 0x9F, 0x01, 0x8F, 0x01, 0x8F, 0xF1, 0x8F, 0xF1, 0x8F, 0xF9, 0x8F,
  0x7D, 0xBF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x73, 0xF8, 0x0E, 0x7F,
  0xC0, 0xE7, 0x1C, 0x1C, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC7, 0x0E,
  0x1C, 0xE0, 0x71, 0xCE, 0x07, 0xF9, 0xC0, 0x3F, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xCF, 0xC0, 0x1D, 0xFE, 0x03, 0xBC,
  0xF0, 0x73, 0x87, 0x07, 0x38, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0x73, 0x83,
  0x87, 0x38, 0x1C, 0xF7, 0x01, 0xFE, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xFE, 0x07, 0x8F, 0x87, 0x83, 0xC3, 0xC0, 0xE1, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x0F, 0xF8,
  0x07, 0xBC, 0x3F, 0xCF, 0x3D, 0xC3, 0xDE, 0xE1, 0xFE, 0x70, 0x7F, 0x38,
  0x1F, 0x1C, 0x0F, 0x8F, 0x07, 0xC7, 0x87, 0xF3, 0xFF, 0xFC, 0xFF, 0xDE,
  0x3F, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x30, 0x3C,
  0x3F, 0x1F, 0xCF, 0xC3, 0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x00, 0x40, 0x80, 0x1C, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xF1, 0xFC, 0x3E, 0x07, 0x80, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x18,
  0x38, 0x67, 0xCC, 0x7F, 0xFB, 0x7F, 0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x1E,
  0x00, 0x0E, 0xC0, 0x07, 0xB8, 0x03, 0xCF, 0x01, 0xF1, 0xE0, 0xF8, 0x7C,
  0x1C, 0x0E, 0x01, 0x01, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x3E, 0x78, 0x1F,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF1, 0x8F,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFB, 0xC0, 0xF3, 0xC0, 0xE3, 0xC0, 0x83, 0xC0, 0x83, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7E, 0x7E, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0xF7, 0xC1, 0xEF, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xEF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0xFF, 0x03,
  0xFF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3D, 0xF8, 0x7B, 0xFC, 0x7F, 0xFE, 0x7C, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x3E, 0x78, 0x1E, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x1F, 0x7C, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x3F, 0x3F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFE, 0x7E, 0x3E, 0x78, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0x78, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x7B, 0xFF, 0xFF, 0x7C, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0xC0, 0x1E, 0x3F, 0x3F, 0x3F, 0x1F,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x00, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xE0, 0x01,
  0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x7C, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01,
  0x00, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x7C, 0x3F, 0xE1, 0xFE, 0x0F,
  0xE0, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xF0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x19, 0xFC, 0x3F, 0x7F, 0x0F, 0xFF, 0xC7, 0x8F, 0xF1, 0xC1,
  0xFC, 0x70, 0x7F, 0x1C, 0x1F, 0xC7, 0x07, 0xF1, 0xC1, 0xFC, 0x70, 0x7F,
  0x1C, 0x1F, 0xC7, 0x87, 0xF1, 0xF7, 0xFC, 0x3F, 0xFF, 0x07, 0xDF, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF1, 0xC0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE0, 0xE0, 0x78, 0x3C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x0F, 0xF8,
  0x03, 0xC0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFF, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF,
  0xE0, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0xE7, 0xEF, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0,
  0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0x03, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0xF1, 0xFF, 0xF7, 0xE7, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xFF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF1,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xEE, 0x3F, 0xEE, 0x37, 0xEE, 0x77, 0xE6, 0x77, 0xE7, 0x77, 0xF7,
  0x67, 0xF3, 0xE7, 0xF3, 0xE7, 0xF3, 0xC7, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xF7, 0x0F, 0xEE, 0x1F, 0xCE, 0x3F,
  0x9C, 0x7F, 0x38, 0xFE, 0x39, 0xFC, 0x73, 0xF8, 0xF7, 0xF0, 0xEF, 0xE1,
  0xDF, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0x7E, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3E, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xE7, 0xEF,
  0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xDF, 0x0F, 0x9F, 0xFF, 0x1F,
  0xFC, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0,
  0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E,
  0x7E, 0x78, 0x1F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C,
  0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0x07, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0x7C, 0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xDF, 0x0F, 0x9F, 0xFF,
  0x1F, 0xFC, 0x1F, 0xE0, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0x80, 0x1E,
  0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xEF, 0x1E,
  0x1D, 0xE3, 0xE3, 0xBC, 0x6C, 0x77, 0x8D, 0x8E, 0xF1, 0xB1, 0xCE, 0x76,
  0x79, 0xCC, 0xCF, 0x39, 0x99, 0xE7, 0x33, 0x38, 0xE6, 0x67, 0x1C, 0xCE,
  0xE3, 0xD8, 0xDC, 0x7B, 0x1B, 0x8F, 0xE3, 0x70, 0xFC, 0x6E, 0x1F, 0x0D,
  0xC3, 0xE1, 0xB8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F,
  0x00, 0xF8, 0x07, 0xDF, 0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x3C, 0x1E, 0x1F,
  0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3E, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x0F,
  0x0F, 0x03, 0xC7, 0xC0, 0x79, 0xE0, 0x1F, 0xF8, 0x03, 0xC0, 0xF0, 0x03,
  0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x3E, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x1E, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C,
  0x1C, 0x38, 0x1E, 0x78, 0x0E, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7E, 0x3E, 0x78, 0x1F, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x1F, 0xCF, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8, 0x7B, 0xFC, 0xFF,
  0xFD, 0xFD, 0xFB, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFF,
  0x8F, 0xBF, 0xFF, 0x7F, 0xFC, 0xF3, 0xF0, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xF7, 0xF7, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x03, 0xFC, 0x0F, 0xFC,
  0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xC7, 0x9F, 0xEF, 0x7F, 0xDF,
  0xF9, 0xFF, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x0F,
  0xDF, 0xF7, 0xBF, 0xEF, 0x3F, 0x9E, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7,
  0xC3, 0xEF, 0x03, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x07, 0xFC, 0x1E,
  0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x1E, 0x7F, 0xBD,
  0xFF, 0x7F, 0xE7, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF,
  0xBF, 0xEF, 0x3F, 0xDE, 0x1E, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x0F, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8, 0x7B, 0xFC, 0xFF, 0xFD,
  0xF9, 0xFB, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x01, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x7F,
  0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C,
  0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xE7, 0x1E, 0x77, 0xDF, 0xBF, 0xEF, 0xDE,
  0x78, 0xEF, 0x1C, 0x7F, 0x0E, 0x3F, 0x87, 0x1F, 0xC3, 0x8F, 0xE1, 0xC7,
  0xF0, 0xE3, 0xF8, 0x71, 0xFC, 0x38, 0xFE, 0x1C, 0x7F, 0x0E, 0x3F, 0x87,
  0x1F, 0xC3, 0x8F, 0xE1, 0xC7, 0xF0, 0xE3, 0xF8, 0x71, 0xE0, 0xF3, 0xE1,
  0xEF, 0xF3, 0xFF, 0xF7, 0xF7, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xC0,
  0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xFC, 0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0xF3, 0xE1,
  0xEF, 0xF3, 0xFF, 0xF7, 0xF7, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xFE, 0x3E, 0xFF, 0xFD, 0xEF, 0xF3, 0xCF, 0xC7, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1F, 0x1E, 0x7F,
  0xBD, 0xFF, 0x7F, 0xE7, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x3F, 0x7F, 0xDE, 0xFF, 0xBC, 0xFE, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xF1, 0xF0, 0xF7, 0xFC,
  0xF7, 0xFE, 0xFE, 0x7E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xF8,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0x7C, 0x3E, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0x80,
  0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x03, 0xC1, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x80, 0xF1,
  0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xE0, 0xE1, 0xFC, 0x3C, 0x3B,
  0x87, 0x87, 0x78, 0xF0, 0xEF, 0x1E, 0x1C, 0xE3, 0xE3, 0x9C, 0x6C, 0xF3,
  0x9D, 0x9C, 0x73, 0x33, 0x8E, 0x66, 0x71, 0xEC, 0xCE, 0x1D, 0x9D, 0xC3,
  0xB1, 0xB8, 0x76, 0x3F, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xE0, 0x78, 0x7C, 0x00, 0x78, 0x07, 0xCF, 0x03, 0xE3, 0xE0, 0xF0,
  0x78, 0x7C, 0x0F, 0x3E, 0x03, 0xEF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x03, 0xCF,
  0x01, 0xF1, 0xE0, 0x78, 0x7C, 0x3C, 0x0F, 0x1F, 0x01, 0xEF, 0x80, 0x7C,
  0x78, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xFB,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x3F,
  0xF0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x3F, 0x83, 0xFF, 0xE1, 0xFE, 0xF8, 0xFE, 0x3E, 0xF7,
  0x0F, 0xFB, 0x83, 0xF8, 0x00, 0x78,
};

const GFXglyph JetBrainsMono_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 25, 20, 7, -25 },
  { 20, 12, 10, 20, 4, -25 },
  { 35, 18, 25, 20, 1, -25 },
  { 92, 16, 35, 20, 2, -30 },
  { 162, 20, 25, 20, 0, -25 },
  { 225, 17, 25, 20, 2, -25 },
  { 279, 4, 10, 20, 8, -25 },
  { 284, 10, 33, 20, 6, -29 },
  { 326, 11, 33, 20, 4, -29 },
  { 372, 18, 18, 20, 1, -21 },
  { 413, 16, 16, 20, 2, -19 },
  { 445, 8, 10, 20, 5, -5 },
  { 455, 11, 4, 20, 5, -13 },
  { 461, 6, 6, 20, 7, -6 },
  { 466, 16, 32, 20, 2, -28 },
  { 530, 16, 25, 20, 2, -25 },
  { 580, 16, 25, 20, 3, -25 },
  { 630, 16, 25, 20, 2, -25 },
  { 680, 16, 25, 20, 2, -25 },
  { 730, 15, 25, 20, 2, -25 },
  { 777, 15, 25, 20, 3, -25 },
  { 824, 16, 25, 20, 2, -25 },
  { 874, 16, 25, 20, 2, -25 },
  { 924, 16, 25, 20, 2, -25 },
  { 974, 16, 25, 20, 2, -25 },
  { 1024, 6, 19, 20, 7, -19 },
  { 1039, 8, 24, 20, 5, -19 },
  { 1063, 15, 18, 20, 3, -20 },
  { 1097, 15, 12, 20, 3, -17 },
  { 1120, 15, 18, 20, 3, -20 },
  { 1154, 13, 25, 20, 4, -25 },
  { 1195, 18, 31, 20, 1, -25 },
  { 1265, 18, 25, 20, 1, -25 },
  { 1322, 15, 25, 20, 3, -25 },
  { 1369, 15, 25, 20, 3, -25 },
  { 1416, 15, 25, 20, 3, -25 },
  { 1463, 15, 25, 20, 3, -25 },
  { 1510, 15, 25, 20, 3, -25 },
  { 1557, 15, 25, 20, 3, -25 },
  { 1604, 15, 25, 20, 3, -25 },
  { 1651, 14, 25, 20, 3, -25 },
  { 1695, 16, 25, 20, 1, -25 },
  { 1745, 16, 25, 20, 3, -25 },
  { 1795, 14, 25, 20, 4, -25 },
  { 1839, 16, 25, 20, 2, -25 },
  { 1889, 15, 25, 20, 3, -25 },
  { 1936, 15, 25, 20, 3, -25 },
  { 1983, 16, 25, 20, 3, -25 },
  { 2033, 16, 31, 20, 2, -25 },
  { 2095, 16, 25, 20, 3, -25 },
  { 2145, 16, 25, 20, 2, -25 },
  { 2195, 17, 25, 20, 2, -25 },
  { 2249, 15, 25, 20, 3, -25 },
  { 2296, 18, 25, 20, 1, -25 },
  { 2353, 19, 25, 20, 1, -25 },
  { 2413, 18, 25, 20, 1, -25 },
  { 2470, 19, 25, 20, 1, -25 },
  { 2530, 15, 25, 20, 3, -25 },
  { 2577, 10, 32, 20, 6, -28 },
  { 2617, 16, 32, 20, 2, -28 },
  { 2681, 9, 32, 20, 5, -28 },
  { 2717, 16, 13, 20, 2, -25 },
  { 2743, 16, 3, 20, 2, 1 },
  { 2749, 8, 5, 20, 6, -27 },
  { 2754, 16, 19, 20, 2, -19 },
  { 2792, 15, 25, 20, 3, -25 },
  { 2839, 15, 19, 20, 3, -19 },
  { 2875, 15, 25, 20, 3, -25 },
  { 2922, 15, 19, 20, 3, -19 },
  { 2958, 16, 25, 20, 2, -25 },
  { 3008, 15, 25, 20, 3, -19 },
  { 3055, 15, 25, 20, 3, -25 },
  { 3102, 16, 27, 20, 3, -27 },
  { 3156, 13, 33, 20, 3, -27 },
  { 3210, 16, 25, 20, 3, -25 },
  { 3260, 18, 25, 20, 1, -25 },
  { 3317, 17, 19, 20, 2, -19 },
  { 3358, 15, 19, 20, 3, -19 },
  { 3394, 15, 19, 20, 3, -19 },
  { 3430, 15, 25, 20, 3, -19 },
  { 3477, 15, 25, 20, 3, -19 },
  { 3524, 16, 19, 20, 3, -19 },
  { 3562, 16, 19, 20, 2, -19 },
  { 3600, 16, 24, 20, 2, -24 },
  { 3648, 15, 19, 20, 3, -19 },
  { 3684, 18, 19, 20, 1, -19 },
  { 3727, 19, 19, 20, 1, -19 },
  { 3773, 18, 19, 20, 1, -19 },
  { 3816, 18, 25, 20, 1, -19 },
  { 3873, 15, 19, 20, 3, -19 },
  { 3909, 15, 32, 20, 3, -28 },
  { 3969, 4, 32, 20, 8, -28 },
  { 3985, 15, 32, 20, 3, -28 },
  { 4045, 17, 8, 20, 2, -16 },
};

const GFXfont JetBrainsMono_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBold34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_SEMIBOLD34PT7B_H_
