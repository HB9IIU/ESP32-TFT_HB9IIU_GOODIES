#ifndef _JETBRAINSMONO_THIN22PT7B_H_
#define _JETBRAINSMONO_THIN22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin22pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x00, 0x3B, 0x8E, 0x38, 0xE2, 0x8A, 0x28,
  0x80, 0x08, 0x41, 0x08, 0x21, 0x08, 0x41, 0x08, 0xFF, 0xC4, 0x20, 0x84,
  0x20, 0x84, 0x23, 0xFF, 0x90, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x08,
  0x04, 0x02, 0x07, 0xC4, 0x96, 0x46, 0x23, 0x90, 0x48, 0x34, 0x0F, 0x01,
  0xE0, 0x98, 0x44, 0x23, 0x11, 0x88, 0xA4, 0xCF, 0xC1, 0x00, 0x80, 0x40,
  0x38, 0x1A, 0x20, 0x91, 0x08, 0x88, 0x84, 0x44, 0x22, 0x40, 0xE4, 0x00,
  0x40, 0x02, 0x00, 0x27, 0x82, 0x44, 0x12, 0x21, 0x11, 0x10, 0x89, 0x04,
  0x58, 0x1E, 0x1F, 0x04, 0x30, 0x82, 0x10, 0x02, 0x00, 0x60, 0x04, 0x03,
  0xC0, 0x4C, 0x38, 0x8B, 0x09, 0x60, 0xCC, 0x18, 0x83, 0x10, 0x91, 0xE1,
  0xFE, 0x1C, 0xC4, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xC1, 0x02, 0x07, 0x04, 0xC0, 0x81, 0x06, 0x08, 0x20, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x82, 0x08, 0x42, 0x30, 0x80, 0x04, 0x00, 0x80,
  0x10, 0x62, 0x37, 0x5C, 0x1C, 0x02, 0x80, 0xD8, 0x11, 0x06, 0x10, 0x83,
  0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x36, 0x64, 0x48, 0x80, 0xFE, 0xFF, 0x80, 0x00, 0x80, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x18, 0x00, 0x3E, 0x20, 0xB0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x39, 0x8C, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x05,
  0x84, 0x7C, 0x0C, 0x0D, 0x06, 0x42, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43, 0xFF, 0x3E, 0x10,
  0x48, 0x0A, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x03, 0xFF, 0x7F, 0x80, 0x80, 0x80, 0x80, 0xC0,
  0x40, 0x78, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x0D, 0x04, 0x7C,
  0x03, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80, 0xC0, 0x41, 0x40, 0xA0, 0x60,
  0x3F, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02,
  0x61, 0xDC, 0x83, 0x40, 0x80, 0x40, 0x20, 0x18, 0x0E, 0x05, 0x04, 0x7C,
  0x04, 0x06, 0x02, 0x02, 0x01, 0x01, 0x01, 0x30, 0xE6, 0xC1, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0xFF, 0xE0, 0x28, 0x0A, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x3E, 0x20, 0x90, 0x30, 0x1C, 0x0A, 0x08, 0x8C, 0x38, 0x36,
  0x20, 0xB0, 0x30, 0x18, 0x0C, 0x05, 0x06, 0x7C, 0x3E, 0x20, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x83, 0x63, 0x0E, 0x80, 0x80, 0xC0, 0x40, 0x40,
  0x20, 0x20, 0xFD, 0x80, 0x00, 0x1F, 0xF0, 0x77, 0x30, 0x00, 0x00, 0x03,
  0x66, 0x44, 0x88, 0x00, 0x80, 0xC1, 0x83, 0x06, 0x04, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x00,
  0xF8, 0x18, 0x18, 0x10, 0x20, 0x41, 0x86, 0x70, 0x81, 0x00, 0x00, 0x00,
  0x18, 0x30, 0x1F, 0x84, 0x19, 0x01, 0x20, 0x14, 0x03, 0x87, 0x71, 0x9E,
  0x61, 0xC8, 0x39, 0x07, 0x20, 0xE4, 0x1C, 0xC3, 0x88, 0xF0, 0xEA, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x07, 0x80, 0x04, 0x01, 0x40, 0x28, 0x05, 0x00,
  0xB0, 0x22, 0x04, 0x40, 0x88, 0x10, 0x84, 0x10, 0xFE, 0x10, 0x46, 0x04,
  0x80, 0x90, 0x16, 0x03, 0xFE, 0x60, 0xB0, 0x38, 0x1C, 0x0E, 0x07, 0x05,
  0xFC, 0xC3, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x05, 0xFC, 0x3E, 0x20,
  0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x0A, 0x05, 0x04, 0x7C, 0xFC, 0x61, 0xB0, 0x58, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0B, 0x0D, 0xF8, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x3E, 0x20, 0x90, 0x30,
  0x18, 0x04, 0x02, 0x01, 0x00, 0x8F, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x05,
  0x04, 0x7C, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF,
  0x1F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x1C, 0x0B, 0x0C, 0xFC, 0xC0, 0xF0, 0x2C, 0x13, 0x04, 0xC2,
  0x30, 0x8C, 0x43, 0xF0, 0xC4, 0x31, 0x8C, 0x23, 0x0C, 0xC1, 0x30, 0x6C,
  0x0B, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC1, 0xE0, 0xE8, 0x74,
  0x5A, 0x2C, 0xA6, 0x53, 0x29, 0x88, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0xD0, 0x68, 0x34, 0x19, 0x0C, 0x86, 0x23, 0x11, 0x88,
  0xC2, 0x61, 0x30, 0x98, 0x2C, 0x16, 0x07, 0x03, 0x3E, 0x20, 0x90, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x05,
  0x04, 0x7C, 0xFF, 0x30, 0x6C, 0x0B, 0x01, 0xC0, 0x70, 0x1C, 0x0B, 0x06,
  0xFE, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3E, 0x20,
  0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0A, 0x0D, 0x04, 0x7C, 0x02, 0x01, 0x80, 0x40, 0x10, 0xFE, 0x30, 0x6C,
  0x0B, 0x02, 0xC0, 0xF0, 0x2C, 0x0B, 0x0C, 0xFE, 0x31, 0x0C, 0x23, 0x08,
  0xC1, 0x30, 0x4C, 0x0B, 0x03, 0x3F, 0x20, 0xB0, 0x30, 0x1C, 0x02, 0x01,
  0x80, 0x78, 0x07, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x05, 0x06, 0x7E, 0xFF,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0A,
  0x0D, 0x04, 0x7C, 0xC0, 0x68, 0x09, 0x01, 0x30, 0x22, 0x08, 0x41, 0x08,
  0x20, 0x84, 0x11, 0x02, 0x20, 0x64, 0x05, 0x80, 0xA0, 0x14, 0x02, 0x80,
  0x20, 0x84, 0x30, 0xC6, 0x18, 0xC5, 0x18, 0xA2, 0x94, 0x52, 0x8A, 0x52,
  0x49, 0x4A, 0x29, 0x45, 0x28, 0xA5, 0x14, 0x62, 0x8C, 0x51, 0x04, 0xC0,
  0x6C, 0x08, 0x82, 0x08, 0x41, 0x10, 0x14, 0x02, 0x80, 0x20, 0x0E, 0x01,
  0x40, 0x44, 0x08, 0x82, 0x08, 0x41, 0x90, 0x16, 0x01, 0xC0, 0x28, 0x09,
  0x81, 0x10, 0x43, 0x08, 0x22, 0x06, 0x40, 0x50, 0x0E, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80, 0x40, 0x40, 0x60,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x01,
  0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF0, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40,
  0x10, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x43, 0xF0, 0x08, 0x0E, 0x05, 0x06, 0x42, 0x21, 0x19, 0x04, 0x83, 0x80,
  0x80, 0xFF, 0xE0, 0xC2, 0x10, 0x3E, 0x20, 0xB0, 0x20, 0x10, 0x09, 0xFF,
  0x03, 0x01, 0x80, 0xC0, 0xF0, 0x6F, 0xD0, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xE6, 0x0B, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x05,
  0xFC, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0xA0,
  0x50, 0x47, 0xC0, 0x00, 0x80, 0x40, 0x20, 0x13, 0xEA, 0x0D, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x0D, 0x06, 0x7D, 0x3E, 0x20, 0x90,
  0x30, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x20, 0x50, 0x47, 0xC0, 0x0F,
  0xC6, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x3E, 0xA0, 0xD0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x41, 0xA0, 0xCF, 0xA0, 0x10, 0x08, 0x04, 0x04,
  0x7C, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xE6, 0x0B, 0x07, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x0C, 0x03, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0xC0, 0x03, 0x07, 0x02, 0x00, 0x00, 0x7E, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x06, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0xB0, 0x4C, 0x33, 0x08,
  0xC4, 0x3F, 0x0C, 0x43, 0x18, 0xC2, 0x30, 0x4C, 0x1B, 0x03, 0xF8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x3F, 0xFF, 0xC4, 0x62, 0x31,
  0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x62, 0x31, 0x10, 0xFE, 0x60,
  0xB0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x10,
  0x3E, 0x20, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50,
  0x47, 0xC0, 0xFE, 0x60, 0xB0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x5F, 0xCC, 0x06, 0x03, 0x01, 0x80, 0x3E, 0xA0, 0xD0, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xD0, 0x67, 0xD0, 0x08, 0x04,
  0x02, 0x01, 0xBE, 0xC3, 0x81, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x3F, 0x20, 0xF0, 0x38, 0x04, 0x01, 0xE0, 0x0C, 0x01, 0x00,
  0xC0, 0x50, 0x6F, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x1F, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xA0, 0xD0, 0x47, 0xC0,
  0x80, 0xE0, 0x24, 0x09, 0x04, 0x41, 0x08, 0x42, 0x20, 0x88, 0x16, 0x05,
  0x01, 0x40, 0x20, 0x84, 0x30, 0x85, 0x28, 0xA5, 0x24, 0xA4, 0x94, 0x92,
  0x52, 0x4A, 0x31, 0x46, 0x30, 0xC6, 0x18, 0xC0, 0xC0, 0x90, 0x42, 0x30,
  0xC8, 0x14, 0x02, 0x01, 0xC0, 0x50, 0x22, 0x18, 0x44, 0x1A, 0x03, 0x80,
  0xF0, 0x24, 0x19, 0x04, 0x21, 0x08, 0x82, 0x20, 0x48, 0x14, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0xC0, 0xFF, 0x80, 0x80, 0xC0, 0x40,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x1F, 0xF0, 0x07, 0x82, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x3E, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x06, 0x01, 0x00, 0xF0, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0C, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x06, 0x03, 0xE3,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x06, 0x1E, 0x00, 0x60, 0xCC,
  0x62, 0x30, 0xF0,
};

const GFXglyph JetBrainsMono_Thin22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 6, 7, 13, 4, -16 },
  { 13, 11, 16, 13, 1, -16 },
  { 35, 9, 22, 13, 2, -19 },
  { 60, 13, 16, 13, 0, -16 },
  { 86, 11, 16, 13, 1, -16 },
  { 108, 1, 7, 13, 6, -16 },
  { 109, 6, 21, 13, 5, -18 },
  { 125, 6, 21, 13, 3, -18 },
  { 141, 11, 11, 13, 1, -13 },
  { 157, 10, 10, 13, 2, -12 },
  { 170, 4, 7, 13, 4, -3 },
  { 174, 7, 1, 13, 3, -8 },
  { 175, 3, 3, 13, 5, -3 },
  { 177, 9, 20, 13, 2, -18 },
  { 200, 9, 16, 13, 2, -16 },
  { 218, 10, 16, 13, 2, -16 },
  { 238, 10, 16, 13, 2, -16 },
  { 258, 9, 16, 13, 2, -16 },
  { 276, 9, 16, 13, 2, -16 },
  { 294, 9, 16, 13, 2, -16 },
  { 312, 9, 16, 13, 2, -16 },
  { 330, 10, 16, 13, 2, -16 },
  { 350, 9, 16, 13, 2, -16 },
  { 368, 9, 16, 13, 2, -16 },
  { 386, 3, 12, 13, 5, -12 },
  { 391, 4, 16, 13, 4, -12 },
  { 399, 9, 11, 13, 2, -13 },
  { 412, 9, 6, 13, 2, -10 },
  { 419, 9, 11, 13, 2, -13 },
  { 432, 7, 16, 13, 4, -16 },
  { 446, 11, 20, 13, 1, -16 },
  { 474, 11, 16, 13, 1, -16 },
  { 496, 9, 16, 13, 2, -16 },
  { 514, 9, 16, 13, 2, -16 },
  { 532, 9, 16, 13, 2, -16 },
  { 550, 8, 16, 13, 3, -16 },
  { 566, 9, 16, 13, 3, -16 },
  { 584, 9, 16, 13, 2, -16 },
  { 602, 9, 16, 13, 2, -16 },
  { 620, 8, 16, 13, 3, -16 },
  { 636, 9, 16, 13, 2, -16 },
  { 654, 10, 16, 13, 2, -16 },
  { 674, 9, 16, 13, 3, -16 },
  { 692, 9, 16, 13, 2, -16 },
  { 710, 9, 16, 13, 2, -16 },
  { 728, 9, 16, 13, 2, -16 },
  { 746, 10, 16, 13, 2, -16 },
  { 766, 9, 20, 13, 2, -16 },
  { 789, 10, 16, 13, 2, -16 },
  { 809, 9, 16, 13, 2, -16 },
  { 827, 11, 16, 13, 1, -16 },
  { 849, 9, 16, 13, 2, -16 },
  { 867, 11, 16, 13, 1, -16 },
  { 889, 11, 16, 13, 1, -16 },
  { 911, 11, 16, 13, 1, -16 },
  { 933, 11, 16, 13, 1, -16 },
  { 955, 9, 16, 13, 2, -16 },
  { 973, 5, 20, 13, 5, -18 },
  { 986, 9, 20, 13, 2, -18 },
  { 1009, 5, 20, 13, 3, -18 },
  { 1022, 9, 9, 13, 2, -16 },
  { 1033, 11, 1, 13, 1, 1 },
  { 1035, 4, 3, 13, 4, -17 },
  { 1037, 9, 12, 13, 2, -12 },
  { 1051, 9, 16, 13, 2, -16 },
  { 1069, 9, 12, 13, 2, -12 },
  { 1083, 9, 16, 13, 2, -16 },
  { 1101, 9, 12, 13, 2, -12 },
  { 1115, 10, 16, 13, 2, -16 },
  { 1135, 9, 16, 13, 2, -12 },
  { 1153, 9, 16, 13, 2, -16 },
  { 1171, 10, 17, 13, 2, -17 },
  { 1193, 8, 21, 13, 2, -17 },
  { 1214, 10, 16, 13, 2, -16 },
  { 1234, 11, 16, 13, 1, -16 },
  { 1256, 9, 12, 13, 2, -12 },
  { 1270, 9, 12, 13, 2, -12 },
  { 1284, 9, 12, 13, 2, -12 },
  { 1298, 9, 16, 13, 2, -12 },
  { 1316, 9, 16, 13, 2, -12 },
  { 1334, 8, 12, 13, 3, -12 },
  { 1346, 9, 12, 13, 2, -12 },
  { 1360, 9, 16, 13, 2, -16 },
  { 1378, 9, 12, 13, 2, -12 },
  { 1392, 10, 12, 13, 2, -12 },
  { 1407, 11, 12, 13, 1, -12 },
  { 1424, 10, 12, 13, 2, -12 },
  { 1439, 10, 16, 13, 2, -12 },
  { 1459, 9, 12, 13, 2, -12 },
  { 1473, 9, 20, 13, 2, -18 },
  { 1496, 1, 20, 13, 6, -18 },
  { 1499, 9, 20, 13, 2, -18 },
  { 1522, 9, 4, 13, 2, -10 },
};

const GFXfont JetBrainsMono_Thin22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_THIN22PT7B_H_
