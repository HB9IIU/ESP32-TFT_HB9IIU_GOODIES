#ifndef _JETBRAINSMONO_THIN33PT7B_H_
#define _JETBRAINSMONO_THIN33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin33pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x64, 0x40, 0x00, 0x0F,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83, 0x01,
  0x03, 0x00, 0xC0, 0x80, 0x30, 0x20, 0x08, 0x08, 0x02, 0x06, 0x00, 0x81,
  0x80, 0x60, 0x61, 0xFF, 0xFF, 0x06, 0x04, 0x01, 0x03, 0x00, 0x40, 0xC0,
  0x30, 0x30, 0x0C, 0x08, 0x03, 0x02, 0x00, 0x81, 0x80, 0x20, 0x60, 0xFF,
  0xFF, 0x06, 0x04, 0x01, 0x81, 0x00, 0x40, 0x40, 0x10, 0x30, 0x0C, 0x0C,
  0x03, 0x02, 0x00, 0xC0, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x7F, 0x83, 0xB7, 0x18, 0xC6, 0x63, 0x19, 0x0C, 0x3C, 0x30,
  0xD0, 0xC0, 0x63, 0x01, 0x8C, 0x03, 0x30, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x33, 0x00, 0xC6, 0x03, 0x08, 0x0C, 0x30, 0x30, 0xE0, 0xC3, 0xC3,
  0x0F, 0x0C, 0x36, 0x31, 0x8E, 0xDC, 0x1F, 0xE0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xD8, 0xC0, 0x2C, 0x10, 0x13,
  0x04, 0x0C, 0xC1, 0x06, 0x30, 0x41, 0x0C, 0x10, 0xC3, 0x04, 0x60, 0xC3,
  0x10, 0x1F, 0x88, 0x03, 0xC6, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x63,
  0x80, 0x33, 0xF8, 0x08, 0x82, 0x04, 0x60, 0xC3, 0x18, 0x30, 0x86, 0x0C,
  0x41, 0x83, 0x30, 0x60, 0xD8, 0x08, 0x24, 0x03, 0x1B, 0x00, 0x7C, 0x0F,
  0xE0, 0x0E, 0x38, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0E, 0xC0,
  0x06, 0x30, 0x36, 0x0C, 0x13, 0x06, 0x19, 0x81, 0x88, 0xC0, 0x6C, 0x60,
  0x1C, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0xC3, 0x03, 0x31, 0xC7, 0x08,
  0x7E, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x81, 0xC3, 0x83, 0x83, 0x03, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x1E, 0x01, 0x80, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80,
  0xC1, 0xC1, 0xC3, 0xC1, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x03, 0x06, 0x0F, 0xE3, 0x3E, 0x3D, 0x7C, 0x03, 0xF0,
  0x00, 0x60, 0x00, 0x58, 0x00, 0x66, 0x00, 0x63, 0x80, 0x70, 0xC0, 0x30,
  0x30, 0x30, 0x0C, 0x08, 0x04, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x1C, 0xE3, 0x8C, 0x31, 0xC6, 0x18, 0x43, 0x00, 0xFF, 0xFF, 0xF0, 0x23,
  0xFE, 0xF7, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE0,
  0xE3, 0xC6, 0x03, 0x98, 0x06, 0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x30, 0xF1, 0xE3, 0xC7, 0x0F, 0x08, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0x60, 0x19, 0xC0,
  0xE3, 0xCF, 0x07, 0xF8, 0x03, 0x80, 0x3E, 0x01, 0xD8, 0x0C, 0x60, 0x61,
  0x81, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x3F, 0xFF, 0x1F, 0xE0,
  0xC1, 0xC6, 0x01, 0xB0, 0x02, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x3F, 0xFF, 0x7F, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xB0, 0x18, 0xE1, 0x83, 0xF8, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x06, 0x20, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0x78, 0x03, 0xC0, 0x1F, 0xFF,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x7F, 0xF9,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x47, 0xC1, 0x3F, 0xC5, 0x03, 0x18, 0x06, 0x60, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xB0, 0x02, 0x40, 0x19, 0x80,
  0xC3, 0x87, 0x07, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC4, 0x02, 0xFE, 0x1C,
  0x1C, 0x60, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x40, 0x19, 0x80, 0x63, 0x87, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x1F, 0xE0, 0xE1, 0xC6, 0x01, 0x98, 0x06, 0x40,
  0x09, 0x00, 0x34, 0x00, 0x98, 0x06, 0x20, 0x10, 0xE1, 0xC0, 0xCC, 0x01,
  0xC0, 0x0D, 0xC0, 0xE1, 0xC6, 0x01, 0x90, 0x06, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x09, 0x80, 0x63, 0x87, 0x07, 0xF8, 0x1F, 0xE0,
  0xE1, 0xC6, 0x01, 0x90, 0x06, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x98, 0x06, 0x38, 0x78, 0x7F, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x7F, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x7B, 0xC0, 0x3D, 0xF7, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x73, 0x8E, 0x30, 0xC7, 0x18, 0x61, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0xFE, 0x01,
  0xE0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x06, 0x07, 0x83, 0xE0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x0F, 0xF0, 0x1C, 0x1C, 0x30,
  0x0C, 0x60, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFB, 0xC1, 0xFF, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3,
  0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1,
  0xCF, 0xC0, 0xFB, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x06, 0x60, 0x04, 0x60, 0x0C,
  0x20, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x10, 0x18, 0x18, 0x10,
  0x18, 0x10, 0x08, 0x3F, 0xFC, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x04, 0x60,
  0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x03, 0xFF, 0x84, 0x1F, 0x20, 0x19,
  0x00, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x34, 0x01, 0xA0,
  0x39, 0xFF, 0x08, 0x1E, 0x40, 0x1A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0x40, 0x3B, 0xFF, 0x9F, 0xF0, 0x1F, 0xE0,
  0xE1, 0xC6, 0x01, 0x98, 0x06, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x60, 0x19, 0x80,
  0x63, 0x87, 0x03, 0xF8, 0xFF, 0x08, 0x7C, 0x80, 0xE8, 0x06, 0x80, 0x38,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x68,
  0x0E, 0xFF, 0xCF, 0xF0, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xEC,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0xFF, 0xEF, 0xFF, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x1F, 0xE0,
  0xE1, 0xC6, 0x01, 0x98, 0x06, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC3, 0xFF, 0x0F, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x60, 0x19, 0x80,
  0x63, 0x87, 0x03, 0xF8, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0xD0, 0x03, 0x60, 0x19, 0x80, 0x63, 0x87, 0x07, 0xF8, 0x80, 0x1A,
  0x00, 0x68, 0x03, 0x20, 0x0C, 0x80, 0x62, 0x01, 0x88, 0x0C, 0x20, 0x30,
  0x81, 0x82, 0x06, 0x08, 0x30, 0x3F, 0xC0, 0x83, 0x02, 0x06, 0x08, 0x18,
  0x20, 0x30, 0x80, 0xC2, 0x01, 0x88, 0x06, 0x20, 0x0C, 0x80, 0x32, 0x00,
  0x68, 0x01, 0xA0, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x80, 0x7E, 0x03,
  0xFC, 0x0B, 0xD0, 0x2F, 0x61, 0xBC, 0x84, 0xF2, 0x13, 0xCC, 0xCF, 0x12,
  0x3C, 0x58, 0xF1, 0xC3, 0xC3, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1A, 0x01, 0xB0, 0x19, 0x01, 0x90, 0x19,
  0x81, 0x88, 0x18, 0xC1, 0x84, 0x18, 0x41, 0x86, 0x18, 0x21, 0x83, 0x18,
  0x11, 0x81, 0x18, 0x19, 0x80, 0x98, 0x0D, 0x80, 0x58, 0x05, 0x80, 0x78,
  0x03, 0x1F, 0xC1, 0xC3, 0x98, 0x0C, 0xC0, 0x34, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x80, 0x36, 0x01, 0xB0,
  0x18, 0xE1, 0xC3, 0xF8, 0xFF, 0xC2, 0x07, 0xC8, 0x03, 0x20, 0x06, 0x80,
  0x0A, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0A, 0x00, 0x68, 0x03, 0xA0,
  0x1C, 0xFF, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1F, 0xC0,
  0xE1, 0xC6, 0x03, 0x18, 0x06, 0x40, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x02,
  0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x2C, 0x00,
  0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0x90, 0x06, 0x60, 0x19, 0x80,
  0xC3, 0x87, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0xFF, 0xC4, 0x0F, 0x20, 0x0D, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0D, 0x03, 0xCF, 0xFC,
  0x41, 0x82, 0x06, 0x10, 0x30, 0x80, 0xC4, 0x06, 0x20, 0x19, 0x00, 0xC8,
  0x03, 0x40, 0x1A, 0x00, 0x70, 0x03, 0x1F, 0xE0, 0xE1, 0xC6, 0x01, 0x90,
  0x06, 0x40, 0x0F, 0x00, 0x34, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x63, 0x87, 0x07, 0xF8,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x3C, 0x06, 0x70, 0xE3, 0xF8,
  0xC0, 0x03, 0x40, 0x06, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04, 0x20, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x08, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x20, 0x04, 0x60, 0x06, 0x60,
  0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x3C, 0x14, 0x1E, 0x1B, 0x09,
  0x0D, 0x84, 0x86, 0xC2, 0x43, 0x61, 0x21, 0x30, 0x90, 0x88, 0xCC, 0x44,
  0x46, 0x22, 0x21, 0x31, 0x90, 0x98, 0xC8, 0x4C, 0x64, 0x26, 0x32, 0x12,
  0x1B, 0x09, 0x05, 0x06, 0x82, 0x83, 0x41, 0x40, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0xC0, 0x07, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0xC0, 0x03,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x60, 0x04, 0x20, 0x0C,
  0x30, 0x18, 0x10, 0x18, 0x18, 0x30, 0x08, 0x30, 0x0C, 0x60, 0x06, 0x40,
  0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x60, 0x04, 0x30,
  0x0C, 0x30, 0x08, 0x18, 0x18, 0x18, 0x10, 0x0C, 0x30, 0x0C, 0x20, 0x06,
  0x60, 0x06, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0xFF,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x03,
  0x20, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x06, 0x18, 0x30, 0x30, 0xC0, 0xC6,
  0x01, 0x98, 0x06, 0xC0, 0x1C, 0xFF, 0xFF, 0xC3, 0x08, 0x61, 0x80, 0x1F,
  0xE1, 0xC3, 0x98, 0x04, 0xC0, 0x34, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x3F, 0xFB, 0x80, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0F, 0x00, 0x78,
  0x05, 0x70, 0x69, 0xFC, 0x40, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x9F, 0xCB, 0x0E, 0xC0, 0x2C, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xC0,
  0x3E, 0x06, 0xB0, 0xE9, 0xF8, 0x1F, 0xE0, 0xE1, 0xC6, 0x01, 0x98, 0x06,
  0x40, 0x0B, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x98, 0x06, 0x38, 0x70, 0x7F,
  0x80, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x7F,
  0x26, 0x0D, 0x60, 0x3B, 0x00, 0xD0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x06, 0x80, 0x36, 0x01, 0xB0,
  0x1C, 0xE1, 0xA3, 0xF9, 0x1F, 0xE1, 0xC3, 0x98, 0x04, 0xC0, 0x34, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x6C, 0x03, 0x38, 0x70, 0xFE, 0x00, 0x00, 0xFE,
  0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0xC9, 0x83, 0x58, 0x0A,
  0xC0, 0x34, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x06, 0x80, 0x36, 0x01, 0xB0, 0x0C, 0xC0, 0xA3, 0xF9, 0x07, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x7F, 0xC3, 0xF8, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x9F, 0xCB, 0x0E, 0xC0, 0x7C,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x03, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xCF, 0xF8, 0xFE, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x01, 0xA0, 0x0C, 0x80, 0x32,
  0x01, 0x88, 0x0C, 0x20, 0x60, 0x81, 0x82, 0x0C, 0x0F, 0xE0, 0x20, 0xC0,
  0x81, 0x82, 0x06, 0x08, 0x0C, 0x20, 0x18, 0x80, 0x62, 0x00, 0xC8, 0x01,
  0xA0, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xBE, 0xFB, 0x1A, 0x3C, 0x30, 0xE0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x9F, 0xCB,
  0x0E, 0xC0, 0x7C, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x1F, 0xE1, 0xC3, 0x98, 0x04, 0xC0, 0x34, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xA0, 0x0D,
  0x80, 0x6C, 0x06, 0x38, 0x70, 0xFE, 0x00, 0x9F, 0xCB, 0x0E, 0xC0, 0x3C,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0xC0, 0x3E, 0x06, 0xB0, 0xE9, 0xFC, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x1F, 0xC9, 0x83, 0x58, 0x0E,
  0xC0, 0x34, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xA0, 0x0D, 0x80, 0x6C, 0x07, 0x38, 0x68, 0xFE,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xCF, 0xC6,
  0x83, 0xB8, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x1F, 0xE0, 0xC0, 0xC6, 0x01, 0x90, 0x03, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xD8, 0x06, 0x70, 0x38, 0x7F, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x1F, 0xFF, 0xC0,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x3C, 0x06, 0x70, 0xE3, 0xF8, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x90, 0x06, 0x60, 0x18, 0x80, 0x42, 0x03, 0x0C,
  0x0C, 0x10, 0x20, 0x61, 0x81, 0x86, 0x02, 0x10, 0x0C, 0xC0, 0x33, 0x00,
  0x48, 0x01, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x81, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC3, 0x83, 0xC2, 0xC2, 0x42, 0x42, 0x42, 0x46, 0x62, 0x46, 0x66,
  0x46, 0x64, 0x66, 0x64, 0x24, 0x24, 0x24, 0x24, 0x2C, 0x3C, 0x2C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18, 0x60, 0x06, 0x60, 0x18, 0x60,
  0x60, 0xC0, 0x80, 0xC3, 0x00, 0xCC, 0x01, 0x90, 0x01, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0B, 0x00, 0x33, 0x00, 0xC3, 0x01, 0x06, 0x06, 0x06, 0x18,
  0x06, 0x60, 0x0D, 0xC0, 0x0C, 0xC0, 0x0F, 0x00, 0x34, 0x01, 0x98, 0x06,
  0x60, 0x18, 0xC0, 0xC3, 0x03, 0x04, 0x08, 0x18, 0x60, 0x61, 0x80, 0x84,
  0x03, 0x30, 0x04, 0xC0, 0x1A, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x7F,
  0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x07, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0xFF,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x03, 0xF0,
  0x0E, 0x00, 0x00, 0x38, 0x05, 0xF0, 0x1C, 0x60, 0x60, 0xC3, 0x81, 0x8E,
  0x03, 0xE0,
};

const GFXglyph JetBrainsMono_Thin33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 24, 20, 8, -24 },
  { 13, 8, 10, 20, 6, -24 },
  { 23, 18, 24, 20, 1, -24 },
  { 77, 14, 34, 20, 3, -29 },
  { 137, 18, 24, 20, 1, -24 },
  { 191, 17, 24, 20, 2, -24 },
  { 242, 2, 10, 20, 9, -24 },
  { 245, 9, 32, 20, 7, -28 },
  { 281, 9, 32, 20, 4, -28 },
  { 317, 17, 17, 20, 1, -20 },
  { 354, 15, 16, 20, 2, -19 },
  { 384, 6, 10, 20, 6, -5 },
  { 392, 10, 2, 20, 5, -12 },
  { 395, 5, 5, 20, 7, -5 },
  { 399, 14, 31, 20, 3, -27 },
  { 454, 14, 24, 20, 3, -24 },
  { 496, 14, 24, 20, 3, -24 },
  { 538, 14, 24, 20, 3, -24 },
  { 580, 13, 24, 20, 3, -24 },
  { 619, 13, 24, 20, 3, -24 },
  { 658, 14, 24, 20, 3, -24 },
  { 700, 14, 24, 20, 3, -24 },
  { 742, 14, 24, 20, 3, -24 },
  { 784, 14, 24, 20, 3, -24 },
  { 826, 14, 24, 20, 3, -24 },
  { 868, 5, 18, 20, 7, -18 },
  { 880, 6, 23, 20, 6, -18 },
  { 898, 14, 16, 20, 3, -19 },
  { 926, 14, 9, 20, 3, -15 },
  { 942, 14, 16, 20, 3, -19 },
  { 970, 11, 24, 20, 6, -24 },
  { 1003, 16, 30, 20, 2, -24 },
  { 1063, 16, 24, 20, 2, -24 },
  { 1111, 13, 24, 20, 4, -24 },
  { 1150, 14, 24, 20, 3, -24 },
  { 1192, 12, 24, 20, 4, -24 },
  { 1228, 13, 24, 20, 4, -24 },
  { 1267, 13, 24, 20, 4, -24 },
  { 1306, 14, 24, 20, 3, -24 },
  { 1348, 12, 24, 20, 4, -24 },
  { 1384, 12, 24, 20, 4, -24 },
  { 1420, 14, 24, 20, 2, -24 },
  { 1462, 14, 24, 20, 4, -24 },
  { 1504, 13, 24, 20, 4, -24 },
  { 1543, 14, 24, 20, 3, -24 },
  { 1585, 12, 24, 20, 4, -24 },
  { 1621, 13, 24, 20, 3, -24 },
  { 1660, 14, 24, 20, 4, -24 },
  { 1702, 14, 30, 20, 3, -24 },
  { 1755, 13, 24, 20, 4, -24 },
  { 1794, 14, 24, 20, 3, -24 },
  { 1836, 16, 24, 20, 2, -24 },
  { 1884, 12, 24, 20, 4, -24 },
  { 1920, 16, 24, 20, 2, -24 },
  { 1968, 17, 24, 20, 1, -24 },
  { 2019, 16, 24, 20, 2, -24 },
  { 2067, 16, 24, 20, 2, -24 },
  { 2115, 14, 24, 20, 3, -24 },
  { 2157, 8, 31, 20, 7, -27 },
  { 2188, 14, 31, 20, 3, -27 },
  { 2243, 8, 31, 20, 5, -27 },
  { 2274, 14, 13, 20, 3, -24 },
  { 2297, 16, 1, 20, 2, 1 },
  { 2299, 5, 5, 20, 7, -26 },
  { 2303, 13, 18, 20, 3, -18 },
  { 2333, 12, 24, 20, 4, -24 },
  { 2369, 14, 18, 20, 3, -18 },
  { 2401, 13, 24, 20, 3, -24 },
  { 2440, 13, 18, 20, 3, -18 },
  { 2470, 15, 24, 20, 2, -24 },
  { 2515, 13, 24, 20, 3, -18 },
  { 2554, 12, 24, 20, 4, -24 },
  { 2590, 15, 25, 20, 3, -25 },
  { 2637, 12, 31, 20, 3, -25 },
  { 2684, 14, 24, 20, 4, -24 },
  { 2726, 16, 24, 20, 2, -24 },
  { 2774, 14, 18, 20, 3, -18 },
  { 2806, 12, 18, 20, 4, -18 },
  { 2833, 13, 18, 20, 3, -18 },
  { 2863, 12, 24, 20, 4, -18 },
  { 2899, 13, 24, 20, 3, -18 },
  { 2938, 13, 18, 20, 4, -18 },
  { 2968, 14, 18, 20, 3, -18 },
  { 3000, 15, 23, 20, 2, -23 },
  { 3044, 12, 18, 20, 4, -18 },
  { 3071, 14, 18, 20, 3, -18 },
  { 3103, 16, 18, 20, 2, -18 },
  { 3139, 15, 18, 20, 2, -18 },
  { 3173, 14, 24, 20, 3, -18 },
  { 3215, 13, 18, 20, 3, -18 },
  { 3245, 14, 31, 20, 3, -27 },
  { 3300, 2, 31, 20, 9, -27 },
  { 3308, 14, 31, 20, 3, -27 },
  { 3363, 14, 6, 20, 3, -15 },
};

const GFXfont JetBrainsMono_Thin33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_THIN33PT7B_H_
