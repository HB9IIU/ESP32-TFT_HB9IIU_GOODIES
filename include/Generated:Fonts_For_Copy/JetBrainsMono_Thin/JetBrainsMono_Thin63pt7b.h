#ifndef _JETBRAINSMONO_THIN63PT7B_H_
#define _JETBRAINSMONO_THIN63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin63pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x3E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFB, 0x3F, 0x00, 0xF8, 0x61,
  0xF0, 0x3C, 0x0C, 0x0F, 0x07, 0x01, 0x80, 0xF1, 0xE0, 0x30, 0x1E, 0x38,
  0x06, 0x01, 0xC7, 0x00, 0xC0, 0x3C, 0xE0, 0x18, 0x03, 0x9C, 0x03, 0x00,
  0x73, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xE0,
  0x30, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x7C, 0x18, 0x00,
  0x07, 0xC3, 0x00, 0x00, 0x7C, 0x60, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xDF, 0xC0,
  0x00, 0x18, 0x7C, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C,
  0x07, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0F, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0xF8, 0x03, 0x00, 0x7F, 0x00, 0x60,
  0x0F, 0xE0, 0x0C, 0x01, 0xDC, 0x01, 0x80, 0x3B, 0x80, 0x30, 0x07, 0x78,
  0x06, 0x01, 0xE7, 0x80, 0xC0, 0x78, 0xF8, 0x18, 0x0F, 0x0F, 0x83, 0x07,
  0xC0, 0xFE, 0x67, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0xFF, 0xC0,
  0x00, 0x0E, 0x1F, 0x3E, 0x00, 0x01, 0xC3, 0xC0, 0x70, 0x00, 0x38, 0x38,
  0x07, 0x00, 0x03, 0x07, 0x00, 0x38, 0x00, 0x70, 0x70, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x06, 0x00, 0x70,
  0x03, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x03, 0x83, 0x80,
  0x03, 0x00, 0x38, 0x38, 0x00, 0x38, 0x07, 0x07, 0x00, 0x03, 0xC0, 0xF0,
  0xE0, 0x00, 0x1F, 0xFE, 0x0E, 0x00, 0x00, 0xFF, 0xC1, 0xC0, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x0F, 0x80, 0x00, 0x03, 0x83, 0xFE, 0x00, 0x00, 0x70, 0x7F, 0xF8, 0x00,
  0x06, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x1C, 0x1C, 0x01,
  0xC0, 0x03, 0x81, 0xC0, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x07, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x1C, 0x00, 0xC1, 0xC0, 0x01,
  0xC0, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0xC3, 0x80, 0x00, 0xFC, 0xF8, 0x70,
  0x00, 0x07, 0xFF, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0xE0, 0x1C, 0x00,
  0x39, 0xC0, 0x3C, 0x00, 0xE7, 0x80, 0x3C, 0x01, 0xCE, 0x00, 0x3C, 0x07,
  0x1C, 0x00, 0x38, 0x1E, 0x38, 0x00, 0x78, 0x38, 0x70, 0x00, 0x78, 0xF0,
  0xE0, 0x00, 0x79, 0xC1, 0xC0, 0x00, 0x77, 0x83, 0x80, 0x00, 0xFE, 0x07,
  0x00, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x03, 0xE0, 0x70, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x3D, 0xE0, 0xE0,
  0x00, 0xF1, 0xC1, 0xE0, 0x03, 0xC1, 0xC1, 0xE0, 0x0F, 0x03, 0xC3, 0xF0,
  0xFC, 0x03, 0x83, 0xFF, 0xF0, 0x03, 0x81, 0xFF, 0x80, 0x03, 0x80, 0x78,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x40, 0x03, 0xC0, 0x02, 0xF0, 0x03, 0xC0, 0x0E, 0xFE, 0x03, 0x80, 0x7F,
  0xFF, 0xC1, 0x83, 0xFF, 0x1F, 0xF1, 0x8F, 0xF8, 0x07, 0xFD, 0xBF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE,
  0x3F, 0x03, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x07, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x3E, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x03,
  0xC1, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x7C, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0x80, 0x1C, 0x00, 0x20, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F,
  0x80, 0x0F, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8E, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x3F, 0xE0, 0x1C, 0x3F,
  0xFE, 0x07, 0x3F, 0xFF, 0xC1, 0xCE, 0x01, 0xF8, 0x76, 0x00, 0x1E, 0x1F,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x1F, 0xFC, 0x00, 0xEF, 0xFF, 0xC0, 0x3B,
  0xC0, 0xFC, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0x00, 0x3E,
  0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1E,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x3E, 0x01,
  0xF0, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0xC0, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x01,
  0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x81, 0xFC, 0x0F, 0x70,
  0x1F, 0xFF, 0xDC, 0x00, 0xFF, 0xE7, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0x1F, 0xE7, 0xFB, 0xFE, 0xFF, 0xFF, 0xE7, 0xF8, 0xFC, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x9F,
  0xEF, 0xFB, 0xFF, 0xFF, 0x9F, 0xE3, 0xF0, 0x30, 0x0F, 0xC1, 0xFE, 0x3F,
  0xE3, 0xFF, 0x3F, 0xF3, 0xFE, 0x1F, 0xE0, 0xFC, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x10, 0x1F, 0x80, 0x07, 0xFE,
  0x7E, 0x00, 0x3F, 0xFD, 0xF8, 0x01, 0xF8, 0xFF, 0xE0, 0x0F, 0x80, 0x7F,
  0x80, 0x3C, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xF8, 0x03, 0x80, 0x07, 0xE0,
  0x1E, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x7E, 0x01, 0xE0, 0x01, 0xF8, 0x07,
  0x80, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x7E, 0x01, 0xE0,
  0x01, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x78, 0x00,
  0x7E, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0x80, 0x07, 0xE0, 0x0E, 0x00, 0x1F,
  0x80, 0x38, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xE0,
  0x07, 0xF3, 0xDF, 0x80, 0x0F, 0xFF, 0x7E, 0x00, 0x1F, 0xF1, 0xF8, 0x00,
  0x04, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x38,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xF0,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x3C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xE3, 0x80, 0x01, 0xF0, 0xE0, 0x01, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xFC, 0x38, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x07, 0x81,
  0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xF0,
  0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x07, 0x81,
  0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3F, 0x83, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x01,
  0xC0, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xEC,
  0x00, 0x0D, 0xFB, 0x80, 0x07, 0x7E, 0xE0, 0x01, 0x9F, 0x98, 0x00, 0x67,
  0xE7, 0x00, 0x39, 0xF9, 0xC0, 0x0C, 0x7E, 0x30, 0x03, 0x1F, 0x8E, 0x01,
  0xC7, 0xE3, 0x80, 0x61, 0xF8, 0x60, 0x38, 0x7E, 0x1C, 0x0E, 0x1F, 0x83,
  0x03, 0x07, 0xE0, 0xE1, 0xC1, 0xF8, 0x38, 0x70, 0x7E, 0x06, 0x18, 0x1F,
  0x81, 0xCE, 0x07, 0xE0, 0x73, 0x01, 0xF8, 0x0C, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x78, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xEC, 0x00, 0x07, 0xEE, 0x00,
  0x07, 0xEE, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE3, 0x00,
  0x07, 0xE3, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE1, 0xC0, 0x07, 0xE1, 0xC0,
  0x07, 0xE0, 0xC0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0x70,
  0x07, 0xE0, 0x70, 0x07, 0xE0, 0x30, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x0E,
  0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07,
  0x07, 0xE0, 0x03, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x01, 0xC7, 0xE0, 0x01,
  0xC7, 0xE0, 0x01, 0xC7, 0xE0, 0x00, 0xE7, 0xE0, 0x00, 0xE7, 0xE0, 0x00,
  0x77, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x81, 0xF0, 0x3E, 0x00,
  0x78, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x81,
  0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x3F, 0x0E,
  0x00, 0x01, 0xF1, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3E,
  0x38, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xE0,
  0x07, 0x81, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0x80, 0x01,
  0xF8, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x38, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x3C,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x38, 0xF8, 0x00, 0x0E, 0x0F, 0x80, 0x07, 0xC0, 0xFE,
  0x07, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x78, 0x1F, 0x83, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0xE0,
  0x06, 0x60, 0x0E, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x06, 0x60, 0x0E, 0x70,
  0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x1C, 0x38, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x1C, 0x38, 0x18, 0x18, 0x1C, 0x38,
  0x18, 0x18, 0x18, 0x38, 0x18, 0x18, 0x18, 0x1C, 0x18, 0x18, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x1C, 0x38, 0x1C,
  0x30, 0x0C, 0x38, 0x1C, 0x30, 0x0C, 0x38, 0x1C, 0x30, 0x0C, 0x30, 0x1C,
  0x30, 0x0C, 0x30, 0x0E, 0x70, 0x0E, 0x30, 0x0E, 0x60, 0x0E, 0x70, 0x0E,
  0x60, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0x70, 0x0E, 0x60, 0x06, 0x70, 0x0E,
  0x60, 0x06, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x0E, 0xE0, 0x07, 0x60, 0x06,
  0xC0, 0x07, 0x60, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x0E, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x01, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xDC, 0xF8, 0x00, 0x77,
  0x1F, 0xC0, 0xF9, 0xC3, 0xFF, 0xFC, 0x70, 0x3F, 0xFC, 0x1C, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0xFF,
  0x80, 0xE3, 0xFF, 0xE0, 0xE7, 0xE7, 0xF0, 0xEE, 0x00, 0x78, 0xEC, 0x00,
  0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0E, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x3C, 0xEE, 0x00, 0x7C, 0xE7, 0x81,
  0xF8, 0xE3, 0xFF, 0xF0, 0xE1, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x83, 0xC0,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x01, 0xFF, 0x07, 0x07, 0xFF, 0x87, 0x1F, 0xE7, 0xE7, 0x3E, 0x00, 0xF7,
  0x3C, 0x00, 0x37, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0x78, 0x00, 0x37, 0x3E, 0x00, 0x77,
  0x1F, 0x81, 0xE7, 0x0F, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3E, 0x00, 0x7C,
  0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFE, 0x07, 0x07, 0xFF, 0x87, 0x1F, 0xE7, 0xE7, 0x3E, 0x00, 0xE7, 0x3C,
  0x00, 0x37, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x38, 0x00, 0x37, 0x3E,
  0x00, 0x77, 0x1F, 0x83, 0xE7, 0x0F, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0xFF, 0x80, 0xE3, 0xFF, 0xE0, 0xE7, 0xE7, 0xF0, 0xEF,
  0x00, 0x78, 0xEC, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00,
  0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x03,
  0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF0,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0xE3,
  0xF0, 0x3F, 0x0E, 0xFF, 0x87, 0xFC, 0xEE, 0x7C, 0xF7, 0xEF, 0x81, 0xE8,
  0x1E, 0xF0, 0x0F, 0x00, 0xEF, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07,
  0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00,
  0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00,
  0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0,
  0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0x00, 0x70, 0xE0, 0xFF, 0x80, 0xE3, 0xFF, 0xE0, 0xE7, 0xE7, 0xF0, 0xEF,
  0x00, 0x78, 0xEC, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0xF8, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F,
  0x81, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xE0,
  0xFF, 0x80, 0xE3, 0xFF, 0xE0, 0xE7, 0xE7, 0xF0, 0xEE, 0x00, 0x78, 0xEC,
  0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x3C, 0xEE, 0x00, 0x7C, 0xE7,
  0x81, 0xF8, 0xE3, 0xFF, 0xF0, 0xE1, 0xFF, 0xC0, 0xE0, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x07, 0x07, 0xFF, 0x87, 0x1F,
  0xE7, 0xE7, 0x3E, 0x00, 0xF7, 0x3C, 0x00, 0x37, 0x78, 0x00, 0x1F, 0x70,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x37, 0x3E, 0x00, 0x77, 0x1F, 0x81, 0xE7, 0x0F, 0xFF, 0xC7, 0x03,
  0xFF, 0x07, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0xFF, 0x80, 0x70, 0xFF, 0xF0, 0x39, 0xF9, 0xFE, 0x1D, 0xC0, 0x0F, 0x8E,
  0xC0, 0x03, 0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1F, 0x80, 0x7F,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70,
  0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70,
  0x06, 0x60, 0x0E, 0x70, 0x06, 0x60, 0x1C, 0x38, 0x06, 0x60, 0x1C, 0x38,
  0x06, 0x60, 0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38,
  0x0C, 0x30, 0x1C, 0x38, 0x0C, 0x30, 0x38, 0x1C, 0x0C, 0x30, 0x38, 0x1C,
  0x1C, 0x30, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x18, 0x38, 0x38, 0x1C,
  0x18, 0x18, 0x38, 0x1C, 0x18, 0x18, 0x70, 0x0E, 0x38, 0x18, 0x70, 0x0E,
  0x38, 0x1C, 0x70, 0x0E, 0x30, 0x1C, 0x70, 0x0E, 0x30, 0x0C, 0x70, 0x0E,
  0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0C, 0xE0, 0x07, 0x70, 0x0E, 0xE0, 0x07,
  0x70, 0x0E, 0xE0, 0x07, 0x60, 0x0E, 0xE0, 0x07, 0x60, 0x06, 0xE0, 0x07,
  0x60, 0x06, 0xE0, 0x07, 0xE0, 0x06, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x03,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x67, 0xFE, 0x00, 0x0C, 0xFF,
  0xE0, 0x01, 0xB8, 0x1E, 0x00, 0x37, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x01, 0xC0, 0x3F, 0x00, 0x1C, 0x07, 0xE0, 0x03, 0xE1, 0xFC, 0x00,
  0x1F, 0xFB, 0x80, 0x01, 0xFE, 0x70, 0x00, 0x06, 0x00,
};

const GFXglyph JetBrainsMono_Thin63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 8, 46, 38, 15, -46 },
  { 47, 16, 19, 38, 11, -46 },
  { 85, 34, 46, 38, 2, -46 },
  { 281, 27, 64, 38, 5, -55 },
  { 497, 36, 46, 38, 1, -46 },
  { 704, 31, 48, 38, 4, -47 },
  { 890, 4, 19, 38, 17, -46 },
  { 900, 18, 61, 38, 13, -53 },
  { 1038, 18, 61, 38, 7, -53 },
  { 1176, 32, 32, 38, 3, -38 },
  { 1304, 28, 30, 38, 5, -36 },
  { 1409, 10, 20, 38, 12, -10 },
  { 1434, 20, 3, 38, 9, -22 },
  { 1442, 10, 10, 38, 14, -9 },
  { 1455, 26, 59, 38, 6, -52 },
  { 1647, 26, 48, 38, 6, -47 },
  { 1803, 27, 46, 38, 6, -46 },
  { 1959, 28, 47, 38, 5, -47 },
  { 2124, 25, 47, 38, 6, -46 },
  { 2271, 25, 46, 38, 6, -46 },
  { 2415, 26, 47, 38, 6, -46 },
  { 2568, 27, 47, 38, 5, -46 },
  { 2727, 28, 46, 38, 5, -46 },
  { 2888, 26, 48, 38, 6, -47 },
  { 3044, 27, 47, 38, 5, -47 },
  { 3203, 10, 36, 38, 14, -35 },
  { 3248, 12, 45, 38, 12, -35 },
  { 3316, 26, 32, 38, 6, -37 },
  { 3420, 26, 17, 38, 6, -29 },
  { 3476, 26, 32, 38, 6, -37 },
  { 3580, 21, 46, 38, 11, -46 },
  { 3701, 30, 58, 38, 4, -47 },
  { 3919, 30, 46, 38, 4, -46 },
  { 4092, 26, 46, 38, 7, -46 },
  { 4242, 25, 48, 38, 7, -47 },
  { 4392, 24, 46, 38, 7, -46 },
  { 4530, 24, 46, 38, 8, -46 },
  { 4668, 26, 46, 38, 7, -46 },
  { 4818, 25, 48, 38, 7, -47 },
  { 4968, 24, 46, 38, 7, -46 },
  { 5106, 22, 46, 38, 8, -46 },
  { 5233, 26, 47, 38, 4, -46 },
  { 5386, 27, 46, 38, 7, -46 },
  { 5542, 25, 46, 38, 8, -46 },
  { 5686, 26, 46, 38, 6, -46 },
  { 5836, 24, 46, 38, 7, -46 },
  { 5974, 24, 48, 38, 7, -47 },
  { 6118, 27, 46, 38, 7, -46 },
  { 6274, 25, 58, 38, 7, -47 },
  { 6456, 26, 46, 38, 7, -46 },
  { 6606, 27, 48, 38, 5, -47 },
  { 6768, 30, 46, 38, 4, -46 },
  { 6941, 24, 47, 38, 7, -46 },
  { 7082, 30, 46, 38, 4, -46 },
  { 7255, 32, 46, 38, 3, -46 },
  { 7439, 31, 46, 38, 3, -46 },
  { 7618, 32, 46, 38, 3, -46 },
  { 7802, 26, 46, 38, 6, -46 },
  { 7952, 14, 59, 38, 14, -52 },
  { 8056, 26, 59, 38, 6, -52 },
  { 8248, 14, 59, 38, 10, -52 },
  { 8352, 26, 25, 38, 6, -46 },
  { 8434, 30, 2, 38, 4, 2 },
  { 8442, 10, 8, 38, 13, -49 },
  { 8452, 26, 36, 38, 5, -35 },
  { 8569, 24, 47, 38, 7, -46 },
  { 8710, 25, 36, 38, 7, -35 },
  { 8823, 24, 47, 38, 7, -46 },
  { 8964, 24, 36, 38, 7, -35 },
  { 9072, 29, 46, 38, 4, -46 },
  { 9239, 24, 46, 38, 7, -35 },
  { 9377, 24, 46, 38, 7, -46 },
  { 9515, 28, 48, 38, 6, -48 },
  { 9683, 22, 59, 38, 6, -48 },
  { 9846, 26, 46, 38, 7, -46 },
  { 9996, 31, 46, 38, 3, -46 },
  { 10175, 28, 35, 38, 5, -35 },
  { 10298, 24, 35, 38, 7, -35 },
  { 10403, 24, 36, 38, 7, -35 },
  { 10511, 24, 46, 38, 7, -35 },
  { 10649, 24, 46, 38, 7, -35 },
  { 10787, 25, 35, 38, 8, -35 },
  { 10897, 26, 36, 38, 6, -35 },
  { 11014, 28, 44, 38, 4, -44 },
  { 11168, 24, 36, 38, 7, -35 },
  { 11276, 28, 35, 38, 5, -35 },
  { 11399, 32, 35, 38, 3, -35 },
  { 11539, 28, 35, 38, 5, -35 },
  { 11662, 28, 46, 38, 5, -35 },
  { 11823, 25, 35, 38, 6, -35 },
  { 11933, 26, 59, 38, 6, -52 },
  { 12125, 3, 59, 38, 17, -52 },
  { 12148, 26, 59, 38, 6, -52 },
  { 12340, 27, 12, 38, 5, -28 },
};

const GFXfont JetBrainsMono_Thin63pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin63pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _JETBRAINSMONO_THIN63PT7B_H_
