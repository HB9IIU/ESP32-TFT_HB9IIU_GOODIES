#ifndef _JETBRAINSMONO_THIN16PT7B_H_
#define _JETBRAINSMONO_THIN16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin16pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x8B, 0x99, 0x99, 0x90, 0x12, 0x22, 0x22, 0x22, 0xFD,
  0x24, 0x44, 0x44, 0xFE, 0x44, 0x48, 0x88, 0x10, 0x20, 0xF2, 0x95, 0x2A,
  0x14, 0x18, 0x0C, 0x24, 0x4C, 0x95, 0x27, 0x84, 0x08, 0x70, 0xA4, 0x62,
  0x51, 0x45, 0x41, 0x20, 0x20, 0x2F, 0x14, 0x92, 0x51, 0x38, 0x70, 0x38,
  0x44, 0x44, 0x40, 0x40, 0x60, 0x91, 0x8A, 0x8A, 0x84, 0x8A, 0x71, 0xF8,
  0x19, 0x11, 0x08, 0x42, 0x10, 0x84, 0x20, 0x84, 0x10, 0x60, 0xC2, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x26, 0x80, 0x10, 0x10, 0x10, 0xD7, 0x38, 0x18,
  0x24, 0x46, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x69, 0x48, 0xF8,
  0xF0, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08,
  0x00, 0x38, 0x8D, 0x0C, 0x18, 0x32, 0x66, 0xC1, 0x83, 0x05, 0x09, 0xE0,
  0x31, 0x49, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3F, 0x3C, 0x86, 0x08,
  0x10, 0x20, 0x41, 0x04, 0x10, 0x41, 0x03, 0xF0, 0x7E, 0x08, 0x10, 0x41,
  0x01, 0x80, 0x81, 0x03, 0x05, 0x09, 0xE0, 0x08, 0x41, 0x08, 0x21, 0x18,
  0x61, 0xFC, 0x10, 0x41, 0xFE, 0x08, 0x20, 0xB3, 0x28, 0x41, 0x06, 0x18,
  0x5E, 0x08, 0x10, 0x41, 0x02, 0x0F, 0x90, 0xC1, 0x83, 0x05, 0x09, 0xE0,
  0xFF, 0x06, 0x0C, 0x10, 0x40, 0x82, 0x04, 0x08, 0x20, 0x41, 0x00, 0x3C,
  0x85, 0x0A, 0x14, 0x27, 0x8B, 0x21, 0x83, 0x05, 0x09, 0xE0, 0x38, 0x8E,
  0x0C, 0x18, 0x28, 0x5B, 0x8A, 0x08, 0x10, 0x41, 0x80, 0xF0, 0x03, 0xC0,
  0x6C, 0x00, 0x0A, 0x4A, 0x40, 0x02, 0x18, 0xC6, 0x06, 0x03, 0x01, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x60, 0x30, 0x10, 0x43, 0x18, 0x40, 0xE0, 0x82,
  0x10, 0x89, 0x88, 0x40, 0x11, 0x80, 0x3C, 0x42, 0x81, 0x81, 0x8D, 0x93,
  0x91, 0x91, 0x91, 0x91, 0x9F, 0x80, 0x80, 0x40, 0x38, 0x10, 0x18, 0x18,
  0x28, 0x24, 0x24, 0x44, 0x44, 0x7E, 0x42, 0x82, 0x83, 0xF2, 0x28, 0x61,
  0x87, 0xA9, 0xA1, 0x86, 0x18, 0x7E, 0x7A, 0x18, 0x61, 0x82, 0x08, 0x20,
  0x82, 0x18, 0x5E, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xBC,
  0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20,
  0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0x7A, 0x18, 0x61, 0x82, 0x09, 0xE1,
  0x86, 0x18, 0x5E, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x61,
  0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x3F, 0x1E, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x03, 0x06, 0x13, 0xE0, 0x85, 0x0A, 0x24, 0x49,
  0x1E, 0x24, 0x44, 0x89, 0x12, 0x14, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x3F, 0xC3, 0x86, 0x9D, 0x3A, 0xB3, 0x64, 0xC1, 0x83,
  0x06, 0x0C, 0x10, 0x86, 0x1C, 0x71, 0xA6, 0x9A, 0x65, 0x96, 0x38, 0xE1,
  0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0xF9, 0x0A, 0x14,
  0x18, 0x30, 0xBE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x72, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x5E, 0x08, 0x20, 0x40, 0xFA, 0x18, 0x61, 0x86,
  0x1F, 0x24, 0x8A, 0x28, 0x61, 0x3C, 0x85, 0x0A, 0x04, 0x06, 0x03, 0x01,
  0x03, 0x05, 0x09, 0xE0, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x5E, 0x81, 0x82, 0x42, 0x42, 0x44, 0x44, 0x24, 0x24, 0x28, 0x28, 0x18,
  0x10, 0x91, 0x99, 0x99, 0x99, 0x99, 0xAA, 0xAA, 0xA6, 0x66, 0x66, 0x46,
  0x46, 0x83, 0x42, 0x44, 0x24, 0x28, 0x18, 0x18, 0x28, 0x24, 0x44, 0x42,
  0x81, 0x81, 0x82, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x7E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x07, 0xF0,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x38, 0x82, 0x08, 0x10, 0x40, 0x82, 0x08,
  0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x20, 0xC5, 0x12, 0x8A, 0x18, 0x40, 0xFF, 0x88, 0x80, 0x3C,
  0x85, 0x08, 0x17, 0xF0, 0x60, 0xC1, 0x7E, 0x82, 0x08, 0x3E, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x7E, 0x7A, 0x18, 0x60, 0x82, 0x08, 0x61, 0x78, 0x04,
  0x10, 0x5D, 0x8E, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x7A, 0x18, 0x61, 0xFE,
  0x08, 0x21, 0x78, 0x0E, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x76, 0x38, 0x61, 0x86, 0x18, 0x77, 0x24, 0x10, 0x5E, 0x82,
  0x08, 0x3E, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x30, 0x20, 0x07, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x18, 0x41, 0xF0, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x8B, 0x80, 0x81, 0x02, 0x04, 0x28, 0x51, 0x24, 0x78,
  0x91, 0x12, 0x14, 0x30, 0xE0, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x10, 0x1F, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0x92,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x78, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x76,
  0x38, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10, 0x41, 0xFA, 0x18, 0x61, 0x82,
  0x08, 0x20, 0x80, 0x3C, 0x85, 0x02, 0x03, 0xC0, 0x60, 0xA1, 0x7C, 0x10,
  0x23, 0xF8, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x78, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x78, 0x82, 0x85, 0x0A, 0x22, 0x44, 0x8A, 0x0C, 0x10,
  0x91, 0x91, 0x99, 0x9A, 0xAA, 0x6A, 0x66, 0x66, 0x44, 0xC2, 0x88, 0x90,
  0xC1, 0x03, 0x09, 0x22, 0x82, 0x82, 0x85, 0x0A, 0x22, 0x45, 0x06, 0x0C,
  0x10, 0x20, 0x41, 0x00, 0xFC, 0x20, 0x84, 0x20, 0x84, 0x20, 0xFC, 0x1C,
  0x41, 0x04, 0x10, 0x41, 0x38, 0x10, 0x41, 0x04, 0x10, 0x40, 0xC0, 0xFF,
  0xFE, 0xC0, 0x82, 0x08, 0x20, 0x82, 0x0F, 0x20, 0x82, 0x08, 0x20, 0x8C,
  0x00, 0x73, 0x26, 0x38,
};

const GFXglyph JetBrainsMono_Thin16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -12 },
  { 7, 8, 12, 10, 1, -12 },
  { 19, 7, 16, 10, 1, -14 },
  { 33, 9, 12, 10, 0, -12 },
  { 47, 8, 12, 10, 1, -12 },
  { 59, 1, 5, 10, 4, -12 },
  { 60, 5, 15, 10, 3, -13 },
  { 70, 4, 15, 10, 2, -13 },
  { 78, 8, 8, 10, 1, -10 },
  { 86, 7, 7, 10, 1, -9 },
  { 93, 3, 5, 10, 3, -2 },
  { 95, 5, 1, 10, 2, -6 },
  { 96, 2, 2, 10, 4, -2 },
  { 97, 6, 15, 10, 2, -13 },
  { 109, 7, 12, 10, 1, -12 },
  { 120, 6, 12, 10, 2, -12 },
  { 129, 7, 12, 10, 1, -12 },
  { 140, 7, 12, 10, 1, -12 },
  { 151, 6, 12, 10, 2, -12 },
  { 160, 6, 12, 10, 2, -12 },
  { 169, 7, 12, 10, 1, -12 },
  { 180, 7, 12, 10, 1, -12 },
  { 191, 7, 12, 10, 1, -12 },
  { 202, 7, 12, 10, 1, -12 },
  { 213, 2, 9, 10, 4, -9 },
  { 216, 3, 12, 10, 3, -9 },
  { 221, 7, 8, 10, 1, -9 },
  { 228, 6, 4, 10, 2, -7 },
  { 231, 7, 8, 10, 1, -9 },
  { 238, 5, 12, 10, 3, -12 },
  { 246, 8, 15, 10, 1, -12 },
  { 261, 8, 12, 10, 1, -12 },
  { 273, 6, 12, 10, 2, -12 },
  { 282, 6, 12, 10, 2, -12 },
  { 291, 6, 12, 10, 2, -12 },
  { 300, 6, 12, 10, 2, -12 },
  { 309, 6, 12, 10, 2, -12 },
  { 318, 6, 12, 10, 2, -12 },
  { 327, 6, 12, 10, 2, -12 },
  { 336, 6, 12, 10, 2, -12 },
  { 345, 7, 12, 10, 1, -12 },
  { 356, 7, 12, 10, 2, -12 },
  { 367, 6, 12, 10, 2, -12 },
  { 376, 7, 12, 10, 1, -12 },
  { 387, 6, 12, 10, 2, -12 },
  { 396, 6, 12, 10, 2, -12 },
  { 405, 7, 12, 10, 2, -12 },
  { 416, 6, 15, 10, 2, -12 },
  { 428, 6, 12, 10, 2, -12 },
  { 437, 7, 12, 10, 1, -12 },
  { 448, 8, 12, 10, 1, -12 },
  { 460, 6, 12, 10, 2, -12 },
  { 469, 8, 12, 10, 1, -12 },
  { 481, 8, 12, 10, 1, -12 },
  { 493, 8, 12, 10, 1, -12 },
  { 505, 8, 12, 10, 1, -12 },
  { 517, 7, 12, 10, 1, -12 },
  { 528, 3, 15, 10, 4, -13 },
  { 534, 6, 15, 10, 2, -13 },
  { 546, 4, 15, 10, 2, -13 },
  { 554, 6, 7, 10, 2, -12 },
  { 560, 8, 1, 10, 1, 0 },
  { 561, 3, 3, 10, 3, -13 },
  { 563, 7, 9, 10, 1, -9 },
  { 571, 6, 12, 10, 2, -12 },
  { 580, 6, 9, 10, 2, -9 },
  { 587, 6, 12, 10, 2, -12 },
  { 596, 6, 9, 10, 2, -9 },
  { 603, 7, 12, 10, 1, -12 },
  { 614, 6, 12, 10, 2, -9 },
  { 623, 6, 12, 10, 2, -12 },
  { 632, 7, 12, 10, 2, -12 },
  { 643, 5, 15, 10, 2, -12 },
  { 653, 7, 12, 10, 2, -12 },
  { 664, 8, 12, 10, 1, -12 },
  { 676, 7, 9, 10, 1, -9 },
  { 684, 6, 9, 10, 2, -9 },
  { 691, 6, 9, 10, 2, -9 },
  { 698, 6, 12, 10, 2, -9 },
  { 707, 6, 12, 10, 2, -9 },
  { 716, 6, 9, 10, 2, -9 },
  { 723, 7, 9, 10, 1, -9 },
  { 731, 7, 11, 10, 1, -11 },
  { 741, 6, 9, 10, 2, -9 },
  { 748, 7, 9, 10, 1, -9 },
  { 756, 8, 9, 10, 1, -9 },
  { 765, 7, 9, 10, 1, -9 },
  { 773, 7, 12, 10, 1, -9 },
  { 784, 6, 9, 10, 2, -9 },
  { 791, 6, 15, 10, 2, -13 },
  { 803, 1, 15, 10, 4, -13 },
  { 805, 6, 15, 10, 2, -13 },
  { 817, 7, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_Thin16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_THIN16PT7B_H_
