#ifndef _JETBRAINSMONO_THIN70PT7B_H_
#define _JETBRAINSMONO_THIN70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin70pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x3E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0x80, 0x3F, 0x0E, 0x1F, 0x01,
  0xF0, 0x38, 0x3E, 0x07, 0x80, 0xE0, 0x7C, 0x3C, 0x03, 0x80, 0xF0, 0xF0,
  0x0E, 0x01, 0xE3, 0x80, 0x38, 0x07, 0x9E, 0x00, 0xE0, 0x1E, 0x78, 0x03,
  0x80, 0x39, 0xE0, 0x0E, 0x00, 0xE7, 0x80, 0x38, 0x03, 0x9E, 0x00, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x7C, 0x0E, 0x00, 0x00,
  0xF8, 0x38, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0E, 0xFE, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x00, 0xE0,
  0xF8, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x07,
  0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x1F, 0xC0,
  0x0E, 0x00, 0xFF, 0x00, 0x38, 0x03, 0xFC, 0x00, 0xE0, 0x0F, 0x70, 0x03,
  0x80, 0x3D, 0xE0, 0x0E, 0x01, 0xE7, 0xC0, 0x38, 0x07, 0x8F, 0x00, 0xE0,
  0x3C, 0x1F, 0x03, 0x81, 0xF0, 0x3F, 0x0E, 0x1F, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x1F, 0xFF, 0x80, 0x00,
  0x1C, 0x1E, 0x03, 0xC0, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x38,
  0x01, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x07, 0xC1,
  0xC0, 0x00, 0x0F, 0xFF, 0x83, 0x80, 0x00, 0x07, 0xFF, 0x07, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0xE0, 0xFF, 0xE0, 0x00, 0x01, 0xC1, 0xFF, 0xF0, 0x00, 0x03, 0x83,
  0xE0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0x1C,
  0x0E, 0x00, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x38, 0x00,
  0x01, 0xFF, 0xF8, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0xF0, 0x07, 0x80, 0x07, 0x3C, 0x01, 0xF0, 0x03, 0xCE, 0x00, 0x3C, 0x00,
  0xE3, 0x80, 0x07, 0x80, 0x78, 0xE0, 0x00, 0xF0, 0x1C, 0x38, 0x00, 0x3C,
  0x0F, 0x0E, 0x00, 0x07, 0x83, 0x83, 0x80, 0x00, 0xF1, 0xE0, 0xE0, 0x00,
  0x1E, 0x70, 0x38, 0x00, 0x07, 0xBC, 0x0E, 0x00, 0x00, 0xFE, 0x03, 0x80,
  0x00, 0x1F, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x7E, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x0F, 0x78,
  0x3C, 0x00, 0x07, 0x8E, 0x0F, 0x80, 0x03, 0xC3, 0xC1, 0xE0, 0x01, 0xE0,
  0x78, 0x3E, 0x01, 0xF8, 0x0F, 0x0F, 0xF7, 0xF8, 0x01, 0xC1, 0xFF, 0xFC,
  0x00, 0x78, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x02, 0x78, 0x00, 0xF0, 0x01, 0xEF, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xE0, 0x70, 0x7F, 0xF1, 0xFF, 0x86, 0x1F, 0xFC, 0x07, 0xFE,
  0x67, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x1F,
  0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0xE0, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x60, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFB, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x78, 0x3F, 0xF8, 0x07, 0x8F, 0xFF, 0xE0,
  0x79, 0xFF, 0xFF, 0x07, 0xBC, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x81, 0xF8,
  0x01, 0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x3C,
  0xFF, 0xF0, 0x00, 0xE7, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x78, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0xE7,
  0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x87, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xF0,
  0x30, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFE, 0x0F, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x1F, 0xFF, 0x3F,
  0x00, 0x1F, 0xC3, 0xDF, 0x80, 0x1F, 0x00, 0x6F, 0xC0, 0x0F, 0x00, 0x1F,
  0xE0, 0x07, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x03, 0xF8, 0x03, 0xC0, 0x00,
  0xFC, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x07, 0xE0, 0x0F, 0x00,
  0x03, 0xF0, 0x07, 0x80, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0xFC, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x3C,
  0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x07, 0xF0, 0x03,
  0x80, 0x03, 0xF8, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x03, 0x7E, 0x00,
  0x3F, 0x03, 0xBF, 0x00, 0x0F, 0xFF, 0x9F, 0x80, 0x03, 0xFF, 0x8F, 0xC0,
  0x00, 0x7F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0xF8, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x7E, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0xFE,
  0x0E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x8E, 0x00,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xE1, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3F,
  0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x70, 0x01, 0xFE, 0x0E, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x3E, 0x38, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x3C, 0x38, 0x00, 0x1F, 0x87, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE1,
  0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xEF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0xC0, 0x0E, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0,
  0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xBF, 0xDC, 0x00, 0x0E, 0xFF, 0x70, 0x00, 0x3B,
  0xFC, 0xC0, 0x00, 0xCF, 0xF3, 0x80, 0x07, 0x3F, 0xCE, 0x00, 0x1C, 0xFF,
  0x1C, 0x00, 0x63, 0xFC, 0x70, 0x03, 0x8F, 0xF1, 0xC0, 0x0E, 0x3F, 0xC3,
  0x80, 0x70, 0xFF, 0x0E, 0x01, 0xC3, 0xFC, 0x18, 0x07, 0x0F, 0xF0, 0x70,
  0x38, 0x3F, 0xC1, 0xC0, 0xE0, 0xFF, 0x03, 0x03, 0x03, 0xFC, 0x0E, 0x1C,
  0x0F, 0xF0, 0x38, 0x70, 0x3F, 0xC0, 0x71, 0x80, 0xFF, 0x01, 0xCE, 0x03,
  0xFC, 0x07, 0x38, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0xFF,
  0x00, 0x7C, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFB, 0x80, 0x00, 0x7E, 0xE0, 0x00, 0x1F, 0xB8, 0x00, 0x07,
  0xE7, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0x7E, 0x38, 0x00, 0x1F, 0x8E, 0x00,
  0x07, 0xE3, 0x80, 0x01, 0xF8, 0x70, 0x00, 0x7E, 0x1C, 0x00, 0x1F, 0x83,
  0x80, 0x07, 0xE0, 0xE0, 0x01, 0xF8, 0x38, 0x00, 0x7E, 0x07, 0x00, 0x1F,
  0x81, 0xC0, 0x07, 0xE0, 0x78, 0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x03, 0x80,
  0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1C, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x00,
  0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x07, 0x01, 0xF8, 0x01, 0xC0, 0x7E,
  0x00, 0x78, 0x1F, 0x80, 0x0E, 0x07, 0xE0, 0x03, 0x81, 0xF8, 0x00, 0x70,
  0x7E, 0x00, 0x1C, 0x1F, 0x80, 0x07, 0x87, 0xE0, 0x00, 0xE1, 0xF8, 0x00,
  0x38, 0x7E, 0x00, 0x07, 0x1F, 0x80, 0x01, 0xC7, 0xE0, 0x00, 0x79, 0xF8,
  0x00, 0x0E, 0x7E, 0x00, 0x03, 0x9F, 0x80, 0x00, 0x77, 0xE0, 0x00, 0x1D,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0x80,
  0x1F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xC0, 0x00, 0x7F, 0x0E, 0x00, 0x00, 0x7C, 0x70, 0x00, 0x01, 0xF3,
  0x80, 0x00, 0x07, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x0F, 0x9C, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x1F, 0x87, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x81, 0xC0, 0x00, 0xFF, 0x0E, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xF3, 0x80,
  0x00, 0x1F, 0x1C, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x7F, 0x87, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xA0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1D, 0x80, 0x0F, 0x70, 0x01, 0xD8, 0x00,
  0xE7, 0x00, 0x1D, 0x80, 0x0E, 0x70, 0x01, 0x9C, 0x00, 0xE7, 0x00, 0x19,
  0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x78,
  0x03, 0x9C, 0x01, 0xE7, 0x80, 0x38, 0xC0, 0x1E, 0x38, 0x03, 0x8C, 0x01,
  0xC3, 0x80, 0x30, 0xE0, 0x1C, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x3C,
  0x07, 0x06, 0x01, 0xC3, 0xC0, 0x60, 0x60, 0x3C, 0x1C, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x38, 0x1E,
  0x0C, 0x03, 0x03, 0x81, 0xE0, 0xC0, 0x30, 0x78, 0x0E, 0x0C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0,
  0x38, 0x70, 0x0E, 0x18, 0x01, 0x87, 0x00, 0xF1, 0x80, 0x18, 0x70, 0x0F,
  0x18, 0x01, 0x87, 0x00, 0xF1, 0x80, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x00,
  0x1C, 0xE0, 0x07, 0x30, 0x00, 0xCE, 0x00, 0x73, 0x00, 0x0C, 0xE0, 0x07,
  0xB0, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x73, 0xE0, 0x00, 0x07, 0x7C, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0x73, 0xF0, 0x00, 0xF7, 0x1F, 0xF0,
  0xFE, 0x70, 0xFF, 0xFF, 0x87, 0x03, 0xFF, 0xE0, 0x70, 0x03, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0x01, 0xC3, 0xFF, 0xF0, 0x38,
  0xFF, 0xFF, 0x07, 0x3C, 0x03, 0xF0, 0xEE, 0x00, 0x1F, 0x1D, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x79, 0xF8, 0x00, 0x0F, 0x3B,
  0x80, 0x03, 0xC7, 0x78, 0x01, 0xF8, 0xE7, 0xE1, 0xFE, 0x1C, 0x7F, 0xFF,
  0x03, 0x83, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0xFC, 0x0E,
  0x07, 0xFF, 0xE1, 0xC1, 0xFF, 0xFE, 0x38, 0x7E, 0x01, 0xE7, 0x1F, 0x00,
  0x0E, 0xE7, 0xC0, 0x00, 0xDC, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E,
  0x78, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0xB8, 0xFC, 0x00, 0xF7, 0x0F, 0xF0,
  0xFC, 0xE0, 0x7F, 0xFE, 0x1C, 0x07, 0xFF, 0x83, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x78, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xE0,
  0x7F, 0xFE, 0x1C, 0x1F, 0xFF, 0xE3, 0x87, 0xE0, 0x1E, 0x71, 0xF0, 0x00,
  0xEE, 0x7C, 0x00, 0x0D, 0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xB8, 0xF8, 0x00, 0x77, 0x0F, 0xC0, 0x3C, 0xE0,
  0xFF, 0xFF, 0x1C, 0x0F, 0xFF, 0xC3, 0x80, 0x3F, 0xE0, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x7F, 0xC0, 0x38, 0x7F,
  0xFE, 0x0E, 0x3F, 0xFF, 0xC3, 0x9E, 0x01, 0xF8, 0xEE, 0x00, 0x1F, 0x3B,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x1F, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xF0, 0x07, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x78,
  0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xE3, 0xF8, 0x0F, 0xC3,
  0x9F, 0xF0, 0x7F, 0xCE, 0xFF, 0xE3, 0xFF, 0xBF, 0x07, 0xD8, 0x1E, 0xF8,
  0x0F, 0x40, 0x3F, 0xC0, 0x1D, 0x00, 0xFE, 0x00, 0x78, 0x01, 0xF8, 0x01,
  0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78,
  0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0,
  0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01,
  0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78,
  0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0,
  0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xC0, 0xE0,
  0x7F, 0xC0, 0x38, 0x7F, 0xFE, 0x0E, 0x3F, 0xFF, 0xC3, 0x9E, 0x01, 0xF8,
  0xEE, 0x00, 0x1F, 0x3B, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x78, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x7F, 0xC0, 0x1C, 0x3F, 0xFF, 0x03, 0x8F, 0xFF, 0xF0,
  0x73, 0xC0, 0x3F, 0x0E, 0xE0, 0x01, 0xF1, 0xD8, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0x9F, 0x80, 0x00, 0xF3, 0xB8, 0x00, 0x3C,
  0x77, 0x80, 0x1F, 0x0E, 0x7E, 0x1F, 0xE1, 0xC7, 0xFF, 0xF0, 0x38, 0x3F,
  0xFC, 0x07, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0xE0, 0x7F, 0xFE, 0x1C, 0x1F, 0xFF, 0xE3, 0x87, 0xE0, 0x1E, 0x71,
  0xF0, 0x00, 0xEE, 0x7C, 0x00, 0x0D, 0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x3B, 0x87, 0xC0, 0x0F, 0x70,
  0xFF, 0x0F, 0xCE, 0x07, 0xFF, 0xE1, 0xC0, 0x7F, 0xF8, 0x38, 0x01, 0xF8,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x3F, 0xE0, 0x1C, 0x1F, 0xFF,
  0x03, 0x8F, 0xFF, 0xF8, 0x73, 0xC0, 0x3F, 0x8E, 0xE0, 0x01, 0xF1, 0xD8,
  0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0E, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x00,
  0x0E, 0x70, 0x00, 0xF0, 0x00, 0xE7, 0x00, 0x0F, 0x00, 0x0E, 0x78, 0x00,
  0xF8, 0x00, 0xE7, 0x80, 0x1F, 0x80, 0x1E, 0x38, 0x01, 0xD8, 0x01, 0xC3,
  0x80, 0x19, 0x80, 0x1C, 0x38, 0x01, 0x98, 0x01, 0xC3, 0x80, 0x19, 0xC0,
  0x1C, 0x3C, 0x03, 0x9C, 0x01, 0xC3, 0xC0, 0x39, 0xC0, 0x3C, 0x1C, 0x03,
  0x8C, 0x03, 0x81, 0xC0, 0x30, 0xC0, 0x38, 0x1C, 0x03, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0xE0, 0x38, 0x1E, 0x07, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0xE0,
  0x78, 0x0E, 0x06, 0x06, 0x07, 0x00, 0xE0, 0x60, 0x70, 0x70, 0x0E, 0x0E,
  0x07, 0x07, 0x00, 0xE0, 0xE0, 0x70, 0x70, 0x0F, 0x0E, 0x07, 0x07, 0x00,
  0xF0, 0xE0, 0x30, 0xF0, 0x07, 0x0C, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x38,
  0xE0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07, 0x9C,
  0x03, 0x8E, 0x00, 0x79, 0x80, 0x19, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x0D, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1C, 0xFF, 0xC0, 0x00, 0x77, 0xFF, 0xC0, 0x01, 0xDE,
  0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x7E, 0x00,
  0x78, 0x01, 0xF8, 0x00, 0xF0, 0x0F, 0xE0, 0x01, 0xE0, 0x3F, 0x80, 0x03,
  0xE1, 0xEE, 0x00, 0x07, 0xFF, 0x38, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x0F,
  0x80,
};

const GFXglyph JetBrainsMono_Thin70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 8, 51, 42, 17, -51 },
  { 52, 18, 21, 42, 12, -51 },
  { 100, 38, 51, 42, 2, -51 },
  { 343, 30, 71, 42, 6, -61 },
  { 610, 40, 51, 42, 1, -51 },
  { 865, 34, 53, 42, 5, -52 },
  { 1091, 4, 21, 42, 19, -51 },
  { 1102, 20, 67, 42, 14, -59 },
  { 1270, 20, 67, 42, 8, -59 },
  { 1438, 36, 36, 42, 3, -43 },
  { 1600, 32, 33, 42, 5, -40 },
  { 1732, 12, 22, 42, 13, -11 },
  { 1765, 22, 3, 42, 10, -25 },
  { 1774, 10, 11, 42, 16, -10 },
  { 1788, 28, 66, 42, 7, -58 },
  { 2019, 28, 53, 42, 7, -52 },
  { 2205, 30, 51, 42, 7, -51 },
  { 2397, 31, 52, 42, 6, -52 },
  { 2599, 28, 52, 42, 6, -51 },
  { 2781, 27, 51, 42, 7, -51 },
  { 2954, 28, 52, 42, 7, -51 },
  { 3136, 30, 52, 42, 6, -51 },
  { 3331, 31, 51, 42, 6, -51 },
  { 3529, 30, 53, 42, 6, -52 },
  { 3728, 30, 52, 42, 6, -52 },
  { 3923, 10, 40, 42, 16, -39 },
  { 3973, 13, 50, 42, 13, -39 },
  { 4055, 30, 35, 42, 6, -41 },
  { 4187, 28, 19, 42, 7, -33 },
  { 4254, 30, 35, 42, 6, -41 },
  { 4386, 23, 51, 42, 12, -51 },
  { 4533, 33, 65, 42, 5, -52 },
  { 4802, 32, 51, 42, 5, -51 },
  { 5006, 28, 51, 42, 8, -51 },
  { 5185, 29, 53, 42, 7, -52 },
  { 5378, 27, 51, 42, 8, -51 },
  { 5551, 28, 51, 42, 8, -51 },
  { 5730, 29, 51, 42, 8, -51 },
  { 5915, 29, 53, 42, 7, -52 },
  { 6108, 26, 51, 42, 8, -51 },
  { 6274, 26, 51, 42, 8, -51 },
  { 6440, 29, 52, 42, 5, -51 },
  { 6629, 30, 51, 42, 8, -51 },
  { 6821, 29, 51, 42, 8, -51 },
  { 7006, 30, 51, 42, 6, -51 },
  { 7198, 26, 51, 42, 8, -51 },
  { 7364, 28, 53, 42, 7, -52 },
  { 7550, 29, 51, 42, 8, -51 },
  { 7735, 29, 65, 42, 7, -52 },
  { 7971, 29, 51, 42, 8, -51 },
  { 8156, 30, 53, 42, 6, -52 },
  { 8355, 34, 51, 42, 4, -51 },
  { 8572, 26, 52, 42, 8, -51 },
  { 8741, 32, 51, 42, 5, -51 },
  { 8945, 36, 51, 42, 3, -51 },
  { 9175, 34, 51, 42, 4, -51 },
  { 9392, 36, 51, 42, 3, -51 },
  { 9622, 30, 51, 42, 6, -51 },
  { 9814, 16, 66, 42, 15, -58 },
  { 9946, 28, 66, 42, 7, -58 },
  { 10177, 16, 66, 42, 11, -58 },
  { 10309, 28, 27, 42, 7, -51 },
  { 10404, 34, 3, 42, 4, 2 },
  { 10417, 12, 10, 42, 14, -55 },
  { 10432, 28, 40, 42, 6, -39 },
  { 10572, 27, 52, 42, 8, -51 },
  { 10748, 28, 40, 42, 7, -39 },
  { 10888, 27, 52, 42, 7, -51 },
  { 11064, 28, 40, 42, 7, -39 },
  { 11204, 32, 51, 42, 5, -51 },
  { 11408, 27, 52, 42, 7, -39 },
  { 11584, 26, 51, 42, 8, -51 },
  { 11750, 30, 54, 42, 7, -54 },
  { 11953, 25, 67, 42, 7, -54 },
  { 12163, 29, 51, 42, 8, -51 },
  { 12348, 35, 51, 42, 3, -51 },
  { 12572, 30, 39, 42, 6, -39 },
  { 12719, 26, 39, 42, 8, -39 },
  { 12846, 28, 40, 42, 7, -39 },
  { 12986, 27, 52, 42, 8, -39 },
  { 13162, 27, 52, 42, 7, -39 },
  { 13338, 27, 39, 42, 9, -39 },
  { 13470, 28, 40, 42, 7, -39 },
  { 13610, 30, 49, 42, 5, -49 },
  { 13794, 26, 40, 42, 8, -39 },
  { 13924, 32, 39, 42, 5, -39 },
  { 14080, 36, 39, 42, 3, -39 },
  { 14256, 32, 39, 42, 5, -39 },
  { 14412, 32, 52, 42, 5, -39 },
  { 14620, 28, 39, 42, 7, -39 },
  { 14757, 28, 66, 42, 7, -58 },
  { 14988, 4, 66, 42, 19, -58 },
  { 15021, 28, 66, 42, 7, -58 },
  { 15252, 30, 13, 42, 6, -31 },
};

const GFXfont JetBrainsMono_Thin70pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin70pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _JETBRAINSMONO_THIN70PT7B_H_
