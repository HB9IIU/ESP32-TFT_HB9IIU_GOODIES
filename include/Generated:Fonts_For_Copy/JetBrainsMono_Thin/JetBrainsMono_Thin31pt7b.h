#ifndef _JETBRAINSMONO_THIN31PT7B_H_
#define _JETBRAINSMONO_THIN31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin31pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xC9, 0x24, 0x92, 0x40, 0x0F, 0xF8, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0x03, 0x06, 0x01, 0x03,
  0x00, 0x81, 0x00, 0x40, 0x80, 0x60, 0x40, 0x30, 0x60, 0x10, 0x30, 0xFF,
  0xFF, 0x04, 0x08, 0x06, 0x04, 0x03, 0x06, 0x01, 0x03, 0x00, 0x81, 0x00,
  0x40, 0x80, 0x60, 0x41, 0xFF, 0xFC, 0x10, 0x30, 0x08, 0x10, 0x04, 0x08,
  0x02, 0x04, 0x03, 0x06, 0x01, 0x83, 0x00, 0x81, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0xF8, 0x1F, 0xF1, 0x88, 0xC8, 0x46, 0xC2, 0x16,
  0x10, 0xF0, 0x81, 0x84, 0x06, 0x20, 0x19, 0x00, 0x78, 0x01, 0xF0, 0x02,
  0xE0, 0x11, 0x80, 0x8C, 0x04, 0x30, 0x21, 0xC1, 0x0E, 0x08, 0x78, 0x43,
  0xC2, 0x33, 0x93, 0x07, 0xF0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x3C, 0x01, 0xBF, 0x00, 0xB0, 0xC0, 0x90, 0x60, 0xC8, 0x30, 0x44, 0x18,
  0x42, 0x0C, 0x61, 0x86, 0x20, 0xC2, 0x20, 0x3F, 0x30, 0x06, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x19, 0xF0, 0x09, 0x8C, 0x08, 0x82, 0x0C, 0x41,
  0x8C, 0x20, 0xC4, 0x10, 0x64, 0x08, 0x36, 0x04, 0x12, 0x03, 0x1A, 0x00,
  0xF8, 0x07, 0x80, 0x3B, 0xC0, 0xC1, 0x81, 0x81, 0x82, 0x03, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x30, 0x0C,
  0x30, 0x78, 0x61, 0xB0, 0x63, 0x60, 0x6C, 0xC0, 0x71, 0x80, 0x63, 0x00,
  0xC6, 0x03, 0xCC, 0x0C, 0xCC, 0x30, 0x8F, 0xC1, 0x80, 0xFF, 0xFF, 0x50,
  0x01, 0x83, 0xC3, 0x83, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x04, 0x80, 0xE0,
  0x38, 0x1C, 0x0C, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x0C,
  0x18, 0x70, 0xE0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x60, 0x83, 0xF8, 0x9F, 0x1E, 0xF8, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x1C, 0x08, 0x08,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x3F, 0xFF, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x39, 0xCC, 0xE6, 0x31, 0x98, 0xC4, 0x00, 0xFF, 0xC0,
  0xF7, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0x0F, 0x81, 0xFF, 0x18, 0x1D, 0x80, 0x6C, 0x01, 0x60,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF1, 0x87, 0x8E, 0x3C, 0x71,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x66,
  0x03, 0x1C, 0x70, 0x7F, 0x00, 0x03, 0x00, 0x78, 0x07, 0x40, 0x62, 0x0E,
  0x10, 0x40, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x83, 0xFF, 0xE0, 0x0F, 0x81, 0xEF, 0x18, 0x0D,
  0x80, 0x68, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xF8,
  0x00, 0xE0, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01,
  0x80, 0x3C, 0x03, 0x40, 0x67, 0x0E, 0x1F, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10,
  0x33, 0x03, 0x60, 0x36, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x7F, 0xF3, 0xFF, 0x90, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x47, 0x82, 0xFF, 0x1C,
  0x1C, 0xC0, 0x64, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xB0, 0x05, 0x80, 0x66, 0x03, 0x18, 0x70, 0x7F, 0x00, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x18, 0x1F, 0xF0, 0xE0, 0xEC, 0x03, 0x60, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x26, 0x03, 0x18, 0x70, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x00, 0x0F, 0x81, 0xEF, 0x18, 0x0C, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00,
  0x48, 0x02, 0x60, 0x21, 0x87, 0x07, 0x60, 0x1E, 0x01, 0x9C, 0x38, 0x31,
  0x00, 0xD8, 0x02, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0x38,
  0x30, 0x7F, 0x00, 0x0F, 0x81, 0xEF, 0x18, 0x0D, 0x80, 0x6C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x0C, 0xC0, 0x63, 0xDF,
  0x0F, 0xB0, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x00, 0xF7, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3B, 0xDF, 0xF0, 0x79, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0xE3, 0x1C, 0x61, 0x86, 0x30, 0xC2, 0x00, 0x00, 0x08, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x03, 0x00,
  0x10, 0x00, 0xF8, 0x1F, 0xE0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x06, 0x1F, 0x83, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x07, 0xC0,
  0x3D, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00, 0x58, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC1, 0xF7, 0x87, 0x3F, 0x0C, 0x1E, 0x10, 0x3C, 0x20, 0x78, 0x40,
  0xF0, 0x81, 0xE1, 0x03, 0xC2, 0x07, 0x84, 0x0F, 0x0C, 0x1E, 0x1C, 0x7C,
  0x1F, 0x78, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x7E, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xA0,
  0x06, 0x80, 0x13, 0x00, 0x4C, 0x03, 0x10, 0x0C, 0x60, 0x21, 0x80, 0x82,
  0x06, 0x08, 0x10, 0x30, 0x40, 0xC3, 0x01, 0x0F, 0xFC, 0x20, 0x18, 0x80,
  0x66, 0x00, 0x98, 0x03, 0x40, 0x0D, 0x00, 0x3C, 0x00, 0x40, 0xFE, 0x07,
  0xFE, 0x30, 0x19, 0x80, 0x6C, 0x01, 0x60, 0x0B, 0x00, 0x58, 0x02, 0xC0,
  0x36, 0x01, 0xB0, 0x79, 0xFF, 0x0C, 0x06, 0x60, 0x1B, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x2C, 0x03, 0x60, 0xF3, 0xFE, 0x00,
  0x0F, 0x81, 0xEF, 0x18, 0x0C, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0xF0, 0x06, 0x80, 0x26, 0x03, 0x18, 0x30,
  0x7F, 0x00, 0xFE, 0x0F, 0xF8, 0xC0, 0xEC, 0x06, 0xC0, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x3C, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0xFF, 0xEF, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F,
  0x81, 0xEF, 0x18, 0x0C, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x3F, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0x80, 0x26, 0x03, 0x18, 0x30, 0x7F,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10,
  0xFF, 0xFF, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1E,
  0x00, 0xF0, 0x06, 0x80, 0x26, 0x03, 0x18, 0x30, 0x7F, 0x00, 0xC0, 0x0B,
  0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x04, 0x30, 0x30,
  0xC0, 0x83, 0x06, 0x0C, 0x10, 0x3F, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x0C,
  0x30, 0x30, 0xC0, 0x63, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x1B, 0x00,
  0x6C, 0x00, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF0, 0xC0, 0x3F, 0x01, 0xE8, 0x0F, 0x40, 0xFB, 0x05, 0xC8, 0x2E,
  0x42, 0x71, 0x13, 0x88, 0x9C, 0x68, 0xE1, 0x47, 0x0E, 0x38, 0x61, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xD0, 0x1D,
  0x81, 0xC8, 0x1C, 0x81, 0xCC, 0x1C, 0x41, 0xC6, 0x1C, 0x21, 0xC2, 0x1C,
  0x31, 0xC1, 0x1C, 0x19, 0xC1, 0x9C, 0x09, 0xC0, 0xDC, 0x05, 0xC0, 0x7C,
  0x07, 0xC0, 0x30, 0x0F, 0x83, 0xDC, 0x60, 0x64, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x33, 0x0E,
  0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x8C, 0x03, 0x30, 0x06, 0xC0, 0x0B, 0x00,
  0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x6C, 0x03, 0x30, 0x7C, 0xFF,
  0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x81, 0xEE, 0x18, 0x18,
  0x80, 0x6C, 0x01, 0x60, 0x0B, 0x00, 0x58, 0x02, 0xC0, 0x16, 0x00, 0xB0,
  0x05, 0x80, 0x2C, 0x01, 0x60, 0x0B, 0x00, 0x58, 0x02, 0xC0, 0x16, 0x00,
  0xB0, 0x04, 0x80, 0x66, 0x03, 0x18, 0x70, 0x7F, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0xFF, 0x07, 0xFF, 0x30, 0x0D,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x0D, 0xFF, 0xCF, 0xF8, 0x60, 0xC3, 0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03,
  0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x60, 0x0F, 0x81, 0xEF,
  0x18, 0x0C, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0x38, 0x30, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x34,
  0x03, 0x60, 0x23, 0x0E, 0x1F, 0xC0, 0xC0, 0x07, 0x00, 0x14, 0x00, 0xD8,
  0x03, 0x60, 0x08, 0x80, 0x22, 0x01, 0x8C, 0x06, 0x30, 0x10, 0x40, 0xC1,
  0x03, 0x06, 0x08, 0x18, 0x20, 0x21, 0x80, 0xC6, 0x03, 0x10, 0x04, 0x40,
  0x13, 0x00, 0x6C, 0x01, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC1,
  0x81, 0xC1, 0xC1, 0xC1, 0x41, 0x41, 0x41, 0x41, 0x43, 0x41, 0x43, 0x41,
  0x43, 0x63, 0x42, 0x62, 0x62, 0x62, 0x62, 0x62, 0x22, 0x22, 0x22, 0x22,
  0x26, 0x22, 0x26, 0x26, 0x26, 0x34, 0x24, 0x34, 0x34, 0x34, 0x14, 0x34,
  0x14, 0x14, 0x14, 0x14, 0x14, 0x18, 0x1C, 0x18, 0x1C, 0xC0, 0x04, 0x80,
  0x19, 0x80, 0x21, 0x80, 0xC3, 0x03, 0x03, 0x06, 0x02, 0x18, 0x06, 0x20,
  0x04, 0xC0, 0x0D, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0xD8, 0x03,
  0x10, 0x06, 0x30, 0x18, 0x20, 0x20, 0x60, 0xC0, 0x41, 0x00, 0xC6, 0x00,
  0xD8, 0x01, 0xB0, 0x01, 0x80, 0x80, 0x07, 0x80, 0x09, 0x00, 0x33, 0x00,
  0x42, 0x01, 0x86, 0x02, 0x04, 0x0C, 0x0C, 0x10, 0x08, 0x60, 0x18, 0x80,
  0x13, 0x00, 0x34, 0x00, 0x38, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x0F, 0xE0, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x06, 0x00, 0x38, 0x01, 0x40,
  0x1B, 0x00, 0x98, 0x0C, 0x40, 0x63, 0x06, 0x08, 0x30, 0x63, 0x03, 0x18,
  0x0D, 0x80, 0x70, 0xFF, 0xFE, 0xE1, 0x8C, 0x30, 0x1F, 0xC3, 0x06, 0x60,
  0x34, 0x03, 0x80, 0x10, 0x01, 0x00, 0x10, 0xFF, 0x7F, 0xFC, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x36, 0x0D, 0x3F, 0x90, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0xCD, 0x06, 0xE0, 0x3C,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xE0, 0x3D, 0x06, 0xCF, 0xC0, 0x1F, 0xC1, 0x83,
  0x18, 0x0C, 0x80, 0x2C, 0x01, 0x60, 0x0F, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x3C, 0x01, 0x20, 0x09, 0x80, 0xC6, 0x1C, 0x1F,
  0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x1F, 0x93,
  0x0D, 0x60, 0x34, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x34, 0x03, 0x60, 0x33, 0x0D, 0x1F, 0x90,
  0x1F, 0xC3, 0x06, 0x60, 0x34, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x03, 0x60, 0x33, 0x06,
  0x1F, 0xC0, 0x00, 0x7C, 0x0F, 0xF0, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0xFF, 0xFC, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x1F, 0x93, 0x0D, 0x60, 0x34,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x40, 0x36, 0x05, 0x3F, 0x90, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x63, 0xFE, 0x3E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xCF, 0xCD, 0x06, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x10, 0x02, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x00,
  0x40, 0x3C, 0x07, 0x80, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0xCF, 0xF1, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x78, 0x06, 0xC0, 0x36, 0x03, 0x30, 0x31, 0x83,
  0x0C, 0x18, 0x7F, 0x83, 0xFC, 0x18, 0x30, 0xC1, 0x86, 0x06, 0x30, 0x19,
  0x80, 0xCC, 0x03, 0x60, 0x0B, 0x00, 0x60, 0xFE, 0x01, 0xFC, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x7F, 0x80, 0xDE, 0x7B, 0x8E, 0x3C, 0x30, 0xF0, 0x41, 0xC1, 0x07,
  0x04, 0x1C, 0x10, 0x70, 0x41, 0xC1, 0x07, 0x04, 0x1C, 0x10, 0x70, 0x41,
  0xC1, 0x07, 0x04, 0x1C, 0x10, 0x70, 0x41, 0xC1, 0x04, 0xCF, 0xCD, 0x06,
  0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10, 0x1F,
  0xC3, 0x0E, 0x60, 0x34, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x33, 0x0E, 0x1F,
  0xC0, 0xCF, 0xCD, 0x06, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xE0, 0x3D,
  0x06, 0xCF, 0xCC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x1F, 0x93, 0x0D, 0x60, 0x34, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x34, 0x03, 0x60, 0x33, 0x0D,
  0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x9F,
  0x8B, 0x0E, 0xA0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x3F, 0xC3, 0x83, 0x90, 0x0D, 0x80, 0x3C, 0x00, 0x60, 0x01, 0x80,
  0x07, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xE0, 0x0F,
  0x00, 0x4E, 0x0E, 0x3F, 0xE0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x03, 0xFF, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x07, 0xE0, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x23, 0x0E, 0x1F, 0xC0, 0xC0, 0x0D,
  0x80, 0x36, 0x00, 0x88, 0x06, 0x30, 0x18, 0xC0, 0x41, 0x03, 0x06, 0x0C,
  0x18, 0x20, 0x21, 0x80, 0xC6, 0x03, 0x10, 0x04, 0xC0, 0x1B, 0x00, 0x68,
  0x00, 0xE0, 0x03, 0x00, 0x83, 0x07, 0x06, 0x0E, 0x0A, 0x1E, 0x14, 0x2C,
  0x28, 0x58, 0xD0, 0x91, 0x23, 0x22, 0x66, 0x44, 0x4C, 0xC8, 0x91, 0xB1,
  0x21, 0x62, 0x42, 0x87, 0x85, 0x0F, 0x0A, 0x0E, 0x1C, 0x18, 0x38, 0x30,
  0x60, 0x0C, 0xC0, 0x63, 0x03, 0x06, 0x0C, 0x0C, 0x60, 0x13, 0x00, 0x68,
  0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x4C, 0x03, 0x10, 0x18, 0x60, 0x40,
  0xC3, 0x01, 0x98, 0x06, 0xC0, 0x0C, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0x88,
  0x06, 0x30, 0x18, 0x40, 0xC1, 0x83, 0x06, 0x08, 0x08, 0x60, 0x31, 0x80,
  0x44, 0x01, 0xB0, 0x06, 0xC0, 0x0A, 0x00, 0x38, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xFF,
  0xF0, 0x00, 0x78, 0x0F, 0xC0, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x83,
  0xF8, 0x1F, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0F, 0xE0, 0x7F, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x0F, 0x80, 0x00, 0x70, 0x0F, 0xE0, 0x61, 0x83, 0x06, 0x38,
  0x19, 0xC0, 0x78,
};

const GFXglyph JetBrainsMono_Thin31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 3, 23, 19, 8, -23 },
  { 10, 8, 10, 19, 5, -23 },
  { 20, 17, 23, 19, 1, -23 },
  { 69, 13, 31, 19, 3, -27 },
  { 120, 17, 23, 19, 1, -23 },
  { 169, 15, 23, 19, 2, -23 },
  { 213, 2, 10, 19, 8, -23 },
  { 216, 9, 30, 19, 6, -26 },
  { 250, 8, 30, 19, 4, -26 },
  { 280, 16, 16, 19, 1, -19 },
  { 312, 14, 15, 19, 2, -18 },
  { 339, 5, 10, 19, 6, -5 },
  { 346, 10, 1, 19, 4, -11 },
  { 348, 5, 4, 19, 7, -4 },
  { 351, 13, 29, 19, 3, -26 },
  { 399, 13, 23, 19, 3, -23 },
  { 437, 13, 23, 19, 3, -23 },
  { 475, 13, 23, 19, 3, -23 },
  { 513, 12, 23, 19, 3, -23 },
  { 548, 12, 23, 19, 3, -23 },
  { 583, 13, 23, 19, 3, -23 },
  { 621, 13, 23, 19, 3, -23 },
  { 659, 13, 23, 19, 3, -23 },
  { 697, 13, 23, 19, 3, -23 },
  { 735, 13, 23, 19, 3, -23 },
  { 773, 5, 17, 19, 7, -17 },
  { 784, 6, 22, 19, 6, -17 },
  { 801, 13, 16, 19, 3, -18 },
  { 827, 13, 8, 19, 3, -14 },
  { 840, 13, 16, 19, 3, -18 },
  { 866, 11, 23, 19, 5, -23 },
  { 898, 15, 29, 19, 2, -23 },
  { 953, 14, 23, 19, 2, -23 },
  { 994, 13, 23, 19, 3, -23 },
  { 1032, 13, 23, 19, 3, -23 },
  { 1070, 12, 23, 19, 3, -23 },
  { 1105, 12, 23, 19, 4, -23 },
  { 1140, 12, 23, 19, 4, -23 },
  { 1175, 13, 23, 19, 3, -23 },
  { 1213, 12, 23, 19, 3, -23 },
  { 1248, 11, 23, 19, 4, -23 },
  { 1280, 13, 23, 19, 2, -23 },
  { 1318, 14, 23, 19, 3, -23 },
  { 1359, 12, 23, 19, 4, -23 },
  { 1394, 13, 23, 19, 3, -23 },
  { 1432, 12, 23, 19, 3, -23 },
  { 1467, 12, 23, 19, 3, -23 },
  { 1502, 14, 23, 19, 3, -23 },
  { 1543, 13, 29, 19, 3, -23 },
  { 1591, 13, 23, 19, 3, -23 },
  { 1629, 13, 23, 19, 3, -23 },
  { 1667, 15, 23, 19, 2, -23 },
  { 1711, 12, 23, 19, 3, -23 },
  { 1746, 14, 23, 19, 2, -23 },
  { 1787, 16, 23, 19, 1, -23 },
  { 1833, 15, 23, 19, 2, -23 },
  { 1877, 15, 23, 19, 2, -23 },
  { 1921, 13, 23, 19, 3, -23 },
  { 1959, 7, 29, 19, 7, -26 },
  { 1985, 13, 29, 19, 3, -26 },
  { 2033, 7, 29, 19, 5, -26 },
  { 2059, 13, 12, 19, 3, -23 },
  { 2079, 15, 1, 19, 2, 1 },
  { 2081, 5, 4, 19, 6, -24 },
  { 2084, 12, 17, 19, 3, -17 },
  { 2110, 12, 23, 19, 3, -23 },
  { 2145, 13, 17, 19, 3, -17 },
  { 2173, 12, 23, 19, 3, -23 },
  { 2208, 12, 17, 19, 3, -17 },
  { 2234, 14, 23, 19, 2, -23 },
  { 2275, 12, 23, 19, 3, -17 },
  { 2310, 12, 23, 19, 3, -23 },
  { 2345, 14, 24, 19, 3, -24 },
  { 2387, 11, 30, 19, 3, -24 },
  { 2429, 13, 23, 19, 3, -23 },
  { 2467, 15, 23, 19, 2, -23 },
  { 2511, 14, 17, 19, 2, -17 },
  { 2541, 12, 17, 19, 3, -17 },
  { 2567, 12, 17, 19, 3, -17 },
  { 2593, 12, 23, 19, 3, -17 },
  { 2628, 12, 23, 19, 3, -17 },
  { 2663, 12, 17, 19, 4, -17 },
  { 2689, 13, 17, 19, 3, -17 },
  { 2717, 14, 22, 19, 2, -22 },
  { 2756, 12, 17, 19, 3, -17 },
  { 2782, 14, 17, 19, 2, -17 },
  { 2812, 15, 17, 19, 2, -17 },
  { 2844, 14, 17, 19, 2, -17 },
  { 2874, 14, 23, 19, 2, -17 },
  { 2915, 12, 17, 19, 3, -17 },
  { 2941, 13, 29, 19, 3, -26 },
  { 2989, 1, 29, 19, 9, -26 },
  { 2993, 13, 29, 19, 3, -26 },
  { 3041, 13, 6, 19, 3, -14 },
};

const GFXfont JetBrainsMono_Thin31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_THIN31PT7B_H_
