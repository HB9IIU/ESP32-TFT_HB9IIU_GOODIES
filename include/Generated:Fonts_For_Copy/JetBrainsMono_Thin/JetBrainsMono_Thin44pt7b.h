#ifndef _JETBRAINSMONO_THIN44PT7B_H_
#define _JETBRAINSMONO_THIN44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin44pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x30, 0x80, 0x00, 0x00, 0x4F, 0xFF, 0xFE, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x60, 0x76, 0x07,
  0x60, 0x76, 0x03, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x30, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x06,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0xFB, 0xF8, 0x38, 0x47, 0x8E, 0x08,
  0x71, 0x81, 0x07, 0x30, 0x20, 0x66, 0x04, 0x0C, 0xC0, 0x81, 0x98, 0x10,
  0x03, 0x02, 0x00, 0x70, 0x40, 0x06, 0x08, 0x00, 0xE1, 0x00, 0x0F, 0x20,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x02, 0x78, 0x00, 0x43,
  0x80, 0x08, 0x30, 0x01, 0x07, 0x00, 0x20, 0x60, 0x04, 0x0E, 0x00, 0x81,
  0xF0, 0x10, 0x3E, 0x02, 0x07, 0xC0, 0x40, 0xDC, 0x08, 0x19, 0xC1, 0x07,
  0x1C, 0x21, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x1F, 0x80,
  0x03, 0x9F, 0xE0, 0x03, 0x18, 0x18, 0x01, 0x8C, 0x0C, 0x01, 0x84, 0x03,
  0x01, 0x86, 0x01, 0x80, 0xC3, 0x00, 0xC0, 0xC1, 0x80, 0x60, 0xC0, 0xC0,
  0x30, 0xC0, 0x20, 0x18, 0x60, 0x18, 0x18, 0x60, 0x0C, 0x0C, 0x60, 0x03,
  0xFC, 0x30, 0x00, 0xFC, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x18, 0x7F, 0x00, 0x0C, 0x73,
  0xC0, 0x0C, 0x60, 0x60, 0x0C, 0x30, 0x18, 0x06, 0x18, 0x0C, 0x06, 0x0C,
  0x06, 0x06, 0x06, 0x03, 0x06, 0x03, 0x01, 0x83, 0x01, 0x80, 0xC3, 0x00,
  0xC0, 0x63, 0x00, 0x60, 0x31, 0x80, 0x38, 0x31, 0x80, 0x0F, 0xF9, 0x80,
  0x03, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xE0, 0x07, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x79, 0x80,
  0x01, 0x83, 0x00, 0x6E, 0x0E, 0x03, 0x30, 0x1C, 0x0C, 0xC0, 0x30, 0x63,
  0x00, 0x61, 0x8C, 0x01, 0xCC, 0x30, 0x03, 0xF0, 0xC0, 0x07, 0x83, 0x00,
  0x0E, 0x0C, 0x00, 0x38, 0x30, 0x01, 0xF0, 0xC0, 0x0E, 0xC3, 0x80, 0x71,
  0x87, 0x03, 0x87, 0x0F, 0xFC, 0x0E, 0x1F, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0x6C, 0x00, 0x10, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0xF8, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x18, 0x06, 0xF8, 0x30, 0x7C, 0xFE, 0x63,
  0xFC, 0x3F, 0x5F, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x33, 0x00, 0x00, 0xE7, 0x00, 0x01, 0x87, 0x00, 0x07, 0x06, 0x00,
  0x1C, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B,
  0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x1C,
  0x70, 0x03, 0x9C, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0x78, 0x3E, 0x0E, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0D, 0x80, 0x07, 0x70, 0x01, 0x9E, 0x00, 0xE3, 0xC0,
  0x70, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1E,
  0xC0, 0x07, 0x18, 0x01, 0xC3, 0x00, 0xF0, 0x60, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0,
  0x01, 0xFF, 0x80, 0x7C, 0xFC, 0x1C, 0x03, 0xC7, 0x00, 0x39, 0xC0, 0x03,
  0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x6E, 0x00, 0x19, 0x80, 0x0E, 0x70, 0x03, 0x0E, 0x01,
  0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x06, 0x38, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x7F, 0xFF, 0x9F, 0xFF, 0xE6, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x87, 0xF0, 0x67, 0xFE, 0x1B, 0x03, 0xC7, 0x80, 0x39, 0xC0,
  0x06, 0x70, 0x01, 0xD8, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x36,
  0x00, 0x1D, 0x80, 0x06, 0x70, 0x03, 0x8E, 0x01, 0xC1, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x37, 0xF8, 0x0D, 0xFF,
  0x83, 0xC0, 0x38, 0x70, 0x03, 0x8C, 0x00, 0x3B, 0x80, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xD8, 0x00, 0x1B, 0x80, 0x03, 0x30, 0x00, 0xE7, 0x00, 0x38, 0x70, 0x0E,
  0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0C,
  0xC0, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x40, 0x01,
  0xFF, 0x01, 0xFB, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x9C, 0x00, 0x76, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1C, 0xC0, 0x06,
  0x38, 0x03, 0x87, 0x01, 0xC0, 0xF1, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x01,
  0xEE, 0x00, 0xE0, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x01, 0xDC, 0x00, 0x63, 0x80, 0x78, 0x7F, 0xFC, 0x0F, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0x80, 0x7C, 0xF8, 0x1C, 0x03, 0x87, 0x00, 0x38,
  0xC0, 0x03, 0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xB8, 0x00, 0x33,
  0x00, 0x0E, 0x70, 0x03, 0x87, 0x80, 0xF0, 0x7F, 0xFC, 0x03, 0xF9, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x31, 0xFF, 0xFF, 0xFD, 0xF3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF,
  0xFF, 0x7C, 0x0C, 0x1F, 0x8F, 0xC7, 0xF3, 0xF0, 0xF8, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3,
  0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x07, 0xF8, 0x0F, 0xE0, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x20, 0x00,
  0x1F, 0xF8, 0x03, 0xE3, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00,
  0x39, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xF9, 0xE0, 0x3F, 0xEF, 0x03, 0x81,
  0xF8, 0x1C, 0x07, 0xC0, 0xC0, 0x1E, 0x06, 0x00, 0xF0, 0x30, 0x07, 0x81,
  0x80, 0x3C, 0x0C, 0x01, 0xE0, 0x60, 0x0F, 0x03, 0x00, 0x78, 0x18, 0x03,
  0xC0, 0xC0, 0x1E, 0x06, 0x00, 0xF0, 0x38, 0x0F, 0x81, 0xC0, 0xFC, 0x07,
  0xDD, 0xE0, 0x1F, 0xCF, 0x00, 0x10, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x19, 0x80,
  0x01, 0x98, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x81, 0xC0, 0x18, 0x18,
  0x01, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3,
  0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x01, 0xE3,
  0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x03,
  0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xC0, 0xFC, 0x30, 0x03, 0xCC, 0x00, 0x33,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x07, 0x30, 0x07,
  0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xDF, 0x8E,
  0x01, 0xC6, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3B, 0x00, 0x38, 0xE0, 0x38, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x0F, 0x18, 0x01,
  0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x01, 0xE3, 0xFF, 0xE1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xB0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFC,
  0x0F, 0xDF, 0x8E, 0x01, 0xC6, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x7F, 0xF0, 0x3F,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3B, 0x00, 0x38,
  0xE0, 0x38, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x06, 0x70, 0x03,
  0x8E, 0x01, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0xC0, 0x00, 0xD8, 0x00, 0x3B,
  0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x01, 0x86,
  0x00, 0x70, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x60, 0x60, 0x1C, 0x0C,
  0x03, 0x01, 0x80, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x60, 0x1C, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x30,
  0x03, 0x06, 0x00, 0x70, 0xC0, 0x06, 0x18, 0x00, 0xE3, 0x00, 0x0C, 0x60,
  0x01, 0xCC, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x07, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x60, 0x0F, 0xD8, 0x06, 0xF2, 0x01,
  0xBC, 0xC0, 0x4F, 0x30, 0x33, 0xC4, 0x0C, 0xF1, 0x82, 0x3C, 0x61, 0x8F,
  0x0C, 0x63, 0xC3, 0x10, 0xF0, 0x4C, 0x3C, 0x1B, 0x0F, 0x07, 0x83, 0xC0,
  0xE0, 0xF0, 0x30, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7D, 0x80, 0x3E, 0xC0, 0x1F,
  0x20, 0x0F, 0x98, 0x07, 0xCC, 0x03, 0xE3, 0x01, 0xF1, 0x80, 0xF8, 0xC0,
  0x7C, 0x30, 0x3E, 0x18, 0x1F, 0x06, 0x0F, 0x83, 0x07, 0xC1, 0x83, 0xE0,
  0x61, 0xF0, 0x30, 0xF8, 0x0C, 0x7C, 0x06, 0x3E, 0x03, 0x1F, 0x00, 0xCF,
  0x80, 0x67, 0xC0, 0x1B, 0xE0, 0x0D, 0xF0, 0x06, 0xF8, 0x01, 0xBC, 0x00,
  0xDE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x80, 0x07, 0xFC, 0x0F,
  0x9F, 0x0E, 0x01, 0xC6, 0x00, 0x77, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6E, 0x00, 0x33, 0x00, 0x39, 0xC0,
  0x38, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x00,
  0x3C, 0x60, 0x01, 0xCC, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x1D, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x07, 0xFC, 0x0F, 0xDF, 0x0E, 0x01, 0xC6, 0x00, 0x77, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6E, 0x00, 0x33,
  0x00, 0x39, 0xE0, 0x38, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8C, 0x00, 0xF3, 0x00, 0x0E, 0xC0,
  0x01, 0xB0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x73,
  0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xC0,
  0x30, 0x30, 0x0E, 0x0C, 0x01, 0x83, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x03,
  0x8C, 0x00, 0x63, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7E, 0xFC, 0x1C, 0x03, 0xC7,
  0x00, 0x38, 0xC0, 0x03, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x6E, 0x00, 0x0C, 0xE0,
  0x03, 0x8E, 0x00, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xDC, 0x00, 0x66, 0x00, 0x71, 0xC0,
  0x70, 0x7F, 0xF0, 0x1F, 0xE0, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x00,
  0x0C, 0x38, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x18, 0x1C,
  0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xE0, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x70, 0x06, 0x06, 0x00, 0x70, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0x98,
  0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0xC0, 0x38, 0x0F, 0x80, 0x70, 0x1B, 0x00, 0xE0, 0x36, 0x03, 0x40,
  0x6C, 0x06, 0x80, 0xD8, 0x0D, 0x01, 0x98, 0x1B, 0x03, 0x30, 0x26, 0x06,
  0x60, 0x4C, 0x0C, 0xC0, 0x98, 0x31, 0x83, 0x30, 0x63, 0x06, 0x20, 0xC6,
  0x0C, 0x41, 0x8E, 0x18, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x43, 0x0C, 0x30,
  0x86, 0x18, 0x63, 0x0C, 0x20, 0xC6, 0x08, 0xC1, 0x8C, 0x11, 0x83, 0x18,
  0x33, 0x07, 0x20, 0x66, 0x06, 0x40, 0xCC, 0x0C, 0x81, 0x98, 0x1B, 0x03,
  0x30, 0x36, 0x02, 0x40, 0x6C, 0x05, 0x80, 0xD0, 0x0F, 0x01, 0xA0, 0x1E,
  0x03, 0x40, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x70, 0x00, 0x18,
  0xC0, 0x00, 0xC3, 0x80, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x38,
  0x03, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xB0, 0x00, 0x0C,
  0xC0, 0x00, 0x71, 0x80, 0x01, 0x87, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x38,
  0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x06, 0x06,
  0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xB8, 0x00,
  0x07, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x70, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x83,
  0x00, 0x06, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x03,
  0x38, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x18, 0x70, 0x0E, 0x0C, 0x03, 0x03,
  0x81, 0xC0, 0x60, 0x60, 0x1C, 0x38, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x39,
  0xC0, 0x06, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0x80, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFB,
  0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x98, 0x00, 0x66, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x1F, 0xFF, 0x1F, 0xFF, 0xDF,
  0x00, 0x76, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xF7, 0x00, 0x7C, 0xFF, 0xF7,
  0x1F, 0xF1, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0xC0, 0xCF, 0xF8, 0x6F, 0x1E,
  0x3C, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xDC, 0x00, 0x6F, 0x00, 0x76, 0xC0, 0x73, 0x7D, 0xF1, 0x8F, 0xF0, 0x01,
  0xC0, 0x07, 0xFC, 0x0F, 0xDF, 0x8E, 0x01, 0xC6, 0x00, 0x77, 0x00, 0x1B,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x33, 0x00, 0x39, 0xE0, 0x38,
  0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0x07, 0x1F, 0xF3,
  0x9F, 0x3D, 0xDC, 0x03, 0xEC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x76, 0x00, 0x7B, 0x80, 0x7C, 0xFF, 0xEE, 0x1F,
  0xE7, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0x9F, 0x0E, 0x01, 0xC6, 0x00, 0x77,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x33, 0x00, 0x39,
  0xC0, 0x38, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x0F, 0xF9, 0xCF, 0x9E, 0xEE, 0x01, 0xF6,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xEC, 0x00, 0xF7, 0x81, 0xF9,
  0xFF, 0xDC, 0x3F, 0x8E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x3F, 0xF8, 0x1F,
  0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0xC7, 0xF8, 0x6F, 0x1E, 0x34,
  0x03, 0x9C, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x78, 0xFF, 0xF0, 0xFF, 0x80, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0xEC, 0x00, 0x33,
  0x00, 0x1C, 0xC0, 0x0E, 0x30, 0x07, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0,
  0x70, 0x30, 0x18, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xC0, 0xE0, 0x30, 0x18,
  0x0C, 0x07, 0x03, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x07, 0x0C, 0x00, 0xE3,
  0x00, 0x18, 0xC0, 0x07, 0x30, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0x03, 0x8C, 0xFC, 0xFC, 0xD9, 0xC8, 0xED, 0x0F,
  0x07, 0xE0, 0x70, 0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03, 0xE0,
  0x60, 0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E,
  0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03,
  0xE0, 0x60, 0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03, 0xE0, 0x60,
  0x3E, 0x06, 0x03, 0xE0, 0x60, 0x30, 0x00, 0xC0, 0x63, 0xFC, 0x37, 0x8F,
  0x1A, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x07, 0xFC, 0x0F, 0x9F, 0x0E, 0x01, 0xC6, 0x00, 0x77, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6E, 0x00, 0x33, 0x00, 0x39, 0xC0,
  0x38, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x67, 0xFC, 0x37, 0x8F,
  0x1E, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x6E, 0x00, 0x37, 0x80, 0x3B, 0x60, 0x39, 0xBE, 0xF8, 0xC7, 0xF8, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xF9, 0xCF, 0x8E, 0xEE,
  0x01, 0xF6, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3B, 0x00, 0x3D, 0xC0, 0x3E, 0x7F, 0xF7, 0x0F, 0xF3, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x67, 0xFC, 0x37, 0x9F, 0x1E, 0x01,
  0xCE, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0x83, 0xE1, 0xF0, 0xE0, 0x0E, 0x70, 0x01, 0xD8, 0x00, 0x36,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x77,
  0x80, 0x38, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xB0,
  0x00, 0xDC, 0x00, 0x67, 0x00, 0x61, 0xC0, 0x70, 0xFF, 0xF0, 0x1F, 0xE0,
  0xE0, 0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xC3, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x1C, 0x01, 0x80, 0xC0,
  0x18, 0x0C, 0x03, 0x00, 0xE0, 0x30, 0x06, 0x07, 0x00, 0x60, 0x60, 0x03,
  0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x9C, 0x00,
  0x19, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0xC0, 0x30, 0x0F, 0x80, 0xE0, 0x36, 0x03, 0x80, 0xD8, 0x1A, 0x07, 0x60,
  0x68, 0x19, 0x81, 0xA0, 0x66, 0x04, 0xC1, 0x8C, 0x13, 0x06, 0x30, 0xCC,
  0x18, 0xC3, 0x10, 0xE3, 0x0C, 0x43, 0x0C, 0x31, 0x8C, 0x30, 0x86, 0x30,
  0x66, 0x18, 0xC1, 0x98, 0x63, 0x06, 0x60, 0x8C, 0x19, 0x83, 0x60, 0x64,
  0x0D, 0x81, 0xB0, 0x36, 0x03, 0xC0, 0xD8, 0x0F, 0x01, 0x60, 0x3C, 0x05,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x70, 0x00, 0x73, 0x80, 0x0C, 0x18,
  0x01, 0xC1, 0xC0, 0x18, 0x0E, 0x03, 0x00, 0x60, 0x70, 0x07, 0x06, 0x00,
  0x38, 0xC0, 0x01, 0x9C, 0x00, 0x1D, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0x9C, 0x00, 0x38, 0xC0, 0x07, 0x0E,
  0x00, 0x60, 0x70, 0x0E, 0x03, 0x01, 0xC0, 0x18, 0x18, 0x01, 0xC3, 0x80,
  0x0C, 0x70, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x70,
  0x00, 0x63, 0x00, 0x0E, 0x38, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0xC1,
  0xC0, 0x18, 0x0C, 0x03, 0x80, 0xE0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x70,
  0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x8E, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x1D, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0E, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x18, 0x00, 0x6F, 0xE0, 0x0F, 0x8E, 0x01, 0xE0, 0xE0, 0x3C,
  0x0E, 0x07, 0x80, 0xC1, 0xB0, 0x0E, 0x76, 0x00, 0xFC, 0xC0, 0x02, 0x00,
};

const GFXglyph JetBrainsMono_Thin44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 5, 32, 26, 11, -32 },
  { 21, 12, 13, 26, 7, -32 },
  { 41, 23, 32, 26, 2, -32 },
  { 133, 19, 44, 26, 4, -38 },
  { 238, 25, 32, 26, 1, -32 },
  { 338, 22, 33, 26, 3, -33 },
  { 429, 3, 13, 26, 12, -32 },
  { 434, 12, 42, 26, 9, -37 },
  { 497, 12, 42, 26, 5, -37 },
  { 560, 23, 22, 26, 2, -27 },
  { 624, 20, 21, 26, 3, -25 },
  { 677, 8, 14, 26, 8, -7 },
  { 691, 14, 2, 26, 6, -16 },
  { 695, 6, 6, 26, 10, -6 },
  { 700, 18, 42, 26, 4, -37 },
  { 795, 18, 33, 26, 4, -33 },
  { 870, 19, 32, 26, 4, -32 },
  { 946, 19, 33, 26, 4, -33 },
  { 1025, 18, 32, 26, 4, -32 },
  { 1097, 17, 32, 26, 4, -32 },
  { 1165, 18, 32, 26, 4, -32 },
  { 1237, 19, 32, 26, 4, -32 },
  { 1313, 19, 32, 26, 4, -32 },
  { 1389, 18, 33, 26, 4, -33 },
  { 1464, 19, 33, 26, 4, -33 },
  { 1543, 6, 25, 26, 10, -25 },
  { 1562, 9, 32, 26, 8, -25 },
  { 1598, 18, 22, 26, 4, -26 },
  { 1648, 18, 12, 26, 4, -21 },
  { 1675, 18, 22, 26, 4, -26 },
  { 1725, 15, 32, 26, 7, -32 },
  { 1785, 21, 41, 26, 3, -33 },
  { 1893, 20, 32, 26, 3, -32 },
  { 1973, 18, 32, 26, 5, -32 },
  { 2045, 17, 33, 26, 5, -33 },
  { 2116, 17, 32, 26, 5, -32 },
  { 2184, 17, 32, 26, 5, -32 },
  { 2252, 18, 32, 26, 5, -32 },
  { 2324, 17, 33, 26, 5, -33 },
  { 2395, 17, 32, 26, 5, -32 },
  { 2463, 16, 32, 26, 5, -32 },
  { 2527, 18, 32, 26, 3, -32 },
  { 2599, 19, 32, 26, 5, -32 },
  { 2675, 18, 32, 26, 5, -32 },
  { 2747, 18, 32, 26, 4, -32 },
  { 2819, 17, 32, 26, 5, -32 },
  { 2887, 17, 33, 26, 5, -33 },
  { 2958, 19, 32, 26, 5, -32 },
  { 3034, 17, 41, 26, 5, -33 },
  { 3122, 18, 32, 26, 5, -32 },
  { 3194, 19, 33, 26, 4, -33 },
  { 3273, 21, 32, 26, 3, -32 },
  { 3357, 17, 32, 26, 5, -32 },
  { 3425, 20, 32, 26, 3, -32 },
  { 3505, 23, 32, 26, 2, -32 },
  { 3597, 22, 32, 26, 2, -32 },
  { 3685, 22, 32, 26, 2, -32 },
  { 3773, 18, 32, 26, 4, -32 },
  { 3845, 10, 42, 26, 10, -37 },
  { 3898, 18, 42, 26, 4, -37 },
  { 3993, 10, 42, 26, 7, -37 },
  { 4046, 18, 17, 26, 4, -32 },
  { 4085, 21, 2, 26, 3, 1 },
  { 4091, 7, 7, 26, 9, -35 },
  { 4098, 18, 25, 26, 4, -25 },
  { 4155, 17, 32, 26, 5, -32 },
  { 4223, 17, 25, 26, 5, -25 },
  { 4277, 17, 32, 26, 5, -32 },
  { 4345, 17, 25, 26, 5, -25 },
  { 4399, 20, 32, 26, 3, -32 },
  { 4479, 17, 33, 26, 5, -25 },
  { 4550, 17, 32, 26, 5, -32 },
  { 4618, 20, 34, 26, 4, -34 },
  { 4703, 16, 42, 26, 4, -34 },
  { 4787, 18, 32, 26, 5, -32 },
  { 4859, 22, 32, 26, 2, -32 },
  { 4947, 20, 25, 26, 3, -25 },
  { 5010, 17, 25, 26, 5, -25 },
  { 5064, 17, 25, 26, 5, -25 },
  { 5118, 17, 33, 26, 5, -25 },
  { 5189, 17, 33, 26, 5, -25 },
  { 5260, 17, 25, 26, 6, -25 },
  { 5314, 18, 25, 26, 4, -25 },
  { 5371, 19, 31, 26, 3, -31 },
  { 5445, 17, 24, 26, 5, -24 },
  { 5496, 20, 24, 26, 3, -24 },
  { 5556, 22, 24, 26, 2, -24 },
  { 5622, 20, 24, 26, 3, -24 },
  { 5682, 20, 32, 26, 3, -24 },
  { 5762, 17, 24, 26, 5, -24 },
  { 5813, 18, 42, 26, 4, -37 },
  { 5908, 2, 42, 26, 12, -37 },
  { 5919, 18, 42, 26, 4, -37 },
  { 6014, 19, 9, 26, 4, -20 },
};

const GFXfont JetBrainsMono_Thin44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_THIN44PT7B_H_
