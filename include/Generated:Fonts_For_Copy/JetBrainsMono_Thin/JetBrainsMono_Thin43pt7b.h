#ifndef _JETBRAINSMONO_THIN43PT7B_H_
#define _JETBRAINSMONO_THIN43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin43pt7bBitmaps[] PROGMEM = {
  0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x30, 0x00, 0x00, 0x09, 0xEF, 0xFB, 0xC0, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x60, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x20, 0x03,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x0C, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0x80, 0xC0, 0x06,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7B, 0x78, 0x38, 0xC7, 0x1C, 0x30, 0xE6, 0x0C, 0x19,
  0x83, 0x07, 0x60, 0xC0, 0xD8, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x70,
  0xC0, 0x0E, 0x30, 0x03, 0xCC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x0D, 0xE0, 0x03, 0x1C, 0x00, 0xC3, 0x80, 0x30, 0x60, 0x0C, 0x1C,
  0x03, 0x03, 0x00, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xE0,
  0xC1, 0xDC, 0x30, 0x63, 0x8C, 0x70, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x3F, 0x80, 0x06, 0x71, 0xC0, 0x06, 0x60, 0x60, 0x0C,
  0x60, 0x60, 0x18, 0xC0, 0x60, 0x18, 0xC0, 0x60, 0x30, 0xC0, 0x60, 0x60,
  0xC0, 0x60, 0xC0, 0xC0, 0x60, 0xC0, 0x40, 0x61, 0x80, 0x60, 0x63, 0x00,
  0x70, 0xC3, 0x00, 0x3F, 0xC6, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x61, 0xF8, 0x00, 0x63, 0xFC,
  0x00, 0xC6, 0x0E, 0x01, 0x86, 0x06, 0x01, 0x84, 0x06, 0x03, 0x0C, 0x06,
  0x06, 0x0C, 0x06, 0x0C, 0x0C, 0x06, 0x0C, 0x0C, 0x06, 0x18, 0x04, 0x06,
  0x30, 0x06, 0x06, 0x30, 0x06, 0x06, 0x60, 0x03, 0xFC, 0xC0, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0x87, 0x80, 0x38, 0x0E, 0x01, 0x80,
  0x30, 0x1C, 0x01, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x61, 0xC0, 0x0F, 0x06, 0x01, 0xB0,
  0x18, 0x19, 0x80, 0xE0, 0xCC, 0x03, 0x8C, 0x60, 0x0C, 0x63, 0x00, 0x36,
  0x18, 0x01, 0xF0, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x01, 0xE1, 0x80,
  0x1F, 0x8E, 0x01, 0xCE, 0x38, 0x1C, 0x30, 0xFF, 0xC0, 0xC3, 0xF8, 0x07,
  0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0x00, 0x30, 0x0F, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0x30, 0xC0, 0x0F, 0x00, 0x7C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x08, 0x03, 0x00, 0x7C, 0x0C, 0x0F, 0xFE, 0x31, 0xFC, 0xFE, 0xDF,
  0x80, 0x7F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x70, 0x00,
  0x1C, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x87, 0x00, 0x1C, 0x0E, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0x10, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x0E, 0x18, 0x70, 0xE1, 0x83, 0x0C, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xF3, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x1C, 0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xF0, 0x78, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x19, 0x80, 0x0E, 0x70, 0x03,
  0x8F, 0x03, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1D, 0x80, 0x0F, 0x30, 0x03, 0x86, 0x00, 0xE0, 0xC0, 0x10, 0x18, 0x04,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0xF0, 0x78, 0x38, 0x03, 0x86, 0x00, 0x39, 0xC0, 0x03, 0x30,
  0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xCE, 0x00,
  0xE3, 0x80, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x70, 0x06, 0x30, 0x03, 0x38, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x7F, 0xFF, 0x9F, 0xFF, 0xE6, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x07, 0x01, 0x9F, 0xF0, 0x6F, 0x3E, 0x1E, 0x01, 0xC7, 0x00, 0x39, 0xC0,
  0x06, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0xE0, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x39, 0xC0, 0x0C, 0x38, 0x07, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x19, 0xF8, 0x0D, 0xFF, 0x87, 0xC0, 0xF1, 0xC0, 0x1C, 0x60,
  0x03, 0xB8, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x76, 0x00, 0x19,
  0xC0, 0x0E, 0x38, 0x07, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x03, 0xFF, 0x01, 0xC1, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x18,
  0xC0, 0x0C, 0x38, 0x07, 0x07, 0x03, 0x80, 0x73, 0x80, 0x07, 0x80, 0x03,
  0xF0, 0x03, 0x87, 0x01, 0xC0, 0xE0, 0xC0, 0x1C, 0x60, 0x03, 0xB8, 0x00,
  0x6C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x06, 0x60, 0x03, 0x8E, 0x01, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00,
  0x6C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x19, 0xC0, 0x0E, 0x38,
  0x07, 0x87, 0x8F, 0xC0, 0xFF, 0x70, 0x02, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x3E, 0xFF, 0xFF, 0xDE, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0xC0, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x01,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x0F,
  0xF0, 0x1F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0x07, 0x81, 0xC0, 0x1C, 0x30, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x76,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xF3,
  0xC0, 0x7F, 0xBC, 0x0F, 0x0F, 0xC0, 0xC0, 0x7C, 0x0C, 0x03, 0xC0, 0xC0,
  0x3C, 0x0C, 0x03, 0xC0, 0xC0, 0x3C, 0x0C, 0x03, 0xC0, 0xC0, 0x3C, 0x0C,
  0x03, 0xC0, 0xC0, 0x3C, 0x0C, 0x03, 0xC0, 0xC0, 0x3C, 0x0C, 0x03, 0xC0,
  0xE0, 0x7C, 0x07, 0x9F, 0xC0, 0x3F, 0xBC, 0x00, 0xC0, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x19,
  0x80, 0x01, 0x98, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x60, 0xE0, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x18,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x30, 0x01, 0xC3, 0x00, 0x0C, 0x30, 0x00,
  0xC7, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x70, 0xFF, 0xF0, 0x7F, 0xFE, 0x30, 0x03, 0x98, 0x00,
  0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0xE6, 0x01, 0xE3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xC0, 0x1E, 0x60, 0x03, 0xB0, 0x00, 0xD8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xD8, 0x00, 0xEC, 0x01, 0xE7, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xE0,
  0x0F, 0xFC, 0x0F, 0x0F, 0x0E, 0x01, 0xCE, 0x00, 0x76, 0x00, 0x1B, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x66, 0x00, 0x73,
  0x80, 0x70, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x3C,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E,
  0xC0, 0x1C, 0xC0, 0x3C, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0x0F, 0x0E, 0x01, 0xCE, 0x00, 0x76, 0x00,
  0x1B, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x66,
  0x00, 0x73, 0x80, 0x70, 0xFF, 0xF0, 0x1F, 0xE0, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB8, 0x00, 0x66, 0x00,
  0x19, 0xC0, 0x0C, 0x38, 0x07, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xC0, 0x01,
  0xF0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x06, 0x30, 0x03, 0x8C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xC0, 0x60,
  0x30, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x07, 0x0C,
  0x00, 0xC3, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xCC, 0x00, 0x33, 0x00,
  0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1C, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x2F, 0x60, 0x1B, 0xD8, 0x06, 0xF2, 0x01, 0x3C, 0xC0, 0xCF, 0x30, 0x33,
  0xC4, 0x18, 0xF1, 0x86, 0x3C, 0x61, 0x0F, 0x0C, 0xC3, 0xC3, 0x30, 0xF0,
  0xC8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xC0, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0C, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xD8, 0x03, 0xD8, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC, 0x03, 0xC6, 0x03,
  0xC6, 0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC0, 0xC3, 0xC0, 0xC3, 0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x63,
  0xC0, 0x33, 0xC0, 0x33, 0xC0, 0x1B, 0xC0, 0x1B, 0xC0, 0x1B, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x1F, 0xF8, 0x38, 0x3C,
  0x70, 0x0E, 0xE0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8C, 0x00, 0x73, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFC,
  0x0F, 0x0F, 0x0E, 0x01, 0xCE, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xE6, 0x00, 0x63, 0x80, 0x70,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8C, 0x00, 0xF3, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x01, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x30,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xC0, 0x30, 0x30, 0x0E, 0x0C, 0x01,
  0x83, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x03, 0x8C, 0x00, 0x63, 0x00, 0x1C,
  0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x1C, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xC1, 0xF0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1D, 0x80,
  0x07, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x01,
  0x8E, 0x01, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0C, 0x3F,
  0xF8, 0x0F, 0xF0, 0xC0, 0x00, 0x3E, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x38,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x39, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1B, 0x01,
  0x20, 0x66, 0x04, 0x81, 0x98, 0x12, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30,
  0x66, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0x84, 0x11, 0x82, 0x10, 0xC3,
  0x08, 0x43, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x18, 0xC3, 0x18,
  0x63, 0x0C, 0x40, 0x8C, 0x31, 0x02, 0x20, 0xC4, 0x08, 0x81, 0xB0, 0x36,
  0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x68, 0x0D, 0x81, 0xA0, 0x36, 0x06,
  0x80, 0x58, 0x1A, 0x01, 0x60, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x00, 0x38, 0xC0, 0x01, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x38, 0x0C, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0x60, 0x18, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x30,
  0x00, 0x1C, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x07, 0x00, 0x0C, 0x0C, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0x80,
  0x06, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xEE, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0x60, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x06,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x01, 0xCE, 0x00, 0x61, 0x80, 0x38, 0x70, 0x0C, 0x0C, 0x07, 0x03, 0x01,
  0x80, 0x60, 0xE0, 0x18, 0x38, 0x07, 0x0C, 0x00, 0xC7, 0x00, 0x3B, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xC1, 0xC1, 0x81, 0xC0,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x86, 0x00, 0xE7, 0x00, 0x3B, 0x00,
  0x0D, 0x80, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x63,
  0xFF, 0xF3, 0xFF, 0xFB, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x6C, 0xFF,
  0xE6, 0x3F, 0xE3, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCF, 0xF8, 0xD8, 0x1C, 0xF0,
  0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0xF0,
  0x0E, 0xDF, 0xFC, 0xC7, 0xF0, 0x07, 0xF0, 0x0F, 0xFC, 0x0E, 0x07, 0x8E,
  0x00, 0xCE, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x66,
  0x00, 0x73, 0x80, 0x70, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x0F, 0xE3,
  0x3F, 0xF3, 0x78, 0x1B, 0x60, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0x70, 0x1B, 0x3E, 0xFB, 0x1F, 0xE3, 0x07, 0xE0,
  0x1F, 0xF8, 0x38, 0x1C, 0x60, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x06, 0x70, 0x0E, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xC3, 0x3F, 0xF3, 0x78, 0x1B, 0x60, 0x0F, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x60, 0x0F, 0x70, 0x1B, 0x3F, 0xF3, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1E,
  0x3F, 0xF8, 0x3F, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCF, 0xF8, 0xD8, 0x1C,
  0xF0, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x3C, 0x7F, 0xF0, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07,
  0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x1C, 0x30,
  0x06, 0x0C, 0x03, 0x83, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xC0, 0xE0, 0x30, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xE0,
  0xC0, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30,
  0x00, 0xEC, 0x00, 0x1C, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xE0, 0xCF, 0x87, 0x9B, 0xF9, 0xFB, 0x43, 0x43, 0xF0, 0x70, 0x3E,
  0x06, 0x07, 0xC0, 0xC0, 0xF8, 0x18, 0x1F, 0x03, 0x03, 0xE0, 0x60, 0x7C,
  0x0C, 0x0F, 0x81, 0x81, 0xF0, 0x30, 0x3E, 0x06, 0x07, 0xC0, 0xC0, 0xF8,
  0x18, 0x1F, 0x03, 0x03, 0xE0, 0x60, 0x7C, 0x0C, 0x0F, 0x81, 0x81, 0xF0,
  0x30, 0x3E, 0x06, 0x07, 0xC0, 0xC0, 0xF8, 0x18, 0x1F, 0x03, 0x03, 0xC7,
  0xF0, 0xCF, 0xF8, 0xD8, 0x1C, 0xF0, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x07,
  0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x60, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x3F, 0xFC, 0x0F, 0xF0, 0xC7,
  0xF0, 0xCF, 0xF8, 0xD8, 0x1C, 0xF0, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xE0, 0x06, 0xF0, 0x0E, 0xDF, 0xFC, 0xC7, 0xF0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x0F, 0xE3, 0x3F, 0xF3, 0x78, 0x1B, 0x60, 0x0F, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x07, 0x70, 0x1B, 0x3E,
  0xFB, 0x1F, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xE3, 0xF0, 0x77, 0xFE, 0x3B,
  0x03, 0x9E, 0x00, 0xEF, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0x80, 0x71, 0xC0, 0x0E, 0x60, 0x01, 0x98, 0x00, 0x76,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x01, 0x9C, 0x00, 0xE3,
  0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x1C,
  0x3F, 0xF8, 0x0F, 0xF0, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0x67,
  0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x38, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x81, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x90, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x66, 0x07, 0x01,
  0x98, 0x1E, 0x06, 0x60, 0x78, 0x19, 0x81, 0x20, 0x66, 0x04, 0x81, 0x98,
  0x32, 0x0C, 0x30, 0xCC, 0x30, 0xC3, 0x30, 0xC3, 0x08, 0xC3, 0x0C, 0x21,
  0x0C, 0x31, 0x84, 0x30, 0xC6, 0x19, 0x81, 0x98, 0x66, 0x06, 0x61, 0x98,
  0x19, 0x06, 0x60, 0x64, 0x09, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x60, 0x00,
  0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x0C, 0x03, 0x00, 0xE0,
  0x70, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00,
  0x31, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0x60, 0x0C, 0x07, 0x01, 0xC0, 0x30,
  0x18, 0x01, 0x83, 0x00, 0x1C, 0x70, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00,
  0x76, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x80,
  0x1C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E,
  0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00,
  0x38, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0,
  0x07, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xDF, 0xC0, 0x3C, 0x38, 0x0F, 0x07, 0x03, 0xC0,
  0xE0, 0xF0, 0x1C, 0x7C, 0x03, 0xFB, 0x00, 0x3C,
};

const GFXglyph JetBrainsMono_Thin43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 5, 31, 26, 11, -31 },
  { 21, 12, 13, 26, 7, -31 },
  { 41, 23, 31, 26, 1, -31 },
  { 131, 18, 43, 26, 4, -37 },
  { 228, 24, 32, 26, 1, -32 },
  { 324, 21, 32, 26, 3, -32 },
  { 408, 3, 13, 26, 11, -31 },
  { 413, 12, 41, 26, 9, -36 },
  { 475, 12, 41, 26, 5, -36 },
  { 537, 22, 22, 26, 2, -26 },
  { 598, 20, 20, 26, 3, -24 },
  { 648, 7, 14, 26, 8, -7 },
  { 661, 14, 2, 26, 6, -15 },
  { 665, 6, 6, 26, 10, -6 },
  { 670, 18, 41, 26, 4, -36 },
  { 763, 18, 32, 26, 4, -32 },
  { 835, 19, 31, 26, 4, -31 },
  { 909, 19, 32, 26, 4, -32 },
  { 985, 17, 31, 26, 4, -31 },
  { 1051, 17, 31, 26, 4, -31 },
  { 1117, 18, 31, 26, 4, -31 },
  { 1187, 18, 31, 26, 4, -31 },
  { 1257, 19, 31, 26, 4, -31 },
  { 1331, 18, 32, 26, 4, -32 },
  { 1403, 18, 32, 26, 4, -32 },
  { 1475, 6, 24, 26, 10, -24 },
  { 1493, 8, 31, 26, 8, -24 },
  { 1524, 18, 22, 26, 4, -25 },
  { 1574, 18, 12, 26, 4, -20 },
  { 1601, 18, 22, 26, 4, -25 },
  { 1651, 15, 31, 26, 7, -31 },
  { 1710, 20, 40, 26, 3, -32 },
  { 1810, 20, 31, 26, 3, -31 },
  { 1888, 17, 31, 26, 5, -31 },
  { 1954, 17, 32, 26, 5, -32 },
  { 2022, 16, 31, 26, 5, -31 },
  { 2084, 17, 31, 26, 5, -31 },
  { 2150, 18, 31, 26, 5, -31 },
  { 2220, 17, 32, 26, 5, -32 },
  { 2288, 16, 31, 26, 5, -31 },
  { 2350, 16, 31, 26, 5, -31 },
  { 2412, 18, 31, 26, 3, -31 },
  { 2482, 18, 31, 26, 5, -31 },
  { 2552, 18, 31, 26, 5, -31 },
  { 2622, 18, 31, 26, 4, -31 },
  { 2692, 16, 31, 26, 5, -31 },
  { 2754, 16, 32, 26, 5, -32 },
  { 2818, 18, 31, 26, 5, -31 },
  { 2888, 17, 40, 26, 5, -32 },
  { 2973, 18, 31, 26, 5, -31 },
  { 3043, 18, 32, 26, 4, -32 },
  { 3115, 20, 31, 26, 3, -31 },
  { 3193, 16, 31, 26, 5, -31 },
  { 3255, 20, 31, 26, 3, -31 },
  { 3333, 22, 31, 26, 2, -31 },
  { 3419, 22, 31, 26, 2, -31 },
  { 3505, 22, 31, 26, 2, -31 },
  { 3591, 18, 31, 26, 4, -31 },
  { 3661, 10, 41, 26, 9, -36 },
  { 3713, 18, 41, 26, 4, -36 },
  { 3806, 9, 41, 26, 7, -36 },
  { 3853, 18, 16, 26, 4, -31 },
  { 3889, 20, 2, 26, 3, 1 },
  { 3894, 7, 6, 26, 9, -34 },
  { 3900, 17, 24, 26, 4, -24 },
  { 3951, 16, 31, 26, 5, -31 },
  { 4013, 17, 24, 26, 5, -24 },
  { 4064, 16, 31, 26, 5, -31 },
  { 4126, 16, 24, 26, 5, -24 },
  { 4174, 19, 31, 26, 3, -31 },
  { 4248, 16, 32, 26, 5, -24 },
  { 4312, 16, 31, 26, 5, -31 },
  { 4374, 19, 33, 26, 4, -33 },
  { 4453, 15, 41, 26, 4, -33 },
  { 4530, 18, 31, 26, 5, -31 },
  { 4600, 21, 31, 26, 2, -31 },
  { 4682, 19, 24, 26, 3, -24 },
  { 4739, 16, 24, 26, 5, -24 },
  { 4787, 16, 24, 26, 5, -24 },
  { 4835, 16, 32, 26, 5, -24 },
  { 4899, 16, 32, 26, 5, -24 },
  { 4963, 17, 24, 26, 5, -24 },
  { 5014, 18, 24, 26, 4, -24 },
  { 5068, 19, 30, 26, 3, -30 },
  { 5140, 16, 24, 26, 5, -24 },
  { 5188, 20, 24, 26, 3, -24 },
  { 5248, 22, 24, 26, 2, -24 },
  { 5314, 20, 24, 26, 3, -24 },
  { 5374, 20, 32, 26, 3, -24 },
  { 5454, 17, 24, 26, 4, -24 },
  { 5505, 18, 41, 26, 4, -36 },
  { 5598, 2, 41, 26, 12, -36 },
  { 5609, 18, 41, 26, 4, -36 },
  { 5702, 18, 8, 26, 4, -19 },
};

const GFXfont JetBrainsMono_Thin43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_THIN43PT7B_H_
