#ifndef _JETBRAINSMONO_THIN60PT7B_H_
#define _JETBRAINSMONO_THIN60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin60pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7E,
  0xFF, 0xFF, 0xF3, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x07, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x60, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0C, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7E, 0xFF, 0xC0,
  0x3C, 0x38, 0xF8, 0x1E, 0x0E, 0x0F, 0x0F, 0x03, 0x81, 0xC3, 0x80, 0xE0,
  0x78, 0xE0, 0x38, 0x0E, 0x70, 0x0E, 0x03, 0x9C, 0x03, 0x80, 0xE7, 0x00,
  0xE0, 0x39, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0xC3, 0x80,
  0x00, 0xF8, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x7C, 0x00,
  0x03, 0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x01, 0xF8, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0x70,
  0x0E, 0x03, 0xDC, 0x03, 0x80, 0xE7, 0x80, 0xE0, 0x78, 0xF0, 0x38, 0x3C,
  0x1E, 0x0E, 0x1F, 0x03, 0xF3, 0x9F, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC3, 0xFF, 0x00, 0x00, 0xE1,
  0xF7, 0xE0, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x18, 0x30, 0x07, 0x00, 0x0E,
  0x1C, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x01, 0x81, 0xC0, 0x0C, 0x00,
  0xE0, 0x70, 0x03, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x30,
  0x0E, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0xC0, 0x07, 0x00, 0x70, 0x70, 0x00, 0xC0, 0x1C, 0x38, 0x00, 0x38,
  0x0E, 0x0C, 0x00, 0x07, 0xFF, 0x87, 0x00, 0x00, 0xFF, 0xC3, 0x80, 0x00,
  0x1F, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x81,
  0xF0, 0x00, 0x01, 0xC1, 0xFF, 0x00, 0x00, 0x60, 0xFF, 0xE0, 0x00, 0x38,
  0x70, 0x3C, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0xE0, 0x03,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x30, 0x03, 0x80,
  0x30, 0x0C, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x0E,
  0x07, 0x00, 0x30, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x80,
  0x38, 0x70, 0x00, 0xE0, 0x0E, 0x18, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x07,
  0xC7, 0xC7, 0x00, 0x00, 0xFF, 0xE3, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0x9C, 0x07, 0x00, 0x1C, 0xF0, 0x0E, 0x00, 0x73, 0x80, 0x3C, 0x03, 0x8E,
  0x00, 0x78, 0x0E, 0x38, 0x00, 0xE0, 0x70, 0xE0, 0x01, 0xC3, 0xC3, 0x80,
  0x07, 0x8E, 0x0E, 0x00, 0x0F, 0x78, 0x38, 0x00, 0x1D, 0xC0, 0xE0, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0xF8, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x3F, 0x03, 0x80, 0x01, 0xFE, 0x0F, 0x00, 0x0F, 0x3C,
  0x1C, 0x00, 0x78, 0x70, 0x78, 0x03, 0xC0, 0xE0, 0xF8, 0x3E, 0x01, 0xC1,
  0xFF, 0xF0, 0x07, 0x83, 0xFF, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x03, 0x80, 0x07,
  0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x78, 0x01, 0xFF, 0x00, 0xC0, 0x3F, 0xFF, 0x83, 0x07,
  0xFC, 0xFF, 0x8C, 0x7F, 0xC0, 0x7F, 0xB7, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0xE7,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xCE, 0x00, 0x03, 0xE3, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0xF8, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x02, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0x03, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x28, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E,
  0x00, 0x07, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x3F, 0x00,
  0x70, 0xFF, 0xE0, 0x73, 0xFF, 0xF0, 0x77, 0x80, 0xF8, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x1F, 0x81, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE3, 0xFE, 0x00, 0x73, 0xFF, 0xE0, 0x1F, 0xE1, 0xFC, 0x0F,
  0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x38, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x0F,
  0x80, 0x07, 0xCF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x03, 0xF0, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xC1, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x07, 0xFF, 0xEE, 0x00,
  0x7F, 0xE7, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0x03, 0x00, 0xFC, 0x1F, 0xE1, 0xFE, 0x3F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x07,
  0xFF, 0x3F, 0x00, 0x7F, 0xFD, 0xF8, 0x03, 0xC0, 0x6F, 0xC0, 0x3C, 0x01,
  0xFE, 0x01, 0xC0, 0x07, 0xF0, 0x0E, 0x00, 0x3F, 0x80, 0x70, 0x00, 0xFC,
  0x03, 0x80, 0x07, 0xE0, 0x1C, 0x00, 0x3F, 0x00, 0xE0, 0x01, 0xF8, 0x07,
  0x00, 0x0F, 0xC0, 0x38, 0x00, 0x7E, 0x01, 0xC0, 0x03, 0xF0, 0x0E, 0x00,
  0x1F, 0x80, 0x70, 0x00, 0xFC, 0x03, 0x80, 0x07, 0xE0, 0x1C, 0x00, 0x3F,
  0x00, 0xE0, 0x03, 0xF8, 0x07, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0xFE, 0x00,
  0xE0, 0x0F, 0xF0, 0x07, 0xC1, 0xDF, 0x80, 0x1F, 0xFC, 0xFC, 0x00, 0x7F,
  0xC7, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x03, 0xF0, 0xFE, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0x71, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x07, 0xC0, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x02, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0x00, 0x3F, 0x0E, 0x00, 0x1F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70,
  0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x1E, 0x70, 0x00, 0xF8, 0xE0, 0x03,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xF0,
  0xFE, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x71, 0xC0,
  0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x07, 0xC0, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x80,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x07,
  0xC0, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xD8, 0x00, 0x1B,
  0xDC, 0x00, 0x3B, 0xDC, 0x00, 0x33, 0xCC, 0x00, 0x33, 0xCE, 0x00, 0x73,
  0xC6, 0x00, 0x63, 0xC6, 0x00, 0x63, 0xC7, 0x00, 0xE3, 0xC3, 0x00, 0xC3,
  0xC3, 0x80, 0xC3, 0xC3, 0x81, 0xC3, 0xC1, 0x81, 0x83, 0xC1, 0xC1, 0x83,
  0xC0, 0xC3, 0x83, 0xC0, 0xC3, 0x03, 0xC0, 0xE7, 0x03, 0xC0, 0x66, 0x03,
  0xC0, 0x66, 0x03, 0xC0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xD8,
  0x00, 0x0F, 0x70, 0x00, 0x3C, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00,
  0x0F, 0x18, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x80, 0x0F,
  0x0E, 0x00, 0x3C, 0x18, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x03,
  0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x18, 0x03, 0xC0, 0x70, 0x0F, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0xF0, 0x0E, 0x03, 0xC0, 0x18, 0x0F, 0x00, 0x70, 0x3C,
  0x01, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x0E, 0x0F, 0x00, 0x18, 0x3C, 0x00,
  0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x18,
  0xF0, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0,
  0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1C, 0x00, 0x1F, 0x8E, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x3D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC7, 0x00, 0x0F,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xC0, 0x0F, 0x03, 0xC0,
  0x03, 0xC1, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1C,
  0x00, 0x1F, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x07, 0x9C, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xF0, 0x1F,
  0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x70, 0x03,
  0xE0, 0x0E, 0x70, 0x03, 0xE0, 0x0E, 0x70, 0x07, 0x60, 0x0E, 0x70, 0x07,
  0x60, 0x0E, 0x70, 0x06, 0x60, 0x0E, 0x70, 0x06, 0x60, 0x0E, 0x30, 0x06,
  0x60, 0x0C, 0x30, 0x06, 0x70, 0x0C, 0x38, 0x06, 0x70, 0x1C, 0x38, 0x0E,
  0x70, 0x1C, 0x38, 0x0E, 0x30, 0x1C, 0x38, 0x0C, 0x30, 0x1C, 0x38, 0x0C,
  0x30, 0x1C, 0x38, 0x0C, 0x30, 0x1C, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x0C,
  0x38, 0x18, 0x1C, 0x1C, 0x38, 0x18, 0x1C, 0x1C, 0x18, 0x38, 0x1C, 0x18,
  0x18, 0x38, 0x1C, 0x18, 0x18, 0x38, 0x1C, 0x18, 0x18, 0x38, 0x1C, 0x18,
  0x18, 0x38, 0x0C, 0x18, 0x1C, 0x30, 0x0C, 0x38, 0x1C, 0x30, 0x0E, 0x38,
  0x0C, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x0E, 0x30,
  0x0C, 0x70, 0x0E, 0x30, 0x0C, 0x70, 0x0E, 0x30, 0x0E, 0x70, 0x06, 0x30,
  0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x06, 0x60, 0x07, 0x60,
  0x06, 0x60, 0x07, 0x60, 0x06, 0xE0, 0x07, 0x60, 0x06, 0xE0, 0x07, 0x60,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x80, 0x01, 0xE3, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xC1, 0xC0, 0x03,
  0x81, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C,
  0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0xFC, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0x80,
  0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0xDC,
  0xF0, 0x00, 0xEE, 0x3F, 0x03, 0xE7, 0x0F, 0xFF, 0xE3, 0x83, 0xFF, 0xC1,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x07,
  0x0F, 0xFC, 0x0E, 0x7F, 0xFC, 0x1D, 0xE0, 0x7E, 0x3F, 0x00, 0x3C, 0x7C,
  0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0x7C, 0x00, 0x3C, 0xFC,
  0x00, 0xF1, 0xDE, 0x07, 0xE3, 0x9F, 0xFF, 0x07, 0x0F, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0x81, 0xF8, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x7C, 0x0F,
  0xC1, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x38, 0x1F, 0xF8, 0x70, 0x7F, 0xFC,
  0xE3, 0xF0, 0x3D, 0xC7, 0x80, 0x1F, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03,
  0xDE, 0x00, 0x07, 0x9E, 0x00, 0x1F, 0x1E, 0x00, 0x7E, 0x3F, 0x03, 0xDC,
  0x1F, 0xFF, 0x38, 0x1F, 0xF8, 0x70, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x07, 0xFE, 0x1C, 0x1F, 0xFF, 0x38, 0xFC, 0x0F, 0x71, 0xE0,
  0x07, 0xE7, 0x80, 0x07, 0xDE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0xF8, 0xF0, 0x03, 0xF1, 0xF8, 0x1E, 0xE0, 0xFF,
  0xF9, 0xC0, 0xFF, 0xC3, 0x80, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x60, 0x07, 0x0F, 0xFC, 0x0E, 0x7F, 0xFC, 0x1D, 0xE0,
  0x7E, 0x3F, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x78,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0E, 0x01, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x01, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF0, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x80, 0x18, 0x31, 0xFC, 0x3F, 0xCC, 0xFF, 0x9F, 0xFB,
  0x61, 0xE6, 0x1E, 0xD0, 0x3D, 0x03, 0xF8, 0x07, 0x80, 0x7E, 0x01, 0xE0,
  0x1F, 0x80, 0x70, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00,
  0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E,
  0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00,
  0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03,
  0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8,
  0x03, 0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01,
  0xF8, 0x03, 0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C,
  0x01, 0xF8, 0x03, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC3, 0xFF, 0x03, 0x9F,
  0xFF, 0x07, 0x78, 0x1F, 0x8E, 0xC0, 0x0F, 0x1F, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x18, 0x01, 0xC3, 0xFF, 0x03, 0x9F, 0xFF,
  0x07, 0x78, 0x1F, 0x8F, 0xC0, 0x0F, 0x1F, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x80, 0x00,
  0xEF, 0x00, 0x03, 0xDF, 0x00, 0x0F, 0x3F, 0x00, 0x3C, 0x77, 0x81, 0xF0,
  0xE7, 0xFF, 0xC1, 0xC3, 0xFF, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFE, 0x1C, 0x1F, 0xFF, 0x38, 0xFC,
  0x0F, 0x71, 0xE0, 0x07, 0xE7, 0x80, 0x07, 0xDE, 0x00, 0x07, 0xB8, 0x00,
  0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x80,
  0x01, 0xE7, 0x80, 0x07, 0xC7, 0x80, 0x1F, 0x8F, 0xC0, 0xF7, 0x07, 0xFF,
  0xCE, 0x07, 0xFE, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x01, 0xC3, 0xFF, 0x03, 0x9F, 0xFF, 0x87, 0x78, 0x1F, 0x8E,
  0xC0, 0x0F, 0x9F, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F,
  0x00, 0xFC, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x3F,
  0x00, 0x7C, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xD8, 0x01, 0xE0,
  0x06, 0x70, 0x07, 0x80, 0x39, 0xC0, 0x3B, 0x00, 0xE7, 0x00, 0xCC, 0x03,
  0x9C, 0x03, 0x30, 0x0E, 0x70, 0x0C, 0xC0, 0x38, 0xC0, 0x33, 0x00, 0xC3,
  0x81, 0xCE, 0x07, 0x0E, 0x07, 0x18, 0x1C, 0x38, 0x18, 0x60, 0x70, 0xE0,
  0x61, 0x81, 0xC3, 0x81, 0x86, 0x07, 0x06, 0x06, 0x1C, 0x18, 0x1C, 0x38,
  0x70, 0xE0, 0x70, 0xC0, 0xC3, 0x81, 0xC3, 0x03, 0x0E, 0x07, 0x0C, 0x0C,
  0x38, 0x1C, 0x30, 0x38, 0xE0, 0x31, 0xC0, 0xE3, 0x00, 0xE6, 0x01, 0x9C,
  0x03, 0x98, 0x06, 0x70, 0x0E, 0x60, 0x19, 0xC0, 0x39, 0x80, 0x77, 0x00,
  0xEE, 0x01, 0xD8, 0x01, 0xB8, 0x07, 0x60, 0x07, 0xC0, 0x0D, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x3C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x3C,
  0x1C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x0E,
  0x01, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xCF, 0xF0, 0x00, 0x77, 0xFF, 0x00, 0x1D, 0xC1, 0xE0, 0x07,
  0xE0, 0x3C, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x00, 0xE0, 0x1F, 0x80, 0x1C,
  0x07, 0xE0, 0x03, 0xC7, 0xB8, 0x00, 0x7F, 0xCE, 0x00, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_Thin60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 7, 44, 36, 15, -44 },
  { 40, 16, 18, 36, 10, -44 },
  { 76, 32, 44, 36, 2, -44 },
  { 252, 26, 60, 36, 5, -52 },
  { 447, 34, 44, 36, 1, -44 },
  { 634, 30, 45, 36, 4, -44 },
  { 803, 4, 18, 36, 16, -44 },
  { 812, 17, 57, 36, 12, -50 },
  { 934, 17, 57, 36, 7, -50 },
  { 1056, 30, 31, 36, 3, -37 },
  { 1173, 28, 28, 36, 4, -34 },
  { 1271, 10, 19, 36, 11, -9 },
  { 1295, 20, 3, 36, 8, -21 },
  { 1303, 8, 9, 36, 14, -8 },
  { 1312, 24, 57, 36, 6, -50 },
  { 1483, 24, 45, 36, 6, -44 },
  { 1618, 26, 44, 36, 6, -44 },
  { 1761, 27, 44, 36, 5, -44 },
  { 1910, 24, 45, 36, 5, -44 },
  { 2045, 23, 44, 36, 6, -44 },
  { 2172, 24, 45, 36, 6, -44 },
  { 2307, 26, 45, 36, 5, -44 },
  { 2454, 27, 44, 36, 5, -44 },
  { 2603, 26, 45, 36, 5, -44 },
  { 2750, 26, 44, 36, 5, -44 },
  { 2893, 8, 35, 36, 14, -34 },
  { 2928, 12, 44, 36, 11, -34 },
  { 2994, 26, 30, 36, 5, -35 },
  { 3092, 24, 16, 36, 6, -28 },
  { 3140, 26, 30, 36, 5, -35 },
  { 3238, 20, 44, 36, 10, -44 },
  { 3348, 29, 55, 36, 4, -44 },
  { 3548, 28, 44, 36, 4, -44 },
  { 3702, 24, 44, 36, 7, -44 },
  { 3834, 25, 45, 36, 6, -44 },
  { 3975, 23, 44, 36, 7, -44 },
  { 4102, 24, 44, 36, 7, -44 },
  { 4234, 25, 44, 36, 7, -44 },
  { 4372, 25, 45, 36, 6, -44 },
  { 4513, 22, 44, 36, 7, -44 },
  { 4634, 22, 44, 36, 7, -44 },
  { 4755, 25, 45, 36, 4, -44 },
  { 4896, 25, 44, 36, 7, -44 },
  { 5034, 25, 44, 36, 7, -44 },
  { 5172, 24, 44, 36, 6, -44 },
  { 5304, 22, 44, 36, 7, -44 },
  { 5425, 24, 45, 36, 6, -44 },
  { 5560, 25, 44, 36, 7, -44 },
  { 5698, 25, 55, 36, 6, -44 },
  { 5870, 25, 44, 36, 7, -44 },
  { 6008, 26, 45, 36, 5, -44 },
  { 6155, 28, 44, 36, 4, -44 },
  { 6309, 24, 45, 36, 6, -44 },
  { 6444, 28, 44, 36, 4, -44 },
  { 6598, 32, 44, 36, 2, -44 },
  { 6774, 30, 44, 36, 3, -44 },
  { 6939, 30, 44, 36, 3, -44 },
  { 7104, 25, 44, 36, 5, -44 },
  { 7242, 14, 57, 36, 13, -50 },
  { 7342, 24, 57, 36, 6, -50 },
  { 7513, 14, 57, 36, 9, -50 },
  { 7613, 24, 24, 36, 6, -44 },
  { 7685, 28, 3, 36, 4, 1 },
  { 7696, 10, 8, 36, 12, -47 },
  { 7706, 25, 35, 36, 5, -34 },
  { 7816, 23, 45, 36, 7, -44 },
  { 7946, 24, 35, 36, 6, -34 },
  { 8051, 23, 45, 36, 6, -44 },
  { 8181, 24, 35, 36, 6, -34 },
  { 8286, 27, 44, 36, 4, -44 },
  { 8435, 23, 45, 36, 6, -34 },
  { 8565, 23, 44, 36, 7, -44 },
  { 8692, 26, 46, 36, 6, -46 },
  { 8842, 21, 57, 36, 6, -46 },
  { 8992, 25, 44, 36, 7, -44 },
  { 9130, 29, 44, 36, 3, -44 },
  { 9290, 26, 34, 36, 5, -34 },
  { 9401, 23, 34, 36, 7, -34 },
  { 9499, 24, 35, 36, 6, -34 },
  { 9604, 23, 45, 36, 7, -34 },
  { 9734, 23, 45, 36, 6, -34 },
  { 9864, 23, 34, 36, 8, -34 },
  { 9962, 24, 35, 36, 6, -34 },
  { 10067, 26, 42, 36, 4, -42 },
  { 10204, 24, 34, 36, 6, -33 },
  { 10306, 26, 33, 36, 5, -33 },
  { 10414, 30, 33, 36, 3, -33 },
  { 10538, 28, 33, 36, 4, -33 },
  { 10654, 26, 44, 36, 5, -33 },
  { 10797, 24, 33, 36, 6, -33 },
  { 10896, 24, 57, 36, 6, -50 },
  { 11067, 4, 57, 36, 16, -50 },
  { 11096, 24, 57, 36, 6, -50 },
  { 11267, 26, 11, 36, 5, -27 },
};

const GFXfont JetBrainsMono_Thin60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_THIN60PT7B_H_
