#ifndef _JETBRAINSMONO_THIN8PT7B_H_
#define _JETBRAINSMONO_THIN8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xFC, 0x52, 0x9E, 0xAF, 0x30, 0x5F, 0xE6, 0xFA, 0xCD, 0x98,
  0x66, 0xDC, 0xD6, 0x7B, 0xC0, 0xE0, 0x6A, 0xA9, 0x95, 0x56, 0x2F, 0x25,
  0x4B, 0xA0, 0xC0, 0xE0, 0x80, 0x24, 0xA5, 0x24, 0xF6, 0xFB, 0xC0, 0x59,
  0x25, 0xC0, 0xF4, 0x95, 0xC0, 0xE9, 0x1B, 0xC0, 0x2A, 0x5E, 0x40, 0xF3,
  0x93, 0xC0, 0x4B, 0x5B, 0xC0, 0xF4, 0xA4, 0x80, 0xF6, 0xFB, 0xC0, 0xF6,
  0xF4, 0x80, 0x90, 0x98, 0x2A, 0x30, 0xFC, 0x88, 0xE0, 0xC4, 0xA0, 0x80,
  0xF7, 0xDB, 0xF0, 0x5A, 0xDF, 0x40, 0xD7, 0xDB, 0xC0, 0xF6, 0x4B, 0xC0,
  0xD6, 0xDB, 0xC0, 0xF3, 0xC9, 0xC0, 0xF2, 0x79, 0x00, 0xF6, 0x7B, 0xC0,
  0xB7, 0xDB, 0x40, 0xE9, 0x25, 0xC0, 0x64, 0x9B, 0xC0, 0xB7, 0x6B, 0x40,
  0x92, 0x49, 0xC0, 0xB7, 0xDB, 0x40, 0xB6, 0xFF, 0x40, 0xF6, 0xDB, 0xC0,
  0xF6, 0xE9, 0x00, 0xF6, 0xDB, 0xC8, 0xF6, 0xEB, 0x40, 0xF6, 0x33, 0xC0,
  0xF2, 0x22, 0x22, 0xB6, 0xDB, 0xC0, 0xB6, 0xDC, 0x80, 0xBB, 0xFF, 0x55,
  0x95, 0x22, 0x59, 0x95, 0x52, 0x22, 0xE5, 0x29, 0xC0, 0xEA, 0xAB, 0x92,
  0x24, 0x89, 0xD5, 0x57, 0x5A, 0x80, 0xF0, 0x80, 0xEE, 0xF0, 0x9A, 0xDB,
  0xC0, 0xF2, 0x70, 0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0x6B, 0xA4, 0x80, 0xF6,
  0xBE, 0x9A, 0xDB, 0x40, 0x51, 0x25, 0xC0, 0x38, 0x92, 0x78, 0x92, 0xEB,
  0x40, 0xC4, 0x44, 0x43, 0xFF, 0xF0, 0xF6, 0xD0, 0xF6, 0xF0, 0xF6, 0xF8,
  0xF6, 0xF2, 0xF2, 0x40, 0xF8, 0xF0, 0x5D, 0x24, 0xC0, 0xB6, 0xF0, 0xB7,
  0x20, 0xBF, 0x55, 0xAB, 0x50, 0xB7, 0x24, 0xEA, 0x70, 0x29, 0x2C, 0x91,
  0xFF, 0x89, 0x26, 0x94, 0xBC,
};

const GFXglyph JetBrainsMono_Thin8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 3, 5, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 3, 6, 5, 1, -6 },
  { 17, 1, 3, 5, 2, -6 },
  { 18, 2, 8, 5, 2, -7 },
  { 20, 2, 8, 5, 1, -7 },
  { 22, 4, 4, 5, 0, -5 },
  { 24, 3, 4, 5, 1, -5 },
  { 26, 1, 2, 5, 2, -1 },
  { 27, 3, 1, 5, 1, -3 },
  { 28, 1, 1, 5, 2, -1 },
  { 29, 3, 8, 5, 1, -7 },
  { 32, 3, 6, 5, 1, -6 },
  { 35, 3, 6, 5, 1, -6 },
  { 38, 3, 6, 5, 1, -6 },
  { 41, 3, 6, 5, 1, -6 },
  { 44, 3, 6, 5, 1, -6 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 3, 6, 5, 1, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 3, 6, 5, 1, -6 },
  { 62, 1, 4, 5, 2, -4 },
  { 63, 1, 5, 5, 2, -4 },
  { 64, 3, 4, 5, 1, -5 },
  { 66, 3, 2, 5, 1, -4 },
  { 67, 3, 4, 5, 1, -5 },
  { 69, 3, 6, 5, 1, -6 },
  { 72, 3, 7, 5, 1, -6 },
  { 75, 3, 6, 5, 1, -6 },
  { 78, 3, 6, 5, 1, -6 },
  { 81, 3, 6, 5, 1, -6 },
  { 84, 3, 6, 5, 1, -6 },
  { 87, 3, 6, 5, 1, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 3, 6, 5, 1, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 3, 6, 5, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 3, 7, 5, 1, -6 },
  { 126, 3, 6, 5, 1, -6 },
  { 129, 3, 6, 5, 1, -6 },
  { 132, 4, 6, 5, 0, -6 },
  { 135, 3, 6, 5, 1, -6 },
  { 138, 3, 6, 5, 1, -6 },
  { 141, 4, 6, 5, 0, -6 },
  { 144, 4, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 0, -6 },
  { 150, 3, 6, 5, 1, -6 },
  { 153, 2, 8, 5, 2, -7 },
  { 155, 3, 8, 5, 1, -7 },
  { 158, 2, 8, 5, 1, -7 },
  { 160, 3, 3, 5, 1, -6 },
  { 162, 4, 1, 5, 0, 0 },
  { 163, 1, 1, 5, 2, -6 },
  { 164, 3, 4, 5, 1, -4 },
  { 166, 3, 6, 5, 1, -6 },
  { 169, 3, 4, 5, 1, -4 },
  { 171, 3, 6, 5, 1, -6 },
  { 174, 3, 4, 5, 1, -4 },
  { 176, 3, 6, 5, 1, -6 },
  { 179, 3, 5, 5, 1, -4 },
  { 181, 3, 6, 5, 1, -6 },
  { 184, 3, 6, 5, 1, -6 },
  { 187, 3, 7, 5, 1, -6 },
  { 190, 3, 6, 5, 1, -6 },
  { 193, 4, 6, 5, 0, -6 },
  { 196, 3, 4, 5, 1, -4 },
  { 198, 3, 4, 5, 1, -4 },
  { 200, 3, 4, 5, 1, -4 },
  { 202, 3, 5, 5, 1, -4 },
  { 204, 3, 5, 5, 1, -4 },
  { 206, 3, 4, 5, 1, -4 },
  { 208, 3, 4, 5, 1, -4 },
  { 210, 3, 6, 5, 1, -6 },
  { 213, 3, 4, 5, 1, -4 },
  { 215, 3, 4, 5, 1, -4 },
  { 217, 4, 4, 5, 0, -4 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 3, 5, 5, 1, -4 },
  { 223, 3, 4, 5, 1, -4 },
  { 225, 3, 8, 5, 1, -7 },
  { 228, 1, 8, 5, 2, -7 },
  { 229, 3, 8, 5, 1, -7 },
  { 232, 3, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_Thin8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_THIN8PT7B_H_
