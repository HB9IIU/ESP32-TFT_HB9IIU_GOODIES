#ifndef _JETBRAINSMONO_THIN6PT7B_H_
#define _JETBRAINSMONO_THIN6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xD0, 0xBB, 0xE0, 0xF5, 0xD0, 0xEA, 0xF0, 0x80,
  0x6A, 0x90, 0xFC, 0x5D, 0x80, 0x5C, 0xC0, 0xC0, 0x80, 0x5A, 0xA0, 0xFF,
  0xAB, 0xE5, 0x70, 0xF7, 0xFD, 0xF7, 0xBF, 0xD6, 0xEF, 0xF6, 0xA0, 0xB0,
  0xE4, 0xF0, 0xD8, 0xDA, 0xFF, 0xDC, 0x4D, 0xD0, 0xFF, 0xEB, 0xFF, 0xFB,
  0xFA, 0xEF, 0xFF, 0xEB, 0x64, 0xF0, 0xEF, 0xAB, 0xFF, 0xFF, 0xFF, 0xFA,
  0xFF, 0x40, 0xFB, 0xE7, 0xE9, 0x20, 0xFF, 0xAD, 0x20, 0xFE, 0xD0, 0xE9,
  0x50, 0xA9, 0x20, 0xEB, 0xEA, 0xB0, 0xA9, 0x50, 0xFC, 0xB0, 0xE0, 0x80,
  0xFF, 0x80, 0xBF, 0xEC, 0x7F, 0xEC, 0x7D, 0x20, 0xFF, 0xBF, 0x8A, 0xC0,
  0x65, 0x70, 0xBB, 0xC9, 0x30, 0xFF, 0x80, 0xFC, 0xFC, 0xFE, 0xFD, 0xE8,
  0xDC, 0xE9, 0x30, 0xFC, 0xAD, 0x00, 0xEE, 0x80, 0x6A, 0x80, 0xA9, 0x20,
  0xEC, 0xE9, 0x90, 0xFC, 0xAE, 0xA0, 0xC0,
};

const GFXglyph JetBrainsMono_Thin6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 2, 6, 4, 1, -5 },
  { 7, 3, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 1, 4, 1, -4 },
  { 12, 2, 6, 4, 1, -5 },
  { 14, 1, 6, 4, 1, -5 },
  { 15, 3, 3, 4, 0, -4 },
  { 17, 3, 2, 4, 0, -3 },
  { 18, 1, 2, 4, 1, -1 },
  { 19, 2, 1, 4, 1, -2 },
  { 20, 1, 1, 4, 1, -1 },
  { 21, 2, 6, 4, 1, -5 },
  { 23, 2, 4, 4, 1, -4 },
  { 24, 2, 4, 4, 1, -4 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 2, 4, 4, 1, -4 },
  { 28, 2, 4, 4, 1, -4 },
  { 29, 2, 4, 4, 1, -4 },
  { 30, 2, 4, 4, 1, -4 },
  { 31, 2, 4, 4, 1, -4 },
  { 32, 2, 4, 4, 1, -4 },
  { 33, 2, 4, 4, 1, -4 },
  { 34, 1, 3, 4, 1, -3 },
  { 35, 1, 4, 4, 1, -3 },
  { 36, 2, 3, 4, 1, -3 },
  { 37, 2, 2, 4, 1, -3 },
  { 38, 2, 3, 4, 1, -3 },
  { 39, 2, 4, 4, 1, -4 },
  { 40, 3, 5, 4, 0, -4 },
  { 42, 3, 4, 4, 0, -4 },
  { 44, 2, 4, 4, 1, -4 },
  { 45, 2, 4, 4, 1, -4 },
  { 46, 2, 4, 4, 1, -4 },
  { 47, 2, 4, 4, 1, -4 },
  { 48, 2, 4, 4, 1, -4 },
  { 49, 2, 4, 4, 1, -4 },
  { 50, 2, 4, 4, 1, -4 },
  { 51, 2, 4, 4, 1, -4 },
  { 52, 3, 4, 4, 0, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 2, 4, 4, 1, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 5, 4, 1, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 2, 4, 4, 1, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 3, 4, 4, 0, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 2, 4, 4, 1, -4 },
  { 76, 2, 6, 4, 1, -5 },
  { 78, 2, 6, 4, 1, -5 },
  { 80, 1, 6, 4, 1, -5 },
  { 81, 2, 2, 4, 1, -4 },
  { 82, 3, 1, 4, 0, 0 },
  { 83, 1, 1, 4, 1, -5 },
  { 84, 3, 3, 4, 0, -3 },
  { 86, 2, 4, 4, 1, -4 },
  { 87, 2, 3, 4, 1, -3 },
  { 88, 2, 4, 4, 1, -4 },
  { 89, 2, 3, 4, 1, -3 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 2, 4, 4, 1, -3 },
  { 93, 2, 4, 4, 1, -4 },
  { 94, 2, 5, 4, 1, -5 },
  { 96, 2, 6, 4, 1, -5 },
  { 98, 2, 4, 4, 1, -4 },
  { 99, 3, 4, 4, 0, -4 },
  { 101, 3, 3, 4, 0, -3 },
  { 103, 2, 3, 4, 1, -3 },
  { 104, 2, 3, 4, 1, -3 },
  { 105, 2, 4, 4, 1, -3 },
  { 106, 2, 4, 4, 1, -3 },
  { 107, 2, 3, 4, 1, -3 },
  { 108, 2, 3, 4, 1, -3 },
  { 109, 3, 4, 4, 0, -4 },
  { 111, 2, 3, 4, 1, -3 },
  { 112, 3, 3, 4, 0, -3 },
  { 114, 3, 3, 4, 0, -3 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 3, 4, 4, 0, -3 },
  { 120, 2, 3, 4, 1, -3 },
  { 121, 2, 6, 4, 1, -5 },
  { 123, 1, 6, 4, 1, -5 },
  { 124, 2, 6, 4, 1, -5 },
  { 126, 2, 1, 4, 1, -3 },
};

const GFXfont JetBrainsMono_Thin6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_THIN6PT7B_H_
