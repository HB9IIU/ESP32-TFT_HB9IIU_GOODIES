#ifndef _JETBRAINSMONO_THIN59PT7B_H_
#define _JETBRAINSMONO_THIN59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin59pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x00, 0xE0,
  0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x03,
  0x80, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x03, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x0F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xF3, 0x3F, 0x03, 0xC1, 0x87, 0xC1, 0xC0,
  0xC0, 0xE1, 0xC0, 0x60, 0x78, 0xE0, 0x30, 0x1C, 0xE0, 0x18, 0x0E, 0x70,
  0x0C, 0x03, 0xB8, 0x06, 0x01, 0xDC, 0x03, 0x00, 0xEE, 0x01, 0x80, 0x07,
  0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x78, 0x18, 0x00,
  0x1E, 0x0C, 0x00, 0x07, 0x86, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x19,
  0xF8, 0x00, 0x0C, 0x3E, 0x00, 0x06, 0x0F, 0x00, 0x03, 0x03, 0xC0, 0x01,
  0x80, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0E, 0x00,
  0x18, 0x07, 0xE0, 0x0C, 0x03, 0xF0, 0x06, 0x01, 0xF8, 0x03, 0x00, 0xFE,
  0x01, 0x80, 0x77, 0x00, 0xC0, 0x3B, 0xC0, 0x60, 0x38, 0xF0, 0x30, 0x3C,
  0x3C, 0x18, 0x3C, 0x0F, 0xCC, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x8F, 0xFE, 0x00, 0x03, 0x8F, 0x07,
  0x80, 0x01, 0x87, 0x01, 0xC0, 0x01, 0xC7, 0x00, 0x60, 0x01, 0xC3, 0x80,
  0x38, 0x00, 0xC1, 0xC0, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x70,
  0x07, 0x00, 0x60, 0x38, 0x03, 0x80, 0x60, 0x1C, 0x01, 0xC0, 0x70, 0x0E,
  0x00, 0xE0, 0x70, 0x07, 0x00, 0x70, 0x30, 0x03, 0x80, 0x38, 0x38, 0x01,
  0xC0, 0x1C, 0x38, 0x00, 0x70, 0x1C, 0x18, 0x00, 0x3C, 0x1E, 0x1C, 0x00,
  0x0F, 0xFE, 0x1C, 0x00, 0x03, 0xFC, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x07, 0xF8, 0x00, 0x03, 0x07,
  0xFE, 0x00, 0x03, 0x07, 0x87, 0x80, 0x03, 0x87, 0x00, 0xE0, 0x03, 0x83,
  0x80, 0x70, 0x01, 0x81, 0x80, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x01, 0xC0,
  0x60, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0,
  0x0C, 0x00, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x60, 0x03, 0x00, 0x30, 0x70,
  0x01, 0x80, 0x18, 0x70, 0x00, 0xE0, 0x1C, 0x30, 0x00, 0x70, 0x0E, 0x38,
  0x00, 0x1E, 0x1E, 0x38, 0x00, 0x07, 0xFE, 0x38, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E,
  0x07, 0x80, 0x0E, 0xF0, 0x1E, 0x00, 0xE7, 0x00, 0x70, 0x07, 0x38, 0x01,
  0xC0, 0x71, 0xC0, 0x0F, 0x03, 0x8E, 0x00, 0x3C, 0x38, 0x70, 0x00, 0xE1,
  0xC3, 0x80, 0x03, 0x9C, 0x1C, 0x00, 0x1E, 0xE0, 0xE0, 0x00, 0x7E, 0x07,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x7C, 0x0E, 0x00,
  0x03, 0xF0, 0x70, 0x00, 0x3B, 0x83, 0xC0, 0x03, 0xCE, 0x0E, 0x00, 0x3C,
  0x78, 0x78, 0x03, 0xC1, 0xC1, 0xF0, 0x7C, 0x07, 0x07, 0xFF, 0xC0, 0x1C,
  0x1F, 0xF8, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x07, 0x00, 0x09, 0xF0, 0x0E, 0x00, 0xF7, 0xF8, 0x1C, 0x0F, 0xF3,
  0xFE, 0x18, 0xFF, 0xC0, 0xFF, 0x33, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7E, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0x01, 0xF0, 0x03,
  0xC1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x70, 0x00,
  0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0x80, 0x7F,
  0x03, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7C, 0x07,
  0xF0, 0x1E, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x7C,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x07, 0xF0, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7D, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0xF8, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x20, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x03, 0xF0, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xF0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x7C, 0x0F, 0x81, 0xF8, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7,
  0x00, 0x03, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0xFF, 0x80,
  0x73, 0xFF, 0xE0, 0x77, 0xE3, 0xF0, 0x76, 0x00, 0xF8, 0x7C, 0x00, 0x3C,
  0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x1F, 0xC0, 0x03, 0x3F, 0xFC, 0x03,
  0xBF, 0xFF, 0x03, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x0F, 0xC0, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x07, 0x07, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0xC0,
  0x7E, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x78, 0x3F,
  0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xCE, 0x00, 0x3F, 0x8E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD,
  0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0xCF,
  0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F, 0x04, 0x00, 0x0F, 0x83, 0xF8, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xE8, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x06, 0x07, 0xE0, 0x03, 0xFE, 0x7E, 0x00,
  0x7F, 0xF7, 0xE0, 0x0F, 0x83, 0xFE, 0x01, 0xE0, 0x0F, 0xE0, 0x1C, 0x00,
  0xFE, 0x01, 0xC0, 0x07, 0xE0, 0x3C, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0,
  0x38, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0x80,
  0x07, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x38, 0x00, 0x7E,
  0x03, 0x80, 0x07, 0xE0, 0x38, 0x00, 0x7E, 0x01, 0xC0, 0x07, 0xE0, 0x1C,
  0x00, 0x7E, 0x01, 0xC0, 0x0F, 0xE0, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x3F,
  0xE0, 0x07, 0xFF, 0x7E, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x06,
  0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xE0,
  0x0F, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xE0, 0x01, 0xF8, 0xE0,
  0x00, 0x7C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1E,
  0x00, 0x7C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E,
  0x00, 0x78, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0x00,
  0x1F, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0x70, 0x01, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1E, 0x00, 0x7C, 0x38, 0x00,
  0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x0F, 0x81,
  0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x78, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x0F, 0x81, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0xE0,
  0x03, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFD, 0x80, 0x03,
  0xFE, 0xE0, 0x01, 0xBF, 0x70, 0x00, 0xDF, 0x98, 0x00, 0xEF, 0xCE, 0x00,
  0x67, 0xE3, 0x00, 0x73, 0xF1, 0x80, 0x31, 0xF8, 0xE0, 0x18, 0xFC, 0x30,
  0x1C, 0x7E, 0x18, 0x0C, 0x3F, 0x0E, 0x06, 0x1F, 0x83, 0x07, 0x0F, 0xC1,
  0xC3, 0x07, 0xE0, 0xE1, 0x83, 0xF0, 0x31, 0xC1, 0xF8, 0x1C, 0xC0, 0xFC,
  0x06, 0x60, 0x7E, 0x03, 0x70, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x0F,
  0xC0, 0x38, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7E, 0xC0, 0x00, 0xFD, 0xC0, 0x01, 0xF9, 0x80, 0x03, 0xF3,
  0x00, 0x07, 0xE7, 0x00, 0x0F, 0xC6, 0x00, 0x1F, 0x8E, 0x00, 0x3F, 0x1C,
  0x00, 0x7E, 0x18, 0x00, 0xFC, 0x38, 0x01, 0xF8, 0x30, 0x03, 0xF0, 0x70,
  0x07, 0xE0, 0xE0, 0x0F, 0xC0, 0xC0, 0x1F, 0x81, 0xC0, 0x3F, 0x01, 0x80,
  0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x06, 0x03, 0xF0, 0x0E, 0x07,
  0xE0, 0x0C, 0x0F, 0xC0, 0x1C, 0x1F, 0x80, 0x38, 0x3F, 0x00, 0x30, 0x7E,
  0x00, 0x70, 0xFC, 0x00, 0x61, 0xF8, 0x00, 0xE3, 0xF0, 0x01, 0xC7, 0xE0,
  0x01, 0x8F, 0xC0, 0x03, 0x9F, 0x80, 0x07, 0x3F, 0x00, 0x07, 0x7E, 0x00,
  0x0E, 0xFC, 0x00, 0x0D, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0xF8, 0x0F, 0x81, 0xC0, 0x07, 0x87, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x1C,
  0x00, 0x1E, 0x1C, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x7C, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0x81,
  0xF0, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x1F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x1B, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1C, 0x00, 0x0F, 0x8E, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x9C, 0x00, 0x07,
  0x8E, 0x00, 0x1F, 0xC7, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x79,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xF0,
  0x1F, 0x81, 0xE0, 0x03, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xE0, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0xE0, 0x7E,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x01, 0xCF, 0x00, 0x03, 0x8F, 0x00, 0x0E, 0x0F, 0x00, 0x3C,
  0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0xC0, 0x07, 0x80, 0x1D, 0x80, 0x0F,
  0x00, 0x3B, 0x80, 0x3E, 0x00, 0x77, 0x00, 0x7C, 0x00, 0xEE, 0x00, 0xDC,
  0x01, 0x9C, 0x01, 0xB8, 0x07, 0x38, 0x03, 0x30, 0x0E, 0x70, 0x06, 0x60,
  0x1C, 0x60, 0x0C, 0xC0, 0x38, 0xC0, 0x39, 0x80, 0x71, 0xC0, 0x73, 0x00,
  0xE3, 0x80, 0xC6, 0x01, 0xC7, 0x01, 0x8E, 0x03, 0x0E, 0x03, 0x1C, 0x06,
  0x1C, 0x06, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x38, 0x30, 0x38, 0x60, 0x70,
  0x60, 0x70, 0xC0, 0xE0, 0xE0, 0xC1, 0x81, 0xC1, 0xC1, 0x83, 0x83, 0x83,
  0x83, 0x07, 0x06, 0x07, 0x06, 0x06, 0x0C, 0x0E, 0x0C, 0x0C, 0x18, 0x1C,
  0x38, 0x18, 0x70, 0x18, 0x60, 0x30, 0xE0, 0x30, 0xC0, 0x61, 0xC0, 0x71,
  0x80, 0xE3, 0x80, 0xE3, 0x01, 0xC7, 0x01, 0xC6, 0x01, 0x8C, 0x03, 0x8C,
  0x03, 0x18, 0x07, 0x38, 0x06, 0x30, 0x0E, 0x60, 0x0C, 0xE0, 0x1C, 0xC0,
  0x19, 0xC0, 0x19, 0x80, 0x3B, 0x80, 0x3B, 0x00, 0x77, 0x00, 0x76, 0x00,
  0x6E, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xB0, 0x03, 0xE0, 0x03,
  0x60, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3,
  0x80, 0x03, 0xC3, 0x80, 0x03, 0x83, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1E, 0x00,
  0x70, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0x80,
  0x07, 0x7C, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00,
  0x37, 0x3F, 0x01, 0xE7, 0x0F, 0xFF, 0xC7, 0x07, 0xFF, 0x87, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xFC, 0x07, 0x0F, 0xFE, 0x0E,
  0x7F, 0xFF, 0x1D, 0xC0, 0x1F, 0x3B, 0x00, 0x0E, 0x7C, 0x00, 0x1E, 0xF8,
  0x00, 0x1D, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xBF, 0x00, 0x0F, 0x77, 0x00, 0x3C, 0xE7, 0x81, 0xF1, 0xC7,
  0xFF, 0xC3, 0x87, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0xF8, 0x38, 0x3F, 0xFC,
  0x70, 0xFF, 0xFC, 0xE3, 0xC0, 0x1D, 0xCF, 0x00, 0x1F, 0x9C, 0x00, 0x1F,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01,
  0xEF, 0x00, 0x03, 0xCE, 0x00, 0x0F, 0x9E, 0x00, 0x37, 0x1F, 0x01, 0xEE,
  0x1F, 0xFF, 0x9C, 0x0F, 0xFC, 0x38, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87,
  0x00, 0x07, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x0F, 0x07,
  0xE0, 0x7C, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x1C, 0x3F, 0xFF, 0x38, 0xF0, 0x07,
  0x73, 0xC0, 0x06, 0xE7, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00,
  0x1E, 0x70, 0x00, 0x7C, 0xF0, 0x01, 0xB8, 0xF8, 0x0F, 0x70, 0xFF, 0xFC,
  0xE0, 0x7F, 0xE1, 0xC0, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x81, 0xFC, 0x07, 0x0F, 0xFE, 0x0E, 0x7F, 0xFF, 0x1C, 0xE0, 0x1F,
  0x3B, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1D, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x38,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x07, 0xE0, 0x7C, 0x33, 0xFC, 0x3F, 0xCD, 0xFF, 0x9D,
  0xF3, 0x40, 0xEC, 0x1E, 0xD0, 0x1E, 0x03, 0xB8, 0x07, 0x00, 0xFE, 0x01,
  0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1C, 0x01, 0xF8, 0x07, 0x00, 0x7E,
  0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1C, 0x01, 0xF8, 0x07, 0x00,
  0x7E, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1C, 0x01, 0xF8, 0x07,
  0x00, 0x7E, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1C, 0x01, 0xF8,
  0x07, 0x00, 0x7E, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1C, 0x01,
  0xF8, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1C,
  0x01, 0xF8, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0,
  0x1C, 0x01, 0xC0, 0x00, 0x7F, 0x01, 0xC3, 0xFF, 0x83, 0x8F, 0xFF, 0xC7,
  0x38, 0x07, 0xCE, 0xC0, 0x07, 0x9D, 0x00, 0x07, 0xBE, 0x00, 0x07, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF0,
  0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0xE3, 0x80,
  0x03, 0xC3, 0x80, 0x0F, 0x07, 0xC0, 0x7C, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x01, 0xC3, 0xFF, 0x83, 0x9F, 0xFF,
  0xC7, 0x70, 0x07, 0xCE, 0xC0, 0x03, 0x9F, 0x00, 0x07, 0xBE, 0x00, 0x07,
  0x78, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0xC0, 0x00,
  0xEF, 0xC0, 0x03, 0xDD, 0xC0, 0x0F, 0x39, 0xE0, 0x7C, 0x71, 0xFF, 0xF0,
  0xE1, 0xFF, 0x81, 0xC0, 0x30, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x1C, 0x3F, 0xFF, 0x38, 0xF0, 0x07, 0x73, 0xC0,
  0x07, 0xE7, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xE7, 0x80,
  0x0D, 0xC7, 0xC0, 0x7B, 0x87, 0xFF, 0xE7, 0x03, 0xFF, 0x0E, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x00, 0xE1, 0xFF, 0xE0,
  0xE3, 0xFF, 0xF0, 0xE6, 0x00, 0xF8, 0xEC, 0x00, 0x3C, 0xE8, 0x00, 0x1C,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xC3, 0xC0, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x71, 0xE0, 0x01, 0xC1, 0xE0, 0x07,
  0x83, 0xF0, 0x3E, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x06, 0x38, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x07, 0x00, 0x3F, 0x00, 0x3C, 0x01, 0xF8, 0x01, 0xE0, 0x0E, 0xC0,
  0x1F, 0x00, 0x77, 0x00, 0xD8, 0x03, 0xB8, 0x06, 0xC0, 0x19, 0xC0, 0x33,
  0x00, 0xCE, 0x01, 0x98, 0x0E, 0x70, 0x0C, 0xC0, 0x71, 0x80, 0xC6, 0x03,
  0x8E, 0x06, 0x30, 0x1C, 0x70, 0x31, 0xC0, 0xC3, 0x81, 0x86, 0x06, 0x1C,
  0x0C, 0x30, 0x70, 0xE0, 0xE1, 0x83, 0x83, 0x06, 0x0C, 0x1C, 0x1C, 0x30,
  0x70, 0xE0, 0xE1, 0x83, 0x86, 0x07, 0x0C, 0x0C, 0x30, 0x38, 0xE0, 0x63,
  0x80, 0xC6, 0x03, 0x1C, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0x80, 0xE7, 0x01,
  0xCC, 0x03, 0x30, 0x0E, 0xE0, 0x19, 0x80, 0x77, 0x00, 0xDC, 0x01, 0xB0,
  0x06, 0xE0, 0x0D, 0x80, 0x3F, 0x00, 0x6C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00,
  0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x3C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x78, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0x9F, 0xF0, 0x00, 0xDE, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xC0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x0F, 0xC0, 0x0F, 0x0F, 0xE0, 0x03,
  0xFF, 0x70, 0x00, 0xFF, 0x38, 0x00, 0x0C, 0x00,
};

const GFXglyph JetBrainsMono_Thin59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 6, 43, 35, 15, -43 },
  { 34, 16, 18, 35, 10, -43 },
  { 70, 31, 43, 35, 2, -43 },
  { 237, 25, 59, 35, 5, -51 },
  { 422, 33, 43, 35, 1, -43 },
  { 600, 29, 45, 35, 4, -44 },
  { 764, 4, 18, 35, 16, -43 },
  { 773, 17, 57, 35, 12, -50 },
  { 895, 16, 57, 35, 7, -50 },
  { 1009, 31, 30, 35, 2, -36 },
  { 1126, 27, 27, 35, 4, -33 },
  { 1218, 10, 18, 35, 11, -9 },
  { 1241, 19, 3, 35, 8, -21 },
  { 1249, 9, 9, 35, 13, -8 },
  { 1260, 24, 55, 35, 6, -49 },
  { 1425, 25, 45, 35, 5, -44 },
  { 1566, 25, 43, 35, 6, -43 },
  { 1701, 26, 44, 35, 5, -44 },
  { 1844, 24, 44, 35, 5, -43 },
  { 1976, 23, 43, 35, 6, -43 },
  { 2100, 24, 44, 35, 6, -43 },
  { 2232, 25, 44, 35, 5, -43 },
  { 2370, 26, 43, 35, 5, -43 },
  { 2510, 25, 45, 35, 5, -44 },
  { 2651, 25, 44, 35, 5, -44 },
  { 2789, 9, 34, 35, 13, -33 },
  { 2828, 11, 42, 35, 11, -33 },
  { 2886, 25, 29, 35, 5, -34 },
  { 2977, 24, 17, 35, 6, -28 },
  { 3028, 25, 29, 35, 5, -34 },
  { 3119, 20, 43, 35, 10, -43 },
  { 3227, 28, 55, 35, 4, -44 },
  { 3420, 27, 43, 35, 4, -43 },
  { 3566, 24, 43, 35, 6, -43 },
  { 3695, 24, 45, 35, 6, -44 },
  { 3830, 23, 43, 35, 6, -43 },
  { 3954, 23, 43, 35, 7, -43 },
  { 4078, 24, 43, 35, 7, -43 },
  { 4207, 24, 45, 35, 6, -44 },
  { 4342, 23, 43, 35, 6, -43 },
  { 4466, 21, 43, 35, 7, -43 },
  { 4579, 24, 44, 35, 4, -43 },
  { 4711, 26, 43, 35, 6, -43 },
  { 4851, 24, 43, 35, 7, -43 },
  { 4980, 25, 43, 35, 5, -43 },
  { 5115, 23, 43, 35, 6, -43 },
  { 5239, 23, 45, 35, 6, -44 },
  { 5369, 26, 43, 35, 6, -43 },
  { 5509, 24, 55, 35, 6, -44 },
  { 5674, 25, 43, 35, 6, -43 },
  { 5809, 25, 45, 35, 5, -44 },
  { 5950, 28, 43, 35, 4, -43 },
  { 6101, 23, 44, 35, 6, -43 },
  { 6228, 27, 43, 35, 4, -43 },
  { 6374, 31, 43, 35, 2, -43 },
  { 6541, 29, 43, 35, 3, -43 },
  { 6697, 29, 43, 35, 3, -43 },
  { 6853, 25, 43, 35, 5, -43 },
  { 6988, 13, 55, 35, 13, -49 },
  { 7078, 24, 55, 35, 6, -49 },
  { 7243, 13, 55, 35, 9, -49 },
  { 7333, 24, 23, 35, 6, -43 },
  { 7402, 28, 3, 35, 4, 1 },
  { 7413, 10, 8, 35, 12, -46 },
  { 7423, 24, 34, 35, 5, -33 },
  { 7525, 23, 44, 35, 6, -43 },
  { 7652, 24, 34, 35, 6, -33 },
  { 7754, 23, 44, 35, 6, -43 },
  { 7881, 23, 34, 35, 6, -33 },
  { 7979, 27, 43, 35, 4, -43 },
  { 8125, 23, 44, 35, 6, -33 },
  { 8252, 23, 43, 35, 6, -43 },
  { 8376, 26, 45, 35, 6, -45 },
  { 8523, 21, 56, 35, 6, -45 },
  { 8670, 24, 43, 35, 7, -43 },
  { 8799, 29, 43, 35, 3, -43 },
  { 8955, 26, 33, 35, 5, -33 },
  { 9063, 23, 33, 35, 6, -33 },
  { 9158, 23, 34, 35, 6, -33 },
  { 9256, 23, 44, 35, 6, -33 },
  { 9383, 23, 44, 35, 6, -33 },
  { 9510, 24, 33, 35, 7, -33 },
  { 9609, 25, 34, 35, 5, -33 },
  { 9716, 26, 42, 35, 4, -42 },
  { 9853, 23, 33, 35, 6, -32 },
  { 9948, 27, 32, 35, 4, -32 },
  { 10056, 29, 32, 35, 3, -32 },
  { 10172, 27, 32, 35, 4, -32 },
  { 10280, 27, 43, 35, 4, -32 },
  { 10426, 23, 32, 35, 6, -32 },
  { 10518, 24, 55, 35, 6, -49 },
  { 10683, 3, 55, 35, 16, -49 },
  { 10704, 24, 55, 35, 6, -49 },
  { 10869, 25, 11, 35, 5, -26 },
};

const GFXfont JetBrainsMono_Thin59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_THIN59PT7B_H_
