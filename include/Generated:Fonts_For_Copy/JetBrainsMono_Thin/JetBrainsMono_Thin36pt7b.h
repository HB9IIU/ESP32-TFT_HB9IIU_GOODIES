#ifndef _JETBRAINSMONO_THIN36PT7B_H_
#define _JETBRAINSMONO_THIN36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin36pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x64, 0x44, 0x40, 0x00,
  0x6F, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x6C, 0x1B, 0x06,
  0xC1, 0xB0, 0x2C, 0x08, 0x01, 0x80, 0x80, 0x30, 0x30, 0x04, 0x06, 0x00,
  0x80, 0xC0, 0x30, 0x10, 0x06, 0x02, 0x00, 0xC0, 0xC1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0xC0, 0x40, 0x18, 0x08, 0x03, 0x03, 0x00, 0x60, 0x60, 0x08,
  0x0C, 0x01, 0x01, 0x00, 0x60, 0x20, 0x0C, 0x0C, 0x1F, 0xFF, 0xF8, 0x20,
  0x30, 0x04, 0x04, 0x01, 0x80, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0x80,
  0xC0, 0x10, 0x18, 0x06, 0x02, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x0F, 0xF0, 0x39, 0x9C, 0x31, 0x8C, 0x61, 0x86,
  0x61, 0x86, 0x61, 0x86, 0x61, 0x80, 0x61, 0x80, 0x61, 0x80, 0x31, 0x80,
  0x39, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0x9C, 0x01, 0x8C,
  0x01, 0x86, 0x01, 0x86, 0x01, 0x82, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x86,
  0x61, 0x86, 0x71, 0x8C, 0x3D, 0xBC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x00, 0x36, 0x18, 0x06, 0xC1,
  0x80, 0xCC, 0x08, 0x08, 0xC0, 0x81, 0x8C, 0x08, 0x30, 0xC0, 0x86, 0x0C,
  0x08, 0x40, 0xC1, 0x8C, 0x06, 0x19, 0x80, 0x3F, 0x10, 0x00, 0x83, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x87, 0x80, 0x19, 0xFC, 0x03, 0x18,
  0x60, 0x23, 0x02, 0x06, 0x30, 0x20, 0xC3, 0x02, 0x08, 0x30, 0x21, 0x83,
  0x02, 0x30, 0x30, 0x26, 0x01, 0x06, 0x40, 0x1C, 0xEC, 0x00, 0xFC, 0x01,
  0x80, 0x01, 0xFC, 0x01, 0xC3, 0x80, 0x60, 0x70, 0x30, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x1C, 0xC0, 0x06, 0x18, 0x0D, 0x07, 0x06, 0xC0,
  0xC1, 0x30, 0x18, 0xCC, 0x03, 0x63, 0x00, 0x78, 0xC0, 0x1C, 0x30, 0x03,
  0x0C, 0x01, 0xE1, 0x80, 0xEC, 0x60, 0x73, 0x0E, 0x78, 0x61, 0xF8, 0x0C,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0xF0, 0x70, 0x30, 0x18, 0x0E, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0x30, 0xC0, 0x3C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0,
  0xE0, 0x70, 0xF8, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x0C, 0x1F, 0xF3, 0x3F, 0x1E,
  0xBE, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x05, 0x80, 0x03, 0x30, 0x01, 0x8E,
  0x00, 0xE1, 0x80, 0x30, 0x30, 0x18, 0x0E, 0x0E, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3C, 0xE3, 0x8C, 0x71, 0x86, 0x18,
  0xC3, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x3F, 0xE0, 0xF0, 0xE3, 0x80, 0x66, 0x00, 0xEC,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x38, 0x78, 0x78, 0xF0, 0xE1, 0xE0, 0x83, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x30,
  0x1C, 0x3D, 0xF0, 0x3F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x66, 0x03, 0x8C,
  0x0E, 0x18, 0x10, 0x30, 0x20, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1F, 0xF0, 0x38, 0x38,
  0x60, 0x0C, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x68, 0x01, 0x98, 0x03, 0x38, 0x0C, 0x3C, 0x78, 0x1F,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x13, 0x00, 0xB0, 0x05,
  0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xFB, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x3F, 0x8D, 0xCF, 0x3C, 0x0E, 0xE0, 0x1B, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01,
  0x98, 0x0E, 0x38, 0xF0, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x13, 0xE0, 0x3F, 0xF8, 0x78, 0x1C, 0x70, 0x0C, 0x60, 0x06,
  0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06,
  0x40, 0x06, 0x60, 0x0E, 0x30, 0x1C, 0x1E, 0x78, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x1F, 0xE0, 0xE0, 0xE1, 0x80, 0x66, 0x00, 0x6C,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0x60, 0x18, 0xC0, 0x70, 0xE1,
  0xC0, 0x7E, 0x00, 0x78, 0x03, 0x98, 0x0C, 0x1C, 0x30, 0x0C, 0xC0, 0x1D,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xB0, 0x03, 0x70,
  0x0C, 0x78, 0xF0, 0x3F, 0xC0, 0x01, 0x80, 0x0F, 0xF0, 0x38, 0x38, 0x30,
  0x0C, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x02, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x3C, 0x1F,
  0xEC, 0x01, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x7F,
  0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xF0,
  0x3C, 0xF9, 0xFB, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x1C, 0x38, 0x70, 0xC3, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x00, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x01,
  0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x1F, 0xC1, 0xF0, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x7C, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xC0, 0xE0,
  0xE0, 0x0C, 0x30, 0x03, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x02, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x0F, 0xEF, 0x03, 0x0F, 0xC1, 0x81, 0xF0, 0x60,
  0x3C, 0x18, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x60, 0x3C, 0x18, 0x0F,
  0x06, 0x03, 0xC1, 0x80, 0xF0, 0x60, 0x7C, 0x1C, 0x1F, 0x03, 0xFB, 0xC0,
  0x7C, 0xD0, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x2C, 0x00, 0x32, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x04,
  0x60, 0x06, 0x10, 0x03, 0x0C, 0x01, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x80,
  0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x06, 0x0F, 0xFF, 0x04, 0x01,
  0x86, 0x00, 0x43, 0x00, 0x31, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x02, 0x60,
  0x01, 0xE0, 0x00, 0xC0, 0xFF, 0xC1, 0x81, 0xE3, 0x00, 0xE6, 0x00, 0xCC,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00,
  0xE6, 0x07, 0x8F, 0xFC, 0x18, 0x1E, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x0D,
  0x80, 0x0B, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x58, 0x01, 0xB0, 0x03, 0x60,
  0x1C, 0xFF, 0xF1, 0xFF, 0x80, 0x07, 0x00, 0x7F, 0x83, 0x03, 0x18, 0x06,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60,
  0x18, 0xF3, 0xC1, 0xFE, 0x00, 0xFF, 0xC3, 0x0F, 0x8C, 0x03, 0x30, 0x06,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x03, 0xB0, 0x1C, 0xFF,
  0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE,
  0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x7F, 0x83, 0x03, 0x18, 0x06, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x18, 0xF3, 0xC1,
  0xFE, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30,
  0xFF, 0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xD8,
  0x06, 0x3C, 0xF0, 0x7F, 0x80, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00,
  0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x61, 0x81, 0x83,
  0x03, 0x06, 0x0C, 0x0F, 0xF8, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0,
  0x61, 0x80, 0xC3, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x30, 0x03,
  0x60, 0x06, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x0F, 0xE0, 0x17, 0x40,
  0x2E, 0x80, 0xDD, 0x81, 0x39, 0x02, 0x72, 0x0C, 0xE6, 0x11, 0xC4, 0x63,
  0x8C, 0xC7, 0x19, 0x0E, 0x16, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x04, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xD0, 0x0F, 0x60, 0x3D, 0x80, 0xF3, 0x03, 0xCC, 0x0F,
  0x10, 0x3C, 0x60, 0xF1, 0x83, 0xC2, 0x0F, 0x0C, 0x3C, 0x10, 0xF0, 0x63,
  0xC1, 0x8F, 0x02, 0x3C, 0x0C, 0xF0, 0x13, 0xC0, 0x6F, 0x01, 0xBC, 0x02,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x70, 0x03, 0x00, 0x7F, 0x83, 0x07, 0x18,
  0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06,
  0x60, 0x38, 0xE1, 0xC1, 0xFC, 0x00, 0xFF, 0xE1, 0x81, 0xF3, 0x00, 0x76,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0xEC, 0x07, 0x9F, 0xFE, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03, 0x00, 0x7F, 0x87, 0x07,
  0x18, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x06, 0x60, 0x38, 0xE3, 0xC1, 0xFE, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0xFF, 0xE1, 0x81, 0xF3, 0x00, 0x76, 0x00,
  0x6C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x36, 0x00, 0xCF, 0xFF, 0x9F, 0xFC, 0x30, 0x60, 0x60, 0x60, 0xC0,
  0xC1, 0x80, 0xC3, 0x01, 0x86, 0x01, 0x8C, 0x03, 0x18, 0x03, 0x30, 0x06,
  0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0C, 0x01, 0x80, 0x0F, 0xF0, 0x38, 0x3C,
  0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x3C, 0x3C, 0x0F, 0xF0,
  0xFF, 0xFF, 0x80, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x2C, 0x01,
  0x98, 0x0E, 0x38, 0xF0, 0x7F, 0x00, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x4C, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x08, 0x20, 0x0C, 0x18,
  0x06, 0x0C, 0x02, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x40,
  0x30, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x08, 0x00, 0x8C, 0x00, 0x66,
  0x00, 0x32, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xC0, 0x60, 0x68, 0x1C, 0x0D, 0x03, 0x81, 0xB0, 0x78, 0x36,
  0x0B, 0x06, 0xC1, 0x60, 0x98, 0x24, 0x13, 0x04, 0x82, 0x21, 0x90, 0xC4,
  0x32, 0x18, 0x86, 0x63, 0x18, 0x8C, 0x63, 0x11, 0x8C, 0x62, 0x11, 0x0C,
  0x42, 0x21, 0x98, 0x44, 0x13, 0x08, 0x82, 0x41, 0x30, 0x48, 0x36, 0x0D,
  0x06, 0xC1, 0xA0, 0x58, 0x34, 0x0A, 0x07, 0x81, 0x40, 0xF0, 0x28, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0xE0, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x30, 0x60,
  0x18, 0x18, 0x04, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x02, 0x30,
  0x00, 0xC8, 0x00, 0x16, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x36, 0x00, 0x0C, 0xC0, 0x06, 0x10, 0x01, 0x86, 0x00, 0xC0, 0x80, 0x30,
  0x30, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01,
  0xB0, 0x00, 0x70, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x10, 0xC0, 0x0C,
  0x30, 0x02, 0x06, 0x01, 0x81, 0x80, 0x40, 0x30, 0x30, 0x0C, 0x08, 0x01,
  0x86, 0x00, 0x61, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x03, 0x30, 0x0C, 0xC0,
  0x63, 0x01, 0x86, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC6, 0x01, 0x98, 0x06,
  0xC0, 0x1B, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xC3, 0x86,
  0x0C, 0x07, 0xE0, 0x3F, 0xF0, 0xC0, 0x73, 0x00, 0x66, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x3F, 0xFC, 0xF0, 0x1B, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0xC0, 0x3C, 0xE1,
  0xD8, 0xFF, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0xFC, 0x37, 0x3C, 0xF0, 0x3B, 0x80, 0x6C, 0x00, 0xB0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xB8, 0x0E, 0xD8, 0x73, 0x3F,
  0x80, 0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0xB8, 0x06, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0xF0, 0x03, 0xC0, 0x19, 0x80, 0x63, 0xCF, 0x07, 0xF8,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0xF8,
  0xCF, 0x7B, 0x60, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xD8, 0x0F, 0x38, 0x6C, 0x7F, 0x30, 0x0F, 0xC0,
  0xF7, 0xC6, 0x03, 0xB0, 0x06, 0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x03, 0xC0, 0x19, 0x80, 0x63, 0x87, 0x07, 0xF8, 0x01, 0xFF, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x1F, 0x8C, 0xF7, 0xB6, 0x02, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xD8, 0x0F, 0x70, 0x6C, 0x7F, 0x30, 0x20, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x38, 0xFF, 0x80, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xFC, 0x37,
  0x3C, 0xF0, 0x3B, 0x80, 0x6C, 0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE7, 0xFC,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x01, 0xE0, 0x06, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xC6, 0x03, 0x0C,
  0x0E, 0x18, 0x18, 0x30, 0x60, 0x7F, 0x80, 0xFF, 0x81, 0x83, 0x83, 0x03,
  0x06, 0x03, 0x0C, 0x07, 0x18, 0x06, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x0D,
  0x80, 0x0C, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x9E, 0x3C,
  0xB7, 0x6E, 0xC3, 0x86, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xCF, 0xC3, 0x73, 0xCF, 0x03, 0xB8, 0x06, 0xC0, 0x1B, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x0F, 0xC0, 0xF7, 0xC6, 0x03, 0x30, 0x06, 0xC0, 0x0B, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x19, 0x80, 0xE3, 0x87, 0x07, 0xF0,
  0xCF, 0xC3, 0x73, 0xCF, 0x03, 0xB8, 0x06, 0xC0, 0x0B, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1B, 0x80, 0xED, 0x87, 0x33, 0xF8, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x1F, 0x8C,
  0xF7, 0xB6, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1D, 0x80, 0xF3, 0x8E, 0xC7, 0xF3, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x8F, 0xC2, 0x77, 0x8A,
  0x03, 0x30, 0x06, 0xC0, 0x1A, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0F, 0xF0, 0x7C, 0xF0, 0xC0,
  0x33, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0x60, 0x06, 0xC0, 0x0C, 0xE0, 0x70, 0xFF, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x02,
  0xE0, 0x19, 0x80, 0xE3, 0x8F, 0x07, 0xF8, 0xC0, 0x03, 0xC0, 0x02, 0x40,
  0x06, 0x60, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x04,
  0x60, 0x06, 0x60, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0xC0,
  0xC0, 0xF0, 0x30, 0x3C, 0x1C, 0x0B, 0x07, 0x02, 0x41, 0x61, 0x90, 0x58,
  0x66, 0x12, 0x19, 0x84, 0x86, 0x63, 0x21, 0x18, 0x8C, 0x42, 0x23, 0x30,
  0x88, 0x4C, 0x32, 0x13, 0x0D, 0x84, 0xC3, 0x61, 0xA0, 0xD0, 0x68, 0x14,
  0x1E, 0x05, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xC0, 0x07, 0x60, 0x06,
  0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x06, 0x60, 0x0C, 0x60,
  0x08, 0x30, 0x18, 0x18, 0x30, 0x18, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xF0, 0x1C, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x03, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0xFC, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0x7E, 0x03, 0xC3, 0x03, 0xC1, 0x83, 0xC0, 0xC6, 0xC0, 0x7E,
  0xC0, 0x18,
};

const GFXglyph JetBrainsMono_Thin36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 26, 22, 9, -26 },
  { 14, 10, 11, 22, 6, -26 },
  { 28, 19, 26, 22, 1, -26 },
  { 90, 16, 36, 22, 3, -31 },
  { 162, 20, 26, 22, 1, -26 },
  { 227, 18, 27, 22, 2, -27 },
  { 288, 2, 11, 22, 10, -26 },
  { 291, 10, 34, 22, 7, -30 },
  { 334, 10, 34, 22, 4, -30 },
  { 377, 18, 18, 22, 2, -22 },
  { 418, 16, 16, 22, 3, -20 },
  { 450, 6, 11, 22, 7, -5 },
  { 459, 12, 2, 22, 5, -13 },
  { 462, 5, 5, 22, 8, -5 },
  { 466, 15, 34, 22, 3, -30 },
  { 530, 15, 27, 22, 3, -27 },
  { 581, 15, 26, 22, 4, -26 },
  { 630, 16, 27, 22, 3, -27 },
  { 684, 15, 26, 22, 3, -26 },
  { 733, 13, 26, 22, 4, -26 },
  { 776, 14, 26, 22, 4, -26 },
  { 822, 16, 26, 22, 3, -26 },
  { 874, 16, 26, 22, 3, -26 },
  { 926, 15, 27, 22, 3, -27 },
  { 977, 16, 27, 22, 3, -27 },
  { 1031, 5, 20, 22, 8, -20 },
  { 1044, 7, 26, 22, 7, -20 },
  { 1067, 15, 18, 22, 3, -21 },
  { 1101, 15, 10, 22, 3, -17 },
  { 1120, 15, 18, 22, 3, -21 },
  { 1154, 12, 26, 22, 6, -26 },
  { 1193, 18, 33, 22, 2, -27 },
  { 1268, 17, 26, 22, 2, -26 },
  { 1324, 15, 26, 22, 4, -26 },
  { 1373, 14, 27, 22, 4, -27 },
  { 1421, 14, 26, 22, 4, -26 },
  { 1467, 14, 26, 22, 4, -26 },
  { 1513, 15, 26, 22, 4, -26 },
  { 1562, 14, 27, 22, 4, -27 },
  { 1610, 14, 26, 22, 4, -26 },
  { 1656, 13, 26, 22, 4, -26 },
  { 1699, 14, 26, 22, 3, -26 },
  { 1745, 15, 26, 22, 4, -26 },
  { 1794, 15, 26, 22, 4, -26 },
  { 1843, 15, 26, 22, 3, -26 },
  { 1892, 14, 26, 22, 4, -26 },
  { 1938, 14, 27, 22, 4, -27 },
  { 1986, 15, 26, 22, 4, -26 },
  { 2035, 14, 33, 22, 4, -27 },
  { 2093, 15, 26, 22, 4, -26 },
  { 2142, 16, 27, 22, 3, -27 },
  { 2196, 17, 26, 22, 2, -26 },
  { 2252, 14, 26, 22, 4, -26 },
  { 2298, 17, 26, 22, 2, -26 },
  { 2354, 19, 26, 22, 1, -26 },
  { 2416, 18, 26, 22, 2, -26 },
  { 2475, 18, 26, 22, 2, -26 },
  { 2534, 15, 26, 22, 3, -26 },
  { 2583, 8, 34, 22, 8, -30 },
  { 2617, 15, 34, 22, 3, -30 },
  { 2681, 8, 34, 22, 6, -30 },
  { 2715, 14, 14, 22, 4, -26 },
  { 2740, 17, 2, 22, 2, 1 },
  { 2745, 6, 5, 22, 7, -28 },
  { 2749, 15, 20, 22, 3, -20 },
  { 2787, 14, 26, 22, 4, -26 },
  { 2833, 14, 20, 22, 4, -20 },
  { 2868, 14, 26, 22, 4, -26 },
  { 2914, 14, 20, 22, 4, -20 },
  { 2949, 16, 26, 22, 3, -26 },
  { 3001, 14, 26, 22, 4, -20 },
  { 3047, 14, 26, 22, 4, -26 },
  { 3093, 16, 28, 22, 3, -28 },
  { 3149, 13, 34, 22, 3, -28 },
  { 3205, 15, 26, 22, 4, -26 },
  { 3254, 17, 26, 22, 2, -26 },
  { 3310, 16, 20, 22, 3, -20 },
  { 3350, 14, 20, 22, 4, -20 },
  { 3385, 14, 20, 22, 4, -20 },
  { 3420, 14, 26, 22, 4, -20 },
  { 3466, 14, 26, 22, 4, -20 },
  { 3512, 14, 20, 22, 5, -20 },
  { 3547, 15, 20, 22, 3, -20 },
  { 3585, 15, 25, 22, 3, -25 },
  { 3632, 14, 20, 22, 4, -20 },
  { 3667, 16, 20, 22, 3, -20 },
  { 3707, 18, 20, 22, 2, -20 },
  { 3752, 16, 20, 22, 3, -20 },
  { 3792, 16, 26, 22, 3, -20 },
  { 3844, 14, 20, 22, 4, -20 },
  { 3879, 14, 34, 22, 4, -30 },
  { 3939, 2, 34, 22, 10, -30 },
  { 3948, 14, 34, 22, 4, -30 },
  { 4008, 16, 7, 22, 3, -16 },
};

const GFXfont JetBrainsMono_Thin36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_THIN36PT7B_H_
