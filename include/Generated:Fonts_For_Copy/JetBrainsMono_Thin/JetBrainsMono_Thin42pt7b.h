#ifndef _JETBRAINSMONO_THIN42PT7B_H_
#define _JETBRAINSMONO_THIN42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin42pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x31,
  0x08, 0x42, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xE0, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x06, 0x00, 0x60, 0x30, 0x00, 0x80, 0x60, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x08,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x40, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C,
  0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x3C, 0xCE, 0x1C, 0x31, 0xC6, 0x0C, 0x39, 0x83, 0x06,
  0xE0, 0xC1, 0xB8, 0x30, 0x6E, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x1C,
  0x30, 0x03, 0x8C, 0x00, 0x7B, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x03, 0x38, 0x00, 0xC7, 0x00, 0x30, 0xE0, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC1, 0xF0, 0x30, 0x3C, 0x0C, 0x1F, 0x03, 0x06, 0xC0, 0xC1, 0x98,
  0x30, 0xE7, 0x8C, 0x70, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x06, 0x7F, 0x80, 0x0D, 0xC3, 0x00, 0x33, 0x03, 0x00, 0xCC, 0x06, 0x01,
  0x18, 0x0C, 0x06, 0x30, 0x18, 0x18, 0x60, 0x30, 0x60, 0xC0, 0x60, 0xC1,
  0x80, 0xC3, 0x01, 0x81, 0x8C, 0x03, 0x06, 0x18, 0x03, 0xFC, 0x60, 0x03,
  0xF1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC3, 0xE0, 0x01, 0x8F, 0xE0, 0x06, 0x30, 0x60, 0x18, 0xC0, 0xC0, 0x21,
  0x80, 0xC0, 0xC3, 0x01, 0x83, 0x06, 0x03, 0x0C, 0x0C, 0x06, 0x18, 0x18,
  0x0C, 0x60, 0x30, 0x19, 0x80, 0x60, 0x33, 0x00, 0x60, 0xCC, 0x00, 0xFF,
  0xB0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0x07, 0x80,
  0x30, 0x0C, 0x03, 0x80, 0x70, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0E, 0x70, 0x00, 0xE1, 0xC0,
  0x36, 0x07, 0x03, 0x30, 0x18, 0x39, 0x80, 0x61, 0x8C, 0x03, 0x9C, 0x60,
  0x0C, 0xC3, 0x00, 0x3C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x38,
  0x30, 0x03, 0x61, 0xC0, 0x39, 0x87, 0x03, 0x8E, 0x3E, 0xF8, 0x30, 0x7F,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0x00, 0x60, 0x3C, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xC0, 0xF0,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x06, 0x03, 0xF8,
  0x30, 0xFB, 0xF9, 0x1F, 0x83, 0xEB, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x6C, 0x00, 0x07, 0x70, 0x00, 0x31, 0xC0, 0x03, 0x86, 0x00, 0x38,
  0x38, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x01, 0xC0, 0x1C, 0x04, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x1E, 0x38, 0xF1, 0xC3, 0x87, 0x1C, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x73, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x00, 0xE6, 0x00, 0x37, 0x00, 0x1F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x04, 0x0F, 0x07, 0x07, 0x87, 0xC3, 0xC1, 0xC1, 0xE0, 0x40,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x01, 0xD8, 0x00, 0xEE, 0x00, 0xE3, 0x80, 0xE0,
  0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x39,
  0x80, 0x1C, 0x60, 0x1C, 0x18, 0x06, 0x06, 0x01, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0x80, 0xE1, 0xC0, 0x1C, 0xE0,
  0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x01, 0xB8, 0x00, 0xCC, 0x00, 0xE7,
  0x00, 0xE1, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x03, 0x1C, 0x03,
  0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x7F, 0xFF, 0x3F, 0xFF,
  0x98, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x7F, 0x06, 0xFF, 0xC3,
  0x60, 0x71, 0xC0, 0x1C, 0xE0, 0x06, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x01, 0xD8, 0x00, 0xCE, 0x00, 0xE3, 0x80, 0xE0, 0xFB, 0xE0,
  0x3F, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0D, 0xFE, 0x03, 0xE3, 0xE1,
  0xE0, 0x1C, 0x70, 0x03, 0x38, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00,
  0x66, 0x00, 0x39, 0xC0, 0x1C, 0x38, 0x0E, 0x07, 0xDF, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0E, 0x03, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xDC, 0x00, 0xC6, 0x00, 0xE1,
  0xC0, 0xE0, 0x71, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x38, 0x0E, 0x0E,
  0x0C, 0x01, 0x8C, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x71,
  0xFB, 0xF0, 0x3F, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xC0, 0xE1, 0xC0,
  0x1C, 0x60, 0x03, 0x38, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB8, 0x00, 0x66,
  0x00, 0x39, 0xC0, 0x1C, 0x3C, 0x1F, 0x07, 0xFD, 0x80, 0x7C, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x23, 0xEF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x3E, 0xFF, 0xFF, 0xFE, 0x08, 0x3E, 0x3F, 0x7F,
  0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0xFE,
  0x03, 0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x07, 0xF8, 0x1F, 0x80, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E,
  0x03, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x6E,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xF3,
  0xC0, 0xFF, 0xBC, 0x0E, 0x07, 0xC0, 0xC0, 0x7C, 0x1C, 0x03, 0xC1, 0x80,
  0x3C, 0x18, 0x03, 0xC1, 0x80, 0x3C, 0x18, 0x03, 0xC1, 0x80, 0x3C, 0x18,
  0x03, 0xC1, 0x80, 0x3C, 0x18, 0x03, 0xC0, 0xC0, 0x7C, 0x0C, 0x07, 0xC0,
  0xF1, 0xBC, 0x07, 0xFB, 0xC0, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x66,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x30, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xFF, 0x80,
  0x7F, 0xF8, 0x30, 0x1F, 0x18, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x3B, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCC,
  0x00, 0xE6, 0x00, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xC0, 0x3C, 0x60, 0x07,
  0x30, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x01, 0xC7,
  0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0x03, 0x86, 0x00,
  0xE6, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0xEE, 0x00, 0x63, 0x80, 0x70, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0xE0, 0xC0, 0xF8, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFE,
  0x0F, 0x03, 0x86, 0x00, 0xE6, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0x63, 0x80, 0x70, 0xFF, 0xF0,
  0x1F, 0xE0, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00,
  0xCE, 0x00, 0xE3, 0x80, 0xE0, 0xFB, 0xE0, 0x3F, 0xE0, 0xC0, 0x01, 0xB0,
  0x00, 0xEC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x00,
  0xC3, 0x00, 0x70, 0xC0, 0x18, 0x30, 0x0E, 0x0C, 0x03, 0x03, 0x01, 0xC0,
  0xC0, 0x60, 0x30, 0x38, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xC0, 0xE0, 0x30,
  0x18, 0x0C, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01,
  0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFD, 0x80, 0x5E,
  0xC0, 0x6F, 0x20, 0x37, 0x98, 0x13, 0xCC, 0x19, 0xE2, 0x0C, 0xF1, 0x84,
  0x78, 0xC6, 0x3C, 0x22, 0x1E, 0x1B, 0x0F, 0x0D, 0x87, 0x83, 0x83, 0xC1,
  0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03, 0xD8, 0x03, 0xD8, 0x03, 0xCC,
  0x03, 0xCC, 0x03, 0xC6, 0x03, 0xC6, 0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3,
  0x03, 0xC1, 0x03, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0xC3, 0xC0, 0xC3, 0xC0,
  0x43, 0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x33, 0xC0, 0x13, 0xC0,
  0x1B, 0xC0, 0x1B, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x07, 0xF0, 0x0F,
  0xFE, 0x0E, 0x03, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCE, 0x00, 0xE3, 0x80, 0xE0, 0xFB,
  0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFE, 0x30, 0x0F, 0x98, 0x00, 0xEC,
  0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x3D, 0xFF,
  0xFC, 0xFF, 0xF8, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0E, 0x03, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCE, 0x00, 0xE3, 0x80, 0xE0, 0xFB,
  0xE0, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0xFF, 0xC0, 0x7F, 0xFC,
  0x30, 0x0F, 0x98, 0x01, 0xCC, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x36,
  0x00, 0x3B, 0x00, 0x39, 0xFF, 0xF8, 0xFF, 0xF0, 0x60, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x0C, 0x07, 0x06, 0x01, 0x83, 0x00, 0xE1, 0x80, 0x30, 0xC0,
  0x1C, 0x60, 0x06, 0x30, 0x03, 0x98, 0x00, 0xCC, 0x00, 0x76, 0x00, 0x1F,
  0x00, 0x0E, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0x80, 0xE1, 0xC0, 0x1C, 0x60,
  0x03, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x6E, 0x00, 0x19, 0x80, 0x0E, 0x78, 0x07, 0x0F, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06,
  0x60, 0x0E, 0x70, 0x1C, 0x3E, 0xF8, 0x0F, 0xF0, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x0C, 0x30, 0x01, 0x87, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x38, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x70, 0xC0, 0x06, 0x18,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x98, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x70,
  0x0F, 0x01, 0xC0, 0x6C, 0x07, 0x01, 0xB0, 0x14, 0x06, 0xC0, 0x58, 0x1B,
  0x01, 0x60, 0x6C, 0x0D, 0x81, 0x98, 0x36, 0x06, 0x60, 0xC8, 0x19, 0x83,
  0x20, 0xC6, 0x0C, 0x83, 0x18, 0x23, 0x0C, 0x60, 0x8C, 0x31, 0x86, 0x30,
  0xC6, 0x18, 0xC3, 0x0C, 0x61, 0x0C, 0x31, 0x84, 0x30, 0xC4, 0x10, 0x83,
  0x10, 0x66, 0x0C, 0x41, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30,
  0x26, 0x06, 0xC0, 0x98, 0x1A, 0x02, 0x60, 0x68, 0x0D, 0x01, 0xA0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x00,
  0x60, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80,
  0x0C, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00,
  0x73, 0x00, 0x03, 0x18, 0x00, 0x30, 0x60, 0x01, 0x83, 0x80, 0x18, 0x0C,
  0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xE0, 0x06, 0x06, 0x00, 0x30, 0x60,
  0x00, 0xC3, 0x00, 0x07, 0x30, 0x00, 0x1B, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x00, 0x06, 0x0C,
  0x00, 0x70, 0x60, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x30, 0x1C,
  0x01, 0x80, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x60, 0x00, 0xC7, 0x00, 0x06,
  0x30, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x37,
  0x00, 0x39, 0x80, 0x18, 0xE0, 0x1C, 0x30, 0x0C, 0x18, 0x0E, 0x06, 0x06,
  0x03, 0x03, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x39, 0xC0, 0x0C, 0xC0, 0x06,
  0xE0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0xE0, 0xE0,
  0xC0, 0xC0, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFB, 0xE0, 0x70, 0x1C, 0x38,
  0x03, 0x8C, 0x00, 0x63, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x1F, 0xFF, 0x1F, 0xFF, 0xCE, 0x00, 0x37, 0x00, 0x0D,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x07, 0x70,
  0x02, 0xCE, 0x01, 0xB1, 0xF7, 0xCC, 0x3F, 0xE3, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x80,
  0xCF, 0xF0, 0xDC, 0x78, 0xF0, 0x0C, 0xE0, 0x0E, 0xC0, 0x06, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0xE0, 0x0E, 0xF0, 0x1C, 0xDE, 0xF8, 0xCF, 0xF0, 0x00, 0x80,
  0x07, 0xFC, 0x07, 0xDF, 0x87, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x1D, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x31, 0xC0, 0x70, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x01, 0x07, 0x0F, 0xF3, 0x8F, 0x1D, 0xCE, 0x03,
  0xEE, 0x00, 0xF6, 0x00, 0x3B, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0xEE, 0x00,
  0xF3, 0x80, 0xF8, 0xFB, 0xDC, 0x3F, 0xCE, 0x00, 0x80, 0x07, 0xFC, 0x07,
  0xCF, 0x07, 0x01, 0xC7, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x6C,
  0x00, 0x67, 0x00, 0x31, 0xC0, 0x70, 0x7D, 0xF0, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x0F, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x07, 0xF9, 0xC7, 0x8E, 0xE7, 0x01, 0xF7, 0x00, 0x7B, 0x00,
  0x1D, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x60, 0x03,
  0xB0, 0x01, 0xDC, 0x01, 0xE7, 0x01, 0xF1, 0xF7, 0xB8, 0x7F, 0x9C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0xF0, 0x7F, 0xF0, 0x3F, 0x80, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x80,
  0xCF, 0xF0, 0xDC, 0x78, 0xF0, 0x1C, 0xE0, 0x0E, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x3E, 0x3F, 0xF0, 0x7E,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x01,
  0x98, 0x01, 0xCC, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE0, 0xC0,
  0xE0, 0x60, 0x60, 0x3F, 0xF0, 0x1F, 0xF8, 0x0C, 0x0C, 0x06, 0x07, 0x03,
  0x01, 0xC1, 0x80, 0x60, 0xC0, 0x38, 0x60, 0x0E, 0x30, 0x03, 0x18, 0x01,
  0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0E, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x02, 0x02, 0x1B, 0xF1, 0xF3, 0x47, 0x67,
  0x70, 0x68, 0x7E, 0x0E, 0x07, 0x80, 0xC0, 0xF0, 0x18, 0x1E, 0x03, 0x03,
  0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x01, 0x81, 0xE0, 0x30, 0x3C, 0x06, 0x07,
  0x80, 0xC0, 0xF0, 0x18, 0x1E, 0x03, 0x03, 0xC0, 0x60, 0x78, 0x0C, 0x0F,
  0x01, 0x81, 0xE0, 0x30, 0x3C, 0x06, 0x07, 0x80, 0xC0, 0xF0, 0x18, 0x1E,
  0x03, 0x03, 0x00, 0x80, 0xCF, 0xF0, 0xDC, 0x78, 0xF0, 0x1C, 0xE0, 0x0E,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xCF, 0x07, 0x01, 0xC7, 0x00,
  0x73, 0x00, 0x19, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x67, 0x00, 0x71, 0xC0,
  0x70, 0x7D, 0xF0, 0x1F, 0xF0, 0x00, 0x80, 0xCF, 0xF0, 0xDC, 0x78, 0xF0,
  0x0C, 0xE0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xF0,
  0x1C, 0xDE, 0xF8, 0xCF, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x07,
  0xF9, 0xC7, 0x8E, 0xE7, 0x01, 0xF7, 0x00, 0x7B, 0x00, 0x1D, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xD8,
  0x00, 0xEC, 0x00, 0x77, 0x00, 0x79, 0xC0, 0x7C, 0x7D, 0xEE, 0x1F, 0xE7,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x80, 0x63, 0xFC, 0x33, 0x8F, 0x1B,
  0x01, 0xCF, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x07, 0xFE,
  0x0F, 0x87, 0x8E, 0x00, 0xE6, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1B, 0x80, 0x18, 0xF8, 0xFC, 0x3F, 0xF8, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x0E, 0x70,
  0x1C, 0x3E, 0xF8, 0x1F, 0xF0, 0xE0, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03,
  0x38, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0E, 0x00, 0x60, 0xC0, 0x18,
  0x18, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x06, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xD8, 0x1C, 0x06, 0xC0, 0xA0, 0x36, 0x05,
  0x83, 0x30, 0x6C, 0x19, 0x83, 0x60, 0xCC, 0x19, 0x06, 0x30, 0x88, 0x31,
  0x84, 0x61, 0x0C, 0x23, 0x18, 0x63, 0x18, 0xC3, 0x18, 0x46, 0x18, 0xC2,
  0x30, 0x64, 0x19, 0x83, 0x20, 0xC8, 0x1B, 0x06, 0xC0, 0xD8, 0x36, 0x06,
  0xC0, 0xB0, 0x34, 0x05, 0x80, 0xA0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x00, 0x70, 0x00, 0xE6, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x01, 0x80, 0xC0,
  0x60, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0xB8, 0x00, 0x36,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xC6,
  0x00, 0x38, 0x60, 0x06, 0x0E, 0x01, 0x80, 0xC0, 0x70, 0x0C, 0x0C, 0x01,
  0xC3, 0x00, 0x18, 0xE0, 0x01, 0xB8, 0x00, 0x38, 0xE0, 0x00, 0xEC, 0x00,
  0x19, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x70, 0x03, 0x06, 0x00,
  0xE0, 0xE0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x38, 0x18, 0x03, 0x07,
  0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x1C, 0xC0, 0x01, 0x98,
  0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x78, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x18,
  0x00, 0xDF, 0x80, 0x3C, 0x30, 0x0F, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x18,
  0x68, 0x07, 0xFA, 0x00, 0x7C,
};

const GFXglyph JetBrainsMono_Thin42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 5, 31, 25, 10, -31 },
  { 21, 11, 13, 25, 7, -31 },
  { 39, 23, 31, 25, 1, -31 },
  { 129, 18, 43, 25, 4, -37 },
  { 226, 23, 31, 25, 1, -31 },
  { 316, 21, 31, 25, 3, -31 },
  { 398, 3, 13, 25, 11, -31 },
  { 403, 11, 40, 25, 9, -35 },
  { 458, 12, 40, 25, 5, -35 },
  { 518, 21, 22, 25, 2, -26 },
  { 576, 19, 20, 25, 3, -24 },
  { 624, 7, 13, 25, 8, -6 },
  { 636, 13, 2, 25, 6, -15 },
  { 640, 6, 6, 25, 10, -6 },
  { 645, 17, 40, 25, 4, -35 },
  { 730, 17, 31, 25, 4, -31 },
  { 796, 18, 31, 25, 4, -31 },
  { 866, 18, 31, 25, 4, -31 },
  { 936, 17, 31, 25, 4, -31 },
  { 1002, 16, 31, 25, 4, -31 },
  { 1064, 17, 31, 25, 4, -31 },
  { 1130, 18, 31, 25, 4, -31 },
  { 1200, 18, 31, 25, 4, -31 },
  { 1270, 17, 31, 25, 4, -31 },
  { 1336, 18, 31, 25, 4, -31 },
  { 1406, 6, 24, 25, 10, -24 },
  { 1424, 8, 31, 25, 8, -24 },
  { 1455, 17, 21, 25, 4, -24 },
  { 1500, 17, 12, 25, 4, -20 },
  { 1526, 17, 21, 25, 4, -24 },
  { 1571, 14, 31, 25, 7, -31 },
  { 1626, 20, 39, 25, 3, -31 },
  { 1724, 19, 31, 25, 3, -31 },
  { 1798, 17, 31, 25, 5, -31 },
  { 1864, 17, 31, 25, 4, -31 },
  { 1930, 16, 31, 25, 5, -31 },
  { 1992, 16, 31, 25, 5, -31 },
  { 2054, 17, 31, 25, 5, -31 },
  { 2120, 17, 31, 25, 4, -31 },
  { 2186, 16, 31, 25, 5, -31 },
  { 2248, 15, 31, 25, 5, -31 },
  { 2307, 17, 31, 25, 3, -31 },
  { 2373, 18, 31, 25, 5, -31 },
  { 2443, 17, 31, 25, 5, -31 },
  { 2509, 17, 31, 25, 4, -31 },
  { 2575, 16, 31, 25, 5, -31 },
  { 2637, 17, 31, 25, 4, -31 },
  { 2703, 17, 31, 25, 5, -31 },
  { 2769, 17, 39, 25, 4, -31 },
  { 2852, 17, 31, 25, 5, -31 },
  { 2918, 18, 31, 25, 4, -31 },
  { 2988, 20, 31, 25, 3, -31 },
  { 3066, 16, 31, 25, 5, -31 },
  { 3128, 19, 31, 25, 3, -31 },
  { 3202, 22, 31, 25, 2, -31 },
  { 3288, 21, 31, 25, 2, -31 },
  { 3370, 21, 31, 25, 2, -31 },
  { 3452, 17, 31, 25, 4, -31 },
  { 3518, 10, 40, 25, 9, -35 },
  { 3568, 17, 40, 25, 4, -35 },
  { 3653, 9, 40, 25, 7, -35 },
  { 3698, 17, 17, 25, 4, -31 },
  { 3735, 20, 2, 25, 3, 1 },
  { 3740, 7, 6, 25, 8, -33 },
  { 3746, 18, 24, 25, 3, -24 },
  { 3800, 16, 31, 25, 5, -31 },
  { 3862, 17, 24, 25, 4, -24 },
  { 3913, 17, 31, 25, 4, -31 },
  { 3979, 17, 24, 25, 4, -24 },
  { 4030, 19, 31, 25, 3, -31 },
  { 4104, 17, 32, 25, 4, -24 },
  { 4172, 16, 31, 25, 5, -31 },
  { 4234, 18, 32, 25, 4, -32 },
  { 4306, 15, 40, 25, 4, -32 },
  { 4381, 17, 31, 25, 5, -31 },
  { 4447, 21, 31, 25, 2, -31 },
  { 4529, 19, 24, 25, 3, -24 },
  { 4586, 16, 24, 25, 5, -24 },
  { 4634, 17, 24, 25, 4, -24 },
  { 4685, 16, 32, 25, 5, -24 },
  { 4749, 17, 32, 25, 4, -24 },
  { 4817, 17, 24, 25, 5, -24 },
  { 4868, 17, 24, 25, 4, -24 },
  { 4919, 18, 30, 25, 3, -30 },
  { 4987, 16, 23, 25, 5, -23 },
  { 5033, 19, 23, 25, 3, -23 },
  { 5088, 21, 23, 25, 2, -23 },
  { 5149, 19, 23, 25, 3, -23 },
  { 5204, 19, 31, 25, 3, -23 },
  { 5278, 17, 23, 25, 4, -23 },
  { 5327, 17, 40, 25, 4, -35 },
  { 5412, 2, 40, 25, 12, -35 },
  { 5422, 17, 40, 25, 4, -35 },
  { 5507, 18, 8, 25, 4, -19 },
};

const GFXfont JetBrainsMono_Thin42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_THIN42PT7B_H_
