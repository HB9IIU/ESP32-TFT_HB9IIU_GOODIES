#ifndef _JETBRAINSMONO_THIN58PT7B_H_
#define _JETBRAINSMONO_THIN58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin58pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60,
  0xC1, 0x83, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0xFF, 0xFF,
  0x7E, 0xF8, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0,
  0x07, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x60, 0x03,
  0x80, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x0C, 0x03, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x01, 0x80,
  0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xC3, 0x1F, 0x03, 0xC1, 0x87, 0x83, 0xC0, 0xC1, 0xE1, 0xC0, 0x60,
  0x71, 0xC0, 0x30, 0x1C, 0xE0, 0x18, 0x0E, 0x70, 0x0C, 0x07, 0x38, 0x06,
  0x03, 0x9C, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x80, 0xC0, 0x01, 0xC0,
  0x60, 0x00, 0xF0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x1E, 0x0C, 0x00, 0x07,
  0xC6, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x37, 0xE0, 0x00, 0x18, 0xF8, 0x00, 0x0C, 0x1E,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0,
  0x70, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0F, 0xC0, 0x18, 0x07, 0xE0, 0x0C,
  0x03, 0xF0, 0x06, 0x01, 0xF8, 0x03, 0x00, 0xEE, 0x01, 0x80, 0xE7, 0x00,
  0xC0, 0x71, 0xC0, 0x60, 0x70, 0xF8, 0x30, 0x78, 0x3F, 0x19, 0xF8, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x87,
  0xFC, 0x00, 0x03, 0x87, 0xFF, 0x00, 0x01, 0x87, 0x83, 0x80, 0x01, 0xC3,
  0x00, 0xE0, 0x01, 0xC3, 0x80, 0x30, 0x00, 0xC1, 0xC0, 0x18, 0x00, 0xE0,
  0xE0, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x60,
  0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x70, 0x30,
  0x03, 0x80, 0x38, 0x38, 0x01, 0xC0, 0x18, 0x38, 0x00, 0xE0, 0x1C, 0x18,
  0x00, 0x38, 0x1E, 0x18, 0x00, 0x0F, 0xFE, 0x1C, 0x00, 0x03, 0xFE, 0x1C,
  0x00, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xF0, 0x00, 0x07, 0x07, 0xFC, 0x00, 0x03, 0x07, 0x8F, 0x00, 0x03,
  0x87, 0x01, 0xC0, 0x03, 0x83, 0x00, 0x60, 0x01, 0x83, 0x80, 0x38, 0x01,
  0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xC0, 0x70, 0x07, 0x00,
  0xC0, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xE0,
  0x60, 0x07, 0x00, 0x70, 0x70, 0x03, 0x80, 0x38, 0x70, 0x00, 0xC0, 0x18,
  0x30, 0x00, 0x70, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x38, 0x00, 0x0F, 0xFE,
  0x38, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x01, 0xC0, 0xE0, 0x01, 0xDE, 0x03, 0x80, 0x1C, 0xE0, 0x1E, 0x00, 0xC7,
  0x00, 0x78, 0x0E, 0x38, 0x01, 0xC0, 0xE1, 0xC0, 0x07, 0x07, 0x0E, 0x00,
  0x3C, 0x70, 0x70, 0x00, 0xE3, 0x83, 0x80, 0x03, 0xB8, 0x1C, 0x00, 0x0F,
  0xC0, 0xE0, 0x00, 0x7C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0xFC, 0x0E, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x73, 0x81, 0xC0,
  0x07, 0x8E, 0x0F, 0x00, 0x78, 0x38, 0x3E, 0x0F, 0x80, 0xE0, 0xFF, 0xF0,
  0x07, 0x03, 0xFF, 0x00, 0x1E, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x77, 0x77, 0x77, 0x70, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x40, 0x03, 0x80, 0x01,
  0xC0, 0x0E, 0x00, 0x77, 0xE0, 0x38, 0x0F, 0xFF, 0xF0, 0xE1, 0xFF, 0x1F,
  0xF3, 0x1F, 0xE0, 0x0F, 0xF5, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E,
  0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3E,
  0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x08,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x0F, 0xC3,
  0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x79, 0xC0, 0x00, 0xF8,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38, 0x01, 0xF0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x20, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0xC0,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0xC0,
  0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x0F,
  0xC0, 0x38, 0xFF, 0xE0, 0x73, 0xFF, 0xE0, 0xEE, 0x03, 0xE1, 0xF0, 0x01,
  0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xE7, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x0F, 0x00, 0x1C, 0x0F, 0x81,
  0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x04, 0x00, 0x07, 0x3F, 0xE0, 0x07, 0x7F, 0xFC, 0x03, 0x70, 0x1F,
  0x03, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xE0,
  0x0F, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x78,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x0F, 0x83, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3B, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0x7C, 0x00, 0x78, 0x1F, 0x80, 0xFC, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC1, 0xE0,
  0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0xC7, 0xF8, 0x07, 0xFF,
  0x9C, 0x00, 0xFF, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x3F,
  0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x08, 0x00,
  0x1F, 0xC7, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0x87, 0xF0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x3C, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xC7, 0xE0, 0x07, 0xFE,
  0x7E, 0x00, 0xFF, 0xF7, 0xE0, 0x1E, 0x01, 0x7E, 0x01, 0xC0, 0x0F, 0xE0,
  0x3C, 0x00, 0xFE, 0x03, 0x80, 0x0F, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0x80,
  0x07, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x38, 0x00, 0x7E,
  0x03, 0x80, 0x07, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x38,
  0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0x80, 0x0F,
  0xE0, 0x1C, 0x00, 0xFE, 0x01, 0xC0, 0x1F, 0xE0, 0x1F, 0x03, 0x7E, 0x00,
  0xFF, 0xF7, 0xE0, 0x07, 0xFE, 0x7E, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xE0,
  0x07, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0,
  0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1F,
  0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0x3F, 0x07, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x1E,
  0x38, 0x00, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x1F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1F, 0x81,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1B, 0xEC, 0x00, 0x1B, 0xEC,
  0x00, 0x3B, 0xEE, 0x00, 0x33, 0xE6, 0x00, 0x33, 0xE7, 0x00, 0x73, 0xE3,
  0x00, 0x63, 0xE3, 0x00, 0x63, 0xE3, 0x80, 0xE3, 0xE1, 0x80, 0xC3, 0xE1,
  0x80, 0xC3, 0xE1, 0xC1, 0x83, 0xE0, 0xC1, 0x83, 0xE0, 0xC3, 0x83, 0xE0,
  0xE3, 0x03, 0xE0, 0x63, 0x03, 0xE0, 0x77, 0x03, 0xE0, 0x36, 0x03, 0xE0,
  0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xEC, 0x00, 0x0F, 0xB8, 0x00, 0x3E, 0xE0, 0x00,
  0xF9, 0x80, 0x03, 0xE7, 0x00, 0x0F, 0x8C, 0x00, 0x3E, 0x38, 0x00, 0xF8,
  0xE0, 0x03, 0xE1, 0x80, 0x0F, 0x87, 0x00, 0x3E, 0x0C, 0x00, 0xF8, 0x38,
  0x03, 0xE0, 0xE0, 0x0F, 0x81, 0x80, 0x3E, 0x07, 0x00, 0xF8, 0x0C, 0x03,
  0xE0, 0x38, 0x0F, 0x80, 0xE0, 0x3E, 0x01, 0x80, 0xF8, 0x07, 0x03, 0xE0,
  0x0C, 0x0F, 0x80, 0x38, 0x3E, 0x00, 0xE0, 0xF8, 0x01, 0x83, 0xE0, 0x07,
  0x0F, 0x80, 0x0C, 0x3E, 0x00, 0x38, 0xF8, 0x00, 0xE3, 0xE0, 0x01, 0x8F,
  0x80, 0x07, 0x3E, 0x00, 0x1C, 0xF8, 0x00, 0x3B, 0xE0, 0x00, 0xEF, 0x80,
  0x01, 0xBE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF0, 0x0F,
  0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x37, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xCE,
  0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1E, 0x00, 0x38, 0x1F, 0x01, 0xF0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x38, 0x00, 0x7E, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8E, 0x00,
  0x7F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1E, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1B, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x38, 0x00, 0xFE, 0x1C, 0x00, 0x0F, 0x8E,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1C, 0x00,
  0x1F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0x81,
  0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0x7C, 0x00, 0x3C, 0x1F, 0x80, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x80, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x3C,
  0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x03,
  0xC0, 0x0D, 0x80, 0x1F, 0x00, 0x36, 0x00, 0x7C, 0x01, 0xD8, 0x01, 0xB0,
  0x07, 0x70, 0x06, 0xC0, 0x1D, 0xC0, 0x1B, 0x00, 0x77, 0x00, 0x6C, 0x01,
  0xDC, 0x01, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x18, 0xC0, 0x39, 0x80, 0x63,
  0x00, 0xC6, 0x03, 0x8C, 0x03, 0x18, 0x0E, 0x38, 0x0C, 0x60, 0x38, 0xE0,
  0x31, 0x80, 0xE3, 0x80, 0xC6, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x18,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C,
  0x1C, 0x1C, 0x18, 0x30, 0x70, 0x70, 0x60, 0xC1, 0xC1, 0xC3, 0x83, 0x87,
  0x07, 0x0C, 0x0E, 0x1C, 0x1C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC3, 0x01, 0x86, 0x03, 0x8C, 0x06, 0x18, 0x0E, 0x30, 0x18, 0xE0, 0x39,
  0xC0, 0x73, 0x80, 0xE6, 0x01, 0xCE, 0x03, 0x98, 0x03, 0x38, 0x0E, 0x60,
  0x0C, 0xC0, 0x39, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x07, 0xC0, 0x0D, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x07, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x70, 0x00, 0x71,
  0xE0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7C, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x70, 0x00, 0x37, 0x7C, 0x00,
  0x77, 0x3F, 0x01, 0xE7, 0x1F, 0xFF, 0xC7, 0x07, 0xFF, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x87, 0xFE, 0x07, 0x1F, 0xFF, 0x0E,
  0x70, 0x1F, 0x1D, 0xC0, 0x0E, 0x3E, 0x00, 0x0E, 0x7C, 0x00, 0x1E, 0xF0,
  0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEF, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0x3B, 0x00, 0x1E, 0x73, 0x80, 0xF8, 0xE3, 0xFF, 0xE1, 0xC3,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x03, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0,
  0x01, 0xE3, 0xC0, 0x07, 0x83, 0xF0, 0x3E, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x3F, 0xE0, 0xC3, 0xFF,
  0xE3, 0x1F, 0x03, 0xCC, 0xF0, 0x03, 0xB3, 0x80, 0x07, 0xDC, 0x00, 0x0F,
  0x70, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x3C, 0xE0, 0x01,
  0xF3, 0xC0, 0x0E, 0xC7, 0xC0, 0x73, 0x0F, 0xFF, 0x8C, 0x0F, 0xFC, 0x30,
  0x03, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7C, 0x0F, 0x81,
  0xE0, 0x07, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC3,
  0xC0, 0x07, 0x83, 0xE0, 0x3E, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x0C, 0x3F, 0xFE,
  0x31, 0xF0, 0x3C, 0xCF, 0x00, 0x3B, 0x38, 0x00, 0x6D, 0xC0, 0x00, 0xF7,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00,
  0x0F, 0x38, 0x00, 0x2C, 0xF0, 0x01, 0xB1, 0xF0, 0x1C, 0xC3, 0xFF, 0xE3,
  0x07, 0xFF, 0x0C, 0x03, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x87, 0xFE, 0x07, 0x1F,
  0xFF, 0x0E, 0x78, 0x3F, 0x1D, 0xC0, 0x1E, 0x3A, 0x00, 0x0E, 0x7C, 0x00,
  0x1E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0xF0, 0xC0, 0x01, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x07,
  0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x1C,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07,
  0x80, 0xC0, 0x03, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0xC0, 0x00,
  0xF0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x3C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xCF, 0xE0,
  0xFE, 0x6F, 0xF8, 0xFF, 0xB6, 0x1E, 0xC3, 0xDE, 0x07, 0x40, 0xFE, 0x03,
  0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0x80, 0x38, 0x07, 0xC0,
  0x1C, 0x03, 0xE0, 0x0E, 0x01, 0xF0, 0x07, 0x00, 0xF8, 0x03, 0x80, 0x7C,
  0x01, 0xC0, 0x3E, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0F, 0x80, 0x38, 0x07,
  0xC0, 0x1C, 0x03, 0xE0, 0x0E, 0x01, 0xF0, 0x07, 0x00, 0xF8, 0x03, 0x80,
  0x7C, 0x01, 0xC0, 0x3E, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0F, 0x80, 0x38,
  0x07, 0xC0, 0x1C, 0x03, 0xE0, 0x0E, 0x01, 0xF0, 0x07, 0x00, 0xF8, 0x03,
  0x80, 0x7C, 0x01, 0xC0, 0x3E, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0F, 0x80,
  0x38, 0x07, 0xE0, 0xFF, 0x81, 0xC7, 0xFF, 0xC3, 0x9E, 0x0F, 0xC7, 0x70,
  0x07, 0x8E, 0x80, 0x03, 0x9F, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00,
  0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7E, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0x80, 0x03,
  0x8E, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x0D,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x03, 0xE0, 0x3E,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xE1, 0xFF, 0x81,
  0xC7, 0xFF, 0xC3, 0x9E, 0x07, 0xC7, 0x70, 0x03, 0xCF, 0x80, 0x03, 0x9F,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B,
  0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xCE, 0xC0, 0x07, 0x1C, 0xE0, 0x3E, 0x38,
  0xFF, 0xF8, 0x70, 0xFF, 0xC0, 0xE0, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x0C, 0x3F, 0xFE, 0x31, 0xF0, 0x3C, 0xCF, 0x00, 0x3B, 0x38, 0x00, 0x7D,
  0xC0, 0x00, 0xF7, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03,
  0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xEC, 0x7C, 0x07, 0x30, 0xFF, 0xF8, 0xC0,
  0xFF, 0xC3, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0xE1, 0xFF, 0x81, 0xC7, 0xFF, 0xC3,
  0x9E, 0x07, 0xC7, 0x70, 0x03, 0xCE, 0x80, 0x03, 0x9F, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0x7C, 0x1E,
  0x00, 0x1E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x3C, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0xC0,
  0x0F, 0x03, 0xE0, 0x7C, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x1B, 0x00, 0x66,
  0x00, 0xD8, 0x07, 0x38, 0x06, 0xC0, 0x39, 0xC0, 0x36, 0x01, 0xCE, 0x01,
  0xB0, 0x0E, 0x70, 0x19, 0xC0, 0x61, 0x80, 0xC6, 0x03, 0x0C, 0x06, 0x30,
  0x38, 0x70, 0x31, 0x81, 0xC3, 0x81, 0x8C, 0x0E, 0x1C, 0x1C, 0x70, 0x70,
  0xE0, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x61, 0xC0, 0xE1,
  0x83, 0x0E, 0x07, 0x1C, 0x1C, 0x70, 0x38, 0xC0, 0xE3, 0x81, 0xC6, 0x03,
  0x18, 0x06, 0x30, 0x18, 0xC0, 0x31, 0x80, 0xCE, 0x01, 0xDC, 0x06, 0x70,
  0x0E, 0xE0, 0x3B, 0x80, 0x76, 0x01, 0xDC, 0x03, 0xB0, 0x06, 0xC0, 0x0D,
  0x80, 0x36, 0x00, 0x6C, 0x01, 0xB0, 0x03, 0xE0, 0x0D, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3B, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0x9F, 0xE0, 0x01, 0xDF, 0xF8, 0x00, 0xFE, 0x0E, 0x00, 0x7E,
  0x03, 0x80, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x38, 0x0F, 0xC0, 0x1E, 0x0E,
  0xE0, 0x07, 0xFF, 0x70, 0x00, 0xFF, 0x38, 0x00, 0x3E, 0x00,
};

const GFXglyph JetBrainsMono_Thin58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 7, 42, 35, 14, -42 },
  { 38, 15, 17, 35, 10, -42 },
  { 70, 31, 42, 35, 2, -42 },
  { 233, 25, 58, 35, 5, -50 },
  { 415, 33, 43, 35, 1, -43 },
  { 593, 29, 44, 35, 4, -43 },
  { 753, 4, 17, 35, 15, -42 },
  { 762, 16, 56, 35, 12, -49 },
  { 874, 16, 56, 35, 7, -49 },
  { 986, 30, 29, 35, 2, -35 },
  { 1095, 26, 27, 35, 4, -33 },
  { 1183, 10, 18, 35, 11, -9 },
  { 1206, 19, 2, 35, 8, -20 },
  { 1211, 9, 9, 35, 13, -8 },
  { 1222, 23, 54, 35, 6, -48 },
  { 1378, 24, 44, 35, 5, -43 },
  { 1510, 25, 42, 35, 6, -42 },
  { 1642, 26, 43, 35, 5, -43 },
  { 1782, 23, 43, 35, 5, -42 },
  { 1906, 22, 42, 35, 6, -42 },
  { 2022, 23, 43, 35, 6, -42 },
  { 2146, 25, 43, 35, 5, -42 },
  { 2281, 25, 42, 35, 5, -42 },
  { 2413, 25, 44, 35, 5, -43 },
  { 2551, 25, 43, 35, 5, -43 },
  { 2686, 9, 33, 35, 13, -32 },
  { 2724, 11, 41, 35, 11, -32 },
  { 2781, 25, 29, 35, 5, -34 },
  { 2872, 23, 16, 35, 6, -27 },
  { 2918, 25, 29, 35, 5, -34 },
  { 3009, 19, 42, 35, 10, -42 },
  { 3109, 28, 53, 35, 4, -43 },
  { 3295, 27, 42, 35, 4, -42 },
  { 3437, 24, 42, 35, 6, -42 },
  { 3563, 24, 44, 35, 6, -43 },
  { 3695, 23, 42, 35, 6, -42 },
  { 3816, 23, 42, 35, 7, -42 },
  { 3937, 23, 42, 35, 7, -42 },
  { 4058, 24, 44, 35, 6, -43 },
  { 4190, 22, 42, 35, 6, -42 },
  { 4306, 21, 42, 35, 7, -42 },
  { 4417, 24, 43, 35, 4, -42 },
  { 4546, 25, 42, 35, 6, -42 },
  { 4678, 23, 42, 35, 7, -42 },
  { 4799, 24, 42, 35, 5, -42 },
  { 4925, 22, 42, 35, 6, -42 },
  { 5041, 23, 44, 35, 6, -43 },
  { 5168, 25, 42, 35, 6, -42 },
  { 5300, 24, 53, 35, 6, -43 },
  { 5459, 25, 42, 35, 6, -42 },
  { 5591, 25, 44, 35, 5, -43 },
  { 5729, 28, 42, 35, 3, -42 },
  { 5876, 23, 43, 35, 6, -42 },
  { 6000, 27, 42, 35, 4, -42 },
  { 6142, 30, 42, 35, 2, -42 },
  { 6300, 29, 42, 35, 3, -42 },
  { 6453, 29, 42, 35, 3, -42 },
  { 6606, 24, 42, 35, 5, -42 },
  { 6732, 13, 54, 35, 13, -48 },
  { 6820, 23, 54, 35, 6, -48 },
  { 6976, 13, 54, 35, 9, -48 },
  { 7064, 23, 22, 35, 6, -42 },
  { 7128, 28, 3, 35, 3, 1 },
  { 7139, 9, 9, 35, 12, -46 },
  { 7150, 24, 33, 35, 5, -32 },
  { 7249, 23, 43, 35, 6, -42 },
  { 7373, 23, 33, 35, 6, -32 },
  { 7468, 22, 43, 35, 6, -42 },
  { 7587, 23, 33, 35, 6, -32 },
  { 7682, 26, 42, 35, 4, -42 },
  { 7819, 22, 42, 35, 6, -32 },
  { 7935, 23, 42, 35, 6, -42 },
  { 8056, 25, 44, 35, 6, -44 },
  { 8194, 20, 54, 35, 6, -44 },
  { 8329, 24, 42, 35, 7, -42 },
  { 8455, 28, 42, 35, 3, -42 },
  { 8602, 25, 32, 35, 5, -32 },
  { 8702, 23, 32, 35, 6, -32 },
  { 8794, 23, 33, 35, 6, -32 },
  { 8889, 23, 42, 35, 6, -32 },
  { 9010, 22, 42, 35, 6, -32 },
  { 9126, 23, 32, 35, 7, -32 },
  { 9218, 24, 33, 35, 5, -32 },
  { 9317, 25, 41, 35, 4, -41 },
  { 9446, 23, 33, 35, 6, -32 },
  { 9541, 26, 32, 35, 4, -32 },
  { 9645, 29, 32, 35, 3, -32 },
  { 9761, 26, 32, 35, 4, -32 },
  { 9865, 26, 42, 35, 4, -32 },
  { 10002, 23, 32, 35, 6, -32 },
  { 10094, 23, 54, 35, 6, -48 },
  { 10250, 3, 54, 35, 16, -48 },
  { 10271, 23, 54, 35, 6, -48 },
  { 10427, 25, 11, 35, 5, -26 },
};

const GFXfont JetBrainsMono_Thin58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_THIN58PT7B_H_
