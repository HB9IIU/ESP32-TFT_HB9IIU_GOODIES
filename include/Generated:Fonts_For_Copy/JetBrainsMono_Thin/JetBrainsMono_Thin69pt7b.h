#ifndef _JETBRAINSMONO_THIN69PT7B_H_
#define _JETBRAINSMONO_THIN69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin69pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xE3, 0x3F, 0x80, 0x3E, 0x0C, 0x1F, 0x01, 0xE0, 0x30, 0x3E,
  0x07, 0x80, 0xC0, 0x78, 0x3C, 0x03, 0x00, 0xF0, 0xE0, 0x0C, 0x03, 0xC7,
  0x80, 0x30, 0x07, 0x1E, 0x00, 0xC0, 0x1E, 0x78, 0x03, 0x00, 0x79, 0xE0,
  0x0C, 0x01, 0xE7, 0x80, 0x30, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x38, 0x03,
  0x00, 0x00, 0xF0, 0x0C, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x07, 0x80, 0xC0,
  0x00, 0x1F, 0x03, 0x00, 0x00, 0x3E, 0x0C, 0x00, 0x00, 0x7C, 0x30, 0x00,
  0x01, 0xFC, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x7F, 0x00, 0x00,
  0x0C, 0x3E, 0x00, 0x00, 0x30, 0x7C, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x03,
  0x00, 0xF0, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x30, 0x07, 0x80, 0x00, 0xC0,
  0x1E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x03,
  0xB8, 0x00, 0xC0, 0x0F, 0xE0, 0x03, 0x00, 0x3F, 0xC0, 0x0C, 0x00, 0xEF,
  0x00, 0x30, 0x03, 0xBC, 0x00, 0xC0, 0x1E, 0x78, 0x03, 0x00, 0x79, 0xE0,
  0x0C, 0x03, 0xC3, 0xC0, 0x30, 0x0F, 0x0F, 0x80, 0xC0, 0xF8, 0x1F, 0x83,
  0x07, 0xC0, 0x3F, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x0F, 0xFC, 0x00, 0x00,
  0x38, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0xF8, 0x7C, 0x00, 0x01, 0xC3, 0xC0,
  0x3C, 0x00, 0x07, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x70, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x00,
  0xF0, 0x1E, 0x0E, 0x00, 0x01, 0xFF, 0xF8, 0x38, 0x00, 0x01, 0xFF, 0xE0,
  0xE0, 0x00, 0x00, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0,
  0x00, 0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x7F, 0xFC, 0x00, 0x01,
  0xC1, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x78, 0x00, 0x0E, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x07, 0x83,
  0x80, 0x01, 0xE0, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x38, 0x00, 0x01,
  0xFF, 0xF0, 0xF0, 0x00, 0x01, 0xFF, 0xC3, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xDE, 0x00,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x3C, 0x03,
  0xC0, 0x01, 0xC7, 0x80, 0x3C, 0x00, 0x78, 0xE0, 0x03, 0xC0, 0x1E, 0x1C,
  0x00, 0x78, 0x03, 0x87, 0x80, 0x07, 0x80, 0xF0, 0xF0, 0x00, 0x78, 0x1C,
  0x1E, 0x00, 0x07, 0x87, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x78, 0x00, 0x0F,
  0x3C, 0x0F, 0x00, 0x00, 0xF7, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x3C, 0x00,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0E,
  0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x38, 0x00, 0x07, 0xBC,
  0x07, 0x80, 0x00, 0xF3, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x1F,
  0x03, 0x81, 0xF8, 0x07, 0xC0, 0x78, 0x1F, 0xEF, 0xF0, 0x07, 0x81, 0xFF,
  0xFC, 0x00, 0x78, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0x0C, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x40, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0xFE, 0x00, 0xE0,
  0x07, 0xEF, 0xFC, 0x0E, 0x03, 0xFF, 0x7F, 0xF0, 0xE1, 0xFF, 0xC0, 0xFF,
  0xC6, 0x7F, 0xE0, 0x01, 0xFF, 0x6F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0x7E,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x08, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x9F, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x1C, 0x01, 0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0xFF, 0x00, 0x78,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0x00,
  0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x01, 0xFE, 0x00,
  0x70, 0xFF, 0xFC, 0x07, 0x1F, 0xFF, 0xE0, 0x73, 0xC0, 0x7F, 0x07, 0x70,
  0x00, 0xF8, 0x76, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x1F, 0xF8, 0x00, 0x39, 0xFF, 0xF8, 0x01, 0xEF, 0xFF, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x70, 0x1E, 0x00, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x0F, 0xFC,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xFF,
  0xFB, 0xC0, 0x07, 0xFF, 0xCE, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0C, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE7, 0xF0, 0x30, 0x03, 0x80, 0x7F, 0x07, 0xFC, 0x3F, 0xF3, 0xFF, 0x9F,
  0xFC, 0x7F, 0xE3, 0xFE, 0x0F, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x07, 0xFE,
  0x3F, 0xC0, 0x03, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0xFB, 0xFC, 0x00, 0xF8,
  0x07, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x1F, 0xF0, 0x07,
  0x80, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x70, 0x00, 0x3F, 0xC0,
  0x1C, 0x00, 0x0F, 0xF0, 0x07, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0x70, 0x00, 0x3F, 0xC0, 0x1C, 0x00, 0x0F, 0xF0, 0x07, 0x00, 0x03,
  0xFC, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x1C, 0x00,
  0x0F, 0xF0, 0x07, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x70,
  0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x07, 0xFC, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0xFF, 0x70,
  0x01, 0xFF, 0xFB, 0xDC, 0x00, 0x3F, 0xFC, 0xF7, 0x00, 0x03, 0xFC, 0x3D,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00,
  0xF8, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0x3F, 0x0E, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x03,
  0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xF8, 0x07,
  0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0x80,
  0x07, 0xF0, 0xE0, 0x00, 0x7E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x7C,
  0xE0, 0x00, 0x3E, 0x38, 0x00, 0x1F, 0x0E, 0x00, 0x3F, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x80, 0xF8, 0x01, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0x80, 0xFF,
  0x9F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x03,
  0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78,
  0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x7F, 0xDC, 0x00, 0x03,
  0x7E, 0xE0, 0x00, 0x3B, 0xF3, 0x80, 0x01, 0xDF, 0xDC, 0x00, 0x1C, 0xFE,
  0x60, 0x00, 0xE7, 0xF3, 0x80, 0x06, 0x3F, 0x9C, 0x00, 0x71, 0xFC, 0x60,
  0x03, 0x8F, 0xE3, 0x80, 0x18, 0x7F, 0x1C, 0x01, 0xC3, 0xF8, 0x70, 0x0E,
  0x1F, 0xC3, 0x80, 0x60, 0xFE, 0x1C, 0x07, 0x07, 0xF0, 0x70, 0x38, 0x3F,
  0x83, 0x83, 0x81, 0xFC, 0x0C, 0x1C, 0x0F, 0xE0, 0x70, 0xC0, 0x7F, 0x03,
  0x8E, 0x03, 0xF8, 0x0C, 0x70, 0x1F, 0xC0, 0x73, 0x00, 0xFE, 0x03, 0xB8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7C, 0x01, 0xFC, 0x01, 0xE0, 0x0F,
  0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFB, 0x80, 0x00, 0xFE, 0xE0, 0x00, 0x3F, 0xB8,
  0x00, 0x0F, 0xE7, 0x00, 0x03, 0xF9, 0xC0, 0x00, 0xFE, 0x38, 0x00, 0x3F,
  0x8E, 0x00, 0x0F, 0xE3, 0x80, 0x03, 0xF8, 0x70, 0x00, 0xFE, 0x1C, 0x00,
  0x3F, 0x87, 0x80, 0x0F, 0xE0, 0xE0, 0x03, 0xF8, 0x38, 0x00, 0xFE, 0x07,
  0x00, 0x3F, 0x81, 0xC0, 0x0F, 0xE0, 0x78, 0x03, 0xF8, 0x0E, 0x00, 0xFE,
  0x03, 0x80, 0x3F, 0x80, 0x70, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x07, 0x80,
  0xFE, 0x00, 0xE0, 0x3F, 0x80, 0x38, 0x0F, 0xE0, 0x07, 0x03, 0xF8, 0x01,
  0xC0, 0xFE, 0x00, 0x78, 0x3F, 0x80, 0x0E, 0x0F, 0xE0, 0x03, 0x83, 0xF8,
  0x00, 0x70, 0xFE, 0x00, 0x1C, 0x3F, 0x80, 0x07, 0x8F, 0xE0, 0x00, 0xE3,
  0xF8, 0x00, 0x38, 0xFE, 0x00, 0x07, 0x3F, 0x80, 0x01, 0xC7, 0xE0, 0x00,
  0x79, 0xF8, 0x00, 0x0E, 0x7E, 0x00, 0x03, 0x9F, 0x80, 0x00, 0xF7, 0xE0,
  0x00, 0x1D, 0xF8, 0x00, 0x07, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xC0, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0x7C, 0x70, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1F, 0x1C, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x7E,
  0x0E, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x3E, 0x70, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x3E, 0x1C, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01,
  0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0xE0, 0x01, 0xF0,
  0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0xCF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x1F, 0x80,
  0x0E, 0xF0, 0x01, 0xF8, 0x00, 0xEF, 0x00, 0x1B, 0x80, 0x0E, 0x70, 0x01,
  0xB8, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x1E, 0x70, 0x03, 0x98, 0x01, 0xE7,
  0x00, 0x39, 0x80, 0x1C, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0x39, 0xC0,
  0x1C, 0x78, 0x03, 0x1C, 0x01, 0xC7, 0x80, 0x31, 0xC0, 0x1C, 0x38, 0x03,
  0x0C, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x38, 0x07, 0x0C, 0x03, 0xC3,
  0x80, 0x70, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x03, 0x83, 0x80, 0x60, 0xE0,
  0x38, 0x3C, 0x06, 0x0E, 0x03, 0x83, 0xC0, 0x60, 0xE0, 0x38, 0x1C, 0x0E,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x70, 0x1C, 0x0C, 0x07, 0x07, 0x01, 0xC0, 0xC0, 0x70,
  0x70, 0x1E, 0x0C, 0x07, 0x07, 0x01, 0xE1, 0xC0, 0x30, 0x70, 0x0E, 0x1C,
  0x03, 0x07, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x0E, 0x18, 0x03, 0x87, 0x00,
  0xE1, 0x80, 0x38, 0xE0, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xE1, 0x80, 0x38,
  0xE0, 0x0F, 0x38, 0x01, 0x8E, 0x00, 0xF3, 0x80, 0x18, 0xE0, 0x07, 0x38,
  0x01, 0x8E, 0x00, 0x73, 0x00, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0xCE, 0x00,
  0x73, 0x00, 0x1D, 0xC0, 0x07, 0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x0D,
  0xC0, 0x07, 0xF0, 0x00, 0xDC, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xE0, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xF3, 0xF0,
  0x01, 0xEF, 0x1F, 0xE0, 0xFC, 0xF0, 0xFF, 0xFF, 0x8F, 0x03, 0xFF, 0xE0,
  0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0xE0, 0xFF, 0xE0, 0x38, 0xFF,
  0xFE, 0x0E, 0x7E, 0x1F, 0xC3, 0xBC, 0x00, 0xF8, 0xEC, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3B,
  0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3B, 0x00, 0x07, 0xCE, 0xF0, 0x03,
  0xE3, 0x9F, 0x87, 0xF0, 0xE3, 0xFF, 0xF8, 0x38, 0x3F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x1F, 0xFC, 0x1E, 0x07, 0xFF, 0xE3, 0xC3, 0xF8, 0x7E,
  0x78, 0xF8, 0x00, 0xEF, 0x1E, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0xFD, 0xE0,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xBC,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x1F, 0xC7, 0xC0, 0x07,
  0x78, 0x7F, 0x07, 0xCF, 0x07, 0xFF, 0xF1, 0xE0, 0x3F, 0xFC, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x0F, 0xC0, 0x0F, 0x80, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xF8, 0x3C, 0x0F, 0xFF, 0xC7, 0x87, 0xF0, 0xFC, 0xF1, 0xF0, 0x01,
  0xDE, 0x3C, 0x00, 0x1F, 0xCF, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x1F, 0x78,
  0x00, 0x03, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0xCF, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x6F, 0x0F, 0x80, 0x3D, 0xE0,
  0xFF, 0xFF, 0x3C, 0x0F, 0xFF, 0x87, 0x80, 0x7F, 0xC0, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0xFF, 0xE0, 0x38, 0xFF, 0xFE, 0x0E, 0x7E,
  0x1F, 0xC3, 0xBC, 0x00, 0xF8, 0xEC, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F,
  0x9C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x7C, 0x38,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3E, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xF0,
  0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8,
  0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x78, 0x03,
  0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x60, 0x01, 0x81, 0xC7, 0xF8, 0x1F,
  0xE3, 0x9F, 0xF8, 0x7F, 0xE7, 0x79, 0xF9, 0xE7, 0xEE, 0xC0, 0xFA, 0x03,
  0xDD, 0x00, 0xF8, 0x03, 0xBC, 0x00, 0xF0, 0x07, 0xF8, 0x01, 0xE0, 0x0F,
  0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x07, 0x00, 0x1F, 0xC0, 0x0E, 0x00, 0x3F,
  0x80, 0x1C, 0x00, 0x7F, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x70, 0x01, 0xFC,
  0x00, 0xE0, 0x03, 0xF8, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0x80, 0x0F, 0xE0,
  0x07, 0x00, 0x1F, 0xC0, 0x0E, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x7F, 0x00,
  0x38, 0x00, 0xFE, 0x00, 0x70, 0x01, 0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x01,
  0xC0, 0x07, 0xF0, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x1F, 0xC0, 0x0E,
  0x00, 0x3F, 0x80, 0x1C, 0x00, 0x7F, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x70,
  0x01, 0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0x80,
  0x0F, 0xE0, 0x07, 0x00, 0x1F, 0xC0, 0x0E, 0x00, 0x3F, 0x80, 0x1C, 0x00,
  0x7F, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x70, 0x01, 0xFC, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x38, 0x3F, 0xF8, 0x0E, 0x3F, 0xFF, 0x83, 0x9F,
  0x87, 0xF0, 0xE7, 0x00, 0x3E, 0x3B, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0xF8, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0xFF, 0x0F,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x3F, 0xF8, 0x0E, 0x3F, 0xFF, 0x83, 0x9F, 0x87, 0xF0,
  0xEF, 0x00, 0x3E, 0x3B, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xCE, 0xC0, 0x01, 0xF3, 0xBC, 0x00, 0xF8, 0xE7, 0xE1, 0xFC, 0x38,
  0xFF, 0xFE, 0x0E, 0x0F, 0xFE, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xF8, 0x3C, 0x0F, 0xFF, 0xC7, 0x87, 0xF0, 0xFC, 0xF1, 0xF0,
  0x01, 0xDE, 0x3C, 0x00, 0x1F, 0xCF, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x3F, 0x8F, 0x80, 0x0E, 0xF0, 0xFE,
  0x0F, 0x9E, 0x0F, 0xFF, 0xE3, 0xC0, 0x7F, 0xF8, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x1F, 0xFE, 0x03, 0x87, 0xFF, 0xE0,
  0x71, 0xF0, 0xFF, 0x0E, 0x70, 0x03, 0xF1, 0xDC, 0x00, 0x1E, 0x3F, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xEE, 0x00, 0x1E, 0x00, 0x3D, 0xC0, 0x03, 0xC0, 0x07,
  0xB8, 0x00, 0xF8, 0x00, 0xE7, 0x80, 0x1F, 0x00, 0x1C, 0xF0, 0x03, 0x70,
  0x03, 0x8E, 0x00, 0x6E, 0x00, 0x71, 0xC0, 0x0C, 0xC0, 0x1E, 0x38, 0x03,
  0x98, 0x03, 0xC7, 0x00, 0x73, 0x00, 0x70, 0xF0, 0x0C, 0x70, 0x0E, 0x1E,
  0x01, 0x8E, 0x01, 0xC1, 0xC0, 0x31, 0xC0, 0x38, 0x38, 0x0E, 0x18, 0x0F,
  0x07, 0x01, 0xC3, 0x01, 0xC0, 0xE0, 0x38, 0x70, 0x38, 0x1E, 0x06, 0x0E,
  0x07, 0x03, 0xC0, 0xC1, 0xC0, 0xE0, 0x38, 0x38, 0x38, 0x1C, 0x07, 0x07,
  0x03, 0x07, 0x80, 0xE0, 0xE0, 0x60, 0xE0, 0x1C, 0x18, 0x0E, 0x1C, 0x03,
  0x83, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x38, 0x70, 0x07, 0x1C, 0x03, 0x0E,
  0x00, 0xE3, 0x80, 0x63, 0xC0, 0x1C, 0x70, 0x0E, 0x70, 0x03, 0x8C, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x0F, 0x70, 0x07, 0x38, 0x00, 0xEE,
  0x00, 0x67, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xB0, 0x01, 0xF8, 0x00,
  0x76, 0x00, 0x3F, 0x00, 0x0E, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x1E,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x7F, 0xC0, 0x00, 0xF3, 0xFF, 0x80,
  0x03, 0xDE, 0x1F, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x3F, 0x80, 0x3C, 0x00,
  0xFE, 0x00, 0x78, 0x03, 0xB8, 0x01, 0xF0, 0x0E, 0xE0, 0x03, 0xE0, 0x3B,
  0x80, 0x07, 0xC1, 0xEE, 0x00, 0x0F, 0xFF, 0x38, 0x00, 0x1F, 0xF8, 0xE0,
  0x00, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_Thin69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 8, 50, 41, 17, -50 },
  { 51, 18, 20, 41, 12, -50 },
  { 96, 37, 50, 41, 2, -50 },
  { 328, 30, 70, 41, 6, -60 },
  { 591, 39, 51, 41, 1, -51 },
  { 840, 35, 52, 41, 4, -51 },
  { 1068, 5, 20, 41, 18, -50 },
  { 1081, 19, 66, 41, 14, -58 },
  { 1238, 19, 66, 41, 8, -58 },
  { 1395, 36, 35, 41, 3, -42 },
  { 1553, 31, 32, 41, 5, -39 },
  { 1677, 12, 21, 41, 13, -10 },
  { 1709, 22, 3, 41, 10, -24 },
  { 1718, 10, 11, 41, 16, -10 },
  { 1732, 28, 65, 41, 7, -57 },
  { 1960, 29, 52, 41, 6, -51 },
  { 2149, 30, 50, 41, 7, -50 },
  { 2337, 31, 51, 41, 6, -51 },
  { 2535, 28, 51, 41, 6, -50 },
  { 2714, 26, 50, 41, 7, -50 },
  { 2877, 28, 51, 41, 7, -50 },
  { 3056, 30, 51, 41, 6, -50 },
  { 3248, 30, 50, 41, 6, -50 },
  { 3436, 29, 52, 41, 6, -51 },
  { 3625, 30, 51, 41, 6, -51 },
  { 3817, 10, 40, 41, 16, -39 },
  { 3867, 13, 50, 41, 13, -39 },
  { 3949, 29, 34, 41, 6, -40 },
  { 4073, 28, 19, 41, 7, -32 },
  { 4140, 29, 34, 41, 6, -40 },
  { 4264, 23, 50, 41, 12, -50 },
  { 4408, 34, 63, 41, 4, -51 },
  { 4676, 32, 50, 41, 5, -50 },
  { 4876, 28, 50, 41, 8, -50 },
  { 5051, 28, 52, 41, 7, -51 },
  { 5233, 26, 50, 41, 8, -50 },
  { 5396, 27, 50, 41, 8, -50 },
  { 5565, 28, 50, 41, 8, -50 },
  { 5740, 28, 52, 41, 7, -51 },
  { 5922, 26, 50, 41, 8, -50 },
  { 6085, 25, 50, 41, 8, -50 },
  { 6242, 28, 51, 41, 5, -50 },
  { 6421, 29, 50, 41, 8, -50 },
  { 6603, 28, 50, 41, 8, -50 },
  { 6778, 29, 50, 41, 6, -50 },
  { 6960, 26, 50, 41, 8, -50 },
  { 7123, 27, 52, 41, 7, -51 },
  { 7299, 29, 50, 41, 8, -50 },
  { 7481, 28, 63, 41, 7, -51 },
  { 7702, 29, 50, 41, 8, -50 },
  { 7884, 30, 52, 41, 6, -51 },
  { 8079, 33, 50, 41, 4, -50 },
  { 8286, 27, 51, 41, 7, -50 },
  { 8459, 32, 50, 41, 5, -50 },
  { 8659, 36, 50, 41, 3, -50 },
  { 8884, 34, 50, 41, 4, -50 },
  { 9097, 35, 50, 41, 3, -50 },
  { 9316, 29, 50, 41, 6, -50 },
  { 9498, 16, 65, 41, 15, -57 },
  { 9628, 28, 65, 41, 7, -57 },
  { 9856, 15, 65, 41, 11, -57 },
  { 9978, 28, 27, 41, 7, -50 },
  { 10073, 33, 3, 41, 4, 2 },
  { 10086, 11, 10, 41, 14, -54 },
  { 10100, 28, 40, 41, 6, -39 },
  { 10240, 26, 51, 41, 8, -50 },
  { 10406, 28, 40, 41, 7, -39 },
  { 10546, 27, 51, 41, 7, -50 },
  { 10719, 27, 40, 41, 7, -39 },
  { 10854, 31, 50, 41, 5, -50 },
  { 11048, 27, 51, 41, 7, -39 },
  { 11221, 26, 50, 41, 8, -50 },
  { 11384, 30, 53, 41, 7, -53 },
  { 11583, 24, 65, 41, 7, -53 },
  { 11778, 29, 50, 41, 8, -50 },
  { 11960, 34, 50, 41, 3, -50 },
  { 12173, 31, 39, 41, 5, -39 },
  { 12325, 26, 39, 41, 8, -39 },
  { 12452, 27, 40, 41, 7, -39 },
  { 12587, 26, 51, 41, 8, -39 },
  { 12753, 27, 51, 41, 7, -39 },
  { 12926, 27, 39, 41, 9, -39 },
  { 13058, 29, 40, 41, 6, -39 },
  { 13203, 30, 49, 41, 5, -49 },
  { 13387, 27, 39, 41, 7, -38 },
  { 13519, 31, 38, 41, 5, -38 },
  { 13667, 35, 38, 41, 3, -38 },
  { 13834, 31, 38, 41, 5, -38 },
  { 13982, 31, 50, 41, 5, -38 },
  { 14176, 27, 38, 41, 7, -38 },
  { 14305, 28, 65, 41, 7, -57 },
  { 14533, 3, 65, 41, 19, -57 },
  { 14558, 28, 65, 41, 7, -57 },
  { 14786, 30, 13, 41, 6, -31 },
};

const GFXfont JetBrainsMono_Thin69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_THIN69PT7B_H_
