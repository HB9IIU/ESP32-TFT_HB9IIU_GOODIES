#ifndef _JETBRAINSMONO_THIN71PT7B_H_
#define _JETBRAINSMONO_THIN71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin71pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0xFF, 0xFF, 0xBF, 0xDF, 0xC7, 0xC0,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xE7,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFC, 0x71, 0xF8, 0x03, 0xE0, 0xE0, 0xF8, 0x0F, 0x81, 0xC0, 0xF8, 0x1E,
  0x03, 0x80, 0xF0, 0x78, 0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x01, 0xE1, 0xC0,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03, 0xCF, 0x00, 0x70, 0x07, 0x9E, 0x00,
  0xE0, 0x0F, 0x3C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x03, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x03, 0xE1, 0xC0,
  0x00, 0x03, 0xF3, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xE3, 0xF0, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x03, 0x81, 0xF0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0xE0, 0x07, 0x00, 0x3F, 0xC0,
  0x0E, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0xEF, 0x00, 0x38, 0x01, 0xCF, 0x00,
  0x70, 0x07, 0x9E, 0x00, 0xE0, 0x0F, 0x1E, 0x01, 0xC0, 0x3C, 0x3E, 0x03,
  0x80, 0xF8, 0x3E, 0x07, 0x03, 0xE0, 0x3F, 0x0E, 0x1F, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x0F, 0xFF,
  0x80, 0x00, 0x1E, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x3C, 0x01, 0xC0, 0x00,
  0x38, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x00,
  0xE0, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x78,
  0x00, 0x38, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x01, 0xE0, 0xE0, 0x00, 0x1E,
  0x03, 0xC1, 0xE0, 0x00, 0x1F, 0xDF, 0x81, 0xC0, 0x00, 0x0F, 0xFF, 0x83,
  0x80, 0x00, 0x03, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xE0, 0xFF, 0xF0, 0x00,
  0x01, 0xC1, 0xFF, 0xF8, 0x00, 0x03, 0x81, 0xE0, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x0E,
  0x00, 0x1E, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x80, 0x0E, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0x1C,
  0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x38, 0x00, 0x01, 0xFF, 0xF8, 0x78, 0x00,
  0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE7, 0x80,
  0xF8, 0x00, 0x39, 0xE0, 0x0F, 0x00, 0x0F, 0x3C, 0x00, 0xF0, 0x01, 0xC7,
  0x00, 0x0F, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0x0E, 0x1C, 0x00, 0x1E, 0x03,
  0xC3, 0x80, 0x01, 0xE0, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x0E, 0x00, 0x03,
  0xE7, 0x81, 0xC0, 0x00, 0x3C, 0xE0, 0x38, 0x00, 0x03, 0xFC, 0x07, 0x00,
  0x00, 0x3F, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x00, 0x7F,
  0x81, 0xE0, 0x00, 0x1E, 0xF0, 0x3C, 0x00, 0x07, 0x8F, 0x03, 0xC0, 0x01,
  0xF0, 0xF0, 0x7C, 0x00, 0x7C, 0x0E, 0x07, 0xC0, 0x3F, 0x01, 0xE0, 0xFF,
  0xFF, 0xC0, 0x1E, 0x07, 0xFF, 0xE0, 0x01, 0xE0, 0x7F, 0xF8, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF7, 0xBC, 0xE7, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x70, 0x00, 0x02, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0xE7, 0xE0, 0x07, 0x00, 0x3F, 0x7F, 0xE0, 0x38, 0x0F,
  0xF9, 0xFF, 0xC1, 0xC1, 0xFF, 0xE1, 0xFF, 0x8E, 0x3F, 0xF0, 0x03, 0xFF,
  0x67, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0E, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xCF, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x0F, 0xF0, 0x0F, 0x80,
  0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x7E, 0x38, 0x00, 0x01, 0xF8, 0x70,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3F, 0x01, 0xC0, 0x00, 0xF8, 0x03, 0x80,
  0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x10, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x74, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x38, 0x1E,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x03,
  0x8F, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0xF0, 0xFF,
  0xF8, 0x07, 0x8F, 0xFF, 0xF0, 0x3D, 0xF0, 0x3F, 0xC1, 0xEE, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE1, 0xFF, 0x00, 0x03, 0xCF, 0xFF, 0xC0, 0x07, 0x7F, 0xFF, 0xC0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0xEF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x70, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xCF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFC, 0xFE, 0x0E, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0xFF,
  0x87, 0xFE, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xA0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x8F, 0xE0,
  0x00, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0xFE, 0xFE, 0x00, 0x3E, 0x01, 0xFF,
  0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0x07, 0xF8, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x0F, 0xE0, 0x0F, 0x00,
  0x03, 0xF8, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x3C,
  0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x03, 0xF8,
  0x03, 0xC0, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x0F,
  0xE0, 0x07, 0x00, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x78, 0x00,
  0x7F, 0x80, 0x1E, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0xFC,
  0x0E, 0xFE, 0x00, 0x1F, 0xFF, 0xBF, 0x80, 0x03, 0xFF, 0xCF, 0xE0, 0x00,
  0x3F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x00, 0xF0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xC0, 0x07, 0xFC, 0x0E, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x07, 0xC3,
  0x80, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x07, 0xC3, 0x80, 0x00,
  0x7C, 0x1C, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0xF8, 0x70,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0x1F, 0x1C, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x7C,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x70, 0x07, 0xFE, 0x0E, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x38,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x1F, 0x38, 0x00, 0x07, 0xC7, 0x00, 0x03, 0xF0, 0xE0, 0x03, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xEF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x7E, 0xC0, 0x00, 0x3B, 0xF7,
  0x00, 0x01, 0xDF, 0xB8, 0x00, 0x0C, 0xFC, 0xE0, 0x00, 0xE7, 0xE7, 0x00,
  0x07, 0x3F, 0x38, 0x00, 0x71, 0xF8, 0xE0, 0x03, 0x8F, 0xC7, 0x00, 0x1C,
  0x7E, 0x38, 0x01, 0xC3, 0xF0, 0xE0, 0x0E, 0x1F, 0x87, 0x00, 0x60, 0xFC,
  0x18, 0x07, 0x07, 0xE0, 0xE0, 0x38, 0x3F, 0x07, 0x01, 0x81, 0xF8, 0x1C,
  0x1C, 0x0F, 0xC0, 0xE0, 0xE0, 0x7E, 0x07, 0x0E, 0x03, 0xF0, 0x1C, 0x70,
  0x1F, 0x80, 0xE3, 0x80, 0xFC, 0x07, 0x38, 0x07, 0xE0, 0x1D, 0xC0, 0x3F,
  0x00, 0xEC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x70, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xDC, 0x00, 0x03, 0xFB, 0x80,
  0x00, 0x7F, 0x78, 0x00, 0x0F, 0xE7, 0x00, 0x01, 0xFC, 0xE0, 0x00, 0x3F,
  0x8E, 0x00, 0x07, 0xF1, 0xC0, 0x00, 0xFE, 0x3C, 0x00, 0x1F, 0xC3, 0x80,
  0x03, 0xF8, 0x70, 0x00, 0x7F, 0x07, 0x00, 0x0F, 0xE0, 0xE0, 0x01, 0xFC,
  0x1E, 0x00, 0x3F, 0x81, 0xC0, 0x07, 0xF0, 0x38, 0x00, 0xFE, 0x03, 0x80,
  0x1F, 0xC0, 0x70, 0x03, 0xF8, 0x0F, 0x00, 0x7F, 0x00, 0xE0, 0x0F, 0xE0,
  0x1C, 0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x38, 0x07, 0xF0, 0x07, 0x80,
  0xFE, 0x00, 0x70, 0x1F, 0xC0, 0x0E, 0x03, 0xF8, 0x01, 0xE0, 0x7F, 0x00,
  0x1C, 0x0F, 0xE0, 0x03, 0x81, 0xFC, 0x00, 0x38, 0x3F, 0x80, 0x07, 0x07,
  0xF0, 0x00, 0xF0, 0xFE, 0x00, 0x0E, 0x1F, 0xC0, 0x01, 0xC3, 0xF8, 0x00,
  0x1C, 0x7F, 0x00, 0x03, 0x8F, 0xE0, 0x00, 0x79, 0xFC, 0x00, 0x07, 0x3F,
  0x80, 0x00, 0xE7, 0xF0, 0x00, 0x0E, 0xFE, 0x00, 0x01, 0xDF, 0xC0, 0x00,
  0x3D, 0xF8, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x3F, 0xE0, 0xE0, 0x00,
  0x07, 0xC3, 0x80, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0xF8, 0xE0, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0B,
  0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x7F,
  0xE0, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x3E,
  0x38, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xF0, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x3F, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x1D,
  0xE0, 0x01, 0xB0, 0x00, 0xEF, 0x00, 0x0D, 0x80, 0x07, 0x78, 0x00, 0xEE,
  0x00, 0x39, 0xC0, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0x70,
  0x01, 0xDC, 0x00, 0xF3, 0x80, 0x0E, 0xE0, 0x07, 0x9C, 0x00, 0x63, 0x00,
  0x38, 0xF0, 0x03, 0x18, 0x01, 0xC7, 0x80, 0x38, 0xC0, 0x0E, 0x3C, 0x01,
  0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C,
  0x38, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x18, 0x70, 0x0F, 0x0E, 0x00, 0xC1,
  0x80, 0x70, 0x78, 0x0E, 0x0C, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x1C, 0x1E,
  0x03, 0x83, 0x80, 0xE0, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xE0,
  0x38, 0x1C, 0x06, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x1E, 0x07, 0x03,
  0x80, 0xC0, 0xE0, 0x3C, 0x1C, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x38,
  0x0F, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x30, 0x0E, 0x0E, 0x01, 0xC1, 0x80,
  0x70, 0x70, 0x0E, 0x0C, 0x01, 0x83, 0x80, 0x70, 0xE0, 0x0C, 0x1C, 0x03,
  0x87, 0x00, 0x61, 0xC0, 0x1E, 0x38, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1C,
  0x70, 0x07, 0x8C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x07, 0x1C, 0x00, 0xE3,
  0x00, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xC7, 0x00, 0x39, 0xC0, 0x06, 0x38,
  0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x01, 0xDC, 0x00, 0x7B, 0x00,
  0x0E, 0xE0, 0x03, 0xD8, 0x00, 0x77, 0x00, 0x0E, 0xC0, 0x03, 0xB8, 0x00,
  0x7E, 0x00, 0x0D, 0xC0, 0x03, 0xF0, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xF7, 0x8F, 0xFC, 0x7F,
  0x3C, 0x1F, 0xFF, 0xF1, 0xE0, 0x3F, 0xFE, 0x0F, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xF8, 0x01, 0xC1, 0xFF, 0xE0, 0x38,
  0x7F, 0xFF, 0x07, 0x1F, 0x07, 0xF0, 0xE7, 0x00, 0x1F, 0x1D, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBF,
  0x00, 0x01, 0xE7, 0x70, 0x00, 0x7C, 0xE7, 0x00, 0x1F, 0x1C, 0x7E, 0x1F,
  0xC3, 0x87, 0xFF, 0xF0, 0x70, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x17, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0xF0, 0x1F, 0xFE, 0x0F, 0x03, 0xFF, 0xF8, 0xF0, 0x7F, 0x0F, 0xCF,
  0x0F, 0x80, 0x1E, 0xF1, 0xE0, 0x00, 0x7F, 0x3C, 0x00, 0x03, 0xF3, 0xC0,
  0x00, 0x3F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1F, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x03,
  0xF1, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x1E, 0xF0, 0x7F, 0x0F, 0xCF, 0x03,
  0xFF, 0xF8, 0xF0, 0x0F, 0xFE, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x7F, 0x9F, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0x03, 0xFF, 0xF8,
  0xF0, 0x7F, 0x0F, 0xCF, 0x0F, 0x80, 0x1E, 0xF1, 0xE0, 0x00, 0x6F, 0x3C,
  0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F, 0x3C,
  0x00, 0x03, 0xF1, 0xE0, 0x00, 0x7F, 0x1F, 0x00, 0x0E, 0xF0, 0xFC, 0x03,
  0xCF, 0x07, 0xFF, 0xF8, 0xF0, 0x1F, 0xFF, 0x0F, 0x00, 0x7F, 0xC0, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x01, 0xF8, 0x01, 0xC1, 0xFF, 0xE0, 0x38, 0x7F, 0xFF, 0x07, 0x1F,
  0x07, 0xF0, 0xE7, 0x00, 0x3F, 0x1D, 0xC0, 0x01, 0xF3, 0xB0, 0x00, 0x1E,
  0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xE0, 0x07, 0xC1, 0xCF, 0xF8, 0x3F, 0xE3, 0xBF, 0xF8, 0xFF, 0xE7,
  0x71, 0xF9, 0xC7, 0xEF, 0x80, 0xF6, 0x03, 0xDE, 0x00, 0xE8, 0x07, 0xBC,
  0x01, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x1F, 0xC0,
  0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70,
  0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00,
  0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F,
  0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC,
  0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1F, 0x80, 0x1C, 0x1F, 0xFE, 0x03, 0x87, 0xFF, 0xF0, 0x71, 0xF0, 0x7F,
  0x0E, 0x70, 0x03, 0xF1, 0xDC, 0x00, 0x1F, 0x3B, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x80,
  0x7F, 0x8F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x1C, 0x1F, 0xFE, 0x03, 0x87, 0xFF, 0xF0,
  0x73, 0xF0, 0x7F, 0x0E, 0x70, 0x01, 0xF1, 0xDC, 0x00, 0x1F, 0x3F, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x1E,
  0x77, 0x00, 0x07, 0xCE, 0x70, 0x01, 0xF1, 0xC7, 0xE1, 0xFC, 0x38, 0x7F,
  0xFF, 0x07, 0x07, 0xFF, 0x80, 0xE0, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0x03, 0xFF, 0xF8, 0xF0,
  0x7F, 0x0F, 0xCF, 0x0F, 0x80, 0x1E, 0xF1, 0xE0, 0x00, 0x7F, 0x3C, 0x00,
  0x03, 0xF3, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F,
  0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3F,
  0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7F, 0x0F, 0x80, 0x1E, 0xF0, 0x7F,
  0x0F, 0xCF, 0x03, 0xFF, 0xF8, 0xF0, 0x0F, 0xFE, 0x0F, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x07,
  0xFF, 0x80, 0xF1, 0xFF, 0xFC, 0x0F, 0x3E, 0x0F, 0xF0, 0xF7, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0xF8,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x03, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0xEF, 0x00, 0x1B, 0x00, 0x1D, 0xE0,
  0x07, 0x60, 0x03, 0x9C, 0x00, 0xEC, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x1E,
  0x70, 0x03, 0x38, 0x03, 0xCF, 0x00, 0x63, 0x00, 0x71, 0xE0, 0x0C, 0x60,
  0x0E, 0x3C, 0x03, 0x8C, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x38, 0x70, 0x0E,
  0x38, 0x0F, 0x0E, 0x01, 0x87, 0x01, 0xE1, 0xE0, 0x30, 0x60, 0x38, 0x3C,
  0x0E, 0x0C, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C,
  0x0E, 0x06, 0x07, 0x07, 0x81, 0xC0, 0xC0, 0xE0, 0xF0, 0x3C, 0x38, 0x0C,
  0x1C, 0x07, 0x87, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x70, 0x0E, 0x1C,
  0x07, 0x0E, 0x01, 0xC3, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x1C, 0x78, 0x07,
  0x9C, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x38,
  0x01, 0xCC, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x07, 0x70, 0x01,
  0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x1E, 0x3F, 0xE0, 0x00, 0x3C, 0xFF, 0xE0, 0x00, 0x7B, 0xF7, 0xE0, 0x00,
  0xF7, 0x81, 0xE0, 0x01, 0xFE, 0x01, 0xE0, 0x03, 0xF8, 0x01, 0xE0, 0x07,
  0xF0, 0x01, 0xE0, 0x0E, 0xE0, 0x01, 0xE0, 0x1D, 0xC0, 0x03, 0xE0, 0x7B,
  0x80, 0x03, 0xFB, 0xE7, 0x00, 0x01, 0xFF, 0xCE, 0x00, 0x01, 0xFF, 0x1C,
  0x00, 0x00, 0x20, 0x00,
};

const GFXglyph JetBrainsMono_Thin71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 9, 52, 43, 17, -52 },
  { 60, 19, 21, 43, 12, -52 },
  { 110, 38, 52, 43, 2, -52 },
  { 357, 31, 72, 43, 6, -62 },
  { 636, 40, 52, 43, 1, -52 },
  { 896, 35, 54, 43, 5, -53 },
  { 1133, 5, 21, 43, 19, -52 },
  { 1147, 19, 69, 43, 15, -60 },
  { 1311, 20, 69, 43, 8, -60 },
  { 1484, 37, 36, 43, 3, -43 },
  { 1651, 32, 33, 43, 5, -40 },
  { 1783, 12, 22, 43, 13, -11 },
  { 1816, 23, 3, 43, 10, -25 },
  { 1825, 10, 11, 43, 16, -10 },
  { 1839, 29, 67, 43, 7, -59 },
  { 2082, 29, 54, 43, 7, -53 },
  { 2278, 31, 52, 43, 7, -52 },
  { 2480, 32, 53, 43, 6, -53 },
  { 2692, 29, 53, 43, 6, -52 },
  { 2885, 27, 52, 43, 7, -52 },
  { 3061, 29, 53, 43, 7, -52 },
  { 3254, 31, 53, 43, 6, -52 },
  { 3460, 31, 52, 43, 6, -52 },
  { 3662, 30, 54, 43, 6, -53 },
  { 3865, 31, 53, 43, 6, -53 },
  { 4071, 10, 41, 43, 16, -40 },
  { 4123, 14, 51, 43, 13, -40 },
  { 4213, 30, 35, 43, 6, -41 },
  { 4345, 29, 19, 43, 7, -33 },
  { 4414, 30, 35, 43, 6, -41 },
  { 4546, 24, 52, 43, 12, -52 },
  { 4702, 34, 66, 43, 5, -53 },
  { 4983, 33, 52, 43, 5, -52 },
  { 5198, 29, 52, 43, 8, -52 },
  { 5387, 29, 54, 43, 7, -53 },
  { 5583, 27, 52, 43, 8, -52 },
  { 5759, 27, 52, 43, 9, -52 },
  { 5935, 29, 52, 43, 8, -52 },
  { 6124, 29, 54, 43, 7, -53 },
  { 6320, 27, 52, 43, 8, -52 },
  { 6496, 25, 52, 43, 9, -52 },
  { 6659, 29, 53, 43, 5, -52 },
  { 6852, 30, 52, 43, 8, -52 },
  { 7047, 28, 52, 43, 9, -52 },
  { 7229, 29, 52, 43, 7, -52 },
  { 7418, 27, 52, 43, 8, -52 },
  { 7594, 28, 54, 43, 7, -53 },
  { 7783, 30, 52, 43, 8, -52 },
  { 7978, 29, 66, 43, 7, -53 },
  { 8218, 30, 52, 43, 8, -52 },
  { 8413, 31, 54, 43, 6, -53 },
  { 8623, 34, 52, 43, 4, -52 },
  { 8844, 27, 53, 43, 8, -52 },
  { 9023, 33, 52, 43, 5, -52 },
  { 9238, 37, 52, 43, 3, -52 },
  { 9479, 35, 52, 43, 4, -52 },
  { 9707, 35, 52, 43, 4, -52 },
  { 9935, 30, 52, 43, 6, -52 },
  { 10130, 16, 67, 43, 16, -59 },
  { 10264, 29, 67, 43, 7, -59 },
  { 10507, 16, 67, 43, 11, -59 },
  { 10641, 29, 28, 43, 7, -52 },
  { 10743, 34, 3, 43, 4, 2 },
  { 10756, 12, 10, 43, 14, -56 },
  { 10771, 29, 41, 43, 6, -40 },
  { 10920, 27, 53, 43, 8, -52 },
  { 11099, 29, 41, 43, 7, -40 },
  { 11248, 28, 53, 43, 7, -52 },
  { 11434, 28, 41, 43, 7, -40 },
  { 11578, 32, 52, 43, 5, -52 },
  { 11786, 28, 53, 43, 7, -40 },
  { 11972, 27, 52, 43, 8, -52 },
  { 12148, 31, 54, 43, 7, -54 },
  { 12358, 25, 67, 43, 7, -54 },
  { 12568, 30, 52, 43, 8, -52 },
  { 12763, 34, 52, 43, 4, -52 },
  { 12984, 31, 40, 43, 6, -40 },
  { 13139, 27, 40, 43, 8, -40 },
  { 13274, 28, 41, 43, 7, -40 },
  { 13418, 27, 53, 43, 8, -40 },
  { 13597, 28, 53, 43, 7, -40 },
  { 13783, 28, 40, 43, 9, -40 },
  { 13923, 29, 41, 43, 7, -40 },
  { 14072, 31, 50, 43, 5, -50 },
  { 14266, 27, 40, 43, 8, -39 },
  { 14401, 32, 39, 43, 5, -39 },
  { 14557, 35, 39, 43, 4, -39 },
  { 14728, 32, 39, 43, 5, -39 },
  { 14884, 32, 52, 43, 5, -39 },
  { 15092, 28, 39, 43, 7, -39 },
  { 15229, 29, 67, 43, 7, -59 },
  { 15472, 3, 67, 43, 20, -59 },
  { 15498, 29, 67, 43, 7, -59 },
  { 15741, 31, 14, 43, 6, -32 },
};

const GFXfont JetBrainsMono_Thin71pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin71pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _JETBRAINSMONO_THIN71PT7B_H_
