#ifndef _JETBRAINSMONO_THIN68PT7B_H_
#define _JETBRAINSMONO_THIN68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFF,
  0xFE, 0xFE, 0x7C, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80,
  0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x71, 0xF8, 0x0F,
  0x83, 0x83, 0xE0, 0x78, 0x1C, 0x0F, 0x87, 0x80, 0xE0, 0x3C, 0x3C, 0x07,
  0x00, 0xE1, 0xC0, 0x38, 0x07, 0x9E, 0x01, 0xC0, 0x1C, 0xF0, 0x0E, 0x00,
  0xE7, 0x80, 0x70, 0x07, 0x3C, 0x03, 0x80, 0x39, 0xE0, 0x1C, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x07, 0xC3, 0x80,
  0x00, 0x1F, 0x9C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x71, 0xF8, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x1F, 0x80,
  0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x80, 0x38,
  0x03, 0xFC, 0x01, 0xC0, 0x1E, 0xE0, 0x0E, 0x00, 0xE7, 0x80, 0x70, 0x0F,
  0x1E, 0x03, 0x80, 0xF0, 0xF8, 0x1C, 0x0F, 0x83, 0xF0, 0xE1, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0xFF, 0xF0, 0x00,
  0x03, 0x87, 0x81, 0xE0, 0x00, 0x1C, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0xE0,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x07, 0x07, 0x00,
  0x03, 0xC0, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0xE0, 0xE0, 0x00, 0x0F, 0xFF,
  0x07, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0x07, 0xFF, 0x80, 0x00, 0x38,
  0x3F, 0x7F, 0x00, 0x01, 0xC1, 0xE0, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0xF0, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x01, 0xE1, 0xC0, 0x00, 0x38, 0x0F, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x78,
  0x00, 0x01, 0xFF, 0xE3, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x79, 0xE0, 0x1E, 0x00, 0x1C, 0x70, 0x03, 0xC0, 0x0F,
  0x1C, 0x00, 0x78, 0x03, 0x8F, 0x00, 0x0F, 0x01, 0xE3, 0xC0, 0x03, 0xC0,
  0x70, 0xF0, 0x00, 0x78, 0x38, 0x3C, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x01,
  0xE7, 0x03, 0xC0, 0x00, 0x7B, 0xC0, 0xF0, 0x00, 0x0F, 0xE0, 0x3C, 0x00,
  0x01, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x1C, 0x00, 0x01, 0xFC, 0x07, 0x00, 0x00, 0xF7, 0x81,
  0xE0, 0x00, 0x78, 0xE0, 0x78, 0x00, 0x3E, 0x3C, 0x0F, 0x00, 0x1F, 0x07,
  0x83, 0xE0, 0x0F, 0x80, 0xF0, 0x7F, 0x1F, 0xC0, 0x1C, 0x0F, 0xFF, 0xC0,
  0x07, 0x80, 0xFF, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x73, 0x9C, 0xE7, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0x3E, 0x00,
  0x70, 0x03, 0xEF, 0xF0, 0x0E, 0x01, 0xFF, 0xFF, 0xC1, 0xC1, 0xFF, 0xC7,
  0xFE, 0x38, 0xFF, 0xC0, 0x1F, 0xF6, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x9F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFD, 0xFF, 0x3F, 0x83, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x03,
  0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x3F, 0x0E, 0x00, 0x03,
  0xE0, 0x70, 0x00, 0x3E, 0x03, 0x80, 0x07, 0xE0, 0x1C, 0x00, 0x3C, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0x8F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3A, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x01, 0xC1, 0xFF, 0xC0,
  0x38, 0xFF, 0xFE, 0x07, 0x3F, 0xBF, 0xE0, 0xEF, 0x00, 0x7E, 0x1D, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0xFE, 0x00, 0x07, 0x1F, 0xFE, 0x00, 0x7B, 0xFF, 0xFC,
  0x03, 0xBC, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0,
  0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0x80, 0x3F, 0x00, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x0F,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x01,
  0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0x70, 0x0F, 0xFF, 0xF7,
  0x80, 0x3F, 0xFF, 0x38, 0x00, 0x7F, 0xE3, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x0F, 0xE7,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x83, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xF9,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xCF, 0xE0, 0xE0, 0x07, 0xC0,
  0xFF, 0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xD0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x3F,
  0xFE, 0x7F, 0x00, 0x3F, 0x03, 0xBF, 0x80, 0x1E, 0x00, 0xDF, 0xC0, 0x1E,
  0x00, 0x3F, 0xE0, 0x0F, 0x00, 0x0F, 0xF0, 0x07, 0x00, 0x07, 0xF8, 0x03,
  0x80, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0x00,
  0x70, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0x0F, 0xE0,
  0x0E, 0x00, 0x07, 0xF0, 0x07, 0x00, 0x03, 0xF8, 0x03, 0x80, 0x01, 0xFC,
  0x01, 0xC0, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x70, 0x00, 0x3F,
  0x80, 0x38, 0x00, 0x3F, 0xC0, 0x1C, 0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x0F,
  0xF0, 0x07, 0x80, 0x0F, 0xF8, 0x01, 0xE0, 0x05, 0xFC, 0x00, 0xF8, 0x0E,
  0xFE, 0x00, 0x3F, 0xFE, 0x7F, 0x00, 0x0F, 0xFE, 0x3B, 0x80, 0x01, 0xFE,
  0x1D, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x0F,
  0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3C, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x7F, 0xE0, 0xF0,
  0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x78, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x1F,
  0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0E, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x78, 0x0F, 0xFC, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0xFC, 0x3C, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x80, 0x00, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x6F, 0xD8, 0x00, 0x07, 0xFE,
  0xE0, 0x00, 0x3F, 0xF7, 0x00, 0x01, 0xBF, 0x9C, 0x00, 0x1D, 0xFC, 0xE0,
  0x00, 0xEF, 0xE3, 0x00, 0x06, 0x7F, 0x1C, 0x00, 0x73, 0xF8, 0xE0, 0x03,
  0x9F, 0xC3, 0x00, 0x38, 0xFF, 0x1C, 0x01, 0xC7, 0xF8, 0xE0, 0x0C, 0x3F,
  0xC3, 0x80, 0xE1, 0xFE, 0x1C, 0x07, 0x0F, 0xF0, 0xE0, 0x30, 0x7F, 0x83,
  0x83, 0x83, 0xFC, 0x1C, 0x1C, 0x1F, 0xE0, 0x60, 0xC0, 0xFF, 0x03, 0x8E,
  0x07, 0xF8, 0x1C, 0x70, 0x3F, 0xC0, 0x67, 0x01, 0xFE, 0x03, 0xB8, 0x0F,
  0xF0, 0x1D, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xE0,
  0x1E, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x70, 0x00, 0x1F, 0xDC, 0x00,
  0x07, 0xF7, 0x00, 0x01, 0xFC, 0xE0, 0x00, 0x7F, 0x38, 0x00, 0x1F, 0xC7,
  0x00, 0x07, 0xF1, 0xC0, 0x01, 0xFC, 0x70, 0x00, 0x7F, 0x0E, 0x00, 0x1F,
  0xC3, 0x80, 0x07, 0xF0, 0xF0, 0x01, 0xFC, 0x1C, 0x00, 0x7F, 0x07, 0x00,
  0x1F, 0xC0, 0xE0, 0x07, 0xF0, 0x38, 0x01, 0xFC, 0x0F, 0x00, 0x7F, 0x01,
  0xC0, 0x1F, 0xC0, 0x70, 0x07, 0xF0, 0x0E, 0x01, 0xFC, 0x03, 0x80, 0x7F,
  0x00, 0xE0, 0x1F, 0xC0, 0x1C, 0x07, 0xF0, 0x07, 0x01, 0xFC, 0x00, 0xE0,
  0x7F, 0x00, 0x38, 0x1F, 0xC0, 0x0E, 0x07, 0xF0, 0x01, 0xC1, 0xFC, 0x00,
  0x70, 0x7F, 0x00, 0x0E, 0x1F, 0xC0, 0x03, 0x87, 0xF0, 0x00, 0xE1, 0xFC,
  0x00, 0x1C, 0x7F, 0x00, 0x07, 0x1F, 0xC0, 0x01, 0xE7, 0xF0, 0x00, 0x39,
  0xFC, 0x00, 0x0E, 0x7F, 0x00, 0x01, 0xDF, 0xC0, 0x00, 0x77, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x78, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0x7F, 0x07, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0, 0x03,
  0xFF, 0x0F, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xF8, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x1F,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x81, 0xE0, 0x07, 0xFE, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x1F, 0x1E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0xC7, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03,
  0x80, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x00, 0x1F, 0xC0, 0x03,
  0x60, 0x03, 0xBC, 0x00, 0x6E, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x0E, 0x70,
  0x03, 0xB8, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x0E, 0x60, 0x07,
  0x38, 0x01, 0x8C, 0x00, 0xE7, 0x00, 0x31, 0x80, 0x3C, 0xF0, 0x06, 0x38,
  0x07, 0x1E, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x38, 0x07,
  0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x70, 0xE0, 0x18, 0x30, 0x0E, 0x1C,
  0x03, 0x06, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x38, 0x78, 0x1C, 0x1C, 0x0E,
  0x0F, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x83, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0x3C, 0x38, 0x0E, 0x0C, 0x07,
  0x87, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x0E,
  0x01, 0xC3, 0x00, 0x61, 0xC0, 0x38, 0x60, 0x0C, 0x38, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x70, 0x07, 0x18, 0x03, 0xCC,
  0x00, 0xE7, 0x00, 0x39, 0x80, 0x0C, 0xE0, 0x07, 0x30, 0x01, 0x9C, 0x00,
  0xE6, 0x00, 0x33, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x76, 0x00, 0x1D, 0xC0, 0x0E, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x38,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x38,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF3, 0xF0, 0x00, 0x0E, 0xF8, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xDC, 0xFC, 0x00, 0x7B, 0x8F, 0xF0, 0x7E, 0x70, 0xFF, 0xFF, 0x0E, 0x07,
  0xFF, 0xC1, 0xC0, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x03,
  0xFC, 0x01, 0xE1, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0x07, 0x9E, 0x03, 0xF0,
  0xF7, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xDF, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xCF, 0xC0,
  0x00, 0x79, 0xFC, 0x00, 0x1E, 0x3D, 0xC0, 0x07, 0xC7, 0x9F, 0x07, 0xF0,
  0xF1, 0xFF, 0xFC, 0x1E, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x07, 0xFD, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0xFF, 0x81, 0xC0, 0xFF, 0xF8, 0x70, 0x7F, 0xFF, 0x1C,
  0x3E, 0x01, 0xE7, 0x1E, 0x00, 0x1D, 0xCF, 0x00, 0x03, 0xF3, 0x80, 0x00,
  0x7D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x3C, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0x71, 0xF0, 0x03, 0xDC, 0x3F, 0x83, 0xE7, 0x07,
  0xFF, 0xF1, 0xC0, 0x7F, 0xF0, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x70, 0x7F, 0xFF, 0x1C, 0x3E, 0x01, 0xE7,
  0x1E, 0x00, 0x1D, 0xCF, 0x00, 0x03, 0x73, 0x80, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x03,
  0xF1, 0xE0, 0x01, 0xDC, 0x7E, 0x00, 0xE7, 0x0F, 0xFF, 0xF1, 0xC0, 0xFF,
  0xF8, 0x70, 0x0F, 0xF8, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3F, 0xC0,
  0x3C, 0x3F, 0xFE, 0x0F, 0x1F, 0xFF, 0xC3, 0xCF, 0x01, 0xF8, 0xF7, 0x00,
  0x1F, 0x3F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x3C, 0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00,
  0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x00, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0E, 0x00, 0x3E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0xF8, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x0F, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC3, 0x8F, 0xF0, 0x7F, 0xCE,
  0x7F, 0xE3, 0xFF, 0xBB, 0x07, 0xCC, 0x1E, 0xE8, 0x0F, 0x40, 0x3F, 0xA0,
  0x1F, 0x00, 0xFF, 0x00, 0x78, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03,
  0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0,
  0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01,
  0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F,
  0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0,
  0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03,
  0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0,
  0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01,
  0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F,
  0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x3C, 0x3F, 0xFE, 0x0F, 0x1F, 0xFF,
  0xC3, 0xCF, 0x01, 0xF8, 0xF7, 0x00, 0x1F, 0x3F, 0x80, 0x03, 0xEF, 0xC0,
  0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE0, 0x7C, 0x00, 0x78, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x1E, 0x1F,
  0xFF, 0x03, 0xCF, 0xFF, 0xF0, 0x7B, 0xE0, 0x3F, 0x0F, 0x70, 0x01, 0xF1,
  0xFC, 0x00, 0x0F, 0x3F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03,
  0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1C, 0xFC, 0x00, 0x07, 0x9F, 0xC0,
  0x01, 0xE3, 0xDC, 0x00, 0x7C, 0x79, 0xF0, 0x7F, 0x0F, 0x1F, 0xFF, 0xC1,
  0xE0, 0xFF, 0xE0, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x70, 0x7F, 0xFF, 0x1C, 0x3E, 0x01, 0xE7, 0x1E, 0x00, 0x1D,
  0xCF, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0x71, 0xF0,
  0x03, 0xDC, 0x3F, 0x83, 0xE7, 0x07, 0xFF, 0xF1, 0xC0, 0x7F, 0xF0, 0x70,
  0x03, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x38, 0x7F, 0xFC, 0x0E, 0x3F, 0xFF,
  0xC3, 0x9E, 0x01, 0xF8, 0xEE, 0x00, 0x1F, 0x3B, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x78,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0x1F, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0x77, 0x00, 0x1F, 0x00, 0x1D, 0xC0,
  0x06, 0xC0, 0x07, 0x70, 0x01, 0xB0, 0x03, 0xDE, 0x00, 0x6C, 0x00, 0xE3,
  0x80, 0x3B, 0x80, 0x38, 0xE0, 0x0E, 0xE0, 0x0E, 0x38, 0x03, 0x18, 0x03,
  0x8E, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0x31, 0x80, 0x78, 0xF0, 0x1C, 0x60,
  0x1C, 0x1C, 0x07, 0x1C, 0x07, 0x07, 0x01, 0xC7, 0x01, 0xC1, 0xC0, 0x60,
  0xC0, 0x70, 0x70, 0x18, 0x30, 0x1C, 0x1C, 0x0E, 0x0C, 0x0F, 0x07, 0x83,
  0x83, 0x83, 0x80, 0xE0, 0xE0, 0xE0, 0xE0, 0x38, 0x30, 0x38, 0x38, 0x0E,
  0x0C, 0x06, 0x0E, 0x03, 0x87, 0x01, 0x83, 0x80, 0xE1, 0xC0, 0x71, 0xE0,
  0x3C, 0x70, 0x1C, 0x70, 0x07, 0x1C, 0x07, 0x1C, 0x01, 0xC6, 0x01, 0xC7,
  0x00, 0x71, 0x80, 0x31, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0xB8, 0x01, 0xEE, 0x00, 0xEE, 0x00, 0x3B, 0x00, 0x3B, 0x80, 0x0E, 0xC0,
  0x06, 0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x39, 0xFF, 0x80, 0x01, 0xDF, 0xFE, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x7E,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0xFC, 0x00,
  0x78, 0x0F, 0xE0, 0x01, 0xE0, 0x77, 0x00, 0x07, 0xFF, 0xB8, 0x00, 0x1F,
  0xF9, 0xC0, 0x00, 0x7F, 0x80,
};

const GFXglyph JetBrainsMono_Thin68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 8, 50, 41, 17, -50 },
  { 51, 18, 21, 41, 11, -50 },
  { 99, 36, 50, 41, 2, -50 },
  { 324, 29, 69, 41, 6, -59 },
  { 575, 38, 50, 41, 1, -50 },
  { 813, 34, 51, 41, 4, -50 },
  { 1030, 5, 21, 41, 18, -50 },
  { 1044, 19, 65, 41, 14, -57 },
  { 1199, 19, 65, 41, 8, -57 },
  { 1354, 35, 34, 41, 3, -41 },
  { 1503, 31, 31, 41, 5, -38 },
  { 1624, 11, 21, 41, 13, -10 },
  { 1653, 21, 3, 41, 10, -24 },
  { 1661, 10, 10, 41, 15, -9 },
  { 1674, 28, 63, 41, 6, -56 },
  { 1895, 28, 51, 41, 6, -50 },
  { 2074, 29, 50, 41, 7, -50 },
  { 2256, 30, 50, 41, 6, -50 },
  { 2444, 27, 51, 41, 6, -50 },
  { 2617, 26, 50, 41, 7, -50 },
  { 2780, 27, 51, 41, 7, -50 },
  { 2953, 29, 51, 41, 6, -50 },
  { 3138, 30, 50, 41, 6, -50 },
  { 3326, 29, 51, 41, 6, -50 },
  { 3511, 29, 50, 41, 6, -50 },
  { 3693, 10, 39, 41, 15, -38 },
  { 3742, 13, 49, 41, 13, -38 },
  { 3822, 29, 34, 41, 6, -39 },
  { 3946, 28, 19, 41, 6, -32 },
  { 4013, 29, 34, 41, 6, -39 },
  { 4137, 22, 50, 41, 12, -50 },
  { 4275, 33, 62, 41, 4, -50 },
  { 4531, 31, 50, 41, 5, -50 },
  { 4725, 28, 50, 41, 7, -50 },
  { 4900, 28, 51, 41, 7, -50 },
  { 5079, 27, 50, 41, 7, -50 },
  { 5248, 27, 50, 41, 8, -50 },
  { 5417, 28, 50, 41, 8, -50 },
  { 5592, 28, 51, 41, 7, -50 },
  { 5771, 26, 50, 41, 7, -50 },
  { 5934, 25, 50, 41, 8, -50 },
  { 6091, 28, 51, 41, 5, -50 },
  { 6270, 30, 50, 41, 7, -50 },
  { 6458, 28, 50, 41, 8, -50 },
  { 6633, 29, 50, 41, 6, -50 },
  { 6815, 26, 50, 41, 7, -50 },
  { 6978, 27, 51, 41, 7, -50 },
  { 7151, 29, 50, 41, 7, -50 },
  { 7333, 28, 62, 41, 7, -50 },
  { 7550, 29, 50, 41, 7, -50 },
  { 7732, 29, 51, 41, 6, -50 },
  { 7917, 33, 50, 41, 4, -50 },
  { 8124, 26, 51, 41, 7, -50 },
  { 8290, 31, 50, 41, 5, -50 },
  { 8484, 35, 50, 41, 3, -50 },
  { 8703, 33, 50, 41, 4, -50 },
  { 8910, 34, 50, 41, 3, -50 },
  { 9123, 29, 50, 41, 6, -50 },
  { 9305, 15, 63, 41, 15, -56 },
  { 9424, 28, 63, 41, 6, -56 },
  { 9645, 15, 63, 41, 11, -56 },
  { 9764, 27, 27, 41, 7, -50 },
  { 9856, 33, 3, 41, 4, 2 },
  { 9869, 11, 9, 41, 14, -53 },
  { 9882, 27, 39, 41, 6, -38 },
  { 10014, 27, 51, 41, 7, -50 },
  { 10187, 27, 39, 41, 7, -38 },
  { 10319, 26, 51, 41, 7, -50 },
  { 10485, 27, 39, 41, 7, -38 },
  { 10617, 31, 50, 41, 5, -50 },
  { 10811, 26, 50, 41, 7, -38 },
  { 10974, 26, 50, 41, 7, -50 },
  { 11137, 30, 52, 41, 6, -52 },
  { 11332, 25, 64, 41, 6, -52 },
  { 11532, 28, 50, 41, 8, -50 },
  { 11707, 34, 50, 41, 3, -50 },
  { 11920, 30, 38, 41, 5, -38 },
  { 12063, 26, 38, 41, 7, -38 },
  { 12187, 27, 39, 41, 7, -38 },
  { 12319, 27, 50, 41, 7, -38 },
  { 12488, 26, 50, 41, 7, -38 },
  { 12651, 26, 38, 41, 9, -38 },
  { 12775, 28, 39, 41, 6, -38 },
  { 12912, 29, 48, 41, 5, -48 },
  { 13086, 26, 38, 41, 7, -37 },
  { 13210, 31, 37, 41, 5, -37 },
  { 13354, 34, 37, 41, 3, -37 },
  { 13512, 31, 37, 41, 5, -37 },
  { 13656, 31, 49, 41, 5, -37 },
  { 13846, 27, 37, 41, 7, -37 },
  { 13971, 27, 63, 41, 7, -56 },
  { 14184, 3, 63, 41, 19, -56 },
  { 14208, 27, 63, 41, 7, -56 },
  { 14421, 29, 12, 41, 6, -30 },
};

const GFXfont JetBrainsMono_Thin68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_THIN68PT7B_H_
