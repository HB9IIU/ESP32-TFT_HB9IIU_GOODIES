#ifndef _JETBRAINSMONO_THIN51PT7B_H_
#define _JETBRAINSMONO_THIN51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin51pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18,
  0x03, 0x80, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x18, 0x03, 0x80, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x78, 0x63, 0xC1, 0xC1,
  0x87, 0x0E, 0x06, 0x0E, 0x30, 0x18, 0x39, 0xC0, 0x60, 0x67, 0x01, 0x81,
  0xDC, 0x06, 0x07, 0x70, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x81, 0x80, 0x0E,
  0x06, 0x00, 0x1C, 0x18, 0x00, 0x78, 0x60, 0x00, 0xF1, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x06, 0x78,
  0x00, 0x18, 0x70, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x07, 0x00,
  0x18, 0x1C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xF8, 0x06, 0x03, 0xE0, 0x18,
  0x0D, 0x80, 0x60, 0x77, 0x01, 0x81, 0xDE, 0x06, 0x0E, 0x3C, 0x18, 0x78,
  0x7C, 0x63, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x39, 0xFF, 0x80, 0x03, 0x0C,
  0x0E, 0x00, 0x38, 0xE0, 0x30, 0x01, 0x86, 0x01, 0x80, 0x18, 0x30, 0x0E,
  0x01, 0xC1, 0x80, 0x70, 0x0C, 0x0C, 0x03, 0x80, 0xC0, 0x60, 0x1C, 0x0C,
  0x03, 0x00, 0xE0, 0xE0, 0x18, 0x07, 0x06, 0x00, 0xC0, 0x30, 0x60, 0x07,
  0x01, 0x87, 0x00, 0x38, 0x1C, 0x30, 0x00, 0xFF, 0xC3, 0x00, 0x03, 0xFC,
  0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x0C, 0x3F, 0xE0,
  0x00, 0xE3, 0xC7, 0x80, 0x06, 0x18, 0x0C, 0x00, 0x61, 0xC0, 0x70, 0x06,
  0x0C, 0x01, 0x80, 0x70, 0x60, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x30, 0x18,
  0x03, 0x03, 0x80, 0xC0, 0x18, 0x18, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x06,
  0x1C, 0x01, 0x80, 0x71, 0xC0, 0x0E, 0x03, 0x0C, 0x00, 0x38, 0x38, 0xC0,
  0x00, 0xFF, 0x8E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xEE, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x70, 0x38, 0x03, 0x98, 0x0E, 0x01, 0xCE, 0x01, 0xC0, 0x63, 0x80, 0x38,
  0x38, 0xE0, 0x07, 0x0C, 0x38, 0x01, 0xC7, 0x0E, 0x00, 0x39, 0x83, 0x80,
  0x07, 0xE0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03,
  0x80, 0x03, 0xE0, 0x60, 0x01, 0xDC, 0x1C, 0x00, 0xE7, 0x07, 0x00, 0x70,
  0xE0, 0xF0, 0x7C, 0x1C, 0x1F, 0xFC, 0x03, 0x83, 0xFE, 0x00, 0x70, 0x18,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x3C,
  0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x1F, 0x00, 0x06, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x0F, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x01, 0xFF,
  0x03, 0x81, 0xF7, 0xF8, 0xC3, 0xFC, 0x3F, 0xB3, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x01,
  0xC0, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x0E, 0x00, 0x1C, 0x00, 0x80, 0x02, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x07, 0x83,
  0x80, 0x1E, 0x38, 0x00, 0x7B, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0x81,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x38, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x8F, 0x00, 0x78, 0x7E, 0x0F, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x00, 0x3D, 0x80, 0x01, 0xE6, 0x00, 0x1E, 0x18, 0x00, 0xF0, 0x60,
  0x07, 0x81, 0x80, 0x18, 0x06, 0x00, 0x40, 0x18, 0x02, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xF0,
  0x07, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x30, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06,
  0x70, 0x00, 0xE7, 0x80, 0x1C, 0x3C, 0x07, 0x81, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0xFF,
  0x81, 0x9F, 0xFE, 0x0D, 0xC0, 0x78, 0x6C, 0x01, 0xE3, 0xC0, 0x07, 0x1C,
  0x00, 0x1C, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xCC, 0x00, 0x0E,
  0x70, 0x00, 0xE1, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x3F, 0xE0,
  0x1F, 0xFF, 0xC0, 0xFC, 0x07, 0x83, 0xC0, 0x07, 0x0E, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x38, 0x00, 0x78, 0x70,
  0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x38, 0x07, 0x83, 0x80,
  0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x3B,
  0x00, 0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x67, 0x00, 0x07, 0x18, 0x00,
  0x30, 0xE0, 0x03, 0x83, 0xC0, 0x78, 0x0F, 0x07, 0x00, 0x1E, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xF8, 0x00, 0x78, 0xF0, 0x0F, 0x01, 0xC0, 0xF0, 0x07,
  0x0E, 0x00, 0x1C, 0x70, 0x00, 0x77, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x33, 0x80, 0x03, 0x9E, 0x00, 0x38, 0x78, 0x07, 0xC1, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE7,
  0x00, 0x01, 0x9C, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x87,
  0x00, 0x3E, 0x1F, 0x03, 0xB0, 0x1F, 0xFD, 0xC0, 0x3F, 0xCE, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x7E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0x04, 0x1F, 0x8F, 0xEF, 0xF7,
  0xF9, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3E, 0x07, 0xFC,
  0x03, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x1F, 0x80,
  0x3F, 0xEF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3C, 0x0F, 0xF0, 0x1C, 0x03, 0xF8,
  0x0C, 0x00, 0xFC, 0x06, 0x00, 0x7E, 0x07, 0x00, 0x3F, 0x03, 0x80, 0x1F,
  0x81, 0xC0, 0x0F, 0xC0, 0xE0, 0x07, 0xE0, 0x70, 0x03, 0xF0, 0x38, 0x01,
  0xF8, 0x1C, 0x00, 0xFC, 0x0E, 0x00, 0x7E, 0x03, 0x00, 0x3F, 0x01, 0x80,
  0x1F, 0x80, 0xE0, 0x0F, 0xC0, 0x70, 0x0F, 0xE0, 0x1E, 0x1F, 0xF0, 0x07,
  0xFD, 0xF8, 0x01, 0xFC, 0xEC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x76, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x63, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0xC3, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x81, 0xC0,
  0x01, 0x81, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0,
  0x03, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06, 0x00, 0x70, 0x06, 0x00, 0x70,
  0x0E, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1C, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xC0, 0x0F, 0x8C, 0x00, 0x3C, 0xC0, 0x01, 0xCC, 0x00, 0x0E,
  0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00,
  0x38, 0xC0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0C, 0x00, 0x78, 0xC0,
  0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x3C, 0xC0, 0x1F,
  0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3C, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01,
  0xCC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00,
  0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x70, 0x00, 0x71, 0x80, 0x03, 0x8E,
  0x00, 0x38, 0x3C, 0x07, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0x00, 0x7C, 0x60, 0x03, 0xCC, 0x00,
  0x39, 0x80, 0x03, 0xB0, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x36, 0x00, 0x0E, 0xC0, 0x03, 0x98, 0x00, 0xE3, 0x00, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3C, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x70, 0x00, 0x71, 0x80, 0x03, 0x8E, 0x00, 0x38,
  0x3C, 0x07, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x30, 0x00,
  0x38, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0xE0,
  0xC0, 0x03, 0x83, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x30, 0x03, 0x80, 0xC0,
  0x0E, 0x03, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x38,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x1C, 0x03,
  0x00, 0x70, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x07,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0xCC,
  0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x37, 0xB0, 0x01, 0xBD, 0x80, 0x19, 0xE6,
  0x00, 0xCF, 0x30, 0x06, 0xF9, 0x80, 0x67, 0xC6, 0x03, 0x3E, 0x30, 0x19,
  0xF1, 0x81, 0x8F, 0x86, 0x0C, 0x7C, 0x30, 0x63, 0xE1, 0xC6, 0x1F, 0x06,
  0x30, 0xF8, 0x33, 0x07, 0xC0, 0xD8, 0x3E, 0x06, 0xC1, 0xF0, 0x3C, 0x0F,
  0x80, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3D, 0x80, 0x07,
  0xB0, 0x00, 0xF7, 0x00, 0x1E, 0x60, 0x03, 0xCE, 0x00, 0x78, 0xC0, 0x0F,
  0x18, 0x01, 0xE3, 0x80, 0x3C, 0x30, 0x07, 0x87, 0x00, 0xF0, 0x60, 0x1E,
  0x0C, 0x03, 0xC1, 0xC0, 0x78, 0x18, 0x0F, 0x03, 0x81, 0xE0, 0x30, 0x3C,
  0x06, 0x07, 0x80, 0xE0, 0xF0, 0x0C, 0x1E, 0x01, 0xC3, 0xC0, 0x18, 0x78,
  0x03, 0x0F, 0x00, 0x71, 0xE0, 0x06, 0x3C, 0x00, 0xC7, 0x80, 0x0C, 0xF0,
  0x01, 0x9E, 0x00, 0x3B, 0xC0, 0x03, 0x78, 0x00, 0x6F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81,
  0xC0, 0x3C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x76, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x0E, 0x38, 0x01, 0xE1, 0xE0, 0x3C, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x30,
  0x01, 0xF1, 0x80, 0x01, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x0E,
  0xC0, 0x00, 0xE6, 0x00, 0x1F, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x38, 0x07, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00,
  0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDC,
  0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00,
  0x6E, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0,
  0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03,
  0x70, 0x00, 0x19, 0x80, 0x01, 0xCC, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x07, 0x0E, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x30, 0x01, 0xF1, 0x80, 0x03, 0xCC, 0x00,
  0x0E, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1B, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0, 0x01, 0xE6, 0x00, 0x3E, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x70,
  0x18, 0x03, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x01, 0xC1, 0x80,
  0x0E, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x07, 0x18, 0x00, 0x38,
  0xC0, 0x00, 0xE6, 0x00, 0x07, 0x30, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0x80,
  0x3C, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x06,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0xE3,
  0xC0, 0x07, 0x87, 0xC0, 0x3C, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x06, 0x60, 0x01, 0xCE, 0x00, 0x70, 0xF0, 0x1E, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C,
  0x00, 0x18, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x01,
  0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x76, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xFC,
  0x01, 0xC0, 0x1B, 0x80, 0x68, 0x03, 0x30, 0x0D, 0x80, 0x66, 0x01, 0xB0,
  0x0C, 0xC0, 0x36, 0x03, 0x98, 0x06, 0xC0, 0x73, 0x00, 0xD8, 0x0E, 0x60,
  0x1B, 0x01, 0x8E, 0x06, 0x60, 0x31, 0xC0, 0xC6, 0x06, 0x38, 0x18, 0xC0,
  0xC3, 0x03, 0x18, 0x18, 0x60, 0x63, 0x03, 0x0C, 0x0C, 0x60, 0xE1, 0x81,
  0x0C, 0x1C, 0x30, 0x61, 0x83, 0x07, 0x0C, 0x18, 0x60, 0xE1, 0x83, 0x0C,
  0x1C, 0x30, 0x61, 0x81, 0x86, 0x0C, 0x30, 0x30, 0xC1, 0x86, 0x06, 0x10,
  0x30, 0xC0, 0xC6, 0x06, 0x38, 0x1C, 0xC0, 0x46, 0x03, 0x98, 0x0C, 0xC0,
  0x73, 0x01, 0x98, 0x0E, 0x60, 0x33, 0x00, 0xCC, 0x06, 0x60, 0x19, 0x00,
  0xCC, 0x03, 0x60, 0x19, 0x80, 0x6C, 0x03, 0x70, 0x0D, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x00,
  0x03, 0x81, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00,
  0x38, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x18, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x70,
  0x00, 0x60, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x38, 0x00, 0x30, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0xC0, 0x01, 0xC6, 0x00, 0x0E,
  0x38, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0x80, 0xC0,
  0x1C, 0x07, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x1C, 0x30, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x00, 0x30, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xF0, 0x1E, 0x03, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x00,
  0xE6, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x03,
  0x38, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x7B,
  0xC0, 0x06, 0xCF, 0x00, 0xE6, 0x3F, 0xFE, 0x30, 0x7F, 0xE1, 0x80, 0x30,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x18, 0xFF,
  0xC3, 0x3F, 0xFC, 0x6E, 0x03, 0xCF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0x7B, 0x70, 0x1E,
  0x67, 0xFF, 0x8C, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x71, 0xC0, 0x07, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x70, 0x7F, 0xC7, 0x0F, 0xFF, 0x71, 0xC0, 0x3F, 0x38, 0x01, 0xF7,
  0x00, 0x0F, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0xF3, 0x80, 0x1F, 0x1E, 0x03, 0x70, 0xFF, 0xF7, 0x07, 0xFC, 0x70,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xE0, 0x3C,
  0x38, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1E, 0x03, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC7, 0x0F, 0xFF, 0x71,
  0xC0, 0x37, 0x38, 0x01, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0x76, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0F, 0x38,
  0x00, 0xF3, 0xC0, 0x1F, 0x1F, 0x0F, 0x70, 0xFF, 0xE7, 0x03, 0xF8, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x18, 0xFF, 0xC3, 0x3F, 0xFC, 0x6E, 0x03, 0xCD, 0x00, 0x3D, 0xE0, 0x03,
  0xB8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0x1D,
  0x80, 0x01, 0xCC, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x00, 0x0E, 0x18, 0x00,
  0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x70, 0x30, 0x07, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xE0, 0x30, 0x07, 0x01, 0x80, 0x1C, 0x0C, 0x00, 0xF0, 0x60,
  0x03, 0x83, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x01, 0xC6, 0x00, 0x07,
  0x30, 0x00, 0x39, 0x80, 0x00, 0xEC, 0x00, 0x03, 0x80, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0xC1, 0x9F, 0x87, 0xE3, 0x7F,
  0x9F, 0xE6, 0x83, 0xA0, 0xEE, 0x07, 0x81, 0xDC, 0x07, 0x01, 0xB8, 0x0E,
  0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0,
  0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03,
  0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F,
  0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0,
  0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01,
  0xC0, 0x7E, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x18, 0x7F, 0xC3, 0x3F, 0xFC,
  0x6E, 0x03, 0xCD, 0x00, 0x3D, 0xE0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xE0, 0x3C,
  0x38, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x1E, 0x03, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x18, 0xFF, 0xC3, 0x3F, 0xFC,
  0x6E, 0x03, 0xCF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0x7B, 0x70, 0x1E, 0x67, 0xFF, 0x8C,
  0x7F, 0xC1, 0x80, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x7F, 0xC7, 0x0F, 0xFF, 0x71, 0xC0, 0x3F, 0x38, 0x01,
  0xF7, 0x00, 0x0F, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0xF3, 0x80, 0x1F, 0x1E, 0x03, 0x70, 0xFF, 0xF7, 0x07, 0xFC,
  0x70, 0x04, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x30, 0x0E, 0x3F, 0xF0, 0xE7, 0xFF, 0x8E, 0xE0, 0x3C, 0xF8, 0x01, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x78, 0x03, 0xC7, 0x00,
  0x0F, 0x38, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00, 0x01, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x33, 0x80, 0x03, 0x8F, 0x00, 0x38, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x33, 0x80, 0x0E, 0x70, 0x03, 0x87, 0x80, 0xF0,
  0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x04, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x73, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x86, 0x00, 0x07,
  0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x38, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x60, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0C, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x33,
  0x80, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x07,
  0x00, 0xFC, 0x06, 0x80, 0x6E, 0x03, 0x60, 0x37, 0x01, 0xB0, 0x19, 0x80,
  0xD8, 0x0C, 0xC0, 0x4C, 0x0E, 0x60, 0x66, 0x07, 0x38, 0x31, 0x03, 0x1C,
  0x18, 0xC1, 0x8E, 0x0C, 0x60, 0xC3, 0x06, 0x30, 0x61, 0x86, 0x18, 0x70,
  0xC3, 0x04, 0x38, 0x71, 0x83, 0x18, 0x38, 0xC1, 0x8C, 0x0C, 0x60, 0xC6,
  0x06, 0x60, 0x63, 0x03, 0x30, 0x33, 0x81, 0x98, 0x0D, 0xC0, 0xEC, 0x06,
  0xC0, 0x76, 0x03, 0x60, 0x1B, 0x01, 0xB0, 0x0F, 0x00, 0xD8, 0x07, 0x80,
  0x6C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x1C, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0xC0, 0xE0, 0x03, 0x80, 0xC0, 0x0E, 0x01, 0xC0,
  0x18, 0x01, 0xC0, 0x70, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0x38, 0x00, 0x07, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x8E, 0x00,
  0x0E, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x00, 0x71, 0xC0,
  0x00, 0x77, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x06, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x60,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x86, 0x00, 0x07, 0x1C, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x0F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x06, 0x00, 0x0C, 0xFE,
  0x00, 0x37, 0xBE, 0x00, 0xD8, 0x3C, 0x03, 0xE0, 0x70, 0x0F, 0x80, 0xE0,
  0x3E, 0x01, 0xC1, 0xF8, 0x03, 0xEE, 0xE0, 0x07, 0xFB, 0x80, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_Thin51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 5, 37, 31, 13, -37 },
  { 25, 13, 15, 31, 9, -37 },
  { 50, 27, 37, 31, 2, -37 },
  { 175, 22, 51, 31, 4, -44 },
  { 316, 29, 37, 31, 1, -37 },
  { 451, 26, 39, 31, 3, -38 },
  { 578, 3, 15, 31, 14, -37 },
  { 584, 15, 49, 31, 10, -43 },
  { 676, 14, 49, 31, 6, -43 },
  { 762, 26, 26, 31, 2, -31 },
  { 847, 23, 24, 31, 4, -29 },
  { 916, 8, 16, 31, 10, -8 },
  { 932, 16, 2, 31, 7, -18 },
  { 936, 7, 8, 31, 12, -7 },
  { 943, 21, 48, 31, 5, -42 },
  { 1069, 21, 39, 31, 5, -38 },
  { 1172, 22, 37, 31, 5, -37 },
  { 1274, 23, 38, 31, 4, -38 },
  { 1384, 20, 38, 31, 5, -37 },
  { 1479, 20, 37, 31, 5, -37 },
  { 1572, 21, 38, 31, 5, -37 },
  { 1672, 22, 38, 31, 4, -37 },
  { 1777, 23, 37, 31, 4, -37 },
  { 1884, 21, 39, 31, 5, -38 },
  { 1987, 22, 38, 31, 4, -38 },
  { 2092, 7, 30, 31, 12, -29 },
  { 2119, 9, 37, 31, 10, -29 },
  { 2161, 21, 26, 31, 5, -30 },
  { 2230, 21, 14, 31, 5, -24 },
  { 2267, 21, 26, 31, 5, -30 },
  { 2336, 17, 37, 31, 9, -37 },
  { 2415, 25, 47, 31, 3, -38 },
  { 2562, 24, 37, 31, 3, -37 },
  { 2673, 20, 37, 31, 6, -37 },
  { 2766, 21, 39, 31, 5, -38 },
  { 2869, 19, 37, 31, 6, -37 },
  { 2957, 20, 37, 31, 6, -37 },
  { 3050, 21, 37, 31, 6, -37 },
  { 3148, 21, 39, 31, 5, -38 },
  { 3251, 19, 37, 31, 6, -37 },
  { 3339, 18, 37, 31, 6, -37 },
  { 3423, 20, 38, 31, 4, -37 },
  { 3518, 22, 37, 31, 6, -37 },
  { 3620, 21, 37, 31, 6, -37 },
  { 3718, 21, 37, 31, 5, -37 },
  { 3816, 19, 37, 31, 6, -37 },
  { 3904, 20, 39, 31, 5, -38 },
  { 4002, 21, 37, 31, 6, -37 },
  { 4100, 21, 47, 31, 5, -38 },
  { 4224, 21, 37, 31, 6, -37 },
  { 4322, 22, 39, 31, 4, -38 },
  { 4430, 25, 37, 31, 3, -37 },
  { 4546, 19, 38, 31, 6, -37 },
  { 4637, 24, 37, 31, 3, -37 },
  { 4748, 27, 37, 31, 2, -37 },
  { 4873, 25, 37, 31, 3, -37 },
  { 4989, 25, 37, 31, 3, -37 },
  { 5105, 21, 37, 31, 5, -37 },
  { 5203, 12, 48, 31, 11, -42 },
  { 5275, 21, 48, 31, 5, -42 },
  { 5401, 11, 48, 31, 8, -42 },
  { 5467, 21, 20, 31, 5, -37 },
  { 5520, 25, 3, 31, 3, 1 },
  { 5530, 9, 7, 31, 10, -40 },
  { 5538, 21, 30, 31, 4, -29 },
  { 5617, 19, 38, 31, 6, -37 },
  { 5708, 21, 30, 31, 5, -29 },
  { 5787, 20, 38, 31, 5, -37 },
  { 5882, 20, 30, 31, 5, -29 },
  { 5957, 23, 37, 31, 4, -37 },
  { 6064, 20, 38, 31, 5, -29 },
  { 6159, 19, 37, 31, 6, -37 },
  { 6247, 22, 39, 31, 5, -39 },
  { 6355, 18, 48, 31, 5, -39 },
  { 6463, 21, 37, 31, 6, -37 },
  { 6561, 25, 37, 31, 3, -37 },
  { 6677, 23, 29, 31, 4, -29 },
  { 6761, 19, 29, 31, 6, -29 },
  { 6830, 20, 30, 31, 5, -29 },
  { 6905, 19, 38, 31, 6, -29 },
  { 6996, 20, 38, 31, 5, -29 },
  { 7091, 20, 29, 31, 6, -29 },
  { 7164, 21, 30, 31, 5, -29 },
  { 7243, 22, 36, 31, 4, -36 },
  { 7342, 19, 29, 31, 6, -28 },
  { 7411, 23, 28, 31, 4, -28 },
  { 7492, 25, 28, 31, 3, -28 },
  { 7580, 23, 28, 31, 4, -28 },
  { 7661, 23, 37, 31, 4, -28 },
  { 7768, 20, 28, 31, 5, -28 },
  { 7838, 21, 48, 31, 5, -42 },
  { 7964, 3, 48, 31, 14, -42 },
  { 7982, 21, 48, 31, 5, -42 },
  { 8108, 22, 10, 31, 4, -23 },
};

const GFXfont JetBrainsMono_Thin51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_THIN51PT7B_H_
