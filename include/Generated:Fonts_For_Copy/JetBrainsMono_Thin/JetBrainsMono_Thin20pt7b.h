#ifndef _JETBRAINSMONO_THIN20PT7B_H_
#define _JETBRAINSMONO_THIN20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFA, 0xA8, 0x3C, 0xCF, 0x3C, 0xF3, 0xCD, 0x10, 0x08, 0x84,
  0x21, 0x08, 0x42, 0x11, 0x3F, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x8F, 0xFD,
  0x08, 0x42, 0x10, 0x84, 0x40, 0x08, 0x08, 0x3C, 0x4A, 0x89, 0x89, 0x88,
  0xC8, 0x68, 0x1C, 0x0A, 0x09, 0x09, 0x89, 0x89, 0xCB, 0x7E, 0x08, 0x08,
  0x08, 0x30, 0x14, 0x82, 0x44, 0x44, 0x48, 0x44, 0x84, 0x50, 0x3A, 0x00,
  0x20, 0x04, 0xC0, 0x92, 0x0A, 0x21, 0x22, 0x22, 0x24, 0x22, 0xC1, 0xE0,
  0x1C, 0x08, 0x82, 0x11, 0x04, 0x20, 0x08, 0x03, 0x01, 0x60, 0xC8, 0x61,
  0x28, 0x32, 0x0C, 0x83, 0x11, 0xA7, 0xC4, 0xFF, 0xF0, 0x04, 0x62, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x60, 0xC1, 0xC0,
  0x81, 0x81, 0x02, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC2,
  0x18, 0xCE, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x23, 0x3B, 0x03, 0x01, 0xE0,
  0x48, 0x21, 0x18, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC3, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x69, 0x69, 0x00, 0xFC, 0xFC, 0x01, 0x01, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x3C, 0x66, 0x81, 0x81, 0x81, 0x81, 0x81, 0x99,
  0x99, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3E, 0x08, 0x1C, 0x1A, 0x11, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE,
  0x3C, 0x21, 0x20, 0x50, 0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x03, 0xFE, 0xFF, 0x02, 0x02, 0x04, 0x08, 0x10, 0x1C,
  0x02, 0x01, 0x01, 0x01, 0x81, 0x81, 0xC2, 0x7C, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x10, 0x20, 0x41, 0x41, 0x81, 0x81, 0xFF, 0x01, 0x01, 0x01, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x98, 0xA6, 0xC3, 0x01, 0x01, 0x01, 0x01, 0x81,
  0x42, 0x7C, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x5C, 0xE2, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0xC0, 0xE0, 0x50, 0x20, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x42, 0x24, 0x18, 0x66, 0xC3, 0x81, 0x81, 0x81, 0xC3,
  0x7E, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x7E, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x30, 0xFC, 0x00, 0xFC, 0x6F, 0x60, 0x00, 0x00, 0x64,
  0x4C, 0x88, 0x01, 0x03, 0x0C, 0x30, 0x40, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x06,
  0x18, 0x60, 0x80, 0xF0, 0x18, 0x18, 0x10, 0x20, 0x41, 0x9E, 0x20, 0x40,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x1E, 0x08, 0x64, 0x09, 0x01, 0x80, 0x61,
  0xD8, 0xCE, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0xE1, 0xDC, 0x01,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x50, 0x12, 0x04,
  0x81, 0x20, 0x84, 0x21, 0x08, 0x43, 0xF1, 0x02, 0x40, 0x90, 0x28, 0x0C,
  0xF8, 0x86, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x83, 0xFC, 0x3C, 0x42, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x81, 0x81, 0x43, 0x3E, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x86, 0xFC, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x3C, 0x42, 0x81, 0x81, 0x80, 0x80, 0x80,
  0x80, 0x8F, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3E, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x30, 0x14, 0x12, 0x08, 0xF8, 0x81, 0xC0, 0xA0, 0xD0, 0x48,
  0x64, 0x22, 0x11, 0xF0, 0x84, 0x42, 0x21, 0x90, 0x48, 0x34, 0x0A, 0x06,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0xFE, 0x81, 0xC3, 0xC3, 0xA5, 0xA5, 0xA5, 0x99,
  0x99, 0x99, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0xC1, 0xC1, 0xA1,
  0xA1, 0x91, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x85, 0x83, 0x83, 0x3C,
  0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0xFC, 0x41, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x05, 0x0C, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3C, 0x42, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x04, 0x02,
  0x03, 0x01, 0xF8, 0x43, 0x20, 0x50, 0x28, 0x1C, 0x0A, 0x05, 0xFC, 0x88,
  0x42, 0x21, 0x10, 0x48, 0x24, 0x0A, 0x06, 0x3C, 0x42, 0x81, 0x81, 0x80,
  0xC0, 0x60, 0x1C, 0x02, 0x01, 0x01, 0x81, 0x81, 0xC3, 0x7E, 0xFF, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x80, 0x50, 0x24, 0x09,
  0x02, 0x60, 0x88, 0x42, 0x10, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48, 0x0C,
  0x03, 0x00, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x62, 0x95, 0x29,
  0x4A, 0x52, 0x94, 0xA5, 0x29, 0x4A, 0x52, 0x98, 0x62, 0x10, 0xC0, 0x50,
  0x22, 0x10, 0x84, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x0C, 0x04, 0x81, 0x20,
  0x84, 0x61, 0x90, 0x28, 0x04, 0x80, 0x50, 0x24, 0x08, 0x84, 0x21, 0x04,
  0x81, 0x20, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0xFF, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3E, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10,
  0x10, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7E, 0x18, 0x18,
  0x18, 0x24, 0x24, 0x42, 0x42, 0x81, 0xFF, 0xC0, 0x88, 0x80, 0x3C, 0x42,
  0x81, 0x01, 0x01, 0x7F, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC,
  0x3E, 0x42, 0x81, 0x81, 0x80, 0x80, 0x80, 0x81, 0x81, 0x42, 0x3E, 0x01,
  0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x43, 0x3D, 0x3C, 0x42, 0x81, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x81, 0x42,
  0x3C, 0x03, 0x86, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x02, 0x7C, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x18, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x43, 0xFE, 0x06, 0x0C, 0x00, 0x0F, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x1B, 0xC0, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x1C, 0x12, 0x09, 0x08, 0x88, 0x7C, 0x23, 0x10, 0x88,
  0x24, 0x1A, 0x06, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xFC, 0xF7, 0x99,
  0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0xBC, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3C, 0x42, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xBC, 0xC2, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x43,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01,
  0x01, 0xFD, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x7E,
  0xC1, 0x81, 0x80, 0x40, 0x3E, 0x03, 0x01, 0x81, 0x81, 0x7E, 0x08, 0x04,
  0x02, 0x1F, 0xF0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x7C, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18,
  0x8C, 0x63, 0x18, 0xC5, 0x32, 0x4A, 0x94, 0xA5, 0x29, 0x4A, 0x52, 0x88,
  0xC2, 0x10, 0x40, 0x88, 0x43, 0x30, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x48,
  0x21, 0x08, 0x4C, 0x0C, 0x81, 0x81, 0x43, 0x42, 0x42, 0x24, 0x24, 0x14,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x20, 0x20, 0xFF, 0x02, 0x06, 0x04, 0x08,
  0x10, 0x10, 0x20, 0x40, 0xC0, 0xFF, 0x03, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0xF0, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x30, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xE0, 0xE1, 0x91, 0x89, 0x86,
};

const GFXglyph JetBrainsMono_Thin20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 15, 12, 5, -15 },
  { 5, 6, 6, 12, 3, -15 },
  { 10, 10, 15, 12, 1, -15 },
  { 29, 8, 20, 12, 2, -17 },
  { 49, 12, 15, 12, 0, -15 },
  { 72, 10, 15, 12, 1, -15 },
  { 91, 2, 6, 12, 5, -15 },
  { 93, 6, 19, 12, 4, -17 },
  { 108, 6, 19, 12, 2, -17 },
  { 123, 10, 10, 12, 1, -12 },
  { 136, 10, 9, 12, 1, -11 },
  { 148, 3, 6, 12, 4, -3 },
  { 151, 6, 1, 12, 3, -7 },
  { 152, 2, 3, 12, 5, -3 },
  { 153, 8, 19, 12, 2, -17 },
  { 172, 8, 15, 12, 2, -15 },
  { 187, 9, 15, 12, 2, -15 },
  { 204, 9, 15, 12, 2, -15 },
  { 221, 8, 15, 12, 2, -15 },
  { 236, 8, 15, 12, 2, -15 },
  { 251, 8, 15, 12, 2, -15 },
  { 266, 8, 15, 12, 2, -15 },
  { 281, 9, 15, 12, 2, -15 },
  { 298, 8, 15, 12, 2, -15 },
  { 313, 8, 15, 12, 2, -15 },
  { 328, 2, 11, 12, 5, -11 },
  { 331, 4, 14, 12, 4, -11 },
  { 338, 8, 10, 12, 2, -12 },
  { 348, 8, 5, 12, 2, -9 },
  { 353, 8, 10, 12, 2, -12 },
  { 363, 7, 15, 12, 3, -15 },
  { 377, 10, 19, 12, 1, -15 },
  { 401, 10, 15, 12, 1, -15 },
  { 420, 8, 15, 12, 2, -15 },
  { 435, 8, 15, 12, 2, -15 },
  { 450, 8, 15, 12, 2, -15 },
  { 465, 8, 15, 12, 2, -15 },
  { 480, 9, 15, 12, 2, -15 },
  { 497, 8, 15, 12, 2, -15 },
  { 512, 8, 15, 12, 2, -15 },
  { 527, 8, 15, 12, 2, -15 },
  { 542, 9, 15, 12, 1, -15 },
  { 559, 9, 15, 12, 2, -15 },
  { 576, 9, 15, 12, 2, -15 },
  { 593, 8, 15, 12, 2, -15 },
  { 608, 8, 15, 12, 2, -15 },
  { 623, 8, 15, 12, 2, -15 },
  { 638, 9, 15, 12, 2, -15 },
  { 655, 8, 19, 12, 2, -15 },
  { 674, 9, 15, 12, 2, -15 },
  { 691, 8, 15, 12, 2, -15 },
  { 706, 10, 15, 12, 1, -15 },
  { 725, 8, 15, 12, 2, -15 },
  { 740, 10, 15, 12, 1, -15 },
  { 759, 10, 15, 12, 1, -15 },
  { 778, 10, 15, 12, 1, -15 },
  { 797, 10, 15, 12, 1, -15 },
  { 816, 8, 15, 12, 2, -15 },
  { 831, 5, 19, 12, 4, -17 },
  { 843, 8, 19, 12, 2, -17 },
  { 862, 5, 19, 12, 3, -17 },
  { 874, 8, 8, 12, 2, -15 },
  { 882, 10, 1, 12, 1, 0 },
  { 884, 3, 3, 12, 4, -16 },
  { 886, 8, 11, 12, 2, -11 },
  { 897, 8, 15, 12, 2, -15 },
  { 912, 8, 11, 12, 2, -11 },
  { 923, 8, 15, 12, 2, -15 },
  { 938, 8, 11, 12, 2, -11 },
  { 949, 9, 15, 12, 1, -15 },
  { 966, 8, 15, 12, 2, -11 },
  { 981, 8, 15, 12, 2, -15 },
  { 996, 9, 15, 12, 2, -15 },
  { 1013, 7, 19, 12, 2, -15 },
  { 1030, 9, 15, 12, 2, -15 },
  { 1047, 10, 15, 12, 1, -15 },
  { 1066, 8, 11, 12, 2, -11 },
  { 1077, 8, 11, 12, 2, -11 },
  { 1088, 8, 11, 12, 2, -11 },
  { 1099, 8, 15, 12, 2, -11 },
  { 1114, 8, 15, 12, 2, -11 },
  { 1129, 7, 11, 12, 3, -11 },
  { 1139, 8, 11, 12, 2, -11 },
  { 1150, 9, 14, 12, 1, -14 },
  { 1166, 8, 11, 12, 2, -11 },
  { 1177, 8, 11, 12, 2, -11 },
  { 1188, 10, 11, 12, 1, -11 },
  { 1202, 10, 11, 12, 1, -11 },
  { 1216, 8, 15, 12, 2, -11 },
  { 1231, 8, 11, 12, 2, -11 },
  { 1242, 8, 19, 12, 2, -17 },
  { 1261, 2, 19, 12, 5, -17 },
  { 1266, 8, 19, 12, 2, -17 },
  { 1285, 8, 4, 12, 2, -9 },
};

const GFXfont JetBrainsMono_Thin20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_THIN20PT7B_H_
