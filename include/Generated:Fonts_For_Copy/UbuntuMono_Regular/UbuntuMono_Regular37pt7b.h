#ifndef _UBUNTUMONO_REGULAR37PT7B_H_
#define _UBUNTUMONO_REGULAR37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x31, 0x80, 0x00,
  0x1D, 0xEF, 0xF9, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0D,
  0x86, 0xC3, 0x00, 0x03, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0,
  0x70, 0xC0, 0x30, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E,
  0x03, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x06, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0x3C, 0x0C, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x90, 0x0F, 0x7F,
  0xFC, 0xFF, 0xF0, 0x7F, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x3C, 0x03, 0x3F, 0x03, 0xB9, 0x83, 0x98, 0xC1, 0x8C, 0x71, 0xC6,
  0x38, 0xC3, 0x1C, 0xE1, 0x8E, 0xE0, 0xC6, 0x60, 0x73, 0x70, 0x1F, 0xB0,
  0x07, 0xB8, 0x00, 0x39, 0xE0, 0x19, 0xF8, 0x1D, 0xCC, 0x1C, 0xC7, 0x0C,
  0x61, 0x8E, 0x30, 0xC6, 0x18, 0xE7, 0x0C, 0x77, 0x07, 0x33, 0x01, 0xFB,
  0x80, 0x78, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0x8E, 0x03, 0x83,
  0x01, 0xC1, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x1D, 0xC0, 0x07, 0xC0, 0x07,
  0xC1, 0x87, 0xF1, 0xC7, 0xBC, 0xE3, 0x8F, 0x71, 0xC3, 0xF1, 0xC0, 0xF8,
  0xE0, 0x3C, 0x70, 0x1E, 0x3C, 0x0F, 0x0F, 0x1F, 0xC7, 0xFE, 0xE1, 0xFE,
  0x38, 0x3E, 0x1C, 0xFF, 0xFF, 0xFE, 0xD8, 0x00, 0x80, 0x70, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x02, 0x40,
  0x1C, 0x0F, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x3E,
  0x07, 0x01, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x10, 0xE3, 0x73, 0x3F,
  0xFF, 0xF3, 0xFF, 0x80, 0xE0, 0x07, 0xC0, 0x3B, 0x81, 0xCF, 0x0F, 0x1C,
  0x18, 0x70, 0x20, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x7D, 0xF9, 0xF3, 0xE1, 0xC7, 0x3C, 0xF1, 0x80, 0xFF, 0xFF, 0xFF,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC3, 0xC3, 0xC7, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x0F, 0xC7, 0x1F, 0x9E, 0x3F, 0x3C, 0x7E, 0x78, 0xFC, 0x71, 0xF8, 0x07,
  0xF0, 0x0E, 0xE0, 0x1D, 0xE0, 0x39, 0xC0, 0xF3, 0xC3, 0xC3, 0xFF, 0x03,
  0xFE, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x3F, 0x07, 0xF8,
  0x79, 0xC3, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0x9C,
  0x1E, 0x40, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F,
  0xC1, 0xFF, 0xC7, 0xFF, 0x08, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xD0, 0x1F, 0xFF, 0xFB,
  0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xDC, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC6, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x01,
  0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xD0,
  0x1F, 0x7F, 0xFB, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x1F,
  0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xEF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xE3, 0xFF, 0x83, 0xFE,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x78, 0x0E, 0x78, 0x38, 0xF8, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x8E,
  0x0F, 0x9C, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0xC1,
  0xE7, 0xFF, 0x87, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xE3, 0xC3, 0xCF, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1F,
  0xE0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE3, 0xFF, 0xC1, 0xFB, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x3F, 0x07, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F,
  0xFF, 0x70, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0xCF, 0x9F, 0x3E, 0x1C, 0x73, 0xCF, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x03,
  0xC0, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x01,
  0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xC0, 0x1E, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0x8F, 0xFE, 0x7F, 0xE4, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0E, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F,
  0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x7F, 0x70, 0xFF, 0x71, 0xFF,
  0x73, 0xC7, 0xF3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0x73, 0x87, 0x73, 0x87,
  0x73, 0xC7, 0x71, 0xFF, 0x70, 0xFF, 0x78, 0x7F, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCE, 0x00,
  0x71, 0x80, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x83, 0x00, 0xE0, 0xE0, 0x30,
  0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0xDC, 0x00, 0x7F,
  0x00, 0x1C, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xCE, 0x03, 0x9C,
  0x07, 0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x39, 0xC1, 0xE3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFF, 0x9C, 0x0F, 0xB8, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x77, 0x03, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF1, 0xF0, 0x67, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x21,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7,
  0x07, 0xCE, 0x03, 0x9C, 0x07, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xE7, 0x07, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xB8, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF9, 0xF0, 0x67, 0x80, 0x4F, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x0E, 0xE0, 0x1D, 0xE0, 0x39, 0xF0, 0x71, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFE, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE4, 0x03, 0x98, 0x3E, 0xFF,
  0xF1, 0xFF, 0x81, 0xF8, 0x00, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x78, 0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0xC0, 0xE7, 0x80, 0xEF,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xEF, 0x80, 0xE3, 0xC0, 0xE1, 0xE0, 0xE0,
  0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x0E, 0x38, 0x1E,
  0x38, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x36, 0x7E, 0x36, 0x66, 0x76,
  0x66, 0x67, 0x67, 0x67, 0x63, 0xE7, 0x63, 0xC7, 0x63, 0xC7, 0x61, 0xC7,
  0x60, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x3E, 0xE0, 0xFB, 0x83, 0xE7, 0x0F, 0x9C, 0x3E,
  0x38, 0xF8, 0xE3, 0xE1, 0xCF, 0x87, 0x3E, 0x0C, 0xF8, 0x3B, 0xE0, 0x6F,
  0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xC0, 0x07,
  0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3E, 0x78, 0x0E, 0x70, 0x0F, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78,
  0x0E, 0x3C, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xB8, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3E, 0x78, 0x0E,
  0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0x78, 0x0E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x06,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x03, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x03, 0xCF, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF0, 0x70, 0xF0, 0xE0, 0xE1, 0xC0, 0xE3, 0x81, 0xE7,
  0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x80, 0x0F, 0xE0, 0x7F, 0xF3,
  0xFF, 0x9E, 0x06, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xD8, 0x0F, 0xFF, 0xFB, 0xFF, 0xC1, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3B, 0xC0, 0x73, 0xC3,
  0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0x70, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x39, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xF0,
  0x1C, 0x1C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x0E,
  0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xEE, 0x00,
  0x3B, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x60, 0x07, 0x60, 0x07, 0x61, 0xC7, 0x63, 0xC7, 0x63, 0xC7, 0x63,
  0xE7, 0x67, 0x67, 0x66, 0x66, 0x66, 0x76, 0x6E, 0x36, 0x7C, 0x36, 0x7C,
  0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x0E, 0x70, 0x07, 0x3C,
  0x07, 0x0E, 0x03, 0x87, 0x83, 0x81, 0xC3, 0xC0, 0xF1, 0xC0, 0x39, 0xE0,
  0x0E, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1C, 0xF0, 0x1E, 0x38, 0x0E, 0x1E, 0x0F,
  0x07, 0x07, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x7B, 0x80, 0x1C, 0x70, 0x01,
  0xDC, 0x00, 0xE7, 0x80, 0x38, 0xE0, 0x1E, 0x3C, 0x07, 0x07, 0x03, 0xC1,
  0xE0, 0xE0, 0x38, 0x78, 0x0F, 0x1C, 0x01, 0xCF, 0x00, 0x7B, 0x80, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F,
  0xFF, 0xFF, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70,
  0x0E, 0x78, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x07, 0x20, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x43,
  0x87, 0x0E, 0x1C, 0x20, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8C, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0xFF, 0xCF, 0xFF, 0x78, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x77, 0xFF, 0xCF, 0xFF, 0x0F, 0xF8, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xBE, 0x0F, 0xFE, 0x3F, 0xFC, 0xF0, 0xFB, 0x80, 0xEE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xEE, 0x0F, 0xBF, 0xFC, 0xFF, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xF8,
  0xFF, 0xF3, 0xE0, 0x27, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x8F, 0xFF,
  0x0F, 0xFF, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xDC, 0x7F,
  0xF9, 0xFF, 0xF3, 0xC3, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0F,
  0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEF, 0x01, 0xCF, 0x03, 0x8F,
  0xFF, 0x0F, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C,
  0x1E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x04, 0x1F, 0xFC, 0x0F,
  0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0x82, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF,
  0xF9, 0xE0, 0x77, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0E,
  0xE0, 0x1D, 0xC0, 0x3B, 0xC0, 0x77, 0xC1, 0xE7, 0xFF, 0xC7, 0xFF, 0x83,
  0xF7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x79, 0x01, 0xE3, 0xFF, 0xCF, 0xFF,
  0x07, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xEE, 0x0F,
  0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0x0E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x40, 0x7F, 0x80, 0xFF, 0x80, 0x7C, 0x01, 0xC0, 0x7C, 0x0F, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0x07, 0xFF, 0xEF, 0xF8, 0xFE,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x7B, 0x81, 0xE7, 0x07, 0x8E,
  0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xBC,
  0x07, 0x3C, 0x0E, 0x3C, 0x1C, 0x3C, 0x38, 0x3C, 0x70, 0x3C, 0xE0, 0x3D,
  0xC0, 0x38, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE1, 0x01, 0xFE, 0x03,
  0xFE, 0x01, 0xF0, 0x7C, 0x79, 0xFF, 0xFB, 0xFF, 0xFE, 0x3C, 0x7C, 0x38,
  0xF8, 0x71, 0xF0, 0xE3, 0xE1, 0xC7, 0xC3, 0x8F, 0x87, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0E, 0x7F,
  0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x38, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78,
  0x0E, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x0F, 0x78, 0x0E, 0x3C, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x07,
  0xE0, 0x7F, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0xE0, 0x7B, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3B,
  0xC1, 0xEF, 0xFF, 0x3F, 0xF8, 0xEF, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9,
  0xE0, 0x77, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x80, 0xE7, 0x83, 0xCF, 0xFF, 0x8F, 0xFF,
  0x07, 0xEE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0xE7, 0xFF, 0x9E, 0x06, 0x70,
  0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0,
  0x07, 0x00, 0x1D, 0x80, 0xF7, 0xFF, 0xBF, 0xFE, 0x3F, 0xE0, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x10, 0x3F, 0xE0,
  0x7F, 0xE0, 0x3F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1D, 0xFF, 0xE7, 0xFF, 0x1F, 0xE0, 0xF0, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x07, 0x70, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x6E, 0x1C, 0x37, 0x0E, 0x3B, 0x8F, 0x1C, 0xC7, 0x8E, 0x63,
  0xE7, 0x3B, 0xB3, 0x9D, 0x99, 0x8E, 0xCE, 0xC7, 0xE3, 0xE1, 0xE1, 0xF0,
  0xF0, 0x78, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x70, 0x0F, 0x78, 0x0E, 0x3C,
  0x1C, 0x1C, 0x38, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1C, 0x38, 0x3C, 0x1C, 0x38,
  0x0E, 0x70, 0x0F, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x78, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x3C, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x1C, 0x0E,
  0x38, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x70, 0x03, 0xF0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0xC3, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x1F, 0x00, 0xF8, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x3F, 0x01, 0xF8, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x83,
  0xF8, 0x1F, 0x80, 0x1E, 0x03, 0x3F, 0x83, 0x7F, 0xC7, 0x73, 0xFE, 0x60,
  0xFE, 0x60, 0x38,
};

const GFXglyph UbuntuMono_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 9, 9, 19, 5, -25 },
  { 27, 17, 23, 19, 1, -23 },
  { 76, 15, 30, 19, 2, -26 },
  { 133, 17, 23, 19, 1, -23 },
  { 182, 17, 23, 19, 1, -23 },
  { 231, 3, 10, 19, 8, -25 },
  { 235, 10, 32, 19, 4, -26 },
  { 275, 10, 32, 19, 4, -26 },
  { 315, 14, 14, 19, 2, -23 },
  { 340, 15, 17, 19, 2, -18 },
  { 372, 7, 10, 19, 6, -5 },
  { 381, 8, 3, 19, 5, -11 },
  { 384, 5, 5, 19, 7, -5 },
  { 388, 13, 32, 19, 3, -26 },
  { 440, 15, 23, 19, 2, -23 },
  { 484, 13, 23, 19, 3, -23 },
  { 522, 14, 23, 19, 2, -23 },
  { 563, 14, 23, 19, 2, -23 },
  { 604, 16, 23, 19, 1, -23 },
  { 650, 14, 23, 19, 2, -23 },
  { 691, 15, 23, 19, 2, -23 },
  { 735, 15, 23, 19, 2, -23 },
  { 779, 15, 23, 19, 2, -23 },
  { 823, 15, 23, 19, 2, -23 },
  { 867, 5, 17, 19, 7, -17 },
  { 878, 7, 22, 19, 5, -17 },
  { 898, 15, 15, 19, 2, -17 },
  { 927, 15, 10, 19, 2, -15 },
  { 946, 15, 15, 19, 2, -17 },
  { 975, 12, 23, 19, 3, -23 },
  { 1010, 16, 28, 19, 1, -23 },
  { 1066, 18, 23, 19, 0, -23 },
  { 1118, 15, 23, 19, 2, -23 },
  { 1162, 15, 23, 19, 2, -23 },
  { 1206, 15, 23, 19, 2, -23 },
  { 1250, 14, 23, 19, 3, -23 },
  { 1291, 13, 23, 19, 3, -23 },
  { 1329, 15, 23, 19, 2, -23 },
  { 1373, 15, 23, 19, 2, -23 },
  { 1417, 12, 23, 19, 3, -23 },
  { 1452, 14, 23, 19, 2, -23 },
  { 1493, 16, 23, 19, 2, -23 },
  { 1539, 14, 23, 19, 3, -23 },
  { 1580, 16, 23, 19, 1, -23 },
  { 1626, 14, 23, 19, 2, -23 },
  { 1667, 16, 23, 19, 1, -23 },
  { 1713, 14, 23, 19, 3, -23 },
  { 1754, 16, 29, 19, 1, -23 },
  { 1812, 15, 23, 19, 2, -23 },
  { 1856, 14, 23, 19, 2, -23 },
  { 1897, 16, 23, 19, 1, -23 },
  { 1943, 15, 23, 19, 2, -23 },
  { 1987, 18, 23, 19, 0, -23 },
  { 2039, 16, 23, 19, 1, -23 },
  { 2085, 17, 23, 19, 1, -23 },
  { 2134, 18, 23, 19, 0, -23 },
  { 2186, 15, 23, 19, 2, -23 },
  { 2230, 9, 32, 19, 5, -26 },
  { 2266, 13, 32, 19, 3, -26 },
  { 2318, 9, 32, 19, 4, -26 },
  { 2354, 16, 13, 19, 1, -23 },
  { 2380, 18, 3, 19, 0, 4 },
  { 2387, 6, 6, 19, 6, -25 },
  { 2392, 14, 17, 19, 2, -17 },
  { 2422, 14, 26, 19, 3, -26 },
  { 2468, 15, 17, 19, 2, -17 },
  { 2500, 15, 26, 19, 1, -26 },
  { 2549, 16, 17, 19, 1, -17 },
  { 2583, 16, 26, 19, 2, -26 },
  { 2635, 15, 23, 19, 1, -17 },
  { 2679, 13, 26, 19, 3, -26 },
  { 2722, 15, 24, 19, 2, -24 },
  { 2767, 11, 30, 19, 3, -24 },
  { 2809, 15, 26, 19, 3, -26 },
  { 2858, 15, 26, 19, 2, -26 },
  { 2907, 15, 17, 19, 2, -17 },
  { 2939, 13, 17, 19, 3, -17 },
  { 2967, 16, 17, 19, 1, -17 },
  { 3001, 14, 23, 19, 3, -17 },
  { 3042, 15, 23, 19, 1, -17 },
  { 3086, 12, 17, 19, 4, -17 },
  { 3112, 14, 17, 19, 2, -17 },
  { 3142, 15, 22, 19, 2, -22 },
  { 3184, 13, 17, 19, 3, -17 },
  { 3212, 16, 17, 19, 1, -17 },
  { 3246, 17, 17, 19, 1, -17 },
  { 3283, 16, 17, 19, 1, -17 },
  { 3317, 16, 23, 19, 1, -17 },
  { 3363, 13, 17, 19, 3, -17 },
  { 3391, 13, 32, 19, 3, -26 },
  { 3443, 3, 32, 19, 8, -26 },
  { 3455, 13, 32, 19, 3, -26 },
  { 3507, 16, 6, 19, 1, -13 },
};

const GFXfont UbuntuMono_Regular37pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular37pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular37pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUMONO_REGULAR37PT7B_H_
