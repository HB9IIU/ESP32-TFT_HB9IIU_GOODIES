#ifndef _UBUNTUMONO_REGULAR41PT7B_H_
#define _UBUNTUMONO_REGULAR41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3,
  0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xDF, 0x38, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x76, 0x1D, 0x87, 0x60, 0xD8, 0x30, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70,
  0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0x38, 0x38,
  0x0E, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x70, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0xE0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x83,
  0x80, 0xE1, 0xC0, 0x38, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x04, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x60, 0x1F, 0x7F, 0xFE, 0xFF, 0xFC, 0x1F, 0xF0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x01,
  0xCF, 0xC0, 0x3B, 0x9C, 0x0E, 0x71, 0x83, 0x8C, 0x38, 0x71, 0x87, 0x1C,
  0x30, 0xE3, 0x06, 0x1C, 0xE0, 0xC3, 0xB8, 0x1C, 0x67, 0x03, 0x9D, 0xC0,
  0x3F, 0x70, 0x03, 0xCE, 0xF0, 0x03, 0xBF, 0x00, 0x66, 0x70, 0x1D, 0xC6,
  0x07, 0x38, 0xE0, 0xE6, 0x1C, 0x38, 0xC3, 0x8E, 0x18, 0x71, 0xC3, 0x8E,
  0x70, 0x71, 0x8C, 0x06, 0x73, 0x80, 0xFC, 0xE0, 0x0F, 0x00, 0x03, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xF0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xF0, 0xE0, 0x1C, 0x70, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x0E, 0x1F, 0xC3, 0x8E, 0x78, 0xE7, 0x9F, 0x31, 0xC3, 0xDC, 0x70, 0x7F,
  0x3C, 0x0F, 0xCF, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x3F, 0x1F, 0x1F, 0xE3,
  0xFF, 0xB8, 0x7F, 0xCF, 0x0F, 0xC1, 0xC0, 0xFF, 0xFF, 0x77, 0x77, 0x76,
  0x60, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0x00, 0x40, 0x40, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x03, 0x80, 0x20, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x61, 0xC2, 0x79, 0x8F, 0x7F, 0xBF, 0x3F, 0xFE, 0x03, 0xC0, 0x07,
  0xE0, 0x0F, 0x70, 0x1E, 0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x0C, 0x10, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x1F, 0x1F, 0x07, 0x0E,
  0x3E, 0xFC, 0xF8, 0x60, 0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xFF, 0xFF, 0x7D,
  0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x87, 0xC7, 0x81, 0xE3, 0xC0, 0x79, 0xC0, 0x3D,
  0xE0, 0x0E, 0xF0, 0x07, 0x78, 0xE3, 0xB8, 0xF1, 0xFC, 0x7C, 0xFE, 0x3C,
  0x7F, 0x0E, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0x9C,
  0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xE1, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0,
  0x07, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x07, 0xFC,
  0x1F, 0xB8, 0x1C, 0x70, 0x20, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3E, 0x20, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x38, 0x3C,
  0x20, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x7C,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x60, 0x3E,
  0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0E, 0x38,
  0x07, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x0E, 0x0E,
  0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7E, 0x01, 0xFF, 0x83,
  0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xF8, 0x0F, 0xBF, 0xFE, 0x7F, 0xF8,
  0x3F, 0xC0, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x77, 0xF0, 0x7F, 0xFC,
  0xFF, 0xFE, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x78, 0x0F, 0x3C, 0x1E, 0x3F, 0xFC,
  0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFE,
  0x7C, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0E,
  0x78, 0x1E, 0x3E, 0x3C, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x38, 0x3E,
  0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0x7C, 0x1F, 0x7F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x7C, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF,
  0x07, 0xEF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x3C, 0x00, 0x39, 0xFF,
  0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xFF, 0xFD, 0xF7,
  0x80, 0x0E, 0x1F, 0x3F, 0x3F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x1F, 0x1F, 0x07, 0x0E, 0x3E, 0xFC,
  0xF8, 0x60, 0x00, 0x01, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1E,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xE0,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0x87, 0xFF, 0x3F, 0xFC, 0x81, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x01, 0xF0, 0x03,
  0xFE, 0x07, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x73, 0xC0, 0x3D, 0xC0, 0x0E,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3E,
  0x3F, 0x1E, 0x1F, 0x8E, 0x0F, 0xC7, 0x07, 0xE3, 0x83, 0xF1, 0xC1, 0xF8,
  0xE0, 0xFC, 0x78, 0x7F, 0x3C, 0x3F, 0x8F, 0xFD, 0xC3, 0xFE, 0xF0, 0xFE,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xDC, 0x00, 0x39, 0xC0, 0x03, 0x9E, 0x00, 0x78, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xF0, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x80,
  0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x3C, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xE0, 0x01, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xC3, 0xE0, 0xE3, 0xC0, 0x13, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x18, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1E, 0x0F, 0x8F, 0x01,
  0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0x78, 0x03, 0xBC, 0x03, 0xDE, 0x01, 0xCF, 0x01, 0xE7, 0x83,
  0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE0, 0xE3,
  0xC0, 0x13, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xB8, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x79,
  0xF8, 0x3C, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF4, 0x01, 0xEE,
  0x0F, 0xBF, 0xFF, 0x3F, 0xF8, 0x1F, 0xE0, 0xE0, 0x0F, 0x70, 0x0F, 0x38,
  0x0F, 0x1C, 0x07, 0x8E, 0x07, 0x87, 0x07, 0x83, 0x87, 0x81, 0xC7, 0x80,
  0xE7, 0x80, 0x77, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0x7C,
  0x03, 0x9F, 0x01, 0xC7, 0xC0, 0xE1, 0xF0, 0x70, 0x7C, 0x38, 0x1E, 0x1C,
  0x07, 0x8E, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x07,
  0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x38, 0x07, 0x0F, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3E, 0x0F, 0x8D,
  0x87, 0xE7, 0x61, 0xF9, 0xDC, 0x66, 0x73, 0x39, 0x9C, 0xEE, 0x67, 0x3B,
  0x19, 0xC7, 0xC7, 0x71, 0xF1, 0xDC, 0x78, 0x77, 0x0E, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xEE, 0x07, 0xEE, 0x07, 0xE7,
  0x07, 0xE7, 0x07, 0xE3, 0x87, 0xE3, 0x87, 0xE1, 0xC7, 0xE1, 0xC7, 0xE0,
  0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x3D, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x3C, 0x07, 0x8F, 0x87,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x3D, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x3C, 0x07, 0x8F, 0x87, 0xC1,
  0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x38, 0x7F, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF, 0x03, 0xC7,
  0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x0E,
  0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0x73, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0,
  0x07, 0x80, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x3C, 0x04, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x40, 0x0F, 0x70, 0x1F, 0xFF, 0xFE,
  0x7F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xBC, 0x01, 0xDE, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x78,
  0x00, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x9E, 0x00, 0xE1, 0xC0, 0x1C, 0x38,
  0x07, 0x87, 0x80, 0xE0, 0xF0, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x1C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0xF0, 0x03, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x77, 0x0E, 0x1D, 0xC7, 0x87, 0x71, 0xF1, 0xDC, 0x7C, 0x67,
  0x3B, 0x19, 0xCC, 0xE6, 0x73, 0x39, 0x9D, 0xC6, 0x67, 0x61, 0xF9, 0xF8,
  0x7E, 0x3E, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1C, 0x38, 0x07,
  0x00, 0x70, 0x03, 0xDE, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x1E, 0x0F,
  0x03, 0x87, 0x80, 0xF1, 0xC0, 0x1C, 0xF0, 0x07, 0xB8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0x3C, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x3C, 0x3C, 0x0F,
  0x0E, 0x01, 0xE7, 0x80, 0x39, 0xC0, 0x0F, 0xF0, 0x01, 0xC0, 0xF0, 0x01,
  0xFE, 0x00, 0x39, 0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0x78, 0x0F,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x1E, 0x01, 0xE3, 0x80, 0x1C, 0xF0,
  0x03, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0xF7, 0x00, 0x73, 0xC0, 0x78, 0xE0, 0x78, 0x78, 0x38,
  0x1E, 0x3C, 0x07, 0x1C, 0x03, 0xDE, 0x00, 0xEE, 0x00, 0x7B, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x41, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC2, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x10, 0x3E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C,
  0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x07, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE7,
  0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF8, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x03, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0x1F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xEF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7C, 0x1F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0x03,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xC7, 0x80, 0xF7, 0x80, 0x3B,
  0xC0, 0x1D, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x04, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF0,
  0x20, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x0F,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x7C, 0x1F, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xEF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x60, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xDF, 0x83, 0xFF, 0xC7, 0xFF, 0xCF, 0x07, 0xDC, 0x07, 0xB8, 0x07,
  0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xF0, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC1, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x39, 0x83, 0xDF, 0xFC, 0xFF,
  0xE1, 0xFC, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x0F,
  0x38, 0x07, 0x9C, 0x0F, 0x8E, 0x0F, 0x87, 0x0F, 0x83, 0x8F, 0x81, 0xCF,
  0x00, 0xEF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1D, 0xF0, 0x0E, 0x7C, 0x07,
  0x0F, 0x03, 0x83, 0xC1, 0xC0, 0xF0, 0xE0, 0x3C, 0x70, 0x0F, 0x38, 0x03,
  0xDC, 0x01, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC1, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x7E,
  0x3C, 0x7F, 0xFF, 0xBF, 0xFF, 0xDC, 0x78, 0xFE, 0x1C, 0x3F, 0x0E, 0x1F,
  0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xE0, 0x3F, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE,
  0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x78, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x87,
  0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x77, 0x80, 0x79, 0xE0, 0x3C,
  0xF8, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x1E, 0xF8, 0x3C, 0xFF, 0xFC, 0xFF, 0xF8, 0xE7, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x0F, 0x78, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F,
  0xFF, 0x07, 0xEF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x02,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF7, 0xC0, 0x4F, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xF8, 0x1F, 0xFF, 0xFD, 0xFF,
  0xF0, 0xFF, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x43, 0xFF, 0x83, 0xFF,
  0x01, 0xFC, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x7F, 0xFE, 0x7F, 0xFC,
  0x3F, 0xE0, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0E, 0x38,
  0x07, 0x8F, 0x01, 0xC3, 0xC0, 0x70, 0x70, 0x3C, 0x1E, 0x0E, 0x07, 0x87,
  0x80, 0xE1, 0xE0, 0x3C, 0x70, 0x07, 0x3C, 0x01, 0xEE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x0E, 0x1D, 0xE1, 0xC3, 0x9C,
  0x78, 0x73, 0x8F, 0x8E, 0x71, 0xF1, 0xCE, 0x7E, 0x31, 0xCE, 0xEE, 0x39,
  0x9D, 0xC7, 0x73, 0xB8, 0x7E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x78, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x00, 0x78, 0x03, 0x8E, 0x01, 0xE3,
  0xC0, 0xF0, 0x78, 0x38, 0x0F, 0x1C, 0x01, 0xCF, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x07, 0x3C,
  0x03, 0xC7, 0x81, 0xE0, 0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x9E, 0x00, 0xEF,
  0x00, 0x3C, 0x78, 0x03, 0xDE, 0x00, 0xF3, 0x80, 0x38, 0xF0, 0x1E, 0x3C,
  0x07, 0x87, 0x01, 0xC1, 0xE0, 0x70, 0x78, 0x3C, 0x0E, 0x0F, 0x03, 0xC3,
  0x80, 0xF0, 0xE0, 0x1C, 0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC3, 0xFE, 0x0F, 0xF0,
  0x3F, 0x80, 0x3E, 0x03, 0x3F, 0xC1, 0xFF, 0xF1, 0xFC, 0x7F, 0xEC, 0x0F,
  0xE6, 0x01, 0xE0,
};

const GFXglyph UbuntuMono_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 6, 25, 21, 7, -25 },
  { 20, 10, 10, 21, 5, -28 },
  { 33, 18, 25, 21, 1, -25 },
  { 90, 16, 32, 21, 2, -28 },
  { 154, 19, 25, 21, 1, -25 },
  { 214, 18, 25, 21, 1, -25 },
  { 271, 4, 11, 21, 8, -28 },
  { 277, 11, 36, 21, 5, -29 },
  { 327, 11, 36, 21, 5, -29 },
  { 377, 16, 15, 21, 2, -25 },
  { 407, 17, 19, 21, 2, -20 },
  { 448, 8, 12, 21, 6, -6 },
  { 460, 9, 3, 21, 6, -12 },
  { 464, 6, 6, 21, 7, -6 },
  { 469, 15, 36, 21, 3, -29 },
  { 537, 17, 25, 21, 2, -25 },
  { 591, 15, 25, 21, 3, -25 },
  { 638, 16, 25, 21, 2, -25 },
  { 688, 16, 25, 21, 2, -25 },
  { 738, 18, 25, 21, 1, -25 },
  { 795, 15, 25, 21, 3, -25 },
  { 842, 16, 25, 21, 2, -25 },
  { 892, 16, 25, 21, 3, -25 },
  { 942, 16, 25, 21, 2, -25 },
  { 992, 16, 25, 21, 2, -25 },
  { 1042, 6, 19, 21, 7, -19 },
  { 1057, 8, 25, 21, 5, -19 },
  { 1082, 17, 17, 21, 2, -19 },
  { 1119, 17, 11, 21, 2, -16 },
  { 1143, 17, 17, 21, 2, -19 },
  { 1180, 13, 25, 21, 4, -25 },
  { 1221, 17, 31, 21, 2, -25 },
  { 1287, 20, 25, 21, 0, -25 },
  { 1350, 16, 25, 21, 2, -25 },
  { 1400, 17, 25, 21, 2, -25 },
  { 1454, 17, 25, 21, 2, -25 },
  { 1508, 15, 25, 21, 4, -25 },
  { 1555, 14, 25, 21, 4, -25 },
  { 1599, 17, 25, 21, 2, -25 },
  { 1653, 17, 25, 21, 2, -25 },
  { 1707, 13, 25, 21, 4, -25 },
  { 1748, 15, 25, 21, 2, -25 },
  { 1795, 17, 25, 21, 3, -25 },
  { 1849, 15, 25, 21, 4, -25 },
  { 1896, 18, 25, 21, 1, -25 },
  { 1953, 16, 25, 21, 2, -25 },
  { 2003, 18, 25, 21, 1, -25 },
  { 2060, 16, 25, 21, 3, -25 },
  { 2110, 18, 31, 21, 1, -25 },
  { 2180, 17, 25, 21, 2, -25 },
  { 2234, 16, 25, 21, 2, -25 },
  { 2284, 17, 25, 21, 2, -25 },
  { 2338, 17, 25, 21, 2, -25 },
  { 2392, 19, 25, 21, 1, -25 },
  { 2452, 18, 25, 21, 1, -25 },
  { 2509, 18, 25, 21, 1, -25 },
  { 2566, 19, 25, 21, 1, -25 },
  { 2626, 17, 25, 21, 2, -25 },
  { 2680, 10, 36, 21, 6, -29 },
  { 2725, 15, 36, 21, 3, -29 },
  { 2793, 10, 36, 21, 5, -29 },
  { 2838, 17, 14, 21, 2, -25 },
  { 2868, 20, 3, 21, 0, 4 },
  { 2876, 7, 7, 21, 7, -28 },
  { 2883, 16, 19, 21, 2, -19 },
  { 2921, 16, 28, 21, 3, -28 },
  { 2977, 16, 19, 21, 2, -19 },
  { 3015, 16, 28, 21, 2, -28 },
  { 3071, 17, 19, 21, 2, -19 },
  { 3112, 17, 28, 21, 3, -28 },
  { 3172, 16, 26, 21, 2, -19 },
  { 3224, 15, 28, 21, 3, -28 },
  { 3277, 16, 27, 21, 2, -27 },
  { 3331, 13, 34, 21, 3, -27 },
  { 3387, 17, 28, 21, 3, -28 },
  { 3447, 16, 28, 21, 2, -28 },
  { 3503, 17, 19, 21, 2, -19 },
  { 3544, 15, 19, 21, 3, -19 },
  { 3580, 17, 19, 21, 2, -19 },
  { 3621, 16, 26, 21, 3, -19 },
  { 3673, 16, 26, 21, 2, -19 },
  { 3725, 14, 19, 21, 4, -19 },
  { 3759, 15, 19, 21, 3, -19 },
  { 3795, 15, 25, 21, 3, -25 },
  { 3842, 15, 19, 21, 3, -19 },
  { 3878, 18, 19, 21, 1, -19 },
  { 3921, 19, 19, 21, 1, -19 },
  { 3967, 18, 19, 21, 1, -19 },
  { 4010, 18, 26, 21, 1, -19 },
  { 4069, 15, 19, 21, 3, -19 },
  { 4105, 15, 36, 21, 3, -29 },
  { 4173, 3, 36, 21, 9, -29 },
  { 4187, 14, 36, 21, 3, -29 },
  { 4250, 17, 6, 21, 2, -14 },
};

const GFXfont UbuntuMono_Regular41pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular41pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular41pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUMONO_REGULAR41PT7B_H_
