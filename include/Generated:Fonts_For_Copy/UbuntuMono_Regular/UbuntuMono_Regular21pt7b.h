#ifndef _UBUNTUMONO_REGULAR21PT7B_H_
#define _UBUNTUMONO_REGULAR21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB2, 0x03, 0x7C, 0x9C, 0xE7, 0x39, 0x80, 0x11, 0x19,
  0x8C, 0xDF, 0xFF, 0xF9, 0x11, 0x98, 0xCC, 0xFF, 0xFF, 0xD1, 0x09, 0x8C,
  0xC0, 0x18, 0x18, 0x3E, 0x7F, 0x62, 0xC0, 0xE0, 0x78, 0x3E, 0x0F, 0x03,
  0x01, 0xC3, 0xFF, 0x7E, 0x18, 0x18, 0x70, 0xD6, 0x2C, 0x93, 0x2C, 0xCA,
  0x17, 0x87, 0x78, 0x2B, 0x1A, 0x44, 0x93, 0x25, 0x8B, 0x43, 0x80, 0x3C,
  0x3E, 0x11, 0x88, 0x86, 0xC3, 0xC1, 0xC5, 0xB6, 0x8F, 0x43, 0x31, 0xDF,
  0xA7, 0x98, 0xFF, 0x50, 0x0C, 0x73, 0x8C, 0x61, 0x84, 0x30, 0xC3, 0x04,
  0x18, 0x60, 0xC3, 0x87, 0x0C, 0x41, 0x83, 0x06, 0x18, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x18, 0x63, 0x38, 0x40, 0x18, 0x18, 0x49, 0xFF, 0x1C, 0x1C,
  0x36, 0x26, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF8, 0xC0, 0x60, 0x30, 0x18,
  0x00, 0x37, 0x33, 0x6C, 0xFF, 0xC0, 0xDF, 0x00, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x40, 0x3C, 0x3F, 0x18, 0xD8, 0x6C, 0x16, 0xCF, 0x67, 0xB3, 0xC1,
  0x61, 0x98, 0xCF, 0xC3, 0xC0, 0x18, 0x71, 0xE4, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x67, 0xFF, 0xE0, 0x3C, 0xFE, 0x47, 0x03, 0x03, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x7F, 0xFF, 0x3C, 0x7E, 0x43, 0x03, 0x06, 0x1C,
  0x1E, 0x03, 0x03, 0x03, 0x83, 0xFF, 0x7C, 0x06, 0x07, 0x06, 0x82, 0x43,
  0x23, 0x11, 0x09, 0x84, 0xFF, 0xFF, 0xC0, 0x80, 0x40, 0x20, 0x3F, 0x3F,
  0x20, 0x20, 0x60, 0x7C, 0x7E, 0x07, 0x03, 0x03, 0x43, 0xFF, 0x7C, 0x07,
  0x1F, 0x38, 0x60, 0x40, 0xFE, 0xFF, 0xC3, 0xC1, 0xC1, 0x63, 0x7F, 0x3C,
  0xFF, 0xFF, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x04,
  0x06, 0x03, 0x00, 0x3E, 0x7F, 0x63, 0xC3, 0xC3, 0x7E, 0x3E, 0x67, 0xC3,
  0xC1, 0xC3, 0x7F, 0x3E, 0x3C, 0x7E, 0xE3, 0xC3, 0xC1, 0xC1, 0x7F, 0x3F,
  0x03, 0x07, 0x0E, 0x7C, 0x70, 0xDF, 0x00, 0x06, 0xF8, 0x67, 0x60, 0x00,
  0x06, 0x77, 0x36, 0xC0, 0x01, 0x03, 0x87, 0x0E, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x38, 0x70, 0xE0, 0xC0, 0x00, 0x79, 0xFA, 0x38, 0x20,
  0xC3, 0x0C, 0x10, 0x00, 0x00, 0xC3, 0x83, 0x00, 0x1E, 0x1F, 0x98, 0xE8,
  0x3C, 0x1E, 0x7F, 0x7F, 0xB3, 0xD9, 0xEC, 0xF7, 0xF9, 0xF6, 0x03, 0x80,
  0xFC, 0x3E, 0x0E, 0x03, 0x81, 0xA0, 0x6C, 0x13, 0x0C, 0x43, 0x18, 0x86,
  0x7F, 0x9F, 0xE6, 0x0D, 0x03, 0xC0, 0xC0, 0xFC, 0xFE, 0xC3, 0xC3, 0xC2,
  0xFE, 0xFE, 0xC3, 0xC1, 0xC1, 0xC3, 0xFF, 0xFC, 0x1F, 0x1F, 0x9C, 0x5C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x1C, 0x47, 0xF1, 0xF0, 0xFC,
  0x7F, 0x31, 0xD8, 0x6C, 0x16, 0x0F, 0x07, 0x83, 0xC1, 0x61, 0xB1, 0xDF,
  0xCF, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83,
  0x06, 0x0C, 0x00, 0x1F, 0x1F, 0x9C, 0x5C, 0x0C, 0x06, 0x03, 0x01, 0x83,
  0xC1, 0xF0, 0xDC, 0x67, 0xF1, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0xFF, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFF, 0xFC, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0xFF, 0xE0, 0x3F, 0x3F, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x47, 0xFE, 0x7C, 0xC1, 0xE1,
  0xB1, 0x99, 0xCC, 0xC6, 0xC3, 0xC1, 0xF0, 0xCC, 0x63, 0x30, 0xD8, 0x6C,
  0x18, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0x43, 0x71, 0xB9, 0xDC, 0xAF, 0x56, 0xAA, 0x77, 0x33, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0xC1, 0xE1, 0xE1, 0xF1, 0xD1, 0xD9, 0xC9,
  0xCD, 0xC5, 0xC7, 0xC3, 0xC3, 0xC3, 0x3C, 0x3F, 0xB8, 0xD8, 0x3C, 0x1C,
  0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF8, 0xCF, 0xE3, 0xC0, 0xF8, 0xFE, 0x86,
  0x82, 0x83, 0x82, 0x86, 0xFE, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x3C, 0x3F,
  0xB8, 0xD8, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF8, 0xCF, 0xE3,
  0xC0, 0xE0, 0x3C, 0x06, 0xFC, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B, 0x1D,
  0xFC, 0xFC, 0x62, 0x31, 0x98, 0x6C, 0x10, 0x3E, 0x7F, 0x62, 0xC0, 0x60,
  0x78, 0x3E, 0x07, 0x03, 0x01, 0x43, 0xFF, 0x7E, 0xFF, 0xFF, 0xC6, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xE3, 0x7F, 0x3E,
  0xC0, 0xD0, 0x36, 0x0D, 0x82, 0x61, 0x8C, 0x63, 0x10, 0xCC, 0x13, 0x06,
  0xC1, 0xE0, 0x38, 0x0C, 0x00, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xCE,
  0x65, 0xAA, 0xF5, 0x72, 0xB9, 0xDC, 0x64, 0x30, 0xC1, 0x21, 0x98, 0x86,
  0xC3, 0xC0, 0xE0, 0x60, 0x38, 0x36, 0x33, 0x18, 0xD8, 0x6C, 0x18, 0xC0,
  0xD8, 0x36, 0x18, 0xC6, 0x33, 0x06, 0xC1, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0xFF, 0x7F, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x10, 0x1F, 0xFF, 0xF8, 0xFE, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0x40, 0x60, 0x60, 0x20, 0x30, 0x30, 0x10,
  0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0x18,
  0x0E, 0x0D, 0x0C, 0xC6, 0x36, 0x1B, 0x04, 0xFF, 0xC0, 0x46, 0x21, 0x7E,
  0x7F, 0x03, 0x03, 0x3F, 0x43, 0xC3, 0xC3, 0x7F, 0x3F, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xE3, 0xFD, 0xC6, 0xC1, 0xE0, 0xF0, 0x78, 0x2C, 0x37,
  0xF9, 0xF0, 0x1F, 0x7F, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x7F, 0x1F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x3F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE3, 0x7F, 0x3F, 0x3E, 0x3F, 0xB8, 0xD8, 0x3F, 0xFE, 0x03, 0x01, 0xC0,
  0x7F, 0x1F, 0x80, 0x0F, 0x0F, 0xC6, 0x26, 0x03, 0x07, 0xFB, 0xFC, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x3F, 0x7F, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0x83, 0xFE, 0x7C, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x38, 0x38, 0x00, 0x00, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x1F, 0x0F, 0x0E, 0x1C, 0x00, 0x07, 0xEF, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xBF, 0x7C, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1B,
  0x19, 0x98, 0xD8, 0x78, 0x36, 0x19, 0x8C, 0x66, 0x1B, 0x06, 0xF8, 0xF8,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F,
  0x0F, 0xF7, 0x7F, 0xA6, 0x71, 0x38, 0x9C, 0x4E, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C,
  0x3F, 0xB8, 0xD8, 0x2C, 0x1E, 0x0F, 0x05, 0xC6, 0x7F, 0x1E, 0x00, 0xFC,
  0x7F, 0xB0, 0xD8, 0x2C, 0x1E, 0x0F, 0x07, 0x86, 0xFF, 0x7E, 0x30, 0x18,
  0x0C, 0x00, 0x3F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F,
  0x03, 0x03, 0x03, 0x7F, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80,
  0x3F, 0x7E, 0x40, 0x60, 0x7C, 0x1E, 0x03, 0x43, 0xFF, 0x7E, 0x30, 0x30,
  0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x0F, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x63, 0x7F, 0x3F, 0xC1, 0xE0, 0xB0,
  0xCC, 0x66, 0x23, 0x30, 0xD8, 0x78, 0x1C, 0x0C, 0x00, 0xC0, 0xD0, 0x34,
  0x4D, 0x33, 0x4E, 0xDA, 0xA7, 0x29, 0xCA, 0x31, 0x88, 0x60, 0xC3, 0x31,
  0x8D, 0x87, 0x81, 0x80, 0xE0, 0xD8, 0xCC, 0x43, 0x60, 0xC0, 0xC1, 0xE1,
  0x98, 0xCC, 0x62, 0x21, 0xB0, 0xD8, 0x38, 0x1C, 0x06, 0x06, 0x1E, 0x0E,
  0x00, 0xFF, 0xFC, 0x30, 0xC3, 0x06, 0x18, 0x60, 0xFF, 0xFC, 0x1E, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x10, 0x61, 0x80, 0x81, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x1C, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x11, 0xC0, 0x71,
  0xFC, 0xE7, 0xD0, 0xC0,
};

const GFXglyph UbuntuMono_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -14 },
  { 10, 9, 13, 11, 1, -13 },
  { 25, 8, 17, 11, 1, -15 },
  { 42, 10, 13, 11, 0, -13 },
  { 59, 9, 13, 11, 1, -13 },
  { 74, 2, 6, 11, 4, -14 },
  { 76, 6, 17, 11, 2, -13 },
  { 89, 6, 17, 11, 2, -13 },
  { 102, 8, 8, 11, 1, -13 },
  { 110, 9, 9, 11, 1, -10 },
  { 121, 4, 6, 11, 3, -3 },
  { 124, 5, 2, 11, 3, -7 },
  { 126, 3, 3, 11, 4, -3 },
  { 128, 8, 18, 11, 1, -15 },
  { 146, 9, 13, 11, 1, -13 },
  { 161, 7, 13, 11, 2, -13 },
  { 173, 8, 13, 11, 1, -13 },
  { 186, 8, 13, 11, 1, -13 },
  { 199, 9, 13, 11, 1, -13 },
  { 214, 8, 13, 11, 1, -13 },
  { 227, 8, 13, 11, 1, -13 },
  { 240, 9, 13, 11, 1, -13 },
  { 255, 8, 13, 11, 1, -13 },
  { 268, 8, 13, 11, 1, -13 },
  { 281, 3, 10, 11, 4, -10 },
  { 285, 4, 13, 11, 3, -10 },
  { 292, 9, 9, 11, 1, -10 },
  { 303, 9, 5, 11, 1, -8 },
  { 309, 9, 9, 11, 1, -10 },
  { 320, 7, 13, 11, 2, -13 },
  { 332, 9, 16, 11, 1, -13 },
  { 350, 10, 13, 11, 0, -13 },
  { 367, 8, 13, 11, 1, -13 },
  { 380, 9, 13, 11, 1, -13 },
  { 395, 9, 13, 11, 1, -13 },
  { 410, 8, 13, 11, 2, -13 },
  { 423, 7, 13, 11, 2, -13 },
  { 435, 9, 13, 11, 1, -13 },
  { 450, 9, 13, 11, 1, -13 },
  { 465, 7, 13, 11, 2, -13 },
  { 477, 8, 13, 11, 1, -13 },
  { 490, 9, 13, 11, 1, -13 },
  { 505, 8, 13, 11, 2, -13 },
  { 518, 9, 13, 11, 1, -13 },
  { 533, 8, 13, 11, 1, -13 },
  { 546, 9, 13, 11, 1, -13 },
  { 561, 8, 13, 11, 2, -13 },
  { 574, 9, 16, 11, 1, -13 },
  { 592, 9, 13, 11, 1, -13 },
  { 607, 8, 13, 11, 1, -13 },
  { 620, 9, 13, 11, 1, -13 },
  { 635, 8, 13, 11, 1, -13 },
  { 648, 10, 13, 11, 0, -13 },
  { 665, 9, 13, 11, 1, -13 },
  { 680, 9, 13, 11, 1, -13 },
  { 695, 10, 13, 11, 0, -13 },
  { 712, 9, 13, 11, 1, -13 },
  { 727, 5, 16, 11, 3, -13 },
  { 737, 8, 18, 11, 1, -15 },
  { 755, 6, 16, 11, 2, -13 },
  { 767, 9, 7, 11, 1, -13 },
  { 775, 10, 1, 11, 0, 2 },
  { 777, 4, 4, 11, 3, -15 },
  { 779, 8, 10, 11, 1, -10 },
  { 789, 9, 15, 11, 1, -15 },
  { 806, 8, 10, 11, 1, -10 },
  { 816, 8, 15, 11, 1, -15 },
  { 831, 9, 10, 11, 1, -10 },
  { 843, 9, 15, 11, 1, -15 },
  { 860, 8, 13, 11, 1, -10 },
  { 873, 8, 15, 11, 1, -15 },
  { 888, 8, 14, 11, 1, -14 },
  { 902, 7, 17, 11, 1, -14 },
  { 917, 9, 15, 11, 1, -15 },
  { 934, 8, 15, 11, 1, -15 },
  { 949, 9, 10, 11, 1, -10 },
  { 961, 8, 10, 11, 1, -10 },
  { 971, 9, 10, 11, 1, -10 },
  { 983, 9, 13, 11, 1, -10 },
  { 998, 8, 13, 11, 1, -10 },
  { 1011, 7, 10, 11, 2, -10 },
  { 1020, 8, 10, 11, 1, -10 },
  { 1030, 8, 13, 11, 1, -13 },
  { 1043, 8, 10, 11, 1, -10 },
  { 1053, 9, 10, 11, 1, -10 },
  { 1065, 10, 10, 11, 0, -10 },
  { 1078, 9, 10, 11, 1, -10 },
  { 1090, 9, 13, 11, 1, -10 },
  { 1105, 7, 10, 11, 2, -10 },
  { 1114, 7, 18, 11, 2, -15 },
  { 1130, 2, 18, 11, 4, -15 },
  { 1135, 7, 18, 11, 2, -15 },
  { 1151, 9, 4, 11, 1, -8 },
};

const GFXfont UbuntuMono_Regular21pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular21pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular21pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _UBUNTUMONO_REGULAR21PT7B_H_
