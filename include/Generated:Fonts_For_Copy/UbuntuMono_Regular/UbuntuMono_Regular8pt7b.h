#ifndef _UBUNTUMONO_REGULAR8PT7B_H_
#define _UBUNTUMONO_REGULAR8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xA8, 0xC0, 0xF0, 0x5F, 0x6F, 0xA0, 0x26, 0x86, 0x1E, 0x20, 0xDE,
  0x47, 0xB0, 0x66, 0x5A, 0x50, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0x26, 0x60,
  0x4F, 0x40, 0x60, 0xC0, 0xC0, 0x56, 0xA8, 0x69, 0xB9, 0x60, 0x59, 0x2E,
  0x62, 0x24, 0x70, 0x62, 0x61, 0x60, 0x26, 0xAF, 0x20, 0xD3, 0x1C, 0x24,
  0xE9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60, 0x69, 0x72, 0x60, 0xC3,
  0xC3, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3, 0xC0, 0xD8, 0x80, 0x69, 0xBB,
  0x46, 0x66, 0x6F, 0x90, 0xE9, 0xE9, 0xE0, 0x78, 0x88, 0x70, 0xE9, 0x99,
  0xE0, 0xF3, 0x4E, 0xF3, 0x48, 0x78, 0x89, 0x70, 0x99, 0xF9, 0x90, 0xEA,
  0xC0, 0x64, 0x9E, 0xBA, 0x6A, 0x92, 0x4E, 0x9F, 0xD9, 0x90, 0x9D, 0xBB,
  0x90, 0x69, 0x99, 0x60, 0xD6, 0xE8, 0x69, 0x99, 0x63, 0xE9, 0xEA, 0x90,
  0x68, 0x61, 0xE0, 0xF4, 0x44, 0x40, 0x99, 0x99, 0x60, 0x99, 0x66, 0x60,
  0x99, 0xDF, 0x90, 0x96, 0x46, 0x90, 0x96, 0x62, 0x20, 0x72, 0x44, 0xF0,
  0xEA, 0xB0, 0xAA, 0x54, 0xD5, 0x70, 0x66, 0x90, 0xF0, 0x90, 0x65, 0xB0,
  0x93, 0x5B, 0x80, 0x68, 0x87, 0x05, 0xDA, 0xC0, 0x6F, 0x86, 0x34, 0xE4,
  0x44, 0x75, 0x96, 0xAF, 0xF0, 0x40, 0xC4, 0x43, 0x4D, 0x5C, 0x93, 0x4D,
  0x40, 0xC4, 0x44, 0x43, 0xFB, 0xB9, 0xFF, 0x69, 0x96, 0xD6, 0xE8, 0x76,
  0xB2, 0xD2, 0x40, 0xE7, 0x4F, 0x44, 0x70, 0xFF, 0x96, 0x66, 0x9B, 0xF6,
  0xA6, 0x69, 0x96, 0x62, 0xC0, 0xDB, 0x6A, 0xA4, 0xFE, 0x95, 0x58, 0x5A,
};

const GFXglyph UbuntuMono_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 1, -5 },
  { 18, 2, 6, 4, 1, -5 },
  { 20, 2, 6, 4, 1, -5 },
  { 22, 4, 3, 4, 0, -5 },
  { 24, 4, 3, 4, 0, -4 },
  { 26, 2, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 2, 1, 4, 1, -1 },
  { 29, 2, 7, 4, 1, -6 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 3, 5, 4, 1, -5 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 1, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 5, 4, 1, -4 },
  { 62, 4, 3, 4, 0, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 2, 5, 4, 1, -5 },
  { 70, 4, 6, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 2, 5, 4, 1, -5 },
  { 97, 3, 5, 4, 0, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 3, 5, 4, 1, -5 },
  { 114, 4, 6, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 2, 6, 4, 1, -5 },
  { 146, 2, 7, 4, 1, -6 },
  { 148, 2, 6, 4, 1, -5 },
  { 150, 4, 3, 4, 0, -5 },
  { 152, 4, 1, 4, 0, 1 },
  { 153, 2, 2, 4, 1, -6 },
  { 154, 3, 4, 4, 0, -4 },
  { 156, 3, 6, 4, 1, -6 },
  { 159, 4, 4, 4, 0, -4 },
  { 161, 3, 6, 4, 0, -6 },
  { 164, 4, 4, 4, 0, -4 },
  { 166, 4, 6, 4, 0, -6 },
  { 169, 3, 5, 4, 0, -4 },
  { 171, 2, 6, 4, 1, -6 },
  { 173, 4, 6, 4, 0, -6 },
  { 176, 2, 7, 4, 1, -6 },
  { 178, 3, 6, 4, 1, -6 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 2, 4, 4, 1, -4 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 3, 5, 4, 1, -4 },
  { 191, 3, 5, 4, 0, -4 },
  { 193, 3, 4, 4, 1, -4 },
  { 195, 2, 4, 4, 1, -4 },
  { 196, 4, 5, 4, 0, -5 },
  { 199, 2, 4, 4, 1, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 4, 5, 4, 0, -4 },
  { 209, 2, 4, 4, 1, -4 },
  { 210, 2, 7, 4, 1, -6 },
  { 212, 1, 7, 4, 2, -6 },
  { 213, 2, 7, 4, 1, -6 },
  { 215, 4, 2, 4, 0, -4 },
};

const GFXfont UbuntuMono_Regular8pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular8pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular8pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUMONO_REGULAR8PT7B_H_
