#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &UbuntuMono_Regular6pt7b, 6, "UbuntuMono_Regular6pt7b" },
  { &UbuntuMono_Regular7pt7b, 7, "UbuntuMono_Regular7pt7b" },
  { &UbuntuMono_Regular8pt7b, 8, "UbuntuMono_Regular8pt7b" },
  { &UbuntuMono_Regular9pt7b, 9, "UbuntuMono_Regular9pt7b" },
  { &UbuntuMono_Regular10pt7b, 10, "UbuntuMono_Regular10pt7b" },
  { &UbuntuMono_Regular11pt7b, 11, "UbuntuMono_Regular11pt7b" },
  { &UbuntuMono_Regular12pt7b, 12, "UbuntuMono_Regular12pt7b" },
  { &UbuntuMono_Regular13pt7b, 13, "UbuntuMono_Regular13pt7b" },
  { &UbuntuMono_Regular14pt7b, 14, "UbuntuMono_Regular14pt7b" },
  { &UbuntuMono_Regular15pt7b, 15, "UbuntuMono_Regular15pt7b" },
  { &UbuntuMono_Regular16pt7b, 16, "UbuntuMono_Regular16pt7b" },
  { &UbuntuMono_Regular17pt7b, 17, "UbuntuMono_Regular17pt7b" },
  { &UbuntuMono_Regular18pt7b, 18, "UbuntuMono_Regular18pt7b" },
  { &UbuntuMono_Regular19pt7b, 19, "UbuntuMono_Regular19pt7b" },
  { &UbuntuMono_Regular20pt7b, 20, "UbuntuMono_Regular20pt7b" },
  { &UbuntuMono_Regular21pt7b, 21, "UbuntuMono_Regular21pt7b" },
  { &UbuntuMono_Regular22pt7b, 22, "UbuntuMono_Regular22pt7b" },
  { &UbuntuMono_Regular23pt7b, 23, "UbuntuMono_Regular23pt7b" },
  { &UbuntuMono_Regular24pt7b, 24, "UbuntuMono_Regular24pt7b" },
  { &UbuntuMono_Regular25pt7b, 25, "UbuntuMono_Regular25pt7b" },
  { &UbuntuMono_Regular26pt7b, 26, "UbuntuMono_Regular26pt7b" },
  { &UbuntuMono_Regular27pt7b, 27, "UbuntuMono_Regular27pt7b" },
  { &UbuntuMono_Regular28pt7b, 28, "UbuntuMono_Regular28pt7b" },
  { &UbuntuMono_Regular29pt7b, 29, "UbuntuMono_Regular29pt7b" },
  { &UbuntuMono_Regular30pt7b, 30, "UbuntuMono_Regular30pt7b" },
  { &UbuntuMono_Regular31pt7b, 31, "UbuntuMono_Regular31pt7b" },
  { &UbuntuMono_Regular32pt7b, 32, "UbuntuMono_Regular32pt7b" },
  { &UbuntuMono_Regular33pt7b, 33, "UbuntuMono_Regular33pt7b" },
  { &UbuntuMono_Regular34pt7b, 34, "UbuntuMono_Regular34pt7b" },
  { &UbuntuMono_Regular35pt7b, 35, "UbuntuMono_Regular35pt7b" },
  { &UbuntuMono_Regular36pt7b, 36, "UbuntuMono_Regular36pt7b" },
  { &UbuntuMono_Regular37pt7b, 37, "UbuntuMono_Regular37pt7b" },
  { &UbuntuMono_Regular38pt7b, 38, "UbuntuMono_Regular38pt7b" },
  { &UbuntuMono_Regular39pt7b, 39, "UbuntuMono_Regular39pt7b" },
  { &UbuntuMono_Regular40pt7b, 40, "UbuntuMono_Regular40pt7b" },
  { &UbuntuMono_Regular41pt7b, 41, "UbuntuMono_Regular41pt7b" },
  { &UbuntuMono_Regular42pt7b, 42, "UbuntuMono_Regular42pt7b" },
  { &UbuntuMono_Regular43pt7b, 43, "UbuntuMono_Regular43pt7b" },
  { &UbuntuMono_Regular44pt7b, 44, "UbuntuMono_Regular44pt7b" },
  { &UbuntuMono_Regular45pt7b, 45, "UbuntuMono_Regular45pt7b" },
  { &UbuntuMono_Regular46pt7b, 46, "UbuntuMono_Regular46pt7b" },
  { &UbuntuMono_Regular47pt7b, 47, "UbuntuMono_Regular47pt7b" },
  { &UbuntuMono_Regular48pt7b, 48, "UbuntuMono_Regular48pt7b" },
  { &UbuntuMono_Regular49pt7b, 49, "UbuntuMono_Regular49pt7b" },
  { &UbuntuMono_Regular50pt7b, 50, "UbuntuMono_Regular50pt7b" },
  { &UbuntuMono_Regular51pt7b, 51, "UbuntuMono_Regular51pt7b" },
  { &UbuntuMono_Regular52pt7b, 52, "UbuntuMono_Regular52pt7b" },
  { &UbuntuMono_Regular53pt7b, 53, "UbuntuMono_Regular53pt7b" },
  { &UbuntuMono_Regular54pt7b, 54, "UbuntuMono_Regular54pt7b" },
  { &UbuntuMono_Regular55pt7b, 55, "UbuntuMono_Regular55pt7b" },
  { &UbuntuMono_Regular56pt7b, 56, "UbuntuMono_Regular56pt7b" },
  { &UbuntuMono_Regular57pt7b, 57, "UbuntuMono_Regular57pt7b" },
  { &UbuntuMono_Regular58pt7b, 58, "UbuntuMono_Regular58pt7b" },
  { &UbuntuMono_Regular59pt7b, 59, "UbuntuMono_Regular59pt7b" },
  { &UbuntuMono_Regular60pt7b, 60, "UbuntuMono_Regular60pt7b" },
  { &UbuntuMono_Regular61pt7b, 61, "UbuntuMono_Regular61pt7b" },
  { &UbuntuMono_Regular62pt7b, 62, "UbuntuMono_Regular62pt7b" },
  { &UbuntuMono_Regular63pt7b, 63, "UbuntuMono_Regular63pt7b" },
  { &UbuntuMono_Regular64pt7b, 64, "UbuntuMono_Regular64pt7b" },
  { &UbuntuMono_Regular65pt7b, 65, "UbuntuMono_Regular65pt7b" },
  { &UbuntuMono_Regular66pt7b, 66, "UbuntuMono_Regular66pt7b" },
  { &UbuntuMono_Regular67pt7b, 67, "UbuntuMono_Regular67pt7b" },
  { &UbuntuMono_Regular68pt7b, 68, "UbuntuMono_Regular68pt7b" },
  { &UbuntuMono_Regular69pt7b, 69, "UbuntuMono_Regular69pt7b" },
  { &UbuntuMono_Regular70pt7b, 70, "UbuntuMono_Regular70pt7b" },
  { &UbuntuMono_Regular71pt7b, 71, "UbuntuMono_Regular71pt7b" },
  { &UbuntuMono_Regular72pt7b, 72, "UbuntuMono_Regular72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
