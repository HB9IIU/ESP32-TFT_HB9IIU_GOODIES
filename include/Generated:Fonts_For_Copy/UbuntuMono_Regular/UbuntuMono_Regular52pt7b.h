#ifndef _UBUNTUMONO_REGULAR52PT7B_H_
#define _UBUNTUMONO_REGULAR52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x79,
  0xFB, 0xFF, 0xEF, 0xDF, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60,
  0x60, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xE0, 0x0C, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF4, 0x00, 0x1F, 0x78, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0E, 0x3F,
  0x80, 0x1E, 0x7F, 0xC0, 0x3C, 0x71, 0xE0, 0x38, 0xF1, 0xE0, 0x78, 0xE0,
  0xE0, 0x70, 0xE0, 0xE0, 0xF0, 0xE0, 0xE1, 0xE0, 0xE0, 0xE1, 0xC0, 0xE0,
  0xE3, 0xC0, 0xE0, 0xE3, 0x80, 0xF1, 0xE7, 0x80, 0x71, 0xEF, 0x00, 0x7F,
  0xCE, 0x00, 0x3F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x38, 0xF8, 0x00,
  0x79, 0xFC, 0x00, 0x73, 0xFE, 0x00, 0xF7, 0x8E, 0x01, 0xE7, 0x8F, 0x01,
  0xC7, 0x07, 0x03, 0xC7, 0x07, 0x03, 0x87, 0x07, 0x07, 0x87, 0x07, 0x0F,
  0x07, 0x07, 0x0E, 0x07, 0x07, 0x1E, 0x07, 0x8F, 0x3C, 0x07, 0x8E, 0x38,
  0x03, 0xFE, 0x78, 0x01, 0xFC, 0x70, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC0,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x1E,
  0x00, 0xF8, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3C, 0x1F, 0xE0, 0x78, 0x7F, 0xE0, 0xE1,
  0xF3, 0xE1, 0xC3, 0xC3, 0xF7, 0x8F, 0x83, 0xFF, 0x1E, 0x03, 0xFC, 0x3C,
  0x03, 0xF8, 0x78, 0x03, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0xC3, 0xE0,
  0x3F, 0xC7, 0xF1, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xCF, 0x07, 0xFE,
  0x1F, 0x03, 0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x00,
  0x10, 0x00, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x10, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x06, 0x0F, 0x02, 0x78, 0xF1, 0xEF, 0xE6, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x79, 0xE0,
  0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0x3F, 0x0F, 0xC0, 0xE0, 0x70, 0x04, 0x06,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xE1, 0xFC, 0xFF,
  0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0x07, 0x83, 0xE3, 0xF3, 0xF8, 0xF8, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF9, 0xE0, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x38, 0x7B, 0xE1, 0xE1, 0xFF, 0x8F,
  0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF1, 0xFF, 0x87, 0x87,
  0xDE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9F,
  0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xE1,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xE7, 0xC0, 0x78, 0xF8, 0x0C, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFC, 0x0F, 0xC7, 0x00, 0x7C, 0x20, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x38, 0x0F,
  0xC2, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x40, 0x03, 0xE7, 0x00, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00,
  0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x3C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x40, 0x03, 0xE7, 0x80, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x79, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFC, 0x07, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0xC0,
  0x1F, 0x7C, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x03,
  0xC3, 0xF8, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xF7,
  0xFC, 0x3C, 0x0F, 0xE7, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7,
  0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F,
  0xC7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xF7, 0xE0, 0x3F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x3F, 0x9F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x07, 0x81, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xF1,
  0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x03, 0xC0, 0x78, 0x1E, 0x1F, 0xC7, 0xE0,
  0xF8, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x40, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x70, 0x3F, 0x40, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xC1, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x01, 0xFF, 0x78,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x0F, 0xF0, 0xF8,
  0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F,
  0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFE, 0x3E, 0x0F, 0xF8, 0xFC, 0x3D, 0xE1,
  0xFF, 0xF7, 0x83, 0xFF, 0xDF, 0x07, 0xFF, 0x7C, 0x07, 0xF8, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3E, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F,
  0x9E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x7F, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x1F, 0xCF, 0x00,
  0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0x00, 0xFE, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0x78, 0x7E, 0x00, 0x61, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x83, 0xF8, 0x0E, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0x03, 0xF8, 0x78,
  0x07, 0xE3, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00,
  0x3E, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x7F, 0x8F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xE0, 0x78, 0x7E, 0x00, 0x41, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xFC,
  0x01, 0xF1, 0xF8, 0x07, 0xC3, 0xF8, 0x1F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x79, 0x00, 0x1F, 0x3C, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E,
  0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xE0, 0x03, 0xE7, 0xE0,
  0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0x70,
  0x3B, 0x9D, 0xC0, 0xEE, 0x77, 0x87, 0xB9, 0xCE, 0x1C, 0xE7, 0x38, 0x73,
  0x9C, 0xF3, 0xCE, 0x71, 0xCE, 0x39, 0xC7, 0x38, 0xE7, 0x1E, 0xE3, 0x9C,
  0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF7, 0x80, 0xFF, 0x78, 0x0F, 0xF3,
  0xC0, 0xFF, 0x3C, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0x78, 0xFF, 0x07, 0x8F, 0xF0, 0x3C, 0xFF, 0x03, 0xCF,
  0xF0, 0x1E, 0xFF, 0x01, 0xEF, 0xF0, 0x0E, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0x3E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xC1,
  0xF8, 0x3F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xF0, 0x0F, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x7E, 0xF0, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x7F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x78, 0xF8, 0x01,
  0xF1, 0xF8, 0x07, 0xC1, 0xF8, 0x3F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x18, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0x01, 0xFC, 0x78, 0x03, 0xF3, 0xC0, 0x0F, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x03, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0x03, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80,
  0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xFB,
  0xC0, 0x03, 0xDE, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x3F, 0x03, 0xC7, 0xC0, 0x04, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x40, 0x01,
  0xF7, 0x80, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80,
  0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF,
  0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x39, 0xC7, 0x78, 0xE7, 0x1C,
  0xE3, 0x9C, 0x73, 0x8E, 0x73, 0xCF, 0x39, 0xCE, 0x1C, 0xE7, 0x38, 0x73,
  0x9D, 0xE1, 0xEE, 0x77, 0x03, 0xB9, 0xDC, 0x0E, 0xE7, 0xF0, 0x3F, 0x9F,
  0x80, 0x7C, 0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC3,
  0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x81,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0,
  0x3C, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xF0, 0xF0,
  0x03, 0xC7, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0x70, 0x00, 0x38, 0x40, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x10, 0x1C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0x80,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x7F,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xE0, 0x1E, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBF, 0x00,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x1F, 0xFC, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF3, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFC, 0x0F, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00,
  0x3E, 0xF0, 0x07, 0xCF, 0x01, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0x80, 0x67, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xFC,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x03, 0xF7, 0xE0,
  0x1F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0xF3, 0xF8, 0x0F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF0,
  0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x0C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xF0, 0x18, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x00, 0xF7, 0xE0, 0x0F, 0x7C, 0x00,
  0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x7C,
  0x00, 0xF7, 0xE0, 0x0F, 0x3F, 0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x30, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF7, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x83, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x70, 0x7E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x3F, 0x78, 0x03, 0xF3, 0xC0, 0x1F, 0x1E, 0x03, 0xF0,
  0xF0, 0x3F, 0x07, 0x83, 0xF0, 0x3C, 0x3F, 0x01, 0xE3, 0xF0, 0x0F, 0x3E,
  0x00, 0x7B, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xBF, 0x00, 0x3C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3C,
  0x00, 0x7D, 0xE0, 0x03, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x83, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x3F,
  0x87, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF0, 0xFC,
  0x7F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0x1F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xF0, 0x1F, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x00,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x07,
  0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xF0, 0x03,
  0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xF0, 0x1F, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00,
  0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF,
  0x00, 0x3E, 0xF0, 0x07, 0xEF, 0xC0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0x3F, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0x80, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0,
  0x0F, 0x7E, 0x00, 0xF3, 0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xCF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF,
  0x80, 0x37, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x00, 0xC7, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x40, 0x01, 0xE7, 0x80, 0x7E, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x30, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xF8, 0x0F, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xF8, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xDE, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE3, 0xC0,
  0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0xE0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E,
  0x78, 0x3C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x38, 0xFF, 0x1C, 0x3C, 0xE7, 0x1C, 0x3C, 0xE7, 0x3C, 0x3D, 0xE7, 0xBC,
  0x3D, 0xC3, 0xBC, 0x3F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0x70,
  0xF8, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0x87,
  0x80, 0x1F, 0x07, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xC0, 0x0F,
  0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00,
  0x7C, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x18,
  0x7F, 0x80, 0x73, 0xFF, 0x03, 0xDF, 0xFF, 0x1E, 0x78, 0xFF, 0xFB, 0xC0,
  0xFF, 0xCE, 0x01, 0xFF, 0x18, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 32, 26, 9, -32 },
  { 29, 12, 13, 26, 7, -35 },
  { 49, 24, 32, 26, 1, -32 },
  { 145, 20, 41, 26, 3, -36 },
  { 248, 24, 32, 26, 1, -32 },
  { 344, 23, 32, 26, 2, -32 },
  { 436, 4, 14, 26, 11, -35 },
  { 443, 14, 45, 26, 6, -36 },
  { 522, 14, 45, 26, 6, -36 },
  { 601, 20, 19, 26, 3, -32 },
  { 649, 22, 24, 26, 2, -26 },
  { 715, 10, 14, 26, 8, -7 },
  { 733, 12, 4, 26, 7, -15 },
  { 739, 8, 7, 26, 9, -7 },
  { 746, 18, 45, 26, 4, -36 },
  { 848, 22, 32, 26, 2, -32 },
  { 936, 19, 32, 26, 4, -32 },
  { 1012, 20, 32, 26, 3, -32 },
  { 1092, 20, 32, 26, 3, -32 },
  { 1172, 22, 32, 26, 2, -32 },
  { 1260, 20, 32, 26, 3, -32 },
  { 1340, 20, 32, 26, 3, -32 },
  { 1420, 21, 32, 26, 3, -32 },
  { 1504, 20, 32, 26, 3, -32 },
  { 1584, 20, 32, 26, 3, -32 },
  { 1664, 8, 24, 26, 9, -24 },
  { 1688, 11, 31, 26, 6, -24 },
  { 1731, 21, 21, 26, 3, -24 },
  { 1787, 22, 14, 26, 2, -21 },
  { 1826, 21, 21, 26, 3, -24 },
  { 1882, 16, 32, 26, 5, -32 },
  { 1946, 22, 39, 26, 2, -32 },
  { 2054, 26, 32, 26, 0, -32 },
  { 2158, 20, 32, 26, 3, -32 },
  { 2238, 22, 32, 26, 2, -32 },
  { 2326, 21, 32, 26, 3, -32 },
  { 2410, 19, 32, 26, 5, -32 },
  { 2486, 18, 32, 26, 5, -32 },
  { 2558, 22, 32, 26, 2, -32 },
  { 2646, 22, 32, 26, 2, -32 },
  { 2734, 16, 32, 26, 5, -32 },
  { 2798, 19, 32, 26, 3, -32 },
  { 2874, 23, 32, 26, 3, -32 },
  { 2966, 19, 32, 26, 5, -32 },
  { 3042, 22, 32, 26, 2, -32 },
  { 3130, 20, 32, 26, 3, -32 },
  { 3210, 23, 32, 26, 2, -32 },
  { 3302, 20, 32, 26, 4, -32 },
  { 3382, 23, 40, 26, 2, -32 },
  { 3497, 21, 32, 26, 3, -32 },
  { 3581, 20, 32, 26, 3, -32 },
  { 3661, 22, 32, 26, 2, -32 },
  { 3749, 22, 32, 26, 2, -32 },
  { 3837, 24, 32, 26, 1, -32 },
  { 3933, 22, 32, 26, 2, -32 },
  { 4021, 24, 32, 26, 1, -32 },
  { 4117, 24, 32, 26, 1, -32 },
  { 4213, 21, 32, 26, 3, -32 },
  { 4297, 13, 45, 26, 7, -36 },
  { 4371, 18, 45, 26, 4, -36 },
  { 4473, 13, 45, 26, 6, -36 },
  { 4547, 22, 18, 26, 2, -32 },
  { 4597, 26, 4, 26, 0, 5 },
  { 4610, 9, 9, 26, 8, -36 },
  { 4621, 19, 24, 26, 3, -24 },
  { 4678, 20, 36, 26, 4, -36 },
  { 4768, 20, 24, 26, 3, -24 },
  { 4828, 20, 36, 26, 2, -36 },
  { 4918, 22, 24, 26, 2, -24 },
  { 4984, 22, 36, 26, 3, -36 },
  { 5083, 20, 33, 26, 2, -24 },
  { 5166, 18, 36, 26, 4, -36 },
  { 5247, 20, 34, 26, 3, -34 },
  { 5332, 16, 43, 26, 4, -34 },
  { 5418, 21, 36, 26, 4, -36 },
  { 5513, 20, 36, 26, 3, -36 },
  { 5603, 22, 24, 26, 2, -24 },
  { 5669, 18, 24, 26, 4, -24 },
  { 5723, 22, 24, 26, 2, -24 },
  { 5789, 20, 33, 26, 4, -24 },
  { 5872, 20, 33, 26, 2, -24 },
  { 5955, 17, 24, 26, 6, -24 },
  { 6006, 20, 24, 26, 3, -24 },
  { 6066, 20, 31, 26, 3, -31 },
  { 6144, 18, 24, 26, 4, -24 },
  { 6198, 22, 24, 26, 2, -24 },
  { 6264, 24, 24, 26, 1, -24 },
  { 6336, 23, 24, 26, 2, -24 },
  { 6405, 22, 33, 26, 2, -24 },
  { 6496, 18, 24, 26, 4, -24 },
  { 6550, 18, 45, 26, 4, -36 },
  { 6652, 4, 45, 26, 11, -36 },
  { 6675, 18, 45, 26, 4, -36 },
  { 6777, 22, 8, 26, 2, -18 },
};

const GFXfont UbuntuMono_Regular52pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular52pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular52pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUMONO_REGULAR52PT7B_H_
