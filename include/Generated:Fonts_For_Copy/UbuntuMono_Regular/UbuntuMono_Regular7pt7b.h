#ifndef _UBUNTUMONO_REGULAR7PT7B_H_
#define _UBUNTUMONO_REGULAR7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xD0, 0x50, 0x6F, 0xD0, 0x51, 0x1E, 0x80, 0xF9, 0xD0, 0xEA, 0xF0,
  0xC0, 0x6A, 0x90, 0xA5, 0x60, 0x28, 0x4D, 0x00, 0xC0, 0xC0, 0x80, 0x25,
  0x25, 0x00, 0xFE, 0xB0, 0xAA, 0x65, 0x60, 0x6C, 0xF0, 0x6F, 0x90, 0x48,
  0xB0, 0x5E, 0xB0, 0x65, 0x20, 0xEE, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0, 0x78,
  0x80, 0xEC, 0x4E, 0x00, 0x5A, 0xFF, 0xD6, 0x4F, 0xD0, 0xFE, 0xF0, 0xF2,
  0x30, 0xF6, 0xF0, 0xBA, 0xAA, 0xF2, 0xB0, 0xBE, 0xD0, 0xAA, 0x24, 0xF0,
  0xBA, 0xD0, 0xAA, 0xBE, 0xD0, 0xBE, 0xD0, 0xF6, 0xF0, 0xFA, 0xF6, 0xF2,
  0xF7, 0xD0, 0xC8, 0xF0, 0x49, 0x20, 0xB6, 0xF0, 0xB5, 0xA0, 0xBF, 0xD0,
  0xA9, 0xD0, 0xAD, 0x20, 0x69, 0x60, 0xEA, 0xA0, 0x09, 0x22, 0x40, 0xD5,
  0x50, 0x54, 0x40, 0x80, 0x2F, 0x80, 0x9A, 0xDE, 0xF1, 0x80, 0x2E, 0xD6,
  0xFD, 0x00, 0x69, 0x24, 0xF5, 0xB0, 0x9A, 0xDA, 0x41, 0x26, 0x20, 0x92,
  0xC0, 0x92, 0xEA, 0xC9, 0x26, 0xFE, 0x80, 0xF6, 0x80, 0xF5, 0x80, 0xF7,
  0xC0, 0xF7, 0x90, 0xE8, 0xCD, 0x80, 0x49, 0x30, 0xB5, 0x80, 0xAD, 0x00,
  0xBE, 0x80, 0x6A, 0x80, 0xAD, 0x60, 0x68, 0xEA, 0xA0, 0xFC, 0xA9, 0xA0,
  0xE0,
};

const GFXglyph UbuntuMono_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 1, -5 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 1, -5 },
  { 17, 3, 2, 4, 0, -4 },
  { 18, 3, 3, 4, 0, -3 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 3, 6, 4, 0, -5 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 2, 4, 4, 1, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 1, 3, 4, 1, -3 },
  { 46, 1, 4, 4, 1, -3 },
  { 47, 3, 3, 4, 0, -3 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 3, 3, 4, 0, -3 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 3, 5, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 2, 4, 4, 1, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 2, 4, 4, 1, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 2, 4, 4, 1, -4 },
  { 82, 3, 5, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 0, -4 },
  { 94, 3, 4, 4, 0, -4 },
  { 96, 3, 4, 4, 0, -4 },
  { 98, 3, 4, 4, 0, -4 },
  { 100, 3, 4, 4, 0, -4 },
  { 102, 2, 6, 4, 1, -5 },
  { 104, 3, 6, 4, 0, -5 },
  { 107, 2, 6, 4, 1, -5 },
  { 109, 3, 2, 4, 0, -4 },
  { 110, 3, 1, 4, 0, 0 },
  { 111, 1, 1, 4, 1, -5 },
  { 112, 3, 3, 4, 0, -3 },
  { 114, 3, 5, 4, 0, -5 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 3, 5, 4, 0, -5 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 3, 5, 4, 0, -5 },
  { 124, 3, 4, 4, 0, -3 },
  { 126, 3, 5, 4, 0, -5 },
  { 128, 3, 5, 4, 0, -5 },
  { 130, 3, 6, 4, 0, -5 },
  { 133, 3, 5, 4, 0, -5 },
  { 135, 3, 5, 4, 0, -5 },
  { 137, 3, 3, 4, 0, -3 },
  { 139, 3, 3, 4, 0, -3 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 3, 4, 4, 0, -3 },
  { 145, 3, 4, 4, 0, -3 },
  { 147, 2, 3, 4, 1, -3 },
  { 148, 3, 3, 4, 0, -3 },
  { 150, 3, 4, 4, 0, -4 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 3, 3, 4, 0, -3 },
  { 160, 3, 4, 4, 0, -3 },
  { 162, 2, 3, 4, 1, -3 },
  { 163, 2, 6, 4, 1, -5 },
  { 165, 1, 6, 4, 1, -5 },
  { 166, 2, 6, 4, 1, -5 },
  { 168, 3, 1, 4, 0, -2 },
};

const GFXfont UbuntuMono_Regular7pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular7pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular7pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _UBUNTUMONO_REGULAR7PT7B_H_
