#ifndef _UBUNTUMONO_REGULAR56PT7B_H_
#define _UBUNTUMONO_REGULAR56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0,
  0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x03, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x81,
  0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x81,
  0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F,
  0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xF0, 0x06, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x40, 0x00, 0xF9, 0xF0, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0x8F, 0xF0, 0x01, 0xE7, 0xFE, 0x00, 0xF1, 0xE7, 0x80, 0x78,
  0xF0, 0xF0, 0x1E, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x03, 0xC3, 0x81, 0xC1,
  0xE0, 0xE0, 0x70, 0xF0, 0x3C, 0x1C, 0x3C, 0x0F, 0x07, 0x1E, 0x03, 0xC3,
  0xC7, 0x80, 0x70, 0xF3, 0xC0, 0x1E, 0x79, 0xE0, 0x07, 0xFE, 0x78, 0x00,
  0xFF, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0xF3, 0xFC, 0x00, 0x79, 0xFF, 0x80, 0x1E, 0x79, 0xE0, 0x0F,
  0x3C, 0x38, 0x07, 0x8F, 0x0F, 0x01, 0xE3, 0x83, 0xC0, 0xF0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x0F, 0x03, 0x83, 0xC3, 0xC0, 0xF0,
  0xF1, 0xE0, 0x3C, 0x38, 0x70, 0x07, 0x9E, 0x3C, 0x01, 0xFF, 0x9E, 0x00,
  0x3F, 0xC7, 0x80, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0x8F, 0xC0, 0x1E, 0x03, 0xC0, 0x3E,
  0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3E,
  0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1C, 0x0F, 0xF0, 0x3C, 0x1F,
  0xF8, 0x3C, 0x3E, 0xFC, 0x3C, 0x7C, 0x7E, 0x3C, 0x78, 0x3F, 0x3C, 0xF8,
  0x1F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF0, 0x07, 0xF8, 0xF0, 0x03, 0xF0, 0xF0,
  0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8, 0xFC, 0x07, 0xFC, 0x7F,
  0x1F, 0xFC, 0x7F, 0xFF, 0xBE, 0x3F, 0xFF, 0x3E, 0x0F, 0xFC, 0x1F, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x30, 0x00,
  0x38, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x20, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x81, 0xE0, 0x47, 0x87, 0x87, 0x9F, 0x8E, 0x7E, 0x7F, 0xB7, 0xFB, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x81,
  0xF0, 0x3E, 0x01, 0xC0, 0xE0, 0x02, 0x01, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7E, 0x01, 0xE0, 0x3E, 0x07, 0xC3, 0xF8, 0xFF, 0x07, 0xE0, 0x7C,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0xE0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F,
  0xF0, 0xFC, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x1E, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8,
  0xF8, 0x07, 0xC1, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xEF, 0x80, 0xFE, 0x7C, 0x03, 0xC3, 0xE0, 0x18, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7E, 0x07, 0xE1, 0xE0, 0x0F, 0xC2, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3C, 0x0F, 0xE0, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF9, 0x00, 0x07,
  0xE7, 0x80, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x60, 0x01, 0xFB, 0xC0, 0x3F, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE3, 0xF8, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xC3, 0xF8, 0x3E, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC3, 0xFC,
  0x3E, 0x03, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7D, 0xF0, 0x03, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xF1, 0xF8, 0x07, 0xC7, 0xC0,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xF1, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x07, 0x81, 0xF8,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0x81, 0xE0,
  0xFC, 0x7F, 0x3F, 0xC7, 0xF0, 0xFC, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x78, 0x1F, 0x90, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xE0, 0xFC, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C,
  0x01, 0xFF, 0x78, 0x0F, 0xFF, 0x78, 0x1F, 0xFF, 0x78, 0x3F, 0xFF, 0xF8,
  0x3F, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x78, 0x0F, 0xF8,
  0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8,
  0xF8, 0x0F, 0xF8, 0x78, 0x0F, 0x78, 0x7C, 0x0F, 0x78, 0x7C, 0x0F, 0x7C,
  0x3E, 0x0F, 0x7C, 0x3F, 0xFF, 0x7C, 0x1F, 0xFF, 0x3E, 0x0F, 0xFF, 0x3E,
  0x03, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x08, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x7C,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x01,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x0F,
  0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3E, 0x01, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x7F,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFE, 0x03, 0xC3, 0xF0, 0x01, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x87, 0xF8, 0x0F, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0x81, 0xFE, 0x1F, 0x00, 0xFE, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0xFE, 0x3E, 0x07, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xE0, 0x38,
  0x7E, 0x00, 0x23, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03,
  0xCF, 0x80, 0x0F, 0x3F, 0x00, 0x3C, 0x7E, 0x00, 0xF1, 0xFE, 0x07, 0xC3,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE2, 0x00, 0x1F, 0x38,
  0x01, 0xF1, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF8,
  0xF0, 0x03, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0,
  0xF0, 0x1F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7E, 0x00,
  0xF0, 0xFC, 0x00, 0xF1, 0xF8, 0x00, 0xF3, 0xF0, 0x00, 0xF7, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xF3, 0xF8, 0x00, 0xF1, 0xFC, 0x00, 0xF0, 0xFC, 0x00, 0xF0, 0x7E, 0x00,
  0xF0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x7B, 0x81, 0xDE, 0x7B,
  0xC1, 0xDE, 0x7B, 0xC3, 0xDE, 0x79, 0xC3, 0x9E, 0x79, 0xC3, 0x9E, 0x79,
  0xE7, 0x9E, 0x78, 0xE7, 0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xFF, 0x1E, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFD, 0xE0, 0x0F, 0xF7, 0x80, 0x3F, 0xCF, 0x00, 0xFF, 0x3C, 0x03, 0xFC,
  0x78, 0x0F, 0xF1, 0xE0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC0, 0xF0, 0xFF, 0x03, 0xC3, 0xFC, 0x0F, 0x8F,
  0xF0, 0x1E, 0x3F, 0xC0, 0x78, 0xFF, 0x00, 0xF3, 0xFC, 0x03, 0xCF, 0xF0,
  0x07, 0xBF, 0xC0, 0x1E, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0x80, 0x7F, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF7,
  0xC0, 0x7F, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x3F,
  0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80,
  0xFE, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1,
  0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x3F, 0x81, 0xF0, 0xF8, 0x00, 0x87, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7D,
  0x80, 0x03, 0xE7, 0xC0, 0x3F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF8, 0x07,
  0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7D, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x80, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0xF0, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1E, 0xF8, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x78, 0x7E, 0x1E, 0x78, 0xFF, 0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xE7, 0x1E,
  0x79, 0xE7, 0x9E, 0x79, 0xC3, 0x9E, 0x79, 0xC3, 0x9E, 0x7B, 0xC3, 0xDE,
  0x7B, 0x83, 0xDE, 0x7B, 0x81, 0xDE, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x1E,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x81,
  0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x10, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x18, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x03, 0x80, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x7F, 0xDE, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFC, 0x03, 0xEF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0xC0,
  0x07, 0xBF, 0x80, 0x3C, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE7, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xF8, 0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F,
  0xCF, 0x80, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xE0, 0x18, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x80, 0x31, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xF9, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7E, 0x07, 0xF3, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xFC, 0x01,
  0xF1, 0xFC, 0x07, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x3E,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x81, 0xC0, 0x7C, 0x00, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xC0,
  0x7C, 0xFC, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x81, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFE, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE3, 0x80, 0x3F,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xBF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x0C, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x40, 0x0F, 0x9C, 0x0F, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F,
  0xFC, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7C,
  0x01, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xC1,
  0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x80,
  0x0F, 0x9F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC1, 0xF0,
  0xFF, 0xF7, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x3E,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F,
  0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7B, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x03, 0xF3,
  0xF8, 0x1F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xE7,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0xC0, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x3F, 0x00,
  0x7C, 0x7E, 0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xF9, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xE0, 0x0D, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7E, 0x00, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xF0, 0x1F,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7,
  0x81, 0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x78, 0x1F, 0x07, 0x9E, 0x0F, 0xC1,
  0xE7, 0x83, 0xF0, 0x79, 0xF0, 0xFC, 0x1C, 0x3C, 0x7F, 0x8F, 0x0F, 0x1C,
  0xE3, 0xC3, 0xC7, 0x38, 0xF0, 0xF3, 0xCF, 0x3C, 0x3C, 0xE1, 0xCF, 0x0F,
  0x38, 0x73, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07,
  0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xE1, 0xE0, 0x03,
  0xE1, 0xE0, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xC0, 0x00, 0xFB, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0x80, 0x06, 0x1F, 0xF0, 0x0F, 0x3F, 0xF8, 0x0F, 0x7F, 0xFE,
  0x1E, 0x78, 0x7F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0, 0x0F, 0xF8, 0x60, 0x03,
  0xF0,
};

const GFXglyph UbuntuMono_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 35, 28, 10, -35 },
  { 36, 14, 14, 28, 7, -38 },
  { 61, 24, 35, 28, 2, -35 },
  { 166, 22, 44, 28, 3, -39 },
  { 287, 26, 35, 28, 1, -35 },
  { 401, 24, 35, 28, 2, -35 },
  { 506, 4, 15, 28, 12, -38 },
  { 514, 16, 48, 28, 6, -39 },
  { 610, 16, 48, 28, 6, -39 },
  { 706, 22, 21, 28, 3, -35 },
  { 764, 22, 24, 28, 3, -27 },
  { 830, 12, 16, 28, 8, -8 },
  { 854, 12, 4, 28, 8, -16 },
  { 860, 8, 8, 28, 10, -8 },
  { 868, 20, 48, 28, 4, -39 },
  { 988, 22, 35, 28, 3, -35 },
  { 1085, 21, 35, 28, 4, -35 },
  { 1177, 22, 35, 28, 3, -35 },
  { 1274, 22, 35, 28, 3, -35 },
  { 1371, 24, 35, 28, 2, -35 },
  { 1476, 21, 35, 28, 4, -35 },
  { 1568, 22, 35, 28, 3, -35 },
  { 1665, 21, 35, 28, 4, -35 },
  { 1757, 22, 35, 28, 3, -35 },
  { 1854, 22, 35, 28, 3, -35 },
  { 1951, 8, 26, 28, 10, -26 },
  { 1977, 11, 34, 28, 7, -26 },
  { 2024, 23, 23, 28, 3, -26 },
  { 2091, 22, 15, 28, 3, -22 },
  { 2133, 23, 23, 28, 3, -26 },
  { 2200, 18, 35, 28, 5, -35 },
  { 2279, 24, 43, 28, 2, -35 },
  { 2408, 28, 35, 28, 0, -35 },
  { 2531, 22, 35, 28, 3, -35 },
  { 2628, 23, 35, 28, 3, -35 },
  { 2729, 23, 35, 28, 3, -35 },
  { 2830, 21, 35, 28, 5, -35 },
  { 2922, 20, 35, 28, 5, -35 },
  { 3010, 22, 35, 28, 3, -35 },
  { 3107, 22, 35, 28, 3, -35 },
  { 3204, 18, 35, 28, 5, -35 },
  { 3283, 21, 35, 28, 3, -35 },
  { 3375, 24, 35, 28, 4, -35 },
  { 3480, 21, 35, 28, 5, -35 },
  { 3572, 24, 35, 28, 2, -35 },
  { 3677, 22, 35, 28, 3, -35 },
  { 3774, 24, 35, 28, 2, -35 },
  { 3879, 21, 35, 28, 4, -35 },
  { 3971, 24, 44, 28, 2, -35 },
  { 4103, 23, 35, 28, 3, -35 },
  { 4204, 22, 35, 28, 3, -35 },
  { 4301, 24, 35, 28, 2, -35 },
  { 4406, 22, 35, 28, 3, -35 },
  { 4503, 26, 35, 28, 1, -35 },
  { 4617, 24, 35, 28, 2, -35 },
  { 4722, 26, 35, 28, 1, -35 },
  { 4836, 26, 35, 28, 1, -35 },
  { 4950, 22, 35, 28, 3, -35 },
  { 5047, 13, 48, 28, 8, -39 },
  { 5125, 20, 48, 28, 4, -39 },
  { 5245, 13, 48, 28, 7, -39 },
  { 5323, 24, 19, 28, 2, -35 },
  { 5380, 28, 4, 28, 0, 5 },
  { 5394, 9, 10, 28, 9, -39 },
  { 5406, 21, 26, 28, 3, -26 },
  { 5475, 22, 39, 28, 4, -39 },
  { 5583, 22, 26, 28, 3, -26 },
  { 5655, 22, 39, 28, 2, -39 },
  { 5763, 23, 26, 28, 2, -26 },
  { 5838, 23, 39, 28, 4, -39 },
  { 5951, 22, 35, 28, 2, -26 },
  { 6048, 20, 39, 28, 4, -39 },
  { 6146, 22, 37, 28, 3, -37 },
  { 6248, 18, 46, 28, 4, -37 },
  { 6352, 23, 39, 28, 4, -39 },
  { 6465, 22, 39, 28, 3, -39 },
  { 6573, 24, 26, 28, 2, -26 },
  { 6651, 20, 26, 28, 4, -26 },
  { 6716, 24, 26, 28, 2, -26 },
  { 6794, 22, 35, 28, 4, -26 },
  { 6891, 22, 35, 28, 2, -26 },
  { 6988, 19, 26, 28, 6, -26 },
  { 7050, 20, 26, 28, 4, -26 },
  { 7115, 21, 34, 28, 4, -34 },
  { 7205, 20, 26, 28, 4, -26 },
  { 7270, 24, 26, 28, 2, -26 },
  { 7348, 26, 26, 28, 1, -26 },
  { 7433, 24, 26, 28, 2, -26 },
  { 7511, 24, 35, 28, 2, -26 },
  { 7616, 20, 26, 28, 4, -26 },
  { 7681, 20, 48, 28, 4, -39 },
  { 7801, 4, 48, 28, 12, -39 },
  { 7825, 20, 48, 28, 4, -39 },
  { 7945, 24, 8, 28, 2, -19 },
};

const GFXfont UbuntuMono_Regular56pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular56pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular56pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UBUNTUMONO_REGULAR56PT7B_H_
