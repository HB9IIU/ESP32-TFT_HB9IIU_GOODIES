#ifndef _UBUNTUMONO_REGULAR29PT7B_H_
#define _UBUNTUMONO_REGULAR29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x76, 0x66, 0x66, 0x60, 0x00, 0x7F, 0xF7, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xB1, 0x00, 0x0C, 0x70, 0x63, 0x03, 0x18, 0x18, 0xC1,
  0xC6, 0x7F, 0xFF, 0xFF, 0xE3, 0x18, 0x18, 0xC1, 0xC6, 0x0C, 0x71, 0xFF,
  0xFF, 0xFF, 0x98, 0xC1, 0xC6, 0x0C, 0x30, 0x63, 0x83, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x30, 0x0F, 0xC7, 0xFD, 0xE1, 0xB8, 0x06, 0x00, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF8, 0x3B,
  0xFF, 0x3F, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x37, 0xC1, 0xB3, 0x19,
  0x18, 0xC8, 0xCC, 0x46, 0xC3, 0x36, 0x1F, 0x60, 0x73, 0x00, 0x37, 0x03,
  0x7C, 0x1B, 0x31, 0x99, 0x9C, 0x8C, 0xC6, 0x6C, 0x33, 0x61, 0xF6, 0x07,
  0x00, 0x1F, 0x01, 0xFC, 0x1C, 0x60, 0xE3, 0x86, 0x18, 0x38, 0xC0, 0xCC,
  0x03, 0xC0, 0x3C, 0x33, 0xF3, 0x99, 0xD9, 0xC7, 0xCC, 0x1E, 0x60, 0x63,
  0x83, 0x9E, 0x7C, 0x7F, 0x71, 0xF1, 0x80, 0xFF, 0x6D, 0xB6, 0x02, 0x07,
  0x0E, 0x1C, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x60, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x02, 0x40, 0xF0, 0x78,
  0x38, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07,
  0x07, 0x06, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0x40, 0x0E, 0x01, 0x80, 0x30,
  0x66, 0x2F, 0x5E, 0x7F, 0x03, 0x80, 0xD8, 0x33, 0x8E, 0x30, 0x84, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x18, 0xF3, 0xCF, 0x1C, 0xEF, 0x18,
  0xFF, 0xF0, 0x7F, 0xF7, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x76, 0x07,
  0xE0, 0x3E, 0x63, 0xE7, 0x3E, 0x73, 0xE6, 0x3E, 0x03, 0x60, 0x76, 0x07,
  0x70, 0x63, 0x8E, 0x1F, 0xC0, 0xF8, 0x06, 0x01, 0xC0, 0x78, 0x3F, 0x0F,
  0x60, 0x8C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x7F, 0xEF, 0xFC, 0x3F, 0x1F, 0xF3, 0x87, 0x40,
  0xE0, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x3E, 0x1F, 0xF1, 0x0F,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x1F, 0x03, 0xF0, 0x0F, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x0E, 0xFF, 0x8F, 0xE0, 0x00, 0xC0, 0x0E,
  0x00, 0xF0, 0x0D, 0x80, 0xEC, 0x0E, 0x60, 0x63, 0x06, 0x18, 0x30, 0xC3,
  0x06, 0x38, 0x31, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xC7, 0xF8, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0xF0, 0x7F, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x3C,
  0x0E, 0xFF, 0x8F, 0xE0, 0x03, 0xC1, 0xF8, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x06, 0xF8, 0xFF, 0xDC, 0x3B, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xF8,
  0x3B, 0x8E, 0x7F, 0x83, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0x60, 0x76, 0x07, 0x70, 0x63, 0x8C, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x07,
  0x60, 0x3E, 0x03, 0x60, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0x0F, 0x83, 0xFC,
  0x70, 0xE6, 0x06, 0x60, 0x7E, 0x07, 0x60, 0x76, 0x03, 0x70, 0x73, 0xFF,
  0x1F, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x78, 0x7F, 0x07, 0x80,
  0x7F, 0xF7, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x3B, 0xDE, 0x70, 0x00, 0x00,
  0x01, 0xDE, 0xF3, 0x8D, 0xDE, 0xC0, 0x00, 0x30, 0x0F, 0x07, 0xE1, 0xF0,
  0xFC, 0x0E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x40, 0x07,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0x01, 0xF0, 0xFC, 0x3E, 0x07,
  0x80, 0x40, 0x00, 0x7E, 0x7F, 0xA0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x3C, 0x1C, 0x00,
  0x07, 0xC0, 0xFF, 0x0E, 0x1C, 0x60, 0x67, 0x03, 0x30, 0x1D, 0x87, 0xFC,
  0x7F, 0xE7, 0x3F, 0x31, 0xFB, 0x8F, 0xDC, 0x7E, 0xE3, 0xF3, 0x1F, 0x9C,
  0xEC, 0x7F, 0x71, 0xF3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFE, 0x03, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xB0, 0x0C, 0xC0, 0x33, 0x80, 0xC6,
  0x06, 0x18, 0x18, 0x70, 0x60, 0xC3, 0x03, 0x0F, 0xFC, 0x3F, 0xF9, 0xC0,
  0x66, 0x01, 0x98, 0x07, 0x60, 0x1F, 0x80, 0x30, 0xFE, 0x1F, 0xF3, 0x0F,
  0x60, 0xEC, 0x0D, 0x81, 0xB0, 0x76, 0x1C, 0xFF, 0x1F, 0xF3, 0x07, 0x60,
  0x7C, 0x07, 0x80, 0xF0, 0x3E, 0x0E, 0xFF, 0xDF, 0xE0, 0x07, 0xE1, 0xFF,
  0x3C, 0x33, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0xC1, 0x1F, 0xF0, 0x7E,
  0xFE, 0x1F, 0xE3, 0x0E, 0x60, 0xEC, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x76, 0x1C, 0xFF, 0x1F,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xBF,
  0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x07,
  0xE1, 0xFF, 0x3C, 0x33, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x37, 0x03, 0x30, 0x33, 0xC3, 0x1F,
  0xF0, 0x7E, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0xFF,
  0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1F, 0x0E, 0xFF, 0x9F,
  0x80, 0xC0, 0x6C, 0x0E, 0xC1, 0xCC, 0x38, 0xC7, 0x8C, 0x70, 0xCE, 0x0D,
  0xC0, 0xF8, 0x0F, 0xC0, 0xCE, 0x0C, 0x70, 0xC3, 0x8C, 0x18, 0xC1, 0xCC,
  0x0E, 0xC0, 0x6C, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0xFF, 0xF0, 0x70, 0x63, 0x83, 0x1C, 0x3C, 0xF1, 0xE7, 0x8B, 0x3C,
  0xD9, 0x36, 0xD9, 0xA6, 0xCF, 0x36, 0x39, 0xB1, 0xCD, 0x80, 0x6C, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x3E, 0x01, 0xC0, 0xC0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x07, 0xB0, 0xF6, 0x1E, 0x63, 0xCC, 0x78, 0xCF, 0x19,
  0xE1, 0xBC, 0x37, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1C, 0x0F, 0x81,
  0xFE, 0x1C, 0x38, 0xC0, 0xEE, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0x70, 0x19, 0x81, 0xCE, 0x1C,
  0x3F, 0xC0, 0x7C, 0x00, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xE1, 0xDF, 0xFB, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x81, 0xFE, 0x1C, 0x38, 0xC0, 0xEE,
  0x03, 0x70, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0x70, 0x19, 0x81, 0xCE, 0x1C, 0x3F, 0xC0, 0xFC, 0x01, 0xC0,
  0x07, 0x00, 0x1F, 0x00, 0x38, 0xFE, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D,
  0x81, 0xB0, 0x36, 0x06, 0xC3, 0xDF, 0xF3, 0xF8, 0x63, 0x8C, 0x39, 0x83,
  0x30, 0x76, 0x06, 0xC0, 0xF8, 0x0C, 0x1F, 0x8F, 0xF9, 0xC3, 0x70, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x3E, 0x0E, 0xFF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x77, 0x0E, 0x3F, 0xE1,
  0xF8, 0xE0, 0x0D, 0x80, 0x76, 0x01, 0xDC, 0x06, 0x30, 0x18, 0xC0, 0xE3,
  0x83, 0x0E, 0x0C, 0x18, 0x70, 0x61, 0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xE0,
  0x3B, 0x00, 0x6C, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0xC0, 0x3E, 0x01,
  0xF0, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0xC6, 0xC7, 0x36,
  0x79, 0xB3, 0x4C, 0x9B, 0x67, 0x9B, 0x3C, 0x59, 0xE3, 0xCE, 0x1E, 0x70,
  0x63, 0x83, 0x00, 0xE0, 0x33, 0x83, 0x9C, 0x18, 0x71, 0xC1, 0x9C, 0x0E,
  0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x3B, 0x01, 0x9C,
  0x1C, 0x61, 0xC3, 0x8E, 0x0E, 0xE0, 0x77, 0x01, 0xC0, 0x60, 0x1D, 0xC0,
  0x77, 0x01, 0x8C, 0x0E, 0x38, 0x30, 0x71, 0xC1, 0xC6, 0x03, 0xB8, 0x0F,
  0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x1F, 0xFF, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07,
  0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0xFF,
  0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80, 0x07, 0x00, 0xF0, 0x0F,
  0x81, 0xD8, 0x19, 0xC3, 0x8C, 0x30, 0xE6, 0x07, 0xE0, 0x34, 0x02, 0xFF,
  0xFF, 0xFF, 0xF0, 0x47, 0x18, 0x61, 0x00, 0x3F, 0x0F, 0xF9, 0x07, 0x00,
  0x60, 0x0E, 0x7F, 0xDF, 0xFF, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xBF, 0xF3,
  0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xF8,
  0xFF, 0x9C, 0x3B, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x3B, 0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xFF, 0x38, 0x27, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x11, 0xFF, 0x0F,
  0xE0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0xFB,
  0x3F, 0xEE, 0x1D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x60,
  0x6F, 0x0C, 0xFF, 0x87, 0xF0, 0x0F, 0x83, 0xFE, 0x70, 0xE6, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x06, 0x00, 0x78, 0x23, 0xFE, 0x0F,
  0xE0, 0x07, 0xE0, 0xFF, 0x1C, 0x31, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F,
  0xFC, 0xFF, 0xC1, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0F, 0xE7, 0xFD, 0xC1, 0xB0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x6E, 0x1C, 0xFF, 0x8F, 0xF0,
  0x06, 0x00, 0xC0, 0x3A, 0x0F, 0x7F, 0xC7, 0xE0, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xF8, 0xFF, 0x98, 0x3B, 0x03, 0x60,
  0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x70,
  0x18, 0x07, 0x80, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x71, 0x0F, 0xE0,
  0xF8, 0x03, 0x03, 0xC0, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x34,
  0x3F, 0xF9, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x0E, 0xC1, 0xCC, 0x38, 0xC7, 0x0C, 0xE0, 0xFC, 0x0F, 0xC0,
  0xCE, 0x0C, 0x70, 0xC3, 0x8C, 0x1C, 0xC0, 0xEC, 0x07, 0xFC, 0x1F, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC4, 0x3F, 0x83,
  0xE0, 0x7D, 0xEF, 0xFF, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C,
  0x63, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x7F, 0x1F, 0xF3,
  0x07, 0x60, 0x6C, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0E, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x07, 0x70, 0xE3, 0xFC, 0x0F, 0x80, 0x7F,
  0x1F, 0xF3, 0x07, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x87, 0x7F, 0xCD, 0xF1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00,
  0x0F, 0xE7, 0xFD, 0xE1, 0xB0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x6C, 0x0D, 0xC3, 0x9F, 0xF1, 0xF6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x3F, 0xFF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3F, 0x8F, 0xFB, 0x83, 0x70, 0x0E,
  0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xC0, 0x1F, 0x03, 0x7F, 0xE7, 0xF0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0xFF, 0xFF, 0xC6, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x08, 0xFF, 0x07, 0xC0,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8,
  0x37, 0x0D, 0xFF, 0x1F, 0xC0, 0xE0, 0x37, 0x01, 0x98, 0x1C, 0xE0, 0xC7,
  0x06, 0x18, 0x70, 0xE3, 0x03, 0x38, 0x19, 0x80, 0xEC, 0x03, 0xE0, 0x1E,
  0x00, 0x70, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x8C, 0x7C, 0x73, 0x63,
  0x9B, 0xBC, 0xCD, 0xB6, 0x69, 0xB3, 0xC5, 0x9E, 0x38, 0xE1, 0xC3, 0x06,
  0x00, 0xE0, 0x73, 0x83, 0x0E, 0x30, 0x33, 0x81, 0xF8, 0x07, 0x80, 0x1C,
  0x01, 0xF0, 0x1D, 0x81, 0xC6, 0x1C, 0x38, 0xC0, 0xEE, 0x03, 0x00, 0x60,
  0x36, 0x07, 0x70, 0x77, 0x06, 0x30, 0x63, 0x8E, 0x18, 0xE1, 0x8C, 0x1C,
  0xC0, 0xD8, 0x0F, 0x80, 0x78, 0x07, 0x00, 0x30, 0x06, 0x00, 0xE0, 0xFC,
  0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC3, 0xF0, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0xF8, 0x3C,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0,
  0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x03, 0xC0, 0xF0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE3, 0xF0, 0xF8, 0x00, 0x3C, 0x17, 0xE3, 0xC7, 0xFC, 0x1E,
};

const GFXglyph UbuntuMono_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 18, 15, 5, -18 },
  { 10, 7, 7, 15, 4, -20 },
  { 17, 13, 18, 15, 1, -18 },
  { 47, 11, 23, 15, 2, -20 },
  { 79, 13, 18, 15, 1, -18 },
  { 109, 13, 18, 15, 1, -18 },
  { 139, 3, 8, 15, 6, -20 },
  { 142, 8, 23, 15, 3, -18 },
  { 165, 8, 23, 15, 3, -18 },
  { 188, 11, 11, 15, 2, -18 },
  { 204, 12, 12, 15, 1, -14 },
  { 222, 6, 8, 15, 4, -4 },
  { 228, 6, 2, 15, 4, -8 },
  { 230, 4, 4, 15, 5, -4 },
  { 232, 11, 25, 15, 2, -20 },
  { 267, 12, 18, 15, 1, -18 },
  { 294, 11, 18, 15, 2, -18 },
  { 319, 11, 18, 15, 2, -18 },
  { 344, 11, 18, 15, 2, -18 },
  { 369, 13, 18, 15, 1, -18 },
  { 399, 11, 18, 15, 2, -18 },
  { 424, 11, 18, 15, 2, -18 },
  { 449, 11, 18, 15, 2, -18 },
  { 474, 12, 18, 15, 1, -18 },
  { 501, 12, 18, 15, 1, -18 },
  { 528, 4, 13, 15, 5, -13 },
  { 535, 5, 17, 15, 4, -13 },
  { 546, 12, 11, 15, 1, -13 },
  { 563, 12, 7, 15, 1, -11 },
  { 574, 12, 11, 15, 1, -13 },
  { 591, 9, 18, 15, 3, -18 },
  { 612, 13, 22, 15, 1, -18 },
  { 648, 14, 18, 15, 0, -18 },
  { 680, 11, 18, 15, 2, -18 },
  { 705, 12, 18, 15, 1, -18 },
  { 732, 11, 18, 15, 2, -18 },
  { 757, 10, 18, 15, 3, -18 },
  { 780, 10, 18, 15, 3, -18 },
  { 803, 12, 18, 15, 1, -18 },
  { 830, 12, 18, 15, 1, -18 },
  { 857, 9, 18, 15, 3, -18 },
  { 878, 10, 18, 15, 2, -18 },
  { 901, 12, 18, 15, 2, -18 },
  { 928, 10, 18, 15, 3, -18 },
  { 951, 13, 18, 15, 1, -18 },
  { 981, 11, 18, 15, 2, -18 },
  { 1006, 13, 18, 15, 1, -18 },
  { 1036, 11, 18, 15, 2, -18 },
  { 1061, 13, 22, 15, 1, -18 },
  { 1097, 11, 18, 15, 2, -18 },
  { 1122, 11, 18, 15, 2, -18 },
  { 1147, 12, 18, 15, 1, -18 },
  { 1174, 12, 18, 15, 1, -18 },
  { 1201, 14, 18, 15, 0, -18 },
  { 1233, 13, 18, 15, 1, -18 },
  { 1263, 13, 18, 15, 1, -18 },
  { 1293, 14, 18, 15, 0, -18 },
  { 1325, 11, 18, 15, 2, -18 },
  { 1350, 7, 23, 15, 4, -18 },
  { 1371, 10, 25, 15, 2, -20 },
  { 1403, 7, 23, 15, 3, -18 },
  { 1424, 12, 10, 15, 1, -18 },
  { 1439, 14, 2, 15, 0, 3 },
  { 1443, 5, 5, 15, 5, -20 },
  { 1447, 11, 13, 15, 2, -13 },
  { 1465, 11, 20, 15, 2, -20 },
  { 1493, 12, 13, 15, 1, -13 },
  { 1513, 11, 20, 15, 1, -20 },
  { 1541, 12, 13, 15, 1, -13 },
  { 1561, 12, 20, 15, 2, -20 },
  { 1591, 11, 18, 15, 1, -13 },
  { 1616, 11, 20, 15, 2, -20 },
  { 1644, 11, 18, 15, 2, -18 },
  { 1669, 9, 23, 15, 2, -18 },
  { 1695, 12, 20, 15, 2, -20 },
  { 1725, 11, 20, 15, 2, -20 },
  { 1753, 12, 13, 15, 1, -13 },
  { 1773, 11, 13, 15, 2, -13 },
  { 1791, 12, 13, 15, 1, -13 },
  { 1811, 11, 18, 15, 2, -13 },
  { 1836, 11, 18, 15, 1, -13 },
  { 1861, 10, 13, 15, 3, -13 },
  { 1878, 11, 13, 15, 2, -13 },
  { 1896, 11, 17, 15, 2, -17 },
  { 1920, 10, 13, 15, 2, -13 },
  { 1937, 13, 13, 15, 1, -13 },
  { 1959, 13, 13, 15, 1, -13 },
  { 1981, 13, 13, 15, 1, -13 },
  { 2003, 12, 18, 15, 1, -13 },
  { 2030, 10, 13, 15, 2, -13 },
  { 2047, 10, 25, 15, 2, -20 },
  { 2079, 2, 25, 15, 6, -20 },
  { 2086, 10, 25, 15, 2, -20 },
  { 2118, 12, 4, 15, 1, -9 },
};

const GFXfont UbuntuMono_Regular29pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular29pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular29pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUMONO_REGULAR29PT7B_H_
