#ifndef _UBUNTUMONO_REGULAR12PT7B_H_
#define _UBUNTUMONO_REGULAR12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x8C, 0xFC, 0x28, 0xAF, 0xD2, 0xFD, 0x45, 0x00, 0x2F, 0x88,
  0x61, 0x1F, 0x20, 0x4A, 0xAB, 0x1A, 0x35, 0x54, 0x80, 0x71, 0x45, 0x1A,
  0x9B, 0x67, 0x80, 0xE8, 0x36, 0x48, 0x88, 0x46, 0x20, 0x46, 0x21, 0x11,
  0x26, 0x40, 0x2B, 0x6F, 0x44, 0xF4, 0x40, 0xD8, 0xC0, 0xC0, 0x11, 0x22,
  0x24, 0x44, 0x88, 0x69, 0x9F, 0x99, 0x60, 0x6E, 0x22, 0x22, 0xF0, 0xF9,
  0x12, 0x48, 0xF0, 0xE1, 0x16, 0x11, 0xF0, 0x18, 0xA4, 0x92, 0xFC, 0x20,
  0x80, 0x78, 0x8E, 0x11, 0xF0, 0x3C, 0x8F, 0x99, 0x70, 0xF1, 0x22, 0x44,
  0x40, 0xF9, 0x97, 0x99, 0xF0, 0xE9, 0x9F, 0x13, 0xC0, 0xC0, 0xC0, 0x60,
  0x06, 0x50, 0x13, 0x20, 0xC1, 0x00, 0xF0, 0xF0, 0x83, 0x06, 0xC8, 0x00,
  0xE1, 0x12, 0x40, 0x60, 0x39, 0x24, 0x57, 0xA5, 0x95, 0xD8, 0x38, 0x30,
  0xC4, 0x92, 0x7A, 0x28, 0x40, 0xE9, 0x9E, 0x99, 0xF0, 0x74, 0x21, 0x08,
  0x41, 0xC0, 0xE4, 0xA5, 0x19, 0x4B, 0x80, 0xF4, 0x21, 0xE8, 0x43, 0xE0,
  0xF8, 0x8F, 0x88, 0x80, 0x78, 0x88, 0x99, 0x70, 0x99, 0x9F, 0x99, 0x90,
  0xF4, 0x44, 0x44, 0xF0, 0x71, 0x11, 0x19, 0xE0, 0x95, 0xA9, 0x8A, 0x4A,
  0x60, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x49, 0x27, 0xAD, 0x86, 0x18, 0x40,
  0x9D, 0xDB, 0xB9, 0x90, 0x79, 0x28, 0x61, 0x85, 0x27, 0x80, 0xF9, 0x99,
  0xF8, 0x80, 0x79, 0x28, 0x61, 0x85, 0x27, 0x84, 0x08, 0xE4, 0xA5, 0xCA,
  0x4A, 0x40, 0xF8, 0x86, 0x11, 0xF0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x99, 0x99, 0x99, 0xF0, 0x85, 0x24, 0x92, 0x28, 0xC3, 0x00, 0x86, 0x18,
  0x6E, 0x79, 0x64, 0x80, 0x49, 0x23, 0x0C, 0x31, 0x24, 0x80, 0x85, 0x26,
  0x8C, 0x10, 0x41, 0x00, 0xF1, 0x24, 0x48, 0xF0, 0xF2, 0x49, 0x24, 0xE0,
  0x88, 0x44, 0x42, 0x22, 0x11, 0xE4, 0x92, 0x49, 0xE0, 0x30, 0xC4, 0x92,
  0xFC, 0x90, 0xF1, 0xF9, 0x9F, 0x84, 0x3D, 0x29, 0x4A, 0x5C, 0x78, 0x88,
  0x87, 0x08, 0x5E, 0x94, 0xA5, 0x27, 0x3A, 0x5E, 0x84, 0x1C, 0x7A, 0x3C,
  0x84, 0x21, 0x08, 0x3A, 0x52, 0x94, 0xBC, 0x2E, 0x88, 0xF9, 0x99, 0x99,
  0x40, 0xC4, 0x44, 0x43, 0x20, 0xF1, 0x11, 0x11, 0x1E, 0x84, 0x25, 0x4C,
  0x72, 0xD2, 0xC4, 0x44, 0x44, 0x43, 0xFA, 0x99, 0x65, 0x86, 0x10, 0xF9,
  0x99, 0x99, 0x31, 0x24, 0x92, 0x48, 0xC0, 0xE4, 0xA5, 0x29, 0x7A, 0x10,
  0x3A, 0x52, 0x94, 0xBC, 0x21, 0xF8, 0x88, 0x88, 0xF8, 0xC3, 0x1F, 0x44,
  0xF4, 0x44, 0x47, 0x99, 0x99, 0x97, 0xCD, 0x24, 0x94, 0x30, 0xC0, 0x86,
  0x5B, 0x5E, 0x49, 0x20, 0x49, 0xC3, 0x0C, 0x49, 0x20, 0x49, 0x24, 0x8A,
  0x30, 0x42, 0x38, 0xF3, 0x24, 0x8F, 0x34, 0x44, 0x84, 0x44, 0x43, 0xFF,
  0xC0, 0xC2, 0x22, 0x12, 0x22, 0x2C, 0x66, 0x60,
};

const GFXglyph UbuntuMono_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -8 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 2, 3, 6, 2, -8 },
  { 28, 4, 9, 6, 1, -7 },
  { 33, 4, 9, 6, 1, -7 },
  { 38, 4, 4, 6, 1, -7 },
  { 40, 4, 5, 6, 1, -6 },
  { 43, 2, 3, 6, 2, -1 },
  { 44, 2, 1, 6, 2, -4 },
  { 45, 2, 1, 6, 2, -1 },
  { 46, 4, 10, 6, 1, -8 },
  { 51, 4, 7, 6, 1, -7 },
  { 55, 4, 7, 6, 1, -7 },
  { 59, 4, 7, 6, 1, -7 },
  { 63, 4, 7, 6, 1, -7 },
  { 67, 6, 7, 6, 0, -7 },
  { 73, 4, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 4, 7, 6, 1, -7 },
  { 85, 4, 7, 6, 1, -7 },
  { 89, 4, 7, 6, 1, -7 },
  { 93, 2, 5, 6, 2, -5 },
  { 95, 3, 7, 6, 1, -5 },
  { 98, 5, 5, 6, 1, -6 },
  { 102, 4, 3, 6, 1, -5 },
  { 104, 5, 5, 6, 1, -6 },
  { 108, 4, 7, 6, 1, -7 },
  { 112, 6, 9, 6, 0, -7 },
  { 119, 6, 7, 6, 0, -7 },
  { 125, 4, 7, 6, 1, -7 },
  { 129, 5, 7, 6, 1, -7 },
  { 134, 5, 7, 6, 1, -7 },
  { 139, 5, 7, 6, 1, -7 },
  { 144, 4, 7, 6, 1, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 4, 7, 6, 1, -7 },
  { 156, 4, 7, 6, 1, -7 },
  { 160, 4, 7, 6, 1, -7 },
  { 164, 5, 7, 6, 1, -7 },
  { 169, 5, 7, 6, 1, -7 },
  { 174, 6, 7, 6, 0, -7 },
  { 180, 4, 7, 6, 1, -7 },
  { 184, 6, 7, 6, 0, -7 },
  { 190, 4, 7, 6, 1, -7 },
  { 194, 6, 9, 6, 0, -7 },
  { 201, 5, 7, 6, 1, -7 },
  { 206, 4, 7, 6, 1, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 4, 7, 6, 1, -7 },
  { 220, 6, 7, 6, 0, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 6, 7, 6, 0, -7 },
  { 238, 6, 7, 6, 0, -7 },
  { 244, 4, 7, 6, 1, -7 },
  { 248, 3, 9, 6, 2, -7 },
  { 252, 4, 10, 6, 1, -8 },
  { 257, 3, 9, 6, 1, -7 },
  { 261, 6, 4, 6, 0, -7 },
  { 264, 6, 1, 6, 0, 1 },
  { 265, 2, 2, 6, 2, -8 },
  { 266, 4, 6, 6, 1, -6 },
  { 269, 5, 8, 6, 1, -8 },
  { 274, 4, 6, 6, 1, -6 },
  { 277, 5, 8, 6, 0, -8 },
  { 282, 5, 6, 6, 0, -6 },
  { 286, 5, 8, 6, 1, -8 },
  { 291, 5, 8, 6, 0, -6 },
  { 296, 4, 8, 6, 1, -8 },
  { 300, 4, 8, 6, 1, -8 },
  { 304, 4, 10, 6, 1, -8 },
  { 309, 5, 8, 6, 1, -8 },
  { 314, 4, 8, 6, 1, -8 },
  { 318, 6, 6, 6, 0, -6 },
  { 323, 4, 6, 6, 1, -6 },
  { 326, 6, 6, 6, 0, -6 },
  { 331, 5, 8, 6, 1, -6 },
  { 336, 5, 8, 6, 0, -6 },
  { 341, 4, 6, 6, 1, -6 },
  { 344, 4, 6, 6, 1, -6 },
  { 347, 4, 8, 6, 1, -8 },
  { 351, 4, 6, 6, 1, -6 },
  { 354, 6, 6, 6, 0, -6 },
  { 359, 6, 6, 6, 0, -6 },
  { 364, 6, 6, 6, 0, -6 },
  { 369, 6, 8, 6, 0, -6 },
  { 375, 4, 6, 6, 1, -6 },
  { 378, 4, 10, 6, 1, -8 },
  { 383, 1, 10, 6, 3, -8 },
  { 385, 4, 10, 6, 1, -8 },
  { 390, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuMono_Regular12pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular12pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular12pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUMONO_REGULAR12PT7B_H_
