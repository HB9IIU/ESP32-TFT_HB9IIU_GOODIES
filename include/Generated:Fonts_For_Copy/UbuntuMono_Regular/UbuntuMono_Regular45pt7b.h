#ifndef _UBUNTUMONO_REGULAR45PT7B_H_
#define _UBUNTUMONO_REGULAR45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3,
  0x8E, 0x38, 0xE0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0x06, 0xE0, 0xDC, 0x19,
  0x83, 0x00, 0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C,
  0x03, 0xC3, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0xF0,
  0x70, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC1, 0xE0, 0x1C, 0x1E, 0x01,
  0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0xC1, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFC, 0x3E, 0x03, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xD0, 0x00, 0xF7, 0x80,
  0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x73, 0xF8, 0x07,
  0x1C, 0xE0, 0x39, 0xC7, 0x03, 0x8E, 0x18, 0x3C, 0x70, 0xE1, 0xC3, 0x87,
  0x1C, 0x1C, 0x38, 0xE0, 0xE1, 0xCE, 0x07, 0x0C, 0xF0, 0x38, 0xE7, 0x00,
  0xE7, 0x70, 0x07, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x1D,
  0xFC, 0x01, 0xCE, 0x70, 0x0E, 0xE3, 0x80, 0xE7, 0x0C, 0x0E, 0x38, 0x70,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0x70, 0xE3, 0x83, 0x86, 0x38, 0x1C,
  0x71, 0xC0, 0x73, 0x9C, 0x03, 0xF9, 0xE0, 0x07, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xE1, 0xE0, 0x1C, 0x0E, 0x03, 0xC0, 0xE0,
  0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x1C, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x78,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1E, 0x1F, 0xE1, 0xE3, 0xDF,
  0x1C, 0x38, 0xF1, 0xC7, 0x87, 0x9C, 0x70, 0x3D, 0xC7, 0x01, 0xF8, 0xF0,
  0x0F, 0x8F, 0x00, 0xF8, 0x70, 0x0F, 0x87, 0x81, 0xFC, 0x7E, 0x3F, 0xE3,
  0xFF, 0xDE, 0x1F, 0xF8, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0x77,
  0x76, 0x00, 0x20, 0x0E, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xE0,
  0x02, 0x20, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x02,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x04, 0x1C, 0x17,
  0x8E, 0x7B, 0xF6, 0xFD, 0xFF, 0xFF, 0x7F, 0xFE, 0x01, 0xE0, 0x01, 0xF8,
  0x01, 0xEE, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0xF8, 0x38, 0x38, 0x08,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x0F, 0x8F,
  0xE7, 0xF3, 0xF8, 0xFC, 0x1C, 0x1E, 0x3E, 0x7E, 0x3E, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x78, 0x7C, 0x3C,
  0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x0F, 0x70, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC3, 0x87, 0xF1, 0xF1, 0xFC, 0x7C, 0x7F, 0x1F, 0x1F,
  0xC7, 0xC7, 0xF0, 0xE1, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0F, 0x78,
  0x03, 0xDE, 0x00, 0xE7, 0x80, 0x78, 0xF0, 0x3E, 0x1E, 0x1F, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x01, 0xFE, 0x01, 0xF7, 0x01, 0xF3, 0x80, 0xF1, 0xC0, 0x60, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x1F,
  0x07, 0xCE, 0x01, 0xE2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x0E,
  0x07, 0xC4, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0xC0, 0x3F, 0x7F, 0xFF,
  0x3F, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0x73, 0xC0, 0x1E, 0x78,
  0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0,
  0x78, 0x1E, 0x0E, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x1C, 0x01, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x40, 0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xEF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xC0, 0xFB, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x1E, 0x3E, 0x0F, 0x87, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E,
  0x7C, 0x07, 0x9E, 0x00, 0xE7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0x9E,
  0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0xF8, 0xFC, 0x3C, 0x0F, 0x9E, 0x01, 0xF7, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xE0, 0x1F, 0x7E, 0x0F, 0x8F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF8, 0x7C, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDF,
  0x81, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xF3, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x79, 0xFB, 0xFF,
  0xFF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFD,
  0xFF, 0xFF, 0xE7, 0x80, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3F, 0x1F,
  0xCF, 0xE7, 0xF1, 0xF8, 0x38, 0x3C, 0x7C, 0xFC, 0x7C, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x0F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0xC3, 0xFF, 0xC7, 0xFF, 0x98, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x83,
  0xC1, 0xE0, 0x3C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x0F, 0x70, 0x01,
  0xEE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x1F, 0xE3, 0xC3,
  0xFC, 0x70, 0x7F, 0x1E, 0x0F, 0xE3, 0xC1, 0xFC, 0x78, 0x3F, 0x8F, 0x07,
  0xF9, 0xE0, 0xFF, 0x1C, 0x1F, 0xE3, 0xC3, 0xFC, 0x7C, 0x7B, 0x87, 0xFF,
  0x78, 0x7F, 0xEF, 0x03, 0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x20, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xEE, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xF1, 0xC0, 0x03, 0x87,
  0x80, 0x0E, 0x1E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xF0, 0x07, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x78, 0x0E, 0x01, 0xE0, 0x78,
  0x03, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF0, 0x01,
  0xC3, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xE7,
  0x80, 0x03, 0xDC, 0x00, 0x0F, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xC0, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x07, 0xC1, 0xE1, 0xE0, 0x04, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x02, 0x1F, 0x81, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3F,
  0x0F, 0x01, 0xF1, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78,
  0xF0, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3E, 0x07, 0x1F, 0x00, 0x8F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1D, 0xE0, 0x07, 0x78, 0x01, 0xDF, 0x00, 0x73, 0xC0, 0x1C, 0xF8, 0x07,
  0x1F, 0x81, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFC, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x40, 0x1E, 0x78, 0x3F, 0x3F, 0xFF,
  0x1F, 0xFF, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C,
  0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x87, 0xC0,
  0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xF3, 0xE0, 0x1E, 0x3E, 0x03,
  0xC3, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0xC7,
  0x80, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7E, 0x3E, 0x07,
  0xE3, 0xF0, 0x7E, 0x37, 0x06, 0xE3, 0x70, 0xEE, 0x33, 0x8E, 0xE7, 0x38,
  0xCE, 0x73, 0x9C, 0xE7, 0x1D, 0xCE, 0x71, 0xD8, 0xE7, 0x1F, 0x8E, 0x70,
  0xF8, 0xE7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x00, 0x0F, 0x70, 0x00, 0xF7,
  0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F,
  0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xDC, 0x07, 0xF7, 0x81, 0xFC, 0xE0, 0x7F, 0x3C, 0x1F, 0xC7,
  0x07, 0xF1, 0xE1, 0xFC, 0x38, 0x7F, 0x0F, 0x1F, 0xC1, 0xC7, 0xF0, 0x79,
  0xFC, 0x0E, 0x7F, 0x03, 0x9F, 0xC0, 0x77, 0xF0, 0x1D, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xF0, 0xFC, 0x3C,
  0x03, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xF7,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE3, 0xE0,
  0x3C, 0x1F, 0x0F, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F,
  0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xF0, 0xFC, 0x3C, 0x03, 0xC3,
  0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xF7, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE3, 0xE0, 0x3C, 0x1F,
  0x0F, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x0F,
  0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x03,
  0x9E, 0x00, 0x73, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x3E,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1E, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xF8, 0x1C, 0x3C, 0x01, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3D, 0x80, 0x1F, 0x78, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x1E, 0x3E, 0x0F, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1D, 0xE0, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0E, 0x0F, 0x00, 0xF0, 0x38, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0,
  0x38, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x70, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7,
  0x00, 0x0F, 0x70, 0x00, 0xF7, 0x0F, 0x0F, 0x70, 0xF0, 0xE7, 0x0F, 0x8E,
  0x71, 0xF8, 0xE7, 0x1D, 0x8E, 0x71, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x8C,
  0xE3, 0x38, 0xEE, 0x37, 0x0E, 0xE3, 0x70, 0xEE, 0x3F, 0x07, 0xE3, 0xE0,
  0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78,
  0x00, 0xF7, 0xC0, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x3D, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0x9E, 0x00, 0x78,
  0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0x78, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x7D, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E,
  0x0F, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x03, 0xC8, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x20, 0x70, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x06, 0x1F, 0xF0, 0x3F,
  0xFC, 0x3F, 0xFE, 0x30, 0x3F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0x7F, 0xFF, 0x3F,
  0xFF, 0x0F, 0xFC, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x3F, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x07, 0xCF, 0x00,
  0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x01, 0xEF, 0x00, 0xF3, 0xC0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x02, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x30, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xFC,
  0xE1, 0xFF, 0xF1, 0xFF, 0xF9, 0xF0, 0x7D, 0xE0, 0x1E, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xBC, 0x01, 0xDF, 0x00, 0xE7, 0xC0,
  0x71, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xF8, 0x3E, 0x7C, 0x07, 0x9E, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x61,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xE0, 0x60, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0xC7, 0xFF, 0xE7, 0xC0, 0x77, 0xC0, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x0E, 0xF0, 0x07, 0x7E, 0x0F, 0x9F, 0xFF, 0xC7,
  0xFF, 0xE0, 0xFE, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x60, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF7, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8,
  0x3E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x03,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x10, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x60, 0x79, 0xFF, 0xEF, 0xFF, 0x07, 0xF0, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x78, 0x07,
  0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x1F, 0x07, 0x87, 0x80, 0xF1, 0xE0,
  0x1E, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xEF, 0x80,
  0x3C, 0xF8, 0x07, 0x8F, 0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xC0, 0xF8,
  0x78, 0x0F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x00, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0xC1, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x7F, 0x1F, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x70, 0xF9, 0xEE, 0x1E, 0x1F, 0xC1, 0xC3, 0xF8, 0x38,
  0x7F, 0x07, 0x0F, 0xE0, 0xE1, 0xFC, 0x1C, 0x3F, 0x83, 0x87, 0xF0, 0x70,
  0xFE, 0x0E, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x1F, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0x0F, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x1E, 0x7C, 0x07, 0x87, 0xC1, 0xF0, 0x7F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE3, 0xC0, 0xFC, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3F, 0x07, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0xF7, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0xC7, 0xFF, 0xE7, 0xC0, 0x77, 0xC0, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xF0, 0x07, 0x7C, 0x03, 0x9F, 0x07, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xC0, 0x2F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x8F, 0x80, 0xCF, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0x40,
  0x07, 0x78, 0x0F, 0xBF, 0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x81, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0x78, 0x07, 0x7C, 0x07, 0x3F, 0xFF, 0x1F, 0xFF,
  0x07, 0xFC, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x0F, 0x00, 0x78,
  0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x38, 0x39, 0xC3,
  0xC1, 0xCE, 0x1E, 0x0E, 0x70, 0xF8, 0xF3, 0x87, 0xC7, 0x1C, 0x7E, 0x38,
  0xF3, 0xB9, 0xC7, 0x99, 0xCE, 0x1D, 0xCE, 0x70, 0xEE, 0x3B, 0x87, 0xE1,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xC0, 0x38, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x1C, 0x3E, 0x03, 0xC1, 0xE0,
  0x78, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x3D, 0xE0, 0x07, 0x8F, 0x00, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x3C,
  0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xF0, 0xF0, 0x01, 0xEF, 0x00,
  0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x01,
  0xE0, 0xE0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x87,
  0x00, 0x71, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x00, 0x1E, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0x1F, 0x00, 0xC7, 0xF8, 0x1D, 0xFF, 0xC7, 0x78,
  0xFF, 0xEE, 0x07, 0xF9, 0x80, 0x3E, 0x00,
};

const GFXglyph UbuntuMono_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 28, 23, 8, -28 },
  { 22, 11, 11, 23, 6, -31 },
  { 38, 20, 28, 23, 1, -28 },
  { 108, 18, 35, 23, 2, -31 },
  { 187, 21, 28, 23, 1, -28 },
  { 261, 20, 28, 23, 1, -28 },
  { 331, 4, 12, 23, 9, -31 },
  { 337, 12, 40, 23, 5, -32 },
  { 397, 12, 40, 23, 5, -32 },
  { 457, 17, 17, 23, 3, -28 },
  { 494, 18, 19, 23, 2, -21 },
  { 537, 9, 12, 23, 7, -6 },
  { 551, 10, 4, 23, 6, -14 },
  { 556, 7, 6, 23, 8, -6 },
  { 562, 16, 38, 23, 3, -31 },
  { 638, 18, 28, 23, 2, -28 },
  { 701, 17, 28, 23, 3, -28 },
  { 761, 17, 28, 23, 3, -28 },
  { 821, 17, 28, 23, 3, -28 },
  { 881, 19, 28, 23, 2, -28 },
  { 948, 17, 28, 23, 3, -28 },
  { 1008, 18, 28, 23, 2, -28 },
  { 1071, 17, 28, 23, 3, -28 },
  { 1131, 18, 28, 23, 2, -28 },
  { 1194, 18, 28, 23, 2, -28 },
  { 1257, 7, 21, 23, 8, -21 },
  { 1276, 9, 27, 23, 6, -21 },
  { 1307, 19, 18, 23, 2, -20 },
  { 1350, 18, 11, 23, 2, -17 },
  { 1375, 19, 18, 23, 2, -20 },
  { 1418, 14, 28, 23, 4, -28 },
  { 1467, 19, 34, 23, 2, -28 },
  { 1548, 22, 28, 23, 0, -28 },
  { 1625, 18, 28, 23, 2, -28 },
  { 1688, 19, 28, 23, 2, -28 },
  { 1755, 19, 28, 23, 2, -28 },
  { 1822, 17, 28, 23, 4, -28 },
  { 1882, 16, 28, 23, 4, -28 },
  { 1938, 18, 28, 23, 2, -28 },
  { 2001, 18, 28, 23, 2, -28 },
  { 2064, 15, 28, 23, 4, -28 },
  { 2117, 17, 28, 23, 2, -28 },
  { 2177, 19, 28, 23, 3, -28 },
  { 2244, 17, 28, 23, 4, -28 },
  { 2304, 20, 28, 23, 1, -28 },
  { 2374, 18, 28, 23, 2, -28 },
  { 2437, 20, 28, 23, 1, -28 },
  { 2507, 17, 28, 23, 3, -28 },
  { 2567, 20, 35, 23, 1, -28 },
  { 2655, 19, 28, 23, 2, -28 },
  { 2722, 18, 28, 23, 2, -28 },
  { 2785, 19, 28, 23, 2, -28 },
  { 2852, 18, 28, 23, 2, -28 },
  { 2915, 21, 28, 23, 1, -28 },
  { 2989, 20, 28, 23, 1, -28 },
  { 3059, 20, 28, 23, 1, -28 },
  { 3129, 21, 28, 23, 1, -28 },
  { 3203, 18, 28, 23, 2, -28 },
  { 3266, 11, 38, 23, 6, -31 },
  { 3319, 16, 38, 23, 3, -31 },
  { 3395, 11, 38, 23, 5, -31 },
  { 3448, 19, 15, 23, 2, -28 },
  { 3484, 22, 3, 23, 0, 4 },
  { 3493, 8, 8, 23, 7, -31 },
  { 3501, 16, 21, 23, 3, -21 },
  { 3543, 18, 31, 23, 3, -31 },
  { 3613, 18, 21, 23, 2, -21 },
  { 3661, 17, 31, 23, 2, -31 },
  { 3727, 18, 21, 23, 2, -21 },
  { 3775, 19, 31, 23, 3, -31 },
  { 3849, 17, 28, 23, 2, -21 },
  { 3909, 16, 31, 23, 3, -31 },
  { 3971, 18, 29, 23, 2, -29 },
  { 4037, 14, 36, 23, 3, -29 },
  { 4100, 19, 31, 23, 3, -31 },
  { 4174, 18, 31, 23, 2, -31 },
  { 4244, 19, 21, 23, 2, -21 },
  { 4294, 16, 21, 23, 3, -21 },
  { 4336, 19, 21, 23, 2, -21 },
  { 4386, 18, 28, 23, 3, -21 },
  { 4449, 17, 28, 23, 2, -21 },
  { 4509, 15, 21, 23, 5, -21 },
  { 4549, 17, 21, 23, 3, -21 },
  { 4594, 17, 27, 23, 3, -27 },
  { 4652, 16, 21, 23, 3, -21 },
  { 4694, 20, 21, 23, 1, -21 },
  { 4747, 21, 21, 23, 1, -21 },
  { 4803, 20, 21, 23, 1, -21 },
  { 4856, 19, 28, 23, 2, -21 },
  { 4923, 16, 21, 23, 3, -21 },
  { 4965, 15, 38, 23, 4, -31 },
  { 5037, 3, 38, 23, 10, -31 },
  { 5052, 16, 38, 23, 3, -31 },
  { 5128, 19, 6, 23, 2, -15 },
};

const GFXfont UbuntuMono_Regular45pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular45pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular45pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _UBUNTUMONO_REGULAR45PT7B_H_
