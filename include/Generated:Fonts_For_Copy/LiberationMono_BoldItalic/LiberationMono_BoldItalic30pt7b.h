#ifndef _LIBERATIONMONO_BOLDITALIC30PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF7, 0x8F,
  0x78, 0xE7, 0x0E, 0x71, 0xE7, 0x1E, 0xF1, 0xCE, 0x1C, 0xE1, 0xC0, 0x00,
  0x61, 0xC0, 0x30, 0x60, 0x0C, 0x38, 0x07, 0x0C, 0x01, 0x83, 0x07, 0xFF,
  0xF1, 0xFF, 0xFC, 0x0C, 0x38, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xE1, 0x80,
  0x30, 0x60, 0x7F, 0xFF, 0x3F, 0xFF, 0xC1, 0x87, 0x00, 0xE1, 0x80, 0x30,
  0x60, 0x0C, 0x38, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x7F, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0xF3, 0x7C, 0xF1, 0x1E, 0x78,
  0x88, 0x3C, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF0, 0x06, 0x7C, 0x03, 0x1E, 0xE1, 0x0E, 0x78, 0x8F, 0x3E, 0xCF,
  0x9F, 0xFF, 0x87, 0xFF, 0x80, 0xFE, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xC0, 0x70, 0xFE, 0x06, 0x1C, 0xE0, 0xC1, 0x8E, 0x18,
  0x38, 0xE3, 0x83, 0x8E, 0x70, 0x38, 0xCE, 0x03, 0x9D, 0xC0, 0x1F, 0xB8,
  0x01, 0xF3, 0x00, 0x00, 0x67, 0x80, 0x0D, 0xFC, 0x01, 0xDC, 0xE0, 0x3B,
  0x8E, 0x07, 0x38, 0xC0, 0xE3, 0x8C, 0x1C, 0x31, 0xC1, 0x83, 0x9C, 0x30,
  0x3F, 0x86, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF1,
  0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0xC1, 0xCF, 0xE1, 0xCF, 0x78, 0xE7, 0x1C, 0xE7, 0x8F, 0x73, 0x83, 0xF1,
  0xC1, 0xF8, 0xF0, 0xFC, 0x7F, 0xFF, 0xDF, 0xF7, 0xE7, 0xE0, 0xE0, 0x3D,
  0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0x00, 0x07, 0x00, 0xE1, 0x1C, 0x3B, 0x7F, 0xFE, 0xFF, 0xC7,
  0xC1, 0xFC, 0x73, 0x9E, 0x70, 0x8C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0x70,
  0x00, 0x7F, 0x9F, 0xE7, 0xFB, 0xFE, 0x7B, 0xDF, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xF1, 0xF3, 0xC1, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xFB, 0x9F, 0xE7, 0x3F, 0xCE, 0xFF, 0x9D,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF8, 0xF1, 0xFF, 0xC1,
  0xFF, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xE0, 0xFF, 0xC3,
  0xEF, 0x07, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xE1, 0xF1, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF,
  0xC0, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x1C,
  0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x03, 0xFC, 0x03, 0xE0, 0x03, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0xFF,
  0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x1E,
  0x07, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x83, 0xC3, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x79, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x1F, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xC0, 0x79, 0xE0, 0x78, 0xF8, 0x7C,
  0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF8, 0xF0, 0xF3, 0xC1, 0xE7, 0x80, 0x1E, 0x00, 0x3C, 0xF8, 0x7F, 0xF9,
  0xFF, 0xFB, 0xF1, 0xF7, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E,
  0x0F, 0x1E, 0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x3E, 0x78,
  0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F,
  0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3E, 0x3F, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0x9E, 0x00, 0x1E, 0x00, 0x3C, 0xF0, 0x7C, 0x78,
  0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0x1E, 0x1E, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x78, 0x78, 0xF8, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F,
  0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x3F, 0x78, 0x1F, 0xF8, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3C, 0x38, 0x1C,
  0x07, 0x06, 0x00, 0xC3, 0x00, 0x31, 0xC7, 0x3C, 0x63, 0xFB, 0x31, 0x8E,
  0xCC, 0xC3, 0xB3, 0x70, 0xCD, 0x98, 0x73, 0x6E, 0x18, 0xDB, 0x06, 0x6E,
  0xC3, 0x1B, 0x30, 0xC6, 0xCC, 0x73, 0x33, 0x3D, 0x8C, 0xFB, 0xE3, 0x1C,
  0xE0, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x81, 0xE0, 0xE0, 0x3F, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xDC,
  0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFC, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x79, 0xF0, 0x3E,
  0x7C, 0x1F, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x10,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x63, 0xE0, 0x79, 0xF0, 0x7C, 0x7C, 0x7C, 0x3F, 0xFC, 0x0F,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3C,
  0x7E, 0x1F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x07,
  0x8F, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x03, 0xC7,
  0xC1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F,
  0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x1F, 0x07, 0x87, 0xC1,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xC1, 0xF1, 0xF0, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x30, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0xF0, 0x7E,
  0x0F, 0x0F, 0xC0, 0xF1, 0xF8, 0x1F, 0x3F, 0x01, 0xE7, 0xE0, 0x1E, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x78,
  0x3E, 0x07, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x0F, 0x83, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3B, 0x8F, 0xE7,
  0xF1, 0xFC, 0xDC, 0x3B, 0xBB, 0x87, 0x37, 0x70, 0xE6, 0xCE, 0x1C, 0xFB,
  0xC7, 0x9E, 0x70, 0xE3, 0xCE, 0x1C, 0x71, 0xC3, 0x80, 0x38, 0x70, 0x0F,
  0x1E, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x00, 0x0F, 0x83, 0xC3, 0xE0,
  0xF0, 0xFC, 0x3C, 0x3F, 0x0F, 0x1F, 0xC3, 0x87, 0xF1, 0xE1, 0xFC, 0x78,
  0x77, 0x9E, 0x1D, 0xE7, 0x8F, 0x79, 0xE3, 0xCE, 0x70, 0xF3, 0xBC, 0x3C,
  0xFF, 0x0E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F,
  0x87, 0x87, 0xE1, 0xC1, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xE3, 0xE3, 0xE0, 0xF9, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F,
  0xFC, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x81, 0xF7, 0x80, 0xF3, 0xE0,
  0xF9, 0xF0, 0x78, 0x7C, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x3F, 0x1F, 0x07, 0xC7,
  0xC0, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x83, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x81,
  0xF7, 0x80, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xFC, 0x7C, 0x3F, 0xFC, 0x0F,
  0xFC, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3C, 0x1F, 0x1F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E,
  0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x3C, 0x7C, 0x0F, 0x1F,
  0x03, 0xC3, 0xC1, 0xF0, 0xF8, 0x78, 0x3E, 0x1E, 0x07, 0x87, 0x81, 0xF1,
  0xE0, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x1F, 0x1E,
  0x07, 0xC7, 0x80, 0xC1, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x00, 0xFB,
  0xE0, 0x3C, 0xFC, 0x1F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0x80, 0xF8, 0x03, 0xDE, 0x01, 0xF7,
  0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0xC1, 0xE1, 0xF0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x78, 0x03, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xCF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE,
  0x39, 0xF3, 0x8E, 0x7D, 0xE3, 0xBF, 0x70, 0xEF, 0xDC, 0x3F, 0x7F, 0x0F,
  0xDF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x83,
  0xC0, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8,
  0x01, 0xE3, 0xC0, 0x07, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x80,
  0x78, 0x1E, 0x03, 0xC0, 0x7C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xDE, 0x01,
  0xE7, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x8F, 0x01, 0xE7, 0x80,
  0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0x3C, 0x0F, 0x1C, 0x0E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xF1, 0xE3, 0xC7, 0x03, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF0, 0xF1, 0xF3, 0xC1, 0xE0, 0x07, 0xC3, 0xFF, 0x1F, 0xFE, 0x7C, 0x3D,
  0xF0, 0xFB, 0xC1, 0xE7, 0x87, 0xCF, 0x1F, 0x9F, 0xFF, 0xFF, 0xCF, 0xBE,
  0x1F, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x7C, 0x3E, 0xFE, 0x3D, 0xFE, 0x3F, 0x1F, 0x3E, 0x1F, 0x3C,
  0x0F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8,
  0x3C, 0xFC, 0x7C, 0xFF, 0xF8, 0xF7, 0xF0, 0xF3, 0xE0, 0x01, 0xF8, 0x07,
  0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x1F, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1E, 0xF8, 0x3C, 0x7C, 0x7C, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0xF0, 0x3F, 0xBC, 0x1F,
  0xFF, 0x0F, 0x8F, 0xC3, 0xC1, 0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x8F, 0x81, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC1,
  0xFE, 0xF0, 0x7F, 0x3C, 0x0F, 0x9E, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3E, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x18, 0x7C, 0x3C, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03,
  0xC7, 0x87, 0xFB, 0xC7, 0xFF, 0xC7, 0xE3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x07,
  0xC7, 0xC7, 0xC3, 0xFF, 0xE1, 0xFE, 0xF0, 0x3C, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x3C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x7C,
  0x3C, 0xFE, 0x3D, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x3C, 0x0F, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x3E, 0x3C, 0x3E, 0x1E, 0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x07, 0xBC, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0x7C,
  0x1E, 0x1E, 0x1F, 0x0F, 0x8F, 0x03, 0xC7, 0x81, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3D, 0xE7, 0x8E, 0xFB, 0xF3, 0xFF, 0xFC,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0x38, 0xE7, 0x8E, 0x39, 0xE7, 0x8E, 0x71,
  0xE7, 0x9C, 0x71, 0xE7, 0x1C, 0x73, 0xC7, 0x1C, 0xF3, 0xC7, 0x38, 0xF1,
  0xCE, 0x38, 0xF3, 0x8E, 0x38, 0x3C, 0x7C, 0x3C, 0xFE, 0x3D, 0xFF, 0x3F,
  0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x1F, 0x78,
  0x0F, 0x78, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8,
  0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0x9F, 0x03,
  0xCF, 0xE0, 0xF7, 0xF8, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xC0, 0xF1, 0xF0,
  0x7C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0xF8, 0x3C,
  0x3F, 0x1F, 0x0F, 0xFF, 0x83, 0xDF, 0xC0, 0xF3, 0xE0, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3E, 0x3F, 0x3C, 0x1F, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0xF8,
  0xFC, 0x7F, 0xBC, 0x7F, 0xFC, 0x3E, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x3E, 0x79, 0xFC, 0xF7,
  0xF9, 0xEE, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x08, 0x3E,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x30,
  0x1C, 0xF0, 0x3C, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xFC, 0x7F, 0xBC, 0x7F, 0x3C,
  0x3E, 0x78, 0xF0, 0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xCF, 0x03, 0xC7, 0x83,
  0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x78, 0x07, 0xB8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x0E, 0x71, 0xC3, 0x9C,
  0x71, 0xC7, 0x3C, 0x71, 0xCF, 0x9C, 0xF7, 0xEE, 0x3D, 0xBB, 0x8E, 0xEE,
  0xE3, 0xB3, 0xF0, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xE0,
  0x0F, 0x01, 0xE1, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xE7, 0x80, 0x3D, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1E, 0xF0, 0x07, 0x9E, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x0F, 0x03, 0xC3,
  0xC0, 0x78, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C,
  0x0F, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x9E,
  0x00, 0x79, 0xC0, 0x07, 0xBC, 0x00, 0x3B, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xC3,
  0x7F, 0xFF, 0x41, 0xFF, 0x80, 0x7C,
};

const GFXglyph LiberationMono_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 20, 18, 5, -20 },
  { 21, 12, 9, 18, 5, -22 },
  { 35, 18, 20, 18, 0, -20 },
  { 80, 17, 25, 18, 1, -22 },
  { 134, 20, 20, 18, -1, -20 },
  { 184, 17, 20, 18, 0, -20 },
  { 227, 6, 9, 18, 8, -22 },
  { 234, 12, 28, 18, 4, -22 },
  { 276, 11, 28, 18, 2, -22 },
  { 315, 11, 11, 18, 5, -22 },
  { 331, 16, 15, 18, 1, -18 },
  { 361, 9, 10, 18, 1, -4 },
  { 373, 10, 4, 18, 4, -10 },
  { 378, 5, 4, 18, 5, -4 },
  { 381, 19, 22, 18, 0, -22 },
  { 434, 15, 20, 18, 2, -20 },
  { 472, 15, 20, 18, 1, -20 },
  { 510, 17, 20, 18, 0, -20 },
  { 553, 16, 20, 18, 1, -20 },
  { 593, 17, 20, 18, 0, -20 },
  { 636, 17, 20, 18, 1, -20 },
  { 679, 15, 20, 18, 2, -20 },
  { 717, 15, 20, 18, 3, -20 },
  { 755, 16, 20, 18, 1, -20 },
  { 795, 16, 20, 18, 1, -20 },
  { 835, 8, 16, 18, 5, -16 },
  { 851, 11, 22, 18, 2, -16 },
  { 882, 16, 17, 18, 1, -18 },
  { 916, 16, 11, 18, 1, -16 },
  { 938, 16, 17, 18, 1, -18 },
  { 972, 16, 20, 18, 2, -20 },
  { 1012, 18, 26, 18, 0, -22 },
  { 1071, 18, 20, 18, -2, -20 },
  { 1116, 18, 20, 18, 0, -20 },
  { 1161, 17, 20, 18, 1, -20 },
  { 1204, 18, 20, 18, 0, -20 },
  { 1249, 18, 20, 18, 0, -20 },
  { 1294, 18, 20, 18, 1, -20 },
  { 1339, 16, 20, 18, 1, -20 },
  { 1379, 18, 20, 18, 0, -20 },
  { 1424, 17, 20, 18, 1, -20 },
  { 1467, 16, 20, 18, 1, -20 },
  { 1507, 20, 20, 18, 0, -20 },
  { 1557, 14, 20, 18, 2, -20 },
  { 1592, 19, 20, 18, 0, -20 },
  { 1640, 18, 20, 18, 0, -20 },
  { 1685, 17, 20, 18, 1, -20 },
  { 1728, 18, 20, 18, 0, -20 },
  { 1773, 17, 26, 18, 1, -20 },
  { 1829, 18, 20, 18, 0, -20 },
  { 1874, 18, 20, 18, 0, -20 },
  { 1919, 16, 20, 18, 3, -20 },
  { 1959, 16, 20, 18, 2, -20 },
  { 1999, 18, 20, 18, 2, -20 },
  { 2044, 18, 20, 18, 2, -20 },
  { 2089, 22, 20, 18, -2, -20 },
  { 2144, 18, 20, 18, 2, -20 },
  { 2189, 18, 20, 18, 0, -20 },
  { 2234, 14, 28, 18, 3, -22 },
  { 2283, 11, 22, 18, 4, -22 },
  { 2314, 14, 28, 18, 1, -22 },
  { 2363, 16, 13, 18, 1, -21 },
  { 2389, 18, 1, 18, -2, 2 },
  { 2392, 6, 4, 18, 8, -21 },
  { 2395, 15, 16, 18, 1, -16 },
  { 2425, 16, 22, 18, 1, -22 },
  { 2469, 16, 16, 18, 1, -16 },
  { 2501, 18, 22, 18, 1, -22 },
  { 2551, 16, 16, 18, 1, -16 },
  { 2583, 16, 22, 18, 3, -22 },
  { 2627, 17, 22, 18, 1, -16 },
  { 2674, 16, 22, 18, 1, -22 },
  { 2718, 16, 22, 18, 0, -22 },
  { 2762, 16, 28, 18, -1, -22 },
  { 2818, 17, 22, 18, 1, -22 },
  { 2865, 16, 22, 18, 0, -22 },
  { 2909, 18, 16, 18, 0, -16 },
  { 2945, 16, 16, 18, 1, -16 },
  { 2977, 16, 16, 18, 1, -16 },
  { 3009, 18, 22, 18, -1, -16 },
  { 3059, 16, 22, 18, 1, -16 },
  { 3103, 15, 16, 18, 2, -16 },
  { 3133, 16, 16, 18, 1, -16 },
  { 3165, 13, 20, 18, 3, -20 },
  { 3198, 16, 16, 18, 1, -16 },
  { 3230, 17, 16, 18, 2, -16 },
  { 3264, 18, 16, 18, 1, -16 },
  { 3300, 19, 16, 18, -1, -16 },
  { 3338, 20, 22, 18, -1, -16 },
  { 3393, 17, 16, 18, 0, -16 },
  { 3427, 15, 28, 18, 3, -22 },
  { 3480, 4, 29, 18, 7, -22 },
  { 3495, 15, 28, 18, 0, -22 },
  { 3548, 16, 5, 18, 1, -12 },
};

const GFXfont LiberationMono_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic30pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _LIBERATIONMONO_BOLDITALIC30PT7B_H_
