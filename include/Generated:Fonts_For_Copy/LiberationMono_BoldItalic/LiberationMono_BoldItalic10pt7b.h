#ifndef _LIBERATIONMONO_BOLDITALIC10PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0xC8, 0xBA, 0xA0, 0x14, 0x97, 0xD2, 0xF9, 0x49, 0x00, 0x10,
  0xF5, 0x5C, 0x38, 0xBE, 0x9E, 0x20, 0x66, 0xA7, 0x04, 0x3D, 0x59, 0x80,
  0x38, 0xA3, 0x18, 0xBA, 0x6E, 0xC0, 0xA8, 0x12, 0x64, 0x44, 0xC4, 0x40,
  0x22, 0x22, 0x22, 0x64, 0x80, 0x5D, 0x50, 0x30, 0xCF, 0xCC, 0x30, 0x29,
  0x00, 0x60, 0x80, 0x04, 0x21, 0x84, 0x21, 0x08, 0x00, 0x76, 0xE7, 0x79,
  0x4B, 0x80, 0x1B, 0x84, 0x21, 0x1B, 0xE0, 0x39, 0xB0, 0xC6, 0x31, 0x0F,
  0x80, 0x39, 0xB0, 0xCC, 0x0B, 0x27, 0x00, 0x08, 0x62, 0x92, 0xFC, 0x41,
  0x00, 0x3D, 0x87, 0x82, 0x0B, 0x27, 0x00, 0x76, 0xE1, 0xE9, 0x4B, 0x80,
  0xF8, 0x8C, 0x44, 0x23, 0x00, 0x39, 0xB6, 0xCC, 0x4B, 0x27, 0x00, 0x39,
  0xB4, 0xDF, 0x0B, 0x67, 0x00, 0x40, 0x80, 0x20, 0x05, 0xA0, 0x0D, 0xC8,
  0x1C, 0x0C, 0xFC, 0x00, 0x3F, 0xC0, 0xE0, 0x4E, 0xC0, 0x74, 0xC6, 0x64,
  0x01, 0x00, 0x3D, 0x97, 0xEB, 0xD7, 0xE8, 0x1C, 0x0C, 0x51, 0x49, 0x3D,
  0x14, 0x40, 0x7D, 0xB4, 0xDC, 0x4F, 0x3F, 0x80, 0x39, 0xB4, 0x10, 0xC1,
  0x27, 0x00, 0x79, 0xB4, 0xD3, 0x4B, 0x6F, 0x00, 0x7D, 0x84, 0x1E, 0x43,
  0x0F, 0x80, 0x7D, 0x86, 0x1E, 0x41, 0x0C, 0x00, 0x39, 0xB4, 0x17, 0xC9,
  0x27, 0x00, 0x65, 0xB4, 0xDE, 0x4B, 0x2D, 0x80, 0x7C, 0x41, 0x0C, 0x30,
  0x8F, 0x80, 0x1C, 0x20, 0x82, 0x1B, 0x67, 0x00, 0x6C, 0xF1, 0xC3, 0x85,
  0x1B, 0x32, 0x00, 0x44, 0xCC, 0x88, 0xF0, 0x6D, 0xB6, 0xDD, 0xFA, 0x28,
  0x80, 0x65, 0x97, 0xD6, 0x5B, 0x69, 0x80, 0x39, 0xB4, 0xF3, 0xCF, 0x27,
  0x00, 0x7D, 0xB4, 0xDE, 0x43, 0x0C, 0x00, 0x39, 0xB4, 0xF3, 0xCF, 0x27,
  0x08, 0x38, 0x7D, 0x94, 0xDE, 0x5B, 0x6C, 0x80, 0x3D, 0x36, 0x0E, 0x0F,
  0x27, 0x00, 0xF9, 0x08, 0xC6, 0x21, 0x00, 0xCE, 0xE7, 0x29, 0x4B, 0x80,
  0x8E, 0x2D, 0xB4, 0xE1, 0x84, 0x00, 0x8E, 0x2A, 0xBE, 0xF2, 0xCB, 0x00,
  0x32, 0x14, 0x14, 0x18, 0x28, 0x24, 0x44, 0x8B, 0x65, 0x18, 0x61, 0x04,
  0x00, 0x7C, 0x21, 0x8C, 0x61, 0x0F, 0x80, 0x3B, 0x18, 0x84, 0x23, 0x10,
  0xE0, 0x44, 0x42, 0x22, 0x10, 0x38, 0xC6, 0x21, 0x08, 0xC6, 0xE0, 0x18,
  0xA4, 0x92, 0xFC, 0x90, 0x78, 0x5F, 0xBE, 0x80, 0x21, 0x87, 0x9B, 0x4D,
  0x2F, 0x00, 0x39, 0x34, 0x32, 0x70, 0x04, 0x33, 0xD2, 0xCB, 0x66, 0x80,
  0x39, 0x3F, 0xF0, 0x78, 0x3B, 0x3E, 0x84, 0x23, 0x00, 0x35, 0x34, 0x92,
  0x78, 0x6F, 0x00, 0x61, 0x85, 0x9B, 0x4B, 0x2C, 0x80, 0x18, 0x0C, 0x21,
  0x1B, 0xE0, 0x08, 0x0E, 0x21, 0x08, 0xC6, 0xE0, 0x21, 0x86, 0xD4, 0x71,
  0x6D, 0x80, 0x38, 0x84, 0x23, 0x1B, 0xE0, 0x7D, 0x5F, 0x6A, 0xA8, 0x59,
  0xB4, 0x92, 0xC8, 0x39, 0x3C, 0xF2, 0x70, 0x59, 0xB4, 0xD2, 0xF2, 0x08,
  0x00, 0x3D, 0x2C, 0xB6, 0x78, 0x61, 0x00, 0xFE, 0x31, 0x08, 0x00, 0x39,
  0x07, 0x82, 0x70, 0x2F, 0x44, 0xC7, 0x4D, 0x24, 0xB6, 0x68, 0x8C, 0xAD,
  0xC6, 0x00, 0x45, 0x5F, 0xAE, 0xD8, 0x6C, 0xE3, 0x1C, 0xD8, 0x45, 0x26,
  0x8C, 0x30, 0x8C, 0x00, 0x78, 0x63, 0x18, 0xF8, 0x39, 0x18, 0xC8, 0x21,
  0x18, 0x60, 0xFF, 0xFF, 0xC0, 0x30, 0xC4, 0x20, 0x98, 0xC4, 0xE0, 0x64,
  0x70,
};

const GFXglyph LiberationMono_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 2, 3, 6, 3, -7 },
  { 31, 4, 9, 6, 1, -7 },
  { 36, 4, 9, 6, 1, -7 },
  { 41, 3, 4, 6, 2, -7 },
  { 43, 6, 5, 6, 0, -6 },
  { 47, 3, 3, 6, 0, -1 },
  { 49, 4, 1, 6, 1, -3 },
  { 50, 1, 1, 6, 2, -1 },
  { 51, 6, 7, 6, 0, -7 },
  { 57, 5, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 6, 7, 6, 0, -7 },
  { 73, 6, 7, 6, 0, -7 },
  { 79, 6, 7, 6, 0, -7 },
  { 85, 6, 7, 6, 0, -7 },
  { 91, 5, 7, 6, 1, -7 },
  { 96, 5, 7, 6, 1, -7 },
  { 101, 6, 7, 6, 0, -7 },
  { 107, 6, 7, 6, 0, -7 },
  { 113, 2, 5, 6, 2, -5 },
  { 115, 3, 7, 6, 1, -5 },
  { 118, 6, 5, 6, 0, -6 },
  { 122, 6, 4, 6, 0, -5 },
  { 125, 6, 5, 6, 0, -6 },
  { 129, 5, 7, 6, 1, -7 },
  { 134, 6, 8, 6, 0, -7 },
  { 140, 6, 7, 6, -1, -7 },
  { 146, 6, 7, 6, 0, -7 },
  { 152, 6, 7, 6, 0, -7 },
  { 158, 6, 7, 6, 0, -7 },
  { 164, 6, 7, 6, 0, -7 },
  { 170, 6, 7, 6, 0, -7 },
  { 176, 6, 7, 6, 0, -7 },
  { 182, 6, 7, 6, 0, -7 },
  { 188, 6, 7, 6, 0, -7 },
  { 194, 6, 7, 6, 0, -7 },
  { 200, 7, 7, 6, 0, -7 },
  { 207, 4, 7, 6, 1, -7 },
  { 211, 6, 7, 6, 0, -7 },
  { 217, 6, 7, 6, 0, -7 },
  { 223, 6, 7, 6, 0, -7 },
  { 229, 6, 7, 6, 0, -7 },
  { 235, 6, 9, 6, 0, -7 },
  { 242, 6, 7, 6, 0, -7 },
  { 248, 6, 7, 6, 0, -7 },
  { 254, 5, 7, 6, 1, -7 },
  { 259, 5, 7, 6, 1, -7 },
  { 264, 6, 7, 6, 1, -7 },
  { 270, 6, 7, 6, 1, -7 },
  { 276, 8, 7, 6, -1, -7 },
  { 283, 6, 7, 6, 1, -7 },
  { 289, 6, 7, 6, 0, -7 },
  { 295, 5, 9, 6, 1, -7 },
  { 301, 4, 7, 6, 1, -7 },
  { 305, 5, 9, 6, 0, -7 },
  { 311, 6, 4, 6, 0, -7 },
  { 314, 6, 1, 6, -1, 1 },
  { 315, 2, 2, 6, 3, -8 },
  { 316, 5, 5, 6, 0, -5 },
  { 320, 6, 7, 6, 0, -7 },
  { 326, 6, 5, 6, 0, -5 },
  { 330, 6, 7, 6, 0, -7 },
  { 336, 6, 5, 6, 0, -5 },
  { 340, 5, 7, 6, 1, -7 },
  { 345, 6, 7, 6, 0, -5 },
  { 351, 6, 7, 6, 0, -7 },
  { 357, 5, 7, 6, 0, -7 },
  { 362, 5, 9, 6, 0, -7 },
  { 368, 6, 7, 6, 0, -7 },
  { 374, 5, 7, 6, 0, -7 },
  { 379, 6, 5, 6, 0, -5 },
  { 383, 6, 5, 6, 0, -5 },
  { 387, 6, 5, 6, 0, -5 },
  { 391, 6, 7, 6, 0, -5 },
  { 397, 6, 7, 6, 0, -5 },
  { 403, 5, 5, 6, 1, -5 },
  { 407, 6, 5, 6, 0, -5 },
  { 411, 4, 6, 6, 1, -6 },
  { 414, 6, 5, 6, 0, -5 },
  { 418, 5, 5, 6, 1, -5 },
  { 422, 6, 5, 6, 0, -5 },
  { 426, 6, 5, 6, 0, -5 },
  { 430, 6, 7, 6, 0, -5 },
  { 436, 6, 5, 6, 0, -5 },
  { 440, 5, 9, 6, 1, -7 },
  { 446, 2, 9, 6, 2, -7 },
  { 449, 5, 9, 6, 0, -7 },
  { 455, 6, 2, 6, 0, -4 },
};

const GFXfont LiberationMono_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic10pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _LIBERATIONMONO_BOLDITALIC10PT7B_H_
