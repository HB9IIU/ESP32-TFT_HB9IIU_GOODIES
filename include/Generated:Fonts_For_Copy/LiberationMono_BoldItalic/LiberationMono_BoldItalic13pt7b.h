#ifndef _LIBERATIONMONO_BOLDITALIC13PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x66, 0x04, 0xC0, 0x4A, 0xF7, 0xA0, 0x09, 0x12, 0x7F,
  0x24, 0x24, 0x24, 0xFE, 0x48, 0x50, 0x04, 0x1E, 0x2B, 0x6B, 0x78, 0x3E,
  0x16, 0xD6, 0xD6, 0x7C, 0x10, 0x71, 0x52, 0x54, 0x68, 0x08, 0x16, 0x2B,
  0x4A, 0x8E, 0x1C, 0x6C, 0xD1, 0xC7, 0x3A, 0x67, 0x66, 0xF6, 0xFA, 0x19,
  0x88, 0xC4, 0x63, 0x18, 0xC6, 0x31, 0x84, 0x00, 0x30, 0x86, 0x31, 0x8C,
  0x62, 0x31, 0x98, 0xCC, 0x00, 0x33, 0x7E, 0xE5, 0x00, 0x30, 0xC3, 0x3F,
  0x30, 0xC3, 0x00, 0x6B, 0x40, 0xF0, 0x58, 0x01, 0x02, 0x06, 0x0C, 0x08,
  0x18, 0x30, 0x20, 0x40, 0xC0, 0x3D, 0x9C, 0x71, 0xFF, 0x38, 0xF6, 0x70,
  0x0C, 0xF8, 0x30, 0x60, 0x83, 0x06, 0x0C, 0xFE, 0x1E, 0x36, 0x62, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFE, 0x1E, 0x22, 0x02, 0x06, 0x18, 0x06, 0x46,
  0xC6, 0x78, 0x06, 0x1C, 0x79, 0xB2, 0x48, 0xBF, 0x86, 0x0C, 0x3E, 0x20,
  0x20, 0x7C, 0x66, 0x06, 0x06, 0x44, 0x78, 0x3D, 0x94, 0x3E, 0xCF, 0x3C,
  0xF2, 0x70, 0x7E, 0x08, 0x20, 0xC3, 0x06, 0x18, 0x30, 0x40, 0x1E, 0x32,
  0x62, 0x26, 0x18, 0x66, 0x46, 0xC6, 0x78, 0x3D, 0xBC, 0x71, 0xCD, 0xF0,
  0xF6, 0xF0, 0x2C, 0x00, 0xB0, 0x11, 0x80, 0x00, 0x11, 0x88, 0x80, 0x04,
  0xFE, 0x20, 0xE0, 0xF0, 0x40, 0xFC, 0x00, 0x00, 0xFC, 0x83, 0xC3, 0xC1,
  0x3F, 0xC8, 0x00, 0x3C, 0x8F, 0x18, 0x63, 0x84, 0x00, 0x30, 0x60, 0x0E,
  0x33, 0x21, 0x5F, 0x55, 0xA5, 0xAA, 0xAA, 0xBC, 0x80, 0xC4, 0x78, 0x06,
  0x0E, 0x0A, 0x1A, 0x13, 0x3F, 0x23, 0x63, 0x43, 0x3E, 0x23, 0x63, 0x66,
  0x7C, 0x66, 0x66, 0xC6, 0xFC, 0x3C, 0xCF, 0x1E, 0x0C, 0x10, 0x23, 0x66,
  0x70, 0x3C, 0x26, 0x63, 0x63, 0x62, 0x66, 0x66, 0xCC, 0xF8, 0x3F, 0x20,
  0x60, 0x60, 0x7E, 0x60, 0x60, 0xC0, 0xFE, 0x3F, 0x30, 0x20, 0x60, 0x7E,
  0x60, 0x60, 0x60, 0xC0, 0x3C, 0xDB, 0x1E, 0x0D, 0xD1, 0xA3, 0x66, 0x70,
  0x33, 0x33, 0x62, 0x66, 0x7E, 0x66, 0x66, 0xC6, 0xCC, 0x3F, 0x08, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xB3,
  0x36, 0x78, 0x33, 0x13, 0x1B, 0x0F, 0x07, 0x83, 0x61, 0xB1, 0x9C, 0xC6,
  0x00, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xFC, 0x33, 0x77, 0x77, 0x57,
  0x5A, 0x5A, 0xDA, 0xC6, 0x86, 0x33, 0x33, 0x72, 0x7A, 0x7E, 0x5E, 0x4E,
  0xCE, 0xCC, 0x1E, 0x32, 0x63, 0x63, 0x63, 0xC6, 0xC6, 0x64, 0x78, 0x3E,
  0x23, 0x63, 0x66, 0x7C, 0x60, 0x40, 0xC0, 0xC0, 0x1E, 0x32, 0x63, 0x63,
  0x63, 0xC6, 0xC6, 0x64, 0x78, 0x30, 0x18, 0x1C, 0x3E, 0x23, 0x63, 0x62,
  0x7C, 0x6C, 0x4C, 0xC6, 0xC6, 0x1E, 0x23, 0x63, 0x70, 0x3E, 0x06, 0xC6,
  0xC6, 0x7C, 0xFE, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0x66, 0x8F,
  0x1E, 0x6C, 0xD9, 0xB3, 0x6C, 0xF0, 0xC3, 0xC6, 0xC6, 0x4C, 0x48, 0x78,
  0x70, 0x70, 0x60, 0xC3, 0xC2, 0x86, 0x96, 0xB4, 0xB4, 0xDC, 0xD8, 0x98,
  0x31, 0x86, 0xC1, 0xA0, 0x38, 0x0C, 0x07, 0x83, 0x60, 0x88, 0x63, 0x00,
  0xC6, 0x46, 0x6C, 0x78, 0x30, 0x30, 0x30, 0x20, 0x60, 0x3F, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x60, 0x60, 0xFE, 0x3C, 0xC3, 0x0C, 0x20, 0x86, 0x18,
  0x61, 0x84, 0x30, 0xF0, 0x86, 0x10, 0x86, 0x10, 0x86, 0x10, 0x80, 0x1E,
  0x08, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0xC7, 0x00, 0x0C,
  0x28, 0xD1, 0x36, 0x68, 0x40, 0xFF, 0xC4, 0x3C, 0xCC, 0x1B, 0xF4, 0x59,
  0x9D, 0x80, 0x30, 0x60, 0x83, 0x77, 0x6C, 0xD9, 0xB3, 0x65, 0xB8, 0x39,
  0x3C, 0x30, 0x83, 0x2F, 0x00, 0x03, 0x03, 0x03, 0x3A, 0x66, 0x66, 0x46,
  0xC6, 0x6C, 0x74, 0x3B, 0x3C, 0x7F, 0x83, 0x2F, 0x00, 0x1E, 0x60, 0xC7,
  0xF2, 0x04, 0x18, 0x30, 0x60, 0xC0, 0x3B, 0x26, 0x66, 0x66, 0x66, 0x6E,
  0x74, 0x04, 0xCC, 0x78, 0x30, 0x60, 0x83, 0x77, 0x6C, 0xD9, 0xB3, 0x47,
  0x88, 0x0C, 0x00, 0x01, 0xE0, 0x83, 0x06, 0x0C, 0x19, 0xFC, 0x06, 0x00,
  0x01, 0xE0, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x8E, 0x00, 0x30, 0x30,
  0x30, 0x26, 0x6C, 0x78, 0x78, 0x6C, 0x4C, 0x46, 0x3C, 0x18, 0x30, 0x60,
  0x83, 0x06, 0x0C, 0x19, 0xFC, 0x5F, 0x7B, 0x5B, 0xDA, 0xD2, 0xD2, 0x96,
  0x6E, 0xED, 0x9B, 0x36, 0x68, 0xF1, 0x00, 0x1E, 0xCD, 0x9A, 0x3C, 0x6C,
  0x9E, 0x00, 0x6E, 0xED, 0x9B, 0x36, 0x6C, 0xB7, 0x60, 0xC1, 0x80, 0x3A,
  0x66, 0x66, 0x46, 0xC6, 0x6E, 0x7C, 0x0C, 0x0C, 0x0C, 0x6C, 0xE1, 0x82,
  0x0C, 0x18, 0x30, 0x00, 0x3E, 0x4D, 0xC1, 0xE0, 0x78, 0xDF, 0x00, 0x10,
  0xC7, 0xD8, 0x61, 0x86, 0x18, 0x78, 0xC5, 0x9B, 0x36, 0x68, 0xDB, 0x3A,
  0x00, 0xC7, 0x8B, 0x36, 0x45, 0x8A, 0x1C, 0x00, 0x83, 0x0E, 0xD5, 0xAD,
  0xDB, 0x26, 0x00, 0x63, 0x36, 0x3C, 0x18, 0x3C, 0x6C, 0xC6, 0x63, 0x62,
  0x66, 0x24, 0x2C, 0x38, 0x30, 0x30, 0x20, 0xC0, 0x3E, 0x18, 0x30, 0xC3,
  0x0C, 0x3F, 0x00, 0x1E, 0x20, 0xC1, 0x83, 0x04, 0x30, 0x30, 0x60, 0xC1,
  0x83, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x18, 0x30, 0x60, 0x81,
  0x81, 0x8C, 0x18, 0x30, 0x41, 0x8E, 0x00, 0xE0, 0x38,
};

const GFXglyph LiberationMono_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 5, 4, 8, 2, -10 },
  { 9, 8, 9, 8, 0, -9 },
  { 18, 8, 11, 8, 0, -10 },
  { 29, 8, 9, 8, 0, -9 },
  { 38, 7, 9, 8, 0, -9 },
  { 46, 2, 4, 8, 4, -10 },
  { 47, 5, 13, 8, 2, -10 },
  { 56, 5, 13, 8, 1, -10 },
  { 65, 5, 5, 8, 2, -10 },
  { 69, 6, 7, 8, 1, -8 },
  { 75, 3, 4, 8, 1, -2 },
  { 77, 4, 1, 8, 2, -4 },
  { 78, 3, 2, 8, 2, -2 },
  { 79, 8, 10, 8, 0, -10 },
  { 89, 6, 9, 8, 1, -9 },
  { 96, 7, 9, 8, 0, -9 },
  { 104, 8, 9, 8, 0, -9 },
  { 113, 8, 9, 8, 0, -9 },
  { 122, 7, 9, 8, 0, -9 },
  { 130, 8, 9, 8, 0, -9 },
  { 139, 6, 9, 8, 1, -9 },
  { 146, 7, 9, 8, 1, -9 },
  { 154, 8, 9, 8, 0, -9 },
  { 163, 6, 9, 8, 1, -9 },
  { 170, 3, 7, 8, 2, -7 },
  { 173, 5, 9, 8, 1, -7 },
  { 179, 6, 7, 8, 1, -8 },
  { 185, 6, 5, 8, 1, -7 },
  { 189, 6, 7, 8, 1, -8 },
  { 195, 7, 9, 8, 1, -9 },
  { 203, 8, 12, 8, 0, -10 },
  { 215, 8, 9, 8, -1, -9 },
  { 224, 8, 9, 8, 0, -9 },
  { 233, 7, 9, 8, 1, -9 },
  { 241, 8, 9, 8, 0, -9 },
  { 250, 8, 9, 8, 0, -9 },
  { 259, 8, 9, 8, 0, -9 },
  { 268, 7, 9, 8, 1, -9 },
  { 276, 8, 9, 8, 0, -9 },
  { 285, 8, 9, 8, 0, -9 },
  { 294, 7, 9, 8, 0, -9 },
  { 302, 9, 9, 8, 0, -9 },
  { 313, 6, 9, 8, 1, -9 },
  { 320, 8, 9, 8, 0, -9 },
  { 329, 8, 9, 8, 0, -9 },
  { 338, 8, 9, 8, 0, -9 },
  { 347, 8, 9, 8, 0, -9 },
  { 356, 8, 12, 8, 0, -9 },
  { 368, 8, 9, 8, 0, -9 },
  { 377, 8, 9, 8, 0, -9 },
  { 386, 7, 9, 8, 1, -9 },
  { 394, 7, 9, 8, 1, -9 },
  { 402, 8, 9, 8, 1, -9 },
  { 411, 8, 9, 8, 1, -9 },
  { 420, 10, 9, 8, -1, -9 },
  { 432, 8, 9, 8, 1, -9 },
  { 441, 8, 9, 8, 0, -9 },
  { 450, 6, 13, 8, 1, -10 },
  { 460, 5, 10, 8, 2, -10 },
  { 467, 7, 13, 8, 0, -10 },
  { 479, 7, 6, 8, 0, -9 },
  { 485, 8, 1, 8, -1, 1 },
  { 486, 3, 2, 8, 3, -10 },
  { 487, 7, 7, 8, 0, -7 },
  { 494, 7, 10, 8, 0, -10 },
  { 503, 6, 7, 8, 1, -7 },
  { 509, 8, 10, 8, 0, -10 },
  { 519, 6, 7, 8, 1, -7 },
  { 525, 7, 10, 8, 1, -10 },
  { 534, 8, 10, 8, 0, -7 },
  { 544, 7, 10, 8, 0, -10 },
  { 553, 7, 10, 8, 0, -10 },
  { 562, 7, 13, 8, 0, -10 },
  { 574, 8, 10, 8, 0, -10 },
  { 584, 7, 10, 8, 0, -10 },
  { 593, 8, 7, 8, 0, -7 },
  { 600, 7, 7, 8, 0, -7 },
  { 607, 7, 7, 8, 0, -7 },
  { 614, 7, 10, 8, 0, -7 },
  { 623, 8, 10, 8, 0, -7 },
  { 633, 7, 7, 8, 1, -7 },
  { 640, 7, 7, 8, 0, -7 },
  { 647, 6, 9, 8, 1, -9 },
  { 654, 7, 7, 8, 1, -7 },
  { 661, 7, 7, 8, 1, -7 },
  { 668, 7, 7, 8, 1, -7 },
  { 675, 8, 7, 8, 0, -7 },
  { 682, 8, 10, 8, 0, -7 },
  { 692, 7, 7, 8, 0, -7 },
  { 699, 7, 13, 8, 1, -10 },
  { 711, 2, 13, 8, 3, -10 },
  { 715, 7, 13, 8, 0, -10 },
  { 727, 7, 2, 8, 1, -5 },
};

const GFXfont LiberationMono_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic13pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _LIBERATIONMONO_BOLDITALIC13PT7B_H_
