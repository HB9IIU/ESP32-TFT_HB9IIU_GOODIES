#ifndef _LIBERATIONMONO_BOLDITALIC24PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xC0, 0x00,
  0x0E, 0x1C, 0x78, 0x73, 0xDC, 0xE7, 0x39, 0x8E, 0xE3, 0xB8, 0xCE, 0x33,
  0x9C, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x60, 0x10, 0xC3, 0xFF, 0xE7, 0xFF,
  0x83, 0x0C, 0x06, 0x30, 0x08, 0x60, 0x30, 0x81, 0xFF, 0xE7, 0xFF, 0xC3,
  0x08, 0x04, 0x30, 0x18, 0x40, 0x31, 0x80, 0x00, 0x40, 0x01, 0x00, 0x3F,
  0x03, 0xFE, 0x1E, 0xBC, 0x72, 0x73, 0x88, 0x0F, 0x60, 0x1F, 0x80, 0x7F,
  0xC0, 0x7F, 0x80, 0x5E, 0x03, 0x3B, 0xCC, 0xE7, 0x23, 0x9C, 0x9C, 0x7F,
  0xE0, 0x7E, 0x00, 0x60, 0x01, 0x00, 0x0F, 0x03, 0x0F, 0xC3, 0x0E, 0x63,
  0x06, 0x33, 0x83, 0x19, 0x81, 0x99, 0x80, 0xFD, 0x80, 0x3D, 0x80, 0x01,
  0xBC, 0x01, 0xBF, 0x01, 0x99, 0x81, 0x98, 0xC0, 0xCC, 0x60, 0xC6, 0x60,
  0xC3, 0xF0, 0xC0, 0xF0, 0x01, 0xE0, 0x1F, 0xC0, 0xE3, 0x03, 0x8C, 0x0E,
  0x70, 0x3F, 0x80, 0xFC, 0x07, 0xC6, 0x3F, 0x39, 0xDC, 0xEE, 0x3F, 0x38,
  0xF8, 0xE1, 0xE3, 0x8F, 0x8F, 0xFF, 0x8F, 0x8E, 0x77, 0xEE, 0xEE, 0xCC,
  0x07, 0x87, 0x83, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03,
  0x80, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x81,
  0xC0, 0xF0, 0x38, 0x1C, 0x00, 0x0E, 0x06, 0x13, 0x3F, 0xFF, 0xF1, 0xE1,
  0xF9, 0xCE, 0x44, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F,
  0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x1E, 0x38,
  0xF1, 0xC7, 0x0E, 0x18, 0x60, 0x7F, 0x7E, 0x77, 0x7F, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x1C, 0x70, 0xF3,
  0x87, 0xBC, 0x3D, 0xDD, 0xEE, 0xEE, 0x77, 0x77, 0x83, 0xBC, 0x3D, 0xE1,
  0xCF, 0x0E, 0x38, 0xE1, 0xFE, 0x07, 0xC0, 0x01, 0xC0, 0x3C, 0x0F, 0xC3,
  0xFC, 0x33, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0xE3,
  0xC7, 0x0F, 0x1C, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x07,
  0xE0, 0xFF, 0x8F, 0x1E, 0x70, 0xF1, 0x87, 0x80, 0x38, 0x03, 0xC0, 0xF8,
  0x07, 0xC0, 0x07, 0x80, 0x3D, 0xC1, 0xEE, 0x0F, 0x78, 0xF1, 0xFF, 0x07,
  0xE0, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xF0, 0x1D, 0xC0,
  0xE7, 0x07, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0xFF, 0xBF, 0xFE, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x1F, 0xF8, 0xFF, 0xCF, 0x00, 0x70, 0x03,
  0x80, 0x1D, 0xE1, 0xFF, 0x8F, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xC1,
  0xEE, 0x0E, 0x78, 0xF1, 0xFE, 0x07, 0xE0, 0x03, 0xE0, 0x7F, 0x87, 0x1E,
  0x70, 0xF3, 0x80, 0x3C, 0x01, 0xDF, 0x0F, 0xFC, 0x78, 0xF3, 0x83, 0xBC,
  0x1C, 0xE1, 0xE7, 0x0E, 0x38, 0xF0, 0xFF, 0x03, 0xE0, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0xE0, 0xFF,
  0x8F, 0x1E, 0x70, 0xF3, 0x87, 0x9C, 0x38, 0xE3, 0xC3, 0xF8, 0x3F, 0xE3,
  0xC7, 0xBC, 0x3D, 0xC1, 0xEE, 0x0F, 0x78, 0xF3, 0xFF, 0x07, 0xE0, 0x07,
  0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0xF7, 0x87, 0xB8, 0x3D, 0xE1, 0xEF, 0x1E,
  0x3F, 0xF0, 0xFB, 0x80, 0x3C, 0x01, 0xCE, 0x1E, 0x78, 0xE1, 0xFE, 0x07,
  0xC0, 0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0xF0, 0x07,
  0x07, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1C, 0x38, 0x38,
  0x70, 0x60, 0xE0, 0xC0, 0x00, 0x10, 0x0F, 0x03, 0xF1, 0xFC, 0xFF, 0x0F,
  0x80, 0xC0, 0x0F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0x30, 0x1F,
  0x07, 0xF3, 0xF8, 0xFE, 0x0F, 0x00, 0xC0, 0x00, 0x0F, 0xC3, 0xFE, 0x78,
  0xFF, 0x07, 0xE0, 0x70, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x01, 0xF0, 0x06, 0x30,
  0x10, 0x30, 0x40, 0x21, 0x9D, 0xE6, 0x6A, 0xC9, 0x9D, 0xB6, 0x3B, 0x6C,
  0x64, 0x90, 0xC9, 0x61, 0x36, 0xC6, 0x6D, 0x8C, 0x9B, 0x33, 0x36, 0xE4,
  0x66, 0x70, 0xC0, 0x00, 0xC0, 0xC1, 0xC3, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x1B, 0x00, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83, 0x8E,
  0x0E, 0x38, 0x7F, 0xE1, 0xFF, 0x8E, 0x0F, 0x38, 0x1D, 0xC0, 0x77, 0x01,
  0xF8, 0x07, 0x1F, 0xF0, 0x7F, 0xF1, 0xC3, 0xC7, 0x0F, 0x1C, 0x3C, 0xF0,
  0xF3, 0xC3, 0x8F, 0xF8, 0x3F, 0xF0, 0xE0, 0xE7, 0x83, 0xDE, 0x0F, 0x78,
  0x39, 0xC1, 0xE7, 0xFF, 0x3F, 0xF0, 0x07, 0xE0, 0x7F, 0x87, 0x1E, 0x70,
  0x77, 0x83, 0xB8, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x11,
  0xE0, 0xEF, 0x0F, 0x38, 0xF1, 0xFF, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xC7, 0x87, 0x0F, 0x1C, 0x3C, 0xF0, 0x73, 0xC3, 0xCE, 0x0F, 0x38, 0x3C,
  0xE0, 0xE7, 0x83, 0x9E, 0x1E, 0x78, 0x71, 0xC7, 0x87, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFE, 0x3F, 0xF8, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE3, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x07, 0xE0,
  0x7F, 0x87, 0x1C, 0x70, 0xF7, 0x83, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF3,
  0xFF, 0x9F, 0xBC, 0x1D, 0xE0, 0xEF, 0x07, 0x38, 0x71, 0xFF, 0x03, 0xE0,
  0x1E, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0xC7, 0x87, 0x8F,
  0xFE, 0x1F, 0xFC, 0x38, 0x78, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0x87, 0x07,
  0x0E, 0x1E, 0x1C, 0x3C, 0x78, 0x78, 0x1F, 0xF9, 0xFF, 0xC0, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x03, 0xFF, 0x9F, 0xF8, 0x03, 0xF8, 0x3F, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x79, 0xC3, 0x8F, 0x1C, 0x79, 0xE1, 0xFE, 0x07, 0xC0, 0x1E, 0x1F,
  0x1E, 0x3E, 0x1C, 0x7C, 0x1C, 0xF8, 0x1D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x79, 0xE0, 0x79, 0xE0, 0x78, 0xF0,
  0x70, 0xF0, 0x70, 0x78, 0xF0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1F, 0xFF, 0xFF, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF9, 0xF1, 0xE3,
  0xE6, 0xC7, 0xCF, 0x8D, 0xFF, 0x1B, 0xEE, 0x76, 0xD8, 0xEF, 0x31, 0xDE,
  0xE3, 0x39, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x38, 0x1E, 0x0E,
  0x3E, 0x38, 0x7C, 0x70, 0xF8, 0xE1, 0xF1, 0xC7, 0x63, 0x8E, 0xEE, 0x1D,
  0xDC, 0x3B, 0xB8, 0x77, 0x71, 0xC6, 0xE3, 0x8D, 0x87, 0x1F, 0x0E, 0x3E,
  0x1C, 0x7C, 0x70, 0xF8, 0x07, 0xE0, 0x7F, 0x8F, 0x1E, 0x70, 0xF7, 0x83,
  0xB8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xB8, 0x1D, 0xC1, 0xEF,
  0x0E, 0x78, 0xE1, 0xFE, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xC3, 0xC7,
  0x07, 0x1C, 0x1C, 0xF0, 0x73, 0xC3, 0xCF, 0x1E, 0x3F, 0xF0, 0xFF, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x7F, 0x87, 0x1E, 0x70, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xF8, 0x1D, 0xC1, 0xEF, 0x0E, 0x78, 0xF1, 0xFF, 0x07, 0xE0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0xF8, 0x3F,
  0xF8, 0x70, 0xF8, 0xE0, 0xF1, 0xC1, 0xC7, 0x83, 0x8F, 0x0E, 0x1F, 0xF8,
  0x3F, 0xC0, 0x73, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x0F, 0x0E, 0x1E, 0x1C,
  0x1E, 0x78, 0x3C, 0x03, 0xF0, 0x3F, 0xE1, 0xE3, 0xCF, 0x07, 0x3C, 0x10,
  0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x03, 0xBC, 0x0E,
  0xF0, 0x39, 0xE1, 0xC7, 0xFE, 0x07, 0xE0, 0xFF, 0xFB, 0xFF, 0xE0, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x1C,
  0x1C, 0x70, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0xC7, 0x07,
  0xF8, 0x0F, 0xC0, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0x70, 0xF1,
  0xC3, 0x87, 0x1E, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x07, 0xB8, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x73, 0x80, 0xE7, 0x31, 0xCE, 0xE7, 0x19, 0xEE, 0x37, 0xDC, 0x6F, 0xB1,
  0xDF, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0x70, 0x70,
  0xE0, 0x0E, 0x07, 0x07, 0x87, 0x83, 0xC7, 0x80, 0xE7, 0x80, 0x7B, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFC,
  0x03, 0xCE, 0x01, 0xC7, 0x81, 0xC3, 0xC1, 0xE0, 0xE1, 0xE0, 0x78, 0xF0,
  0x3F, 0xC1, 0xE7, 0x07, 0x1E, 0x3C, 0x39, 0xE0, 0xE7, 0x03, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x0F, 0xE0, 0xFE,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xFF, 0x0F, 0xE0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07,
  0x03, 0x80, 0x0F, 0xE1, 0xFC, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xE0, 0x1F,
  0x01, 0xDC, 0x0C, 0xE0, 0xE7, 0x0E, 0x18, 0x60, 0xE7, 0x07, 0x70, 0x3B,
  0x00, 0xC0, 0xFF, 0xFE, 0xF1, 0xE1, 0x80, 0x0F, 0xC1, 0xFE, 0x3C, 0xE7,
  0x8F, 0x00, 0xE1, 0xFE, 0x7F, 0xEF, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCF,
  0xFF, 0x78, 0xF0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0xF0,
  0x7F, 0xE1, 0xE7, 0x8F, 0x0E, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E,
  0x78, 0x79, 0xE1, 0xC7, 0xCF, 0x1D, 0xF8, 0x77, 0x80, 0x07, 0xC1, 0xFE,
  0x3C, 0xF7, 0x87, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xEF, 0x0E,
  0xF1, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x0F, 0x38, 0xFF, 0xE3, 0x8F, 0x9E, 0x3C, 0x70, 0x73, 0xC1, 0xCF, 0x0F,
  0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x8F, 0x3E, 0x1F, 0xF8, 0x3D, 0xE0, 0x07,
  0xC1, 0xFE, 0x3C, 0x77, 0x87, 0x70, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x0F, 0x0E, 0xF1, 0xE7, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0xC3, 0xC0,
  0x1C, 0x0F, 0xFF, 0x7F, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0x9C, 0x3F, 0x71, 0xE7, 0xCF, 0x0F, 0x38, 0x38, 0xE0, 0xE7, 0x83, 0x9E,
  0x0E, 0x78, 0x79, 0xE1, 0xC7, 0x8F, 0x0F, 0xDC, 0x1E, 0x70, 0x03, 0xCF,
  0x0E, 0x1C, 0x78, 0x7F, 0xC0, 0xFC, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xCF, 0x0E, 0xFC, 0x78, 0xE7, 0x87, 0x3C, 0x39, 0xC1, 0xCE,
  0x0E, 0x70, 0xF7, 0x87, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x07,
  0xF0, 0x7E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x38,
  0xE1, 0xC3, 0x8E, 0x0E, 0x70, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x1E, 0xE0,
  0x73, 0xC3, 0xCF, 0x0F, 0x1C, 0x38, 0x78, 0xE0, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x1F, 0xFF, 0xFF,
  0xF0, 0x33, 0x9C, 0xDE, 0xF3, 0xBD, 0xDC, 0xE7, 0x73, 0x9D, 0xCE, 0x77,
  0x39, 0xD8, 0xC6, 0xE7, 0x3B, 0x9C, 0xEE, 0x73, 0xB9, 0xCE, 0xC6, 0x30,
  0x1C, 0xF0, 0xEF, 0xCF, 0x8E, 0x78, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xEF,
  0x0F, 0x78, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x00, 0x07, 0xC0,
  0xFF, 0x8E, 0x1C, 0xF0, 0xE7, 0x07, 0xF8, 0x3B, 0xC1, 0xDC, 0x0E, 0xE0,
  0xF7, 0x07, 0x3C, 0x78, 0xFF, 0x83, 0xF0, 0x00, 0x1C, 0xF0, 0x7F, 0xE3,
  0xE7, 0x8F, 0x0E, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x78, 0x79,
  0xE1, 0xC7, 0x8F, 0x1F, 0xF8, 0x77, 0xC3, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x0F, 0x38, 0xFF, 0xCE, 0x3C, 0xF1, 0xE7, 0x07,
  0x78, 0x3B, 0xC3, 0xDC, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0xF9, 0xFF, 0xC7,
  0xDE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x39, 0xF3,
  0xBF, 0x3F, 0xF7, 0xE0, 0x7C, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC1, 0xFF, 0x38, 0x73, 0x87,
  0x78, 0x03, 0xF8, 0x3F, 0xE0, 0x7E, 0x00, 0xEE, 0x0E, 0xE0, 0xEF, 0xFC,
  0x3F, 0x00, 0x0C, 0x07, 0x01, 0x83, 0xFF, 0xFF, 0xCE, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0xF1, 0xFC, 0x38, 0x79,
  0xC3, 0xDE, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0xDE, 0x1C, 0xF0,
  0xE7, 0x8F, 0x3C, 0xB9, 0xFF, 0xC7, 0x9E, 0x00, 0xE0, 0x7F, 0x03, 0xB8,
  0x3D, 0xE1, 0xCF, 0x1E, 0x38, 0xE1, 0xCF, 0x0E, 0x70, 0x77, 0x03, 0xB8,
  0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0x77,
  0x38, 0xCE, 0x73, 0x9D, 0xE7, 0x3B, 0xCC, 0x77, 0xB8, 0xF9, 0xE1, 0xB3,
  0xC3, 0xC7, 0x87, 0x8E, 0x0E, 0x1C, 0x00, 0x1E, 0x0E, 0x0E, 0x1C, 0x0F,
  0x3C, 0x07, 0x78, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1E, 0xF0, 0x1C, 0x70, 0x38, 0x78, 0x70, 0x38, 0x1C, 0x0F, 0x1C,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x3F, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0xFE, 0x0F, 0xC0, 0x3C, 0x0B,
  0xF8, 0xF1, 0xFF, 0x03, 0xC0,
};

const GFXglyph LiberationMono_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 16, 14, 4, -16 },
  { 15, 10, 8, 14, 4, -17 },
  { 25, 15, 16, 14, 0, -16 },
  { 55, 14, 20, 14, 0, -18 },
  { 90, 17, 16, 14, -1, -16 },
  { 124, 14, 16, 14, 0, -16 },
  { 152, 4, 8, 14, 7, -17 },
  { 156, 9, 22, 14, 4, -17 },
  { 181, 10, 22, 14, 1, -17 },
  { 209, 9, 9, 14, 4, -17 },
  { 220, 12, 12, 14, 1, -14 },
  { 238, 7, 8, 14, 1, -4 },
  { 245, 8, 2, 14, 3, -8 },
  { 247, 4, 4, 14, 4, -4 },
  { 249, 15, 17, 14, 0, -17 },
  { 281, 13, 16, 14, 1, -16 },
  { 307, 12, 16, 14, 1, -16 },
  { 331, 14, 16, 14, 0, -16 },
  { 359, 13, 16, 14, 1, -16 },
  { 385, 14, 16, 14, 0, -16 },
  { 413, 13, 16, 14, 1, -16 },
  { 439, 13, 16, 14, 1, -16 },
  { 465, 12, 16, 14, 3, -16 },
  { 489, 13, 16, 14, 1, -16 },
  { 515, 13, 16, 14, 1, -16 },
  { 541, 6, 13, 14, 4, -13 },
  { 551, 8, 17, 14, 2, -13 },
  { 568, 12, 13, 14, 1, -14 },
  { 588, 12, 8, 14, 1, -12 },
  { 600, 12, 13, 14, 1, -14 },
  { 620, 12, 16, 14, 2, -16 },
  { 644, 15, 20, 14, 0, -17 },
  { 682, 14, 16, 14, -1, -16 },
  { 710, 14, 16, 14, 0, -16 },
  { 738, 13, 16, 14, 1, -16 },
  { 764, 14, 16, 14, 0, -16 },
  { 792, 15, 16, 14, 0, -16 },
  { 822, 14, 16, 14, 1, -16 },
  { 850, 13, 16, 14, 1, -16 },
  { 876, 15, 16, 14, 0, -16 },
  { 906, 13, 16, 14, 1, -16 },
  { 932, 13, 16, 14, 1, -16 },
  { 958, 16, 16, 14, 0, -16 },
  { 990, 11, 16, 14, 1, -16 },
  { 1012, 15, 16, 14, 0, -16 },
  { 1042, 15, 16, 14, 0, -16 },
  { 1072, 13, 16, 14, 1, -16 },
  { 1098, 14, 16, 14, 0, -16 },
  { 1126, 13, 21, 14, 1, -16 },
  { 1161, 15, 16, 14, 0, -16 },
  { 1191, 14, 16, 14, 0, -16 },
  { 1219, 14, 16, 14, 2, -16 },
  { 1247, 14, 16, 14, 1, -16 },
  { 1275, 14, 16, 14, 2, -16 },
  { 1303, 15, 16, 14, 1, -16 },
  { 1333, 17, 16, 14, -1, -16 },
  { 1367, 14, 16, 14, 2, -16 },
  { 1395, 15, 16, 14, 0, -16 },
  { 1425, 12, 22, 14, 2, -17 },
  { 1458, 9, 17, 14, 3, -17 },
  { 1478, 11, 22, 14, 1, -17 },
  { 1509, 13, 10, 14, 0, -17 },
  { 1526, 15, 1, 14, -2, 1 },
  { 1528, 6, 3, 14, 6, -17 },
  { 1531, 12, 13, 14, 1, -13 },
  { 1551, 14, 17, 14, 0, -17 },
  { 1581, 12, 13, 14, 1, -13 },
  { 1601, 14, 17, 14, 1, -17 },
  { 1631, 12, 13, 14, 1, -13 },
  { 1651, 13, 17, 14, 2, -17 },
  { 1679, 14, 18, 14, 0, -13 },
  { 1711, 13, 17, 14, 0, -17 },
  { 1739, 13, 17, 14, 0, -17 },
  { 1767, 13, 22, 14, -1, -17 },
  { 1803, 14, 17, 14, 1, -17 },
  { 1833, 13, 17, 14, 0, -17 },
  { 1861, 14, 13, 14, 0, -13 },
  { 1884, 13, 13, 14, 0, -13 },
  { 1906, 13, 13, 14, 1, -13 },
  { 1928, 14, 18, 14, 0, -13 },
  { 1960, 13, 18, 14, 1, -13 },
  { 1990, 12, 13, 14, 2, -13 },
  { 2010, 12, 13, 14, 1, -13 },
  { 2030, 10, 16, 14, 3, -16 },
  { 2050, 13, 13, 14, 1, -13 },
  { 2072, 13, 13, 14, 2, -13 },
  { 2094, 15, 13, 14, 1, -13 },
  { 2119, 16, 13, 14, -1, -13 },
  { 2145, 16, 18, 14, -1, -13 },
  { 2181, 13, 13, 14, 0, -13 },
  { 2203, 12, 22, 14, 2, -17 },
  { 2236, 3, 22, 14, 6, -17 },
  { 2245, 12, 22, 14, 0, -17 },
  { 2278, 13, 4, 14, 1, -10 },
};

const GFXfont LiberationMono_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic24pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _LIBERATIONMONO_BOLDITALIC24PT7B_H_
