#ifndef _LIBERATIONMONO_BOLDITALIC71PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x1C, 0xFF, 0xF0,
  0x07, 0xFE, 0x1E, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0x07, 0xFE, 0x03, 0xFE,
  0x07, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xC0,
  0x7F, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0xFF,
  0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x81, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xE0, 0x3F, 0xE0, 0x0F, 0x00, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x78, 0x07, 0xFC, 0x7F,
  0xE0, 0x3C, 0x07, 0xFC, 0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x0F, 0xFC, 0x0F,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x03, 0xFF, 0x03, 0xFF, 0xE7, 0x8F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xC0,
  0x00, 0x07, 0xF9, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0x81, 0xFF, 0xBF, 0xC0, 0x3F, 0x81, 0xFF, 0x9F, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0xF8, 0x1F, 0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x81, 0xFF, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF0, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xFF,
  0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x07,
  0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x06,
  0x07, 0xF0, 0x31, 0xF0, 0xFC, 0x1E, 0x3F, 0x9F, 0x9F, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0x01, 0xF0, 0x0F, 0x80,
  0x1E, 0x01, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x3F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x1F, 0xE3, 0xFF,
  0x1F, 0xF0, 0xFF, 0x1F, 0xF9, 0xFF, 0x87, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F,
  0x87, 0xFE, 0x7F, 0xE1, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F, 0xE3, 0xFF, 0x1F,
  0xF0, 0xFF, 0x1F, 0xF9, 0xFF, 0x87, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0x87,
  0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0xC7, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF0, 0x3F, 0xF0, 0x01,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFF,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0xFC, 0x03, 0xFE, 0x7F,
  0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F,
  0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0xE1, 0xFF,
  0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xFC, 0x79, 0xE0,
  0x0F, 0x80, 0xFF, 0xCF, 0x9E, 0x01, 0xF0, 0x3F, 0xFC, 0xF9, 0xF0, 0x1E,
  0x07, 0xE1, 0xFF, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0xF1, 0xE0, 0x3E, 0x0F,
  0x80, 0xFF, 0x1E, 0x07, 0xC1, 0xF0, 0x0F, 0xE1, 0xE0, 0x7C, 0x3F, 0x00,
  0xFE, 0x1E, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xE0, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x0F, 0x07, 0xC0, 0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x01, 0xF8, 0x3E,
  0x1F, 0x0F, 0x80, 0x1F, 0x83, 0xC1, 0xF1, 0xF8, 0x01, 0xF0, 0x3C, 0x3E,
  0x1F, 0x00, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x03, 0xF0, 0x7C, 0x3E, 0x3F,
  0x00, 0x3E, 0x07, 0x83, 0xE3, 0xE0, 0x03, 0xE0, 0x78, 0x3C, 0x3E, 0x00,
  0x7E, 0x0F, 0x87, 0xC7, 0xE0, 0x07, 0xC0, 0xF8, 0x7C, 0x7E, 0x00, 0xFC,
  0x0F, 0x07, 0xC7, 0xC0, 0x0F, 0x81, 0xF0, 0x7C, 0x7C, 0x00, 0xF8, 0x1E,
  0x07, 0x87, 0xC0, 0x1F, 0x81, 0xE0, 0x78, 0x7C, 0x03, 0xF0, 0x3C, 0x0F,
  0x87, 0xC0, 0x3F, 0x03, 0xC0, 0xF8, 0x7C, 0x07, 0xF0, 0x78, 0x0F, 0x87,
  0xC0, 0xFF, 0x0F, 0x80, 0xF8, 0x7C, 0x1E, 0xE0, 0xF0, 0x0F, 0x87, 0xE3,
  0xCF, 0x3E, 0x00, 0xF8, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0x83, 0xFF, 0x0F,
  0xF8, 0x00, 0x7C, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0xC0, 0x00, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0xFE, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xF3, 0xFF,
  0x01, 0xFF, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFE,
  0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x07, 0xEF, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x1F, 0xBF, 0x80, 0x3F,
  0xDF, 0xC1, 0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x0F, 0xDF, 0xE0, 0x0F, 0xF7,
  0xF0, 0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0x87, 0xE7, 0xF8, 0x03, 0xF9, 0xFC,
  0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE3, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x3F,
  0x9F, 0xE0, 0x0F, 0xF3, 0xF9, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xCF, 0xC7,
  0xF8, 0x03, 0xF8, 0xFE, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF7, 0xE1, 0xFC,
  0x01, 0xFE, 0x1F, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0x00,
  0x7F, 0x87, 0xFF, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFF, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF7, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x3F,
  0xC0, 0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x3F, 0xE0, 0x1F, 0xF3, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0xC7, 0xF8, 0x7F, 0xC0, 0x1F, 0xF1, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x83, 0xFC,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xCF, 0xF8,
  0x07, 0xFC, 0x0F, 0xF3, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0xBF, 0xC0, 0x1F, 0xF0, 0x1F, 0xEF, 0xF0, 0x07, 0xFC, 0x07,
  0xFB, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0,
  0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F,
  0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFF, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0x80,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFF,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0x7F,
  0x80, 0x7F, 0x87, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xF0, 0xFF, 0x80,
  0x7F, 0x8F, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0xF8, 0xFF, 0x00, 0xFF,
  0x9F, 0xFF, 0x9F, 0xF0, 0x0F, 0xF9, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xBF,
  0xBF, 0x9F, 0xE0, 0x0F, 0xFB, 0xFB, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x3F,
  0xBF, 0xC0, 0x0F, 0xF7, 0xF3, 0xFB, 0xFC, 0x00, 0xFF, 0x7E, 0x3F, 0xBF,
  0x80, 0x0F, 0xFF, 0xE3, 0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xF9, 0xFF,
  0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xFC,
  0x00, 0xFF, 0xCF, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xF8,
  0x7F, 0xF8, 0x07, 0xFD, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFF, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0xFC, 0x00, 0xFF, 0x87,
  0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x7F,
  0xC0, 0x00, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xE7, 0xFE, 0x00,
  0x3F, 0xFF, 0xE3, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x02, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xFF, 0xEF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFF, 0x87,
  0xFC, 0x00, 0x0F, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0xFC, 0x01,
  0xFF, 0x9F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFC, 0x00, 0x03,
  0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x87, 0xF8, 0x1F, 0xF0, 0x07, 0xF3, 0xFF, 0x87, 0xFF, 0x00, 0xFE,
  0x7F, 0xF1, 0xFF, 0xF0, 0x3F, 0xDF, 0xFE, 0x7F, 0xFE, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xC0, 0xFE, 0xE7, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE7, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F,
  0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x9F, 0xFF,
  0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF,
  0x00, 0xFF, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFE,
  0x00, 0x7F, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xE1, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF,
  0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x60, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x07,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0x3F,
  0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x07,
  0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xFF,
  0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x7E, 0x1F,
  0xC0, 0x3F, 0x87, 0xEF, 0xC7, 0xF8, 0x0F, 0xF1, 0xF9, 0xF8, 0xFE, 0x01,
  0xFE, 0x3F, 0x3F, 0x1F, 0xC0, 0x3F, 0xCF, 0xC7, 0xE7, 0xF8, 0x07, 0xF9,
  0xF8, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC3,
  0xF7, 0xF8, 0x03, 0xFB, 0xF0, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x0F, 0xDF,
  0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x13, 0xFF, 0xFF,
  0xF8, 0x07, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x78, 0x03, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00,
};

const GFXglyph LiberationMono_BoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 19, 47, 43, 13, -47 },
  { 113, 28, 22, 43, 12, -51 },
  { 190, 42, 47, 43, 1, -47 },
  { 437, 41, 59, 43, 1, -53 },
  { 740, 48, 49, 43, -2, -48 },
  { 1034, 41, 48, 43, -1, -47 },
  { 1280, 12, 22, 43, 20, -51 },
  { 1313, 27, 66, 43, 11, -51 },
  { 1536, 28, 66, 43, 4, -51 },
  { 1767, 27, 26, 43, 12, -51 },
  { 1855, 36, 36, 43, 3, -41 },
  { 2017, 21, 23, 43, 3, -10 },
  { 2078, 22, 8, 43, 10, -23 },
  { 2100, 12, 11, 43, 13, -11 },
  { 2117, 47, 52, 43, -1, -51 },
  { 2423, 37, 49, 43, 4, -48 },
  { 2650, 35, 47, 43, 2, -47 },
  { 2856, 40, 48, 43, 1, -48 },
  { 3096, 39, 49, 43, 2, -48 },
  { 3335, 39, 47, 43, 1, -47 },
  { 3565, 40, 48, 43, 2, -47 },
  { 3805, 37, 49, 43, 4, -48 },
  { 4032, 35, 47, 43, 8, -47 },
  { 4238, 39, 49, 43, 2, -48 },
  { 4477, 37, 49, 43, 3, -48 },
  { 4704, 17, 38, 43, 13, -38 },
  { 4785, 25, 51, 43, 5, -38 },
  { 4945, 36, 39, 43, 3, -43 },
  { 5121, 36, 27, 43, 3, -37 },
  { 5243, 36, 39, 43, 3, -43 },
  { 5419, 37, 48, 43, 5, -48 },
  { 5641, 44, 61, 43, 0, -51 },
  { 5977, 43, 47, 43, -4, -47 },
  { 6230, 41, 47, 43, 1, -47 },
  { 6471, 40, 49, 43, 3, -48 },
  { 6716, 41, 47, 43, 1, -47 },
  { 6957, 43, 47, 43, 1, -47 },
  { 7210, 42, 47, 43, 2, -47 },
  { 7457, 38, 49, 43, 3, -48 },
  { 7690, 42, 47, 43, 1, -47 },
  { 7937, 41, 47, 43, 2, -47 },
  { 8178, 38, 48, 43, 3, -47 },
  { 8406, 46, 47, 43, 1, -47 },
  { 8677, 33, 47, 43, 4, -47 },
  { 8871, 45, 47, 43, 0, -47 },
  { 9136, 42, 47, 43, 1, -47 },
  { 9383, 39, 49, 43, 3, -48 },
  { 9622, 42, 47, 43, 1, -47 },
  { 9869, 39, 62, 43, 3, -48 },
  { 10172, 42, 47, 43, 1, -47 },
  { 10419, 42, 49, 43, 0, -48 },
  { 10677, 40, 47, 43, 6, -47 },
  { 10912, 40, 48, 43, 4, -47 },
  { 11152, 42, 47, 43, 6, -47 },
  { 11399, 44, 47, 43, 4, -47 },
  { 11658, 51, 47, 43, -4, -47 },
  { 11958, 42, 47, 43, 6, -47 },
  { 12205, 44, 47, 43, -1, -47 },
  { 12464, 34, 66, 43, 6, -51 },
  { 12745, 27, 52, 43, 9, -51 },
  { 12921, 34, 66, 43, 2, -51 },
  { 13202, 39, 31, 43, 1, -49 },
  { 13354, 43, 3, 43, -5, 4 },
  { 13371, 16, 10, 43, 18, -51 },
  { 13391, 36, 40, 43, 2, -39 },
  { 13571, 39, 52, 43, 1, -51 },
  { 13825, 37, 40, 43, 3, -39 },
  { 14010, 41, 52, 43, 3, -51 },
  { 14277, 37, 40, 43, 3, -39 },
  { 14462, 39, 52, 43, 6, -52 },
  { 14716, 41, 54, 43, 1, -39 },
  { 14993, 39, 51, 43, 1, -51 },
  { 15242, 37, 51, 43, 0, -51 },
  { 15478, 38, 66, 43, -2, -51 },
  { 15792, 41, 51, 43, 2, -51 },
  { 16054, 37, 51, 43, 0, -51 },
  { 16290, 43, 39, 43, -1, -39 },
  { 16500, 39, 39, 43, 1, -39 },
  { 16691, 37, 40, 43, 3, -39 },
  { 16876, 41, 54, 43, -1, -39 },
  { 17153, 38, 54, 43, 3, -39 },
  { 17410, 36, 39, 43, 5, -39 },
  { 17586, 37, 40, 43, 2, -39 },
  { 17771, 30, 49, 43, 8, -48 },
  { 17955, 38, 39, 43, 3, -38 },
  { 18141, 40, 38, 43, 5, -38 },
  { 18331, 43, 38, 43, 3, -38 },
  { 18536, 46, 38, 43, -2, -38 },
  { 18755, 46, 53, 43, -1, -38 },
  { 19060, 38, 38, 43, 1, -38 },
  { 19241, 37, 66, 43, 6, -51 },
  { 19547, 9, 67, 43, 17, -51 },
  { 19623, 36, 66, 43, 0, -51 },
  { 19920, 38, 11, 43, 3, -29 },
};

const GFXfont LiberationMono_BoldItalic71pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic71pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic71pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _LIBERATIONMONO_BOLDITALIC71PT7B_H_
