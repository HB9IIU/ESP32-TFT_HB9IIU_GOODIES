#ifndef _LIBERATIONMONO_BOLDITALIC53PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC,
  0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xFC, 0x67, 0xFC, 0x1F, 0xE3, 0x8F, 0xF0, 0x7F, 0x0E,
  0x1F, 0xC1, 0xF8, 0x38, 0x7F, 0x0F, 0xE0, 0xE1, 0xE0, 0x3F, 0x83, 0x80,
  0x00, 0xFE, 0x0C, 0x00, 0x03, 0xFC, 0x70, 0x00, 0x0F, 0xFD, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0x3F, 0xF0, 0x00, 0x1C, 0x3F, 0xC0, 0x00, 0x70,
  0x7F, 0x00, 0x01, 0xC1, 0xFC, 0x1E, 0x07, 0x07, 0xF3, 0xF8, 0x1C, 0x1F,
  0xCF, 0xE0, 0xE0, 0x7F, 0x3F, 0x83, 0x83, 0xF8, 0xFF, 0x0E, 0x1F, 0xE1,
  0xFF, 0x39, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x0F,
  0xFF, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x03, 0xC0, 0x7C, 0x7C, 0x00, 0xF0,
  0x1F, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x78, 0x1E, 0x03,
  0xE0, 0x1F, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x3E, 0x00, 0x7C, 0x1F,
  0x0F, 0x80, 0x0F, 0x83, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x78, 0x00, 0x3E,
  0x3F, 0x1E, 0x00, 0x07, 0xFF, 0xC7, 0x80, 0x00, 0x7F, 0xF1, 0xF0, 0x00,
  0x07, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3C, 0x7F, 0xE0, 0x00, 0x0F,
  0x1F, 0xFC, 0x00, 0x03, 0xC7, 0xFF, 0xC0, 0x00, 0xF1, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0x81, 0xF0, 0x07, 0x80, 0xF0,
  0x3C, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x03, 0xC1, 0xF0, 0x1F, 0x00,
  0x7C, 0x7C, 0x07, 0xC0, 0x0F, 0xFF, 0x81, 0xF0, 0x01, 0xFF, 0xE0, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x03, 0xC0, 0xFF, 0xF8, 0x0F, 0x87, 0xFF, 0xE0, 0x7E, 0x3F,
  0xDF, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x3E, 0x3F, 0x83,
  0xF9, 0xF8, 0xFC, 0x07, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0x0F, 0xC0, 0x3F,
  0xF8, 0x3F, 0x00, 0x7F, 0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xFC,
  0x0F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0xF0, 0x7F, 0x81, 0xFE, 0x00, 0x7E, 0x3F,
  0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x03, 0x8F, 0x86, 0x7E, 0xFB, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0x3E, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x87, 0xC1, 0xF0, 0x38, 0x1C,
  0x01, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0x9F, 0xDF, 0xEF,
  0xF7, 0xFB, 0xF9, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC,
  0xFC, 0x7F, 0x7F, 0x1F, 0x9F, 0xEF, 0xE3, 0xF3, 0xFD, 0xFC, 0x7C, 0x7F,
  0x3F, 0x8F, 0x8F, 0xEF, 0xF3, 0xF1, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80,
  0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFE, 0x03,
  0xFC, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1C,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFE, 0x01,
  0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x07, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0x7F, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7E,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x03,
  0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF7, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE7, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xF3,
  0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFE,
  0x03, 0xFF, 0x9F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0xFF,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xCF, 0xFC, 0x0F, 0xF9, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x78, 0x07, 0x03, 0x81, 0xFC, 0xF7,
  0x07, 0x83, 0xFE, 0xF7, 0x07, 0x07, 0x8F, 0xE7, 0x0F, 0x0F, 0x07, 0xE7,
  0x0E, 0x1E, 0x07, 0xC7, 0x1E, 0x3C, 0x07, 0xC7, 0x1E, 0x3C, 0x07, 0x87,
  0x1C, 0x78, 0x07, 0x8F, 0x3C, 0x78, 0x0F, 0x8F, 0x3C, 0xF0, 0x0F, 0x0E,
  0x38, 0xF0, 0x0F, 0x0E, 0x78, 0xF0, 0x1E, 0x1E, 0x79, 0xE0, 0x1E, 0x1E,
  0x79, 0xE0, 0x1E, 0x1C, 0x71, 0xE0, 0x3C, 0x3C, 0x71, 0xE0, 0x3C, 0x38,
  0x71, 0xE0, 0x78, 0x38, 0xF3, 0xC0, 0x78, 0x78, 0xF3, 0xE0, 0xF8, 0x70,
  0xF1, 0xE1, 0xB8, 0xE0, 0xF1, 0xE3, 0xB9, 0xE0, 0xF1, 0xFF, 0x3F, 0xC0,
  0xF0, 0xFE, 0x3F, 0x80, 0xF0, 0x78, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0x07, 0xF8, 0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3E, 0x0F, 0xF0, 0x00,
  0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x01, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F,
  0xE0, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xFF, 0x9F, 0xE0, 0xFF, 0xFC,
  0xFE, 0x07, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x7F, 0x83, 0xFF, 0xF3, 0xFC,
  0x1F, 0xFF, 0x9F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x7F, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xEF, 0x87, 0xDF, 0x01, 0xF7, 0xC3, 0xEF, 0x81, 0xFB, 0xE3, 0xEF, 0xC0,
  0xFD, 0xF9, 0xF7, 0xE0, 0x7E, 0xFD, 0xF3, 0xF0, 0x3F, 0x7E, 0xF9, 0xF8,
  0x1F, 0x3F, 0x7C, 0xF8, 0x1F, 0x8F, 0xFC, 0xFC, 0x0F, 0xC7, 0xFE, 0x7E,
  0x07, 0xE3, 0xDE, 0x3F, 0x03, 0xF1, 0xFF, 0x1F, 0x81, 0xF0, 0xFF, 0x0F,
  0x81, 0xF8, 0x7F, 0x8F, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x7E, 0x07, 0xFE, 0x01, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x1F,
  0xF8, 0x07, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0xFF, 0xE0, 0x1F, 0x81, 0xFF,
  0xC0, 0x7F, 0x03, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0x03, 0xF8, 0x1F, 0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x1F, 0xC0, 0xFD, 0xFC,
  0x3F, 0x81, 0xF9, 0xF8, 0x7F, 0x03, 0xF3, 0xF0, 0xFE, 0x07, 0xE7, 0xE1,
  0xF8, 0x1F, 0xCF, 0xC3, 0xF0, 0x3F, 0x9F, 0xCF, 0xE0, 0x7F, 0x1F, 0x9F,
  0xC0, 0xFC, 0x3F, 0x3F, 0x81, 0xF8, 0x7E, 0x7E, 0x07, 0xF0, 0xFC, 0xFC,
  0x0F, 0xE1, 0xF9, 0xF8, 0x1F, 0xC1, 0xFB, 0xF0, 0x3F, 0x03, 0xFF, 0xE0,
  0x7E, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x1F, 0xFE, 0x07,
  0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0x7F,
  0x00, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0x81, 0xFC, 0x03, 0xFF, 0x03, 0xF8,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x83, 0xFC, 0x01,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8,
  0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFE, 0x01, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x0F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE,
  0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x03, 0xF0, 0xFE,
  0x1F, 0x81, 0xF8, 0xFF, 0x0F, 0xC1, 0xFC, 0x7F, 0x8F, 0xC0, 0xFE, 0x7F,
  0xC7, 0xE0, 0x7F, 0x3F, 0xE3, 0xF0, 0x3F, 0xBF, 0xF3, 0xF0, 0x1F, 0x9F,
  0xFD, 0xF8, 0x0F, 0xDF, 0xBE, 0xFC, 0x07, 0xEF, 0x9F, 0xFC, 0x03, 0xF7,
  0xCF, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xE0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0x7F, 0xE7, 0xFF, 0xE3, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0xFE, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xF8,
  0x01, 0xFE, 0x3F, 0xF0, 0x0F, 0xE7, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xF0,
  0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xE0, 0x7F, 0x83,
  0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0xFC, 0x0F, 0xF3,
  0xFF, 0xC0, 0x7F, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xF0, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC7,
  0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFF,
  0x1F, 0xE0, 0x0F, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0x7F, 0x00, 0xFF, 0xFE,
  0xFE, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xFD, 0xFC, 0x03, 0xFF,
  0xFB, 0xF8, 0x03, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFC,
  0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE3, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xF8, 0x00, 0x7E, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xE3, 0xF8, 0x03, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFF, 0xDF, 0xC0, 0x7F, 0xC3, 0xFF, 0x81, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0xDF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0x00, 0x3F, 0xF1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x1E, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x3F,
  0xF8, 0x0F, 0xE3, 0xFF, 0xE0, 0x7F, 0x3F, 0xFF, 0x03, 0xFB, 0xFF, 0xF8,
  0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE,
  0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xDF, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x7C, 0x07, 0xE7, 0xF0, 0xFF, 0x07, 0xEF,
  0xF9, 0xFF, 0x07, 0xFF, 0xFB, 0xFF, 0x07, 0xDF, 0xFF, 0xFF, 0x07, 0xF9,
  0xFE, 0x3F, 0x07, 0xF1, 0xFE, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0xFC, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x87, 0xFF, 0x01, 0xFC, 0x7F, 0xF8, 0x0F, 0xE7, 0xFF,
  0xE0, 0x7F, 0x7F, 0xFF, 0x07, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x1F, 0xE1,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0x1F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03,
  0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x7F,
  0xE0, 0x07, 0xF3, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x7F,
  0xFE, 0x01, 0xFE, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xC0,
  0x7F, 0xF9, 0xFE, 0x07, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0x7F, 0x07, 0xFC,
  0x3F, 0xF8, 0x3F, 0xC0, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F,
  0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFD, 0xFE, 0x01, 0xFF, 0x8F,
  0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFC, 0x3F, 0xFC,
  0x3F, 0x8F, 0xFF, 0x07, 0xF3, 0xFF, 0xE0, 0xFE, 0xFF, 0xFC, 0x1F, 0xDF,
  0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x02, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x83,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0x03, 0xFF,
  0xF3, 0xF8, 0x0F, 0xFF, 0x1F, 0xC0, 0x7F, 0xF1, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0xC1, 0xF8, 0x7C,
  0x1F, 0xC1, 0xF8, 0x7C, 0x1F, 0xC1, 0xF0, 0x7C, 0x3F, 0xC3, 0xF0, 0x7C,
  0x3F, 0xC3, 0xF0, 0x7C, 0x7F, 0xE3, 0xE0, 0x7C, 0x7F, 0xE7, 0xE0, 0x7C,
  0xFB, 0xE7, 0xE0, 0x7C, 0xFB, 0xE7, 0xC0, 0x7D, 0xF3, 0xEF, 0xC0, 0x7D,
  0xF1, 0xEF, 0x80, 0xFF, 0xE1, 0xEF, 0x80, 0xFF, 0xC1, 0xEF, 0x80, 0xFF,
  0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 15, 35, 32, 9, -35 },
  { 67, 21, 17, 32, 9, -38 },
  { 112, 31, 35, 32, 1, -35 },
  { 248, 30, 43, 32, 1, -39 },
  { 410, 35, 37, 32, -1, -36 },
  { 572, 30, 36, 32, 0, -35 },
  { 707, 9, 17, 32, 15, -38 },
  { 727, 21, 49, 32, 8, -38 },
  { 856, 21, 49, 32, 3, -38 },
  { 985, 20, 20, 32, 9, -38 },
  { 1035, 26, 28, 32, 3, -32 },
  { 1126, 16, 17, 32, 2, -8 },
  { 1160, 16, 6, 32, 8, -17 },
  { 1172, 9, 8, 32, 9, -8 },
  { 1181, 35, 39, 32, -1, -38 },
  { 1352, 27, 37, 32, 3, -36 },
  { 1477, 27, 35, 32, 1, -35 },
  { 1596, 31, 36, 32, 0, -36 },
  { 1736, 29, 37, 32, 2, -36 },
  { 1871, 29, 35, 32, 1, -35 },
  { 1998, 29, 36, 32, 2, -35 },
  { 2129, 27, 37, 32, 3, -36 },
  { 2254, 26, 35, 32, 6, -35 },
  { 2368, 29, 37, 32, 2, -36 },
  { 2503, 28, 37, 32, 2, -36 },
  { 2633, 13, 28, 32, 9, -28 },
  { 2679, 19, 37, 32, 4, -28 },
  { 2767, 26, 29, 32, 3, -32 },
  { 2862, 26, 20, 32, 3, -28 },
  { 2927, 26, 29, 32, 3, -32 },
  { 3022, 27, 36, 32, 4, -36 },
  { 3144, 32, 45, 32, 0, -38 },
  { 3324, 32, 35, 32, -3, -35 },
  { 3464, 30, 35, 32, 1, -35 },
  { 3596, 30, 37, 32, 2, -36 },
  { 3735, 30, 35, 32, 1, -35 },
  { 3867, 32, 35, 32, 1, -35 },
  { 4007, 31, 35, 32, 2, -35 },
  { 4143, 29, 37, 32, 2, -36 },
  { 4278, 31, 35, 32, 1, -35 },
  { 4414, 31, 35, 32, 1, -35 },
  { 4550, 28, 36, 32, 2, -35 },
  { 4676, 34, 35, 32, 1, -35 },
  { 4825, 24, 35, 32, 3, -35 },
  { 4930, 33, 35, 32, 0, -35 },
  { 5075, 31, 35, 32, 1, -35 },
  { 5211, 29, 37, 32, 2, -36 },
  { 5346, 31, 35, 32, 1, -35 },
  { 5482, 29, 46, 32, 2, -36 },
  { 5649, 31, 35, 32, 1, -35 },
  { 5785, 32, 37, 32, 0, -36 },
  { 5933, 30, 35, 32, 4, -35 },
  { 6065, 30, 36, 32, 3, -35 },
  { 6200, 32, 35, 32, 4, -35 },
  { 6340, 33, 35, 32, 3, -35 },
  { 6485, 38, 35, 32, -3, -35 },
  { 6652, 32, 35, 32, 4, -35 },
  { 6792, 32, 35, 32, 0, -35 },
  { 6932, 25, 49, 32, 5, -38 },
  { 7086, 20, 39, 32, 7, -38 },
  { 7184, 25, 49, 32, 2, -38 },
  { 7338, 29, 23, 32, 1, -36 },
  { 7422, 33, 2, 32, -4, 3 },
  { 7431, 13, 7, 32, 13, -38 },
  { 7443, 28, 30, 32, 1, -29 },
  { 7548, 29, 39, 32, 1, -38 },
  { 7690, 28, 30, 32, 2, -29 },
  { 7795, 31, 39, 32, 2, -38 },
  { 7947, 28, 30, 32, 2, -29 },
  { 8052, 29, 39, 32, 5, -39 },
  { 8194, 31, 40, 32, 1, -29 },
  { 8349, 29, 38, 32, 1, -38 },
  { 8487, 28, 38, 32, 0, -38 },
  { 8620, 29, 49, 32, -2, -38 },
  { 8798, 30, 38, 32, 2, -38 },
  { 8941, 28, 38, 32, 0, -38 },
  { 9074, 32, 29, 32, -1, -29 },
  { 9190, 29, 29, 32, 1, -29 },
  { 9296, 28, 30, 32, 2, -29 },
  { 9401, 31, 40, 32, -1, -29 },
  { 9556, 29, 40, 32, 2, -29 },
  { 9701, 27, 29, 32, 4, -29 },
  { 9799, 27, 30, 32, 2, -29 },
  { 9901, 22, 36, 32, 6, -35 },
  { 10000, 29, 29, 32, 2, -28 },
  { 10106, 30, 28, 32, 4, -28 },
  { 10211, 32, 28, 32, 2, -28 },
  { 10323, 34, 28, 32, -1, -28 },
  { 10442, 35, 39, 32, -1, -28 },
  { 10613, 28, 28, 32, 1, -28 },
  { 10711, 28, 49, 32, 4, -38 },
  { 10883, 7, 50, 32, 12, -38 },
  { 10927, 27, 49, 32, 0, -38 },
  { 11093, 29, 8, 32, 2, -22 },
};

const GFXfont LiberationMono_BoldItalic53pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic53pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic53pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _LIBERATIONMONO_BOLDITALIC53PT7B_H_
