#ifndef _LIBERATIONMONO_BOLDITALIC32PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x00, 0x00, 0xF8, 0xF8, 0xF0, 0xF0, 0x3C, 0x79,
  0xE3, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0x70,
  0xE7, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C,
  0x1C, 0x00, 0xC1, 0x80, 0x1C, 0x38, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x03,
  0x07, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x0E, 0x1C, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0x83, 0x80, 0x38, 0x30, 0x03, 0x87, 0x00,
  0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xC9, 0xF1, 0xE6, 0x7C,
  0xF1, 0x8F, 0x3C, 0x60, 0x0F, 0x98, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x0D, 0xF8, 0x02, 0x3E, 0x31, 0x87, 0xBC, 0x63,
  0xCF, 0x18, 0xF3, 0xE6, 0x7C, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFE, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x18, 0x3F, 0x80,
  0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x38, 0x18, 0x71, 0xC0, 0xE1, 0x8E, 0x03,
  0x8E, 0x70, 0x0E, 0x3B, 0x80, 0x39, 0xDC, 0x00, 0x7F, 0x60, 0x00, 0xF3,
  0x3C, 0x00, 0x1F, 0xF8, 0x00, 0xEE, 0x70, 0x07, 0x71, 0xC0, 0x39, 0xC7,
  0x01, 0xC6, 0x1C, 0x0E, 0x38, 0x60, 0x70, 0xE3, 0x81, 0x81, 0x8E, 0x0C,
  0x07, 0xF0, 0x60, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0x1E, 0x03, 0x87, 0x01, 0xE1, 0xC0, 0x78, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x1C, 0xFF, 0x0E, 0x79, 0xE3, 0xBC, 0x79,
  0xCF, 0x0F, 0xF3, 0xC1, 0xF8, 0xF0, 0x7C, 0x3C, 0x1F, 0x8F, 0xFF, 0xFD,
  0xFF, 0xBF, 0x3F, 0x83, 0xC0, 0x79, 0xE7, 0x9E, 0x71, 0xCF, 0x3C, 0xE3,
  0x80, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0xEE, 0x67, 0xFF, 0x7F, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xC3, 0xDE, 0x1C,
  0x70, 0x42, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xC3, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F,
  0x78, 0x0F, 0x79, 0xCF, 0xFB, 0xCF, 0xFB, 0xDF, 0xF3, 0x9F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xFC,
  0x1F, 0xF8, 0x1E, 0x78, 0x38, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE3, 0xE0, 0xF8, 0x3E, 0x1E, 0x07,
  0x80, 0x40, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0xCF,
  0x81, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x1F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF3, 0xC0, 0x3C,
  0xF8, 0x1F, 0x3F, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x77, 0x80,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC1, 0xE1,
  0xF0, 0xF0, 0x78, 0x78, 0x1E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7B, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1E, 0x3F, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x3C, 0x08,
  0x3C, 0x00, 0x78, 0x00, 0x79, 0xF8, 0x7B, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E,
  0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3C, 0x78, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C, 0x0F, 0xFE, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1E, 0x3F, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF1, 0xF1, 0xE0, 0xF9, 0xF0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7E, 0x78, 0x00, 0x78, 0x30, 0x3C, 0x78, 0x3C,
  0x3E, 0x3E, 0x1F, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x1E, 0x1E, 0x1E,
  0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8,
  0xF8, 0xF0, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFC, 0x3F,
  0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xE0, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01,
  0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x39, 0xF1,
  0x8F, 0xF7, 0x19, 0xCF, 0x73, 0x18, 0x77, 0x33, 0x06, 0x67, 0x70, 0xE6,
  0x66, 0x0C, 0x66, 0x60, 0xC6, 0x6E, 0x1C, 0xCE, 0xE1, 0x8C, 0xCC, 0x39,
  0xCC, 0xC3, 0x98, 0xCC, 0x53, 0x0C, 0xFD, 0xF0, 0xE7, 0x1C, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x38, 0x3C, 0x03, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xB8,
  0x00, 0x7B, 0x80, 0x0F, 0x38, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C,
  0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF0,
  0xF8, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xE0, 0x7C, 0x7C, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xCF, 0xC1, 0xF3, 0xE0,
  0x31, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFB, 0xE0, 0x7C, 0x7C, 0x3F, 0x1F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0xFC, 0x7C,
  0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0x81, 0xF3, 0xE0, 0x41, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x1F, 0xE7, 0x8F, 0xFB, 0xE3, 0xFE, 0xF8, 0xFF, 0xBE,
  0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0x7C, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xF0,
  0x7C, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xC1,
  0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xFC, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1,
  0xF8, 0x1E, 0x1F, 0x80, 0xF1, 0xF8, 0x0F, 0x9F, 0x80, 0x7D, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C,
  0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0x80, 0xF8,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0x81, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3,
  0xF1, 0xFC, 0x7E, 0x1D, 0xC7, 0xE1, 0xDC, 0xEE, 0x1D, 0xCF, 0xE1, 0xDD,
  0xDE, 0x3D, 0xDD, 0xC3, 0xDF, 0x9C, 0x39, 0xF9, 0xC3, 0x9F, 0x3C, 0x39,
  0xF3, 0xC7, 0x9F, 0x38, 0x79, 0xE3, 0x87, 0x00, 0x38, 0x70, 0x07, 0x87,
  0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x0F, 0xC1,
  0xE0, 0xFC, 0x1E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1E, 0x0F, 0xE1, 0xE1, 0xFE,
  0x3C, 0x1F, 0xE3, 0xC1, 0xEE, 0x3C, 0x1E, 0xE3, 0xC1, 0xEF, 0x3C, 0x3E,
  0xF7, 0xC3, 0xCF, 0x78, 0x3C, 0xF7, 0x83, 0xC7, 0x78, 0x3C, 0x7F, 0x83,
  0xC7, 0xF8, 0x78, 0x7F, 0x07, 0x87, 0xF0, 0x78, 0x3F, 0x07, 0x83, 0xF0,
  0x78, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDE,
  0x01, 0xF7, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81,
  0xF3, 0xE0, 0x7C, 0xFC, 0x7E, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE3, 0xC1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xFC, 0x7E, 0x1F, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x3E, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF8,
  0x1F, 0x1F, 0x07, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7E, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x82, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x07,
  0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x78, 0xF8, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC1, 0xF0, 0xF8, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x78, 0x01,
  0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x03, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C,
  0x3C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0x78, 0xF3,
  0xE7, 0x8F, 0x3E, 0x70, 0xF7, 0xEF, 0x0F, 0x7E, 0xF0, 0xFE, 0xEE, 0x0E,
  0xEF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0,
  0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1F, 0x1E, 0x00, 0x1E,
  0x78, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x80,
  0xF8, 0x0F, 0x01, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x03, 0xE7,
  0xC0, 0x3C, 0x7C, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0,
  0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x39, 0xE0, 0x38,
  0xF0, 0x3C, 0x38, 0x1C, 0x1C, 0x1E, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0xCF,
  0x00, 0xE7, 0x00, 0x7F, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0xF8, 0x78, 0x70, 0x01, 0xF8, 0x07, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x3E,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x0F, 0xFE, 0x3F, 0xFE, 0x7C, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xBF, 0xFF, 0x3F, 0x3E,
  0x1F, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0xF8, 0x3D, 0xFE, 0x1F, 0xFF, 0x9F, 0x87, 0xCF, 0x83,
  0xE7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1E, 0x78,
  0x0F, 0x3C, 0x0F, 0x9F, 0x07, 0x9F, 0x8F, 0xCF, 0x7F, 0xC7, 0xBF, 0xC3,
  0xC7, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE3, 0xE0,
  0xF9, 0xE0, 0x7D, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x03, 0xE7, 0x81, 0xE3, 0xE3, 0xF1, 0xFF, 0xF0, 0x7F, 0xE0,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF9, 0xE0, 0x7F, 0xBC, 0x1F, 0xF7,
  0x87, 0xE3, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E,
  0x1E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0x7C, 0x07, 0x8F, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE3, 0xE0, 0xFB, 0xE0, 0x3D, 0xF0,
  0x1E, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0x81, 0xF3, 0xE1, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x03,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x03, 0xE3, 0xC1, 0xFD, 0xF0, 0xFF, 0xF8, 0x7C, 0x7E, 0x3E, 0x0F, 0x8F,
  0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x81,
  0xF1, 0xE0, 0x7C, 0x7C, 0x3F, 0x1F, 0x1F, 0x87, 0xFF, 0xE0, 0xFF, 0x78,
  0x1F, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC3, 0xC1, 0xF0, 0xF8, 0xF8, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0xF8, 0x3D, 0xFE, 0x3F,
  0xFF, 0x9F, 0xC7, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x79,
  0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0xBE, 0x07, 0xDF, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x78, 0x3E, 0x1E, 0x1F, 0x07, 0x8F, 0x83, 0xE7,
  0xC0, 0xFB, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7C, 0xF8, 0x1F, 0x1E, 0x07, 0x87, 0xC1, 0xE1, 0xF0, 0x78, 0x3E, 0x3E,
  0x0F, 0x8F, 0x81, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0xE3, 0xC7, 0xBE, 0xFC, 0xFF, 0xFF,
  0x9F, 0x7C, 0xF3, 0xC7, 0x9E, 0x79, 0xE3, 0xCE, 0x3C, 0x73, 0xC7, 0x8E,
  0x78, 0xE3, 0xCF, 0x1C, 0x79, 0xC7, 0x8F, 0x38, 0xF1, 0xCF, 0x1E, 0x39,
  0xE3, 0x8F, 0x3C, 0x71, 0xE7, 0x1E, 0x3C, 0xE3, 0xC7, 0x80, 0x1E, 0x3E,
  0x0F, 0x7F, 0x8F, 0xFF, 0xE7, 0xF1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xEF,
  0x81, 0xF7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3E, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xDF, 0x03,
  0xEF, 0x81, 0xE3, 0xE3, 0xF1, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00,
  0x07, 0x8F, 0x80, 0xF7, 0xF8, 0x3F, 0xFF, 0x07, 0xF1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0x78, 0x7E, 0x3F, 0x0F, 0x7F, 0xC1,
  0xEF, 0xF0, 0x3C, 0xF8, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE7, 0xC3,
  0xFD, 0xE1, 0xFF, 0x78, 0xFC, 0x7E, 0x3E, 0x1F, 0x9F, 0x03, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78,
  0xF8, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xE1, 0xFE, 0xF8, 0x1E, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x1E, 0x1F, 0x8F, 0x3F, 0x87, 0xBF, 0xC3, 0xFF, 0xE1,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xC1,
  0xF3, 0xC0, 0x79, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFE, 0x00, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7, 0x81,
  0xF3, 0xC0, 0xF9, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x1F, 0x3C,
  0x0F, 0x9E, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xE2, 0xF1, 0xFF, 0xF8,
  0xFF, 0x7C, 0x3E, 0x3C, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xE7, 0x80, 0xF9,
  0xE0, 0x3C, 0x78, 0x1F, 0x1F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x07, 0x70,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0xE1, 0xC7, 0x1E, 0x3C, 0x71,
  0xE3, 0x87, 0x3E, 0x38, 0x73, 0x67, 0x87, 0x77, 0x70, 0x76, 0x77, 0x07,
  0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xF0, 0xF0, 0x07,
  0x8F, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF9,
  0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xF0, 0x78, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x40, 0x7E, 0x00,
};

const GFXglyph LiberationMono_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 21, 19, 6, -21 },
  { 22, 13, 10, 19, 5, -23 },
  { 39, 20, 21, 19, 0, -21 },
  { 92, 18, 26, 19, 1, -23 },
  { 151, 22, 21, 19, -1, -21 },
  { 209, 18, 21, 19, 0, -21 },
  { 257, 6, 10, 19, 9, -23 },
  { 265, 12, 30, 19, 5, -23 },
  { 310, 12, 30, 19, 2, -23 },
  { 355, 13, 12, 19, 5, -23 },
  { 375, 16, 16, 19, 2, -18 },
  { 407, 10, 10, 19, 1, -5 },
  { 420, 9, 4, 19, 5, -10 },
  { 425, 5, 5, 19, 6, -5 },
  { 429, 21, 23, 19, 0, -23 },
  { 490, 16, 21, 19, 2, -21 },
  { 532, 16, 21, 19, 1, -21 },
  { 574, 19, 21, 19, 0, -21 },
  { 624, 18, 21, 19, 1, -21 },
  { 672, 18, 21, 19, 0, -21 },
  { 720, 18, 21, 19, 1, -21 },
  { 768, 16, 21, 19, 2, -21 },
  { 810, 16, 21, 19, 4, -21 },
  { 852, 18, 21, 19, 1, -21 },
  { 900, 17, 21, 19, 1, -21 },
  { 945, 8, 17, 19, 6, -17 },
  { 962, 12, 22, 19, 2, -17 },
  { 995, 16, 17, 19, 2, -19 },
  { 1029, 16, 13, 19, 2, -17 },
  { 1055, 16, 17, 19, 2, -19 },
  { 1089, 17, 21, 19, 2, -21 },
  { 1134, 20, 27, 19, 0, -23 },
  { 1202, 20, 21, 19, -2, -21 },
  { 1255, 19, 21, 19, 0, -21 },
  { 1305, 18, 21, 19, 1, -21 },
  { 1353, 19, 21, 19, 0, -21 },
  { 1403, 20, 21, 19, 0, -21 },
  { 1456, 19, 21, 19, 1, -21 },
  { 1506, 18, 21, 19, 1, -21 },
  { 1554, 19, 21, 19, 1, -21 },
  { 1604, 18, 21, 19, 1, -21 },
  { 1652, 17, 21, 19, 1, -21 },
  { 1697, 21, 21, 19, 0, -21 },
  { 1753, 15, 21, 19, 2, -21 },
  { 1793, 20, 21, 19, 0, -21 },
  { 1846, 20, 21, 19, 0, -21 },
  { 1899, 18, 21, 19, 1, -21 },
  { 1947, 19, 21, 19, 0, -21 },
  { 1997, 18, 27, 19, 1, -21 },
  { 2058, 19, 21, 19, 0, -21 },
  { 2108, 19, 21, 19, 0, -21 },
  { 2158, 18, 21, 19, 3, -21 },
  { 2206, 18, 21, 19, 2, -21 },
  { 2254, 20, 21, 19, 2, -21 },
  { 2307, 20, 21, 19, 2, -21 },
  { 2360, 23, 21, 19, -2, -21 },
  { 2421, 20, 21, 19, 2, -21 },
  { 2474, 20, 21, 19, 0, -21 },
  { 2527, 15, 30, 19, 3, -23 },
  { 2584, 12, 23, 19, 4, -23 },
  { 2619, 15, 30, 19, 1, -23 },
  { 2676, 17, 14, 19, 1, -22 },
  { 2706, 19, 2, 19, -2, 2 },
  { 2711, 7, 4, 19, 8, -23 },
  { 2715, 16, 17, 19, 1, -17 },
  { 2749, 17, 23, 19, 1, -23 },
  { 2798, 17, 17, 19, 1, -17 },
  { 2835, 19, 23, 19, 1, -23 },
  { 2890, 17, 17, 19, 1, -17 },
  { 2927, 17, 23, 19, 3, -23 },
  { 2976, 18, 24, 19, 1, -17 },
  { 3030, 17, 23, 19, 1, -23 },
  { 3079, 17, 23, 19, 0, -23 },
  { 3128, 17, 30, 19, -1, -23 },
  { 3192, 18, 23, 19, 1, -23 },
  { 3244, 17, 23, 19, 0, -23 },
  { 3293, 19, 17, 19, 0, -17 },
  { 3334, 17, 17, 19, 1, -17 },
  { 3371, 17, 17, 19, 1, -17 },
  { 3408, 19, 24, 19, -1, -17 },
  { 3465, 18, 24, 19, 1, -17 },
  { 3519, 17, 17, 19, 2, -17 },
  { 3556, 17, 17, 19, 1, -17 },
  { 3593, 13, 21, 19, 4, -21 },
  { 3628, 17, 17, 19, 1, -17 },
  { 3665, 18, 17, 19, 2, -17 },
  { 3704, 20, 17, 19, 1, -17 },
  { 3747, 21, 17, 19, -1, -17 },
  { 3792, 21, 24, 19, -1, -17 },
  { 3855, 17, 17, 19, 1, -17 },
  { 3892, 16, 30, 19, 3, -23 },
  { 3952, 4, 30, 19, 8, -23 },
  { 3967, 16, 30, 19, 0, -23 },
  { 4027, 18, 5, 19, 1, -13 },
};

const GFXfont LiberationMono_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic32pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _LIBERATIONMONO_BOLDITALIC32PT7B_H_
