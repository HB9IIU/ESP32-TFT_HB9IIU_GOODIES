#ifndef _LIBERATIONMONO_BOLDITALIC62PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x87, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01,
  0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x8E, 0xFF, 0xE0, 0x3F, 0xE1, 0xE3, 0xFE, 0x03, 0xFC, 0x1E,
  0x1F, 0xF0, 0x3F, 0xC1, 0xC1, 0xFF, 0x07, 0xF8, 0x1C, 0x1F, 0xF0, 0x7F,
  0x81, 0xC0, 0xC0, 0x07, 0xF8, 0x3C, 0x00, 0x00, 0x7F, 0x83, 0xC0, 0x00,
  0x07, 0xFC, 0x38, 0x00, 0x00, 0x7F, 0xF3, 0x80, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0E, 0x1F, 0xF8, 0x00, 0x00, 0xE0, 0xFF, 0x80, 0x00,
  0x0E, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0xF0, 0x1E, 0x07, 0xF8,
  0xFF, 0x01, 0xC0, 0x7F, 0x8F, 0xF0, 0x1C, 0x07, 0xF8, 0xFF, 0x81, 0xC0,
  0xFF, 0x0F, 0xF8, 0x3C, 0x0F, 0xF0, 0x7F, 0xC3, 0xC3, 0xFE, 0x07, 0xFF,
  0x38, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x00,
  0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x83, 0xE0, 0x00,
  0xFC, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07,
  0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0x07, 0xFF, 0xE3, 0xF0,
  0x00, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xF1, 0xFF,
  0xF0, 0x00, 0x01, 0xF9, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x1F,
  0x80, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x7C,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x78, 0x01, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0xFF, 0x00,
  0x7E, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0xFF, 0xBF, 0x80, 0xFC, 0x1F, 0xF3,
  0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0x83,
  0xF8, 0x0F, 0xE3, 0xF0, 0x7F, 0x80, 0xFF, 0x7F, 0x07, 0xF0, 0x07, 0xFF,
  0xE0, 0x7F, 0x00, 0x7F, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07,
  0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7C, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x10, 0x3F, 0x02, 0x3C, 0x3F, 0x0E, 0x3F, 0x3F, 0x7E, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xCF,
  0xC0, 0x3F, 0xCF, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x07,
  0xC0, 0x1C, 0x03, 0x80, 0x04, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x3F, 0xC7, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE7, 0xFC,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC3,
  0xF1, 0xFF, 0x3F, 0xC3, 0xF1, 0xFF, 0x3F, 0xC7, 0xF1, 0xFF, 0x7F, 0xC7,
  0xF1, 0xFE, 0x7F, 0xC7, 0xF1, 0xFE, 0x7F, 0xC7, 0xE3, 0xFE, 0x7F, 0x87,
  0xE3, 0xFE, 0x7F, 0x87, 0xE3, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x18, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0x80, 0x7F, 0xDF, 0xFF, 0xE0, 0x7F,
  0xBF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x03,
  0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x1F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xE3, 0xFC, 0x00, 0x7F, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFE,
  0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x07, 0x80, 0xFF, 0x1E, 0xF0, 0x3E, 0x07, 0xFC, 0xF3, 0xC0,
  0xF0, 0x7F, 0xFB, 0xCF, 0x07, 0xC1, 0xF0, 0xFE, 0x3C, 0x1E, 0x0F, 0x83,
  0xF8, 0xF0, 0xF8, 0x7C, 0x07, 0xE3, 0xC3, 0xC3, 0xE0, 0x1F, 0x0F, 0x0F,
  0x0F, 0x80, 0xFC, 0x3C, 0x7C, 0x7C, 0x03, 0xE1, 0xE1, 0xE1, 0xE0, 0x0F,
  0x87, 0x87, 0x8F, 0x80, 0x3E, 0x1E, 0x3E, 0x3E, 0x01, 0xF0, 0x78, 0xF1,
  0xF0, 0x07, 0xC1, 0xE3, 0xC7, 0xC0, 0x1E, 0x0F, 0x0F, 0x1F, 0x00, 0xF8,
  0x3C, 0x7C, 0xF8, 0x03, 0xE0, 0xF1, 0xE3, 0xE0, 0x0F, 0x07, 0x87, 0x8F,
  0x80, 0x7C, 0x1E, 0x1E, 0x3E, 0x01, 0xE0, 0x78, 0x78, 0xF0, 0x0F, 0x83,
  0xC1, 0xE3, 0xC0, 0x3E, 0x0F, 0x0F, 0x8F, 0x01, 0xF0, 0x78, 0x3E, 0x3C,
  0x0F, 0xC1, 0xE0, 0xF8, 0xF0, 0x7F, 0x0F, 0x03, 0xE3, 0xE3, 0xDC, 0x78,
  0x0F, 0x8F, 0xFE, 0x7F, 0xE0, 0x3E, 0x3F, 0xF1, 0xFF, 0x00, 0xF8, 0x7F,
  0x87, 0xF0, 0x01, 0xE0, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7E, 0x0F, 0xFC,
  0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x0F, 0xF8,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x3F,
  0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x3F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC0,
  0x1F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x0E, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xF7,
  0xFC, 0x07, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xFD, 0xFF, 0x03, 0xFF, 0xFE,
  0xFF, 0x81, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF,
  0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03,
  0xFC, 0x7F, 0xE0, 0x01, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7D, 0xF8, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x0F,
  0xDF, 0x83, 0xFF, 0xE0, 0x1F, 0xBF, 0x0F, 0xDF, 0xC0, 0x7F, 0x7E, 0x1F,
  0xBF, 0x80, 0xFE, 0xFC, 0x3E, 0x7E, 0x01, 0xFD, 0xF8, 0xFD, 0xFC, 0x03,
  0xF3, 0xF1, 0xFB, 0xF8, 0x07, 0xE7, 0xE7, 0xE7, 0xF0, 0x1F, 0xCF, 0xCF,
  0xCF, 0xE0, 0x3F, 0x9F, 0xBF, 0x1F, 0x80, 0x7F, 0x1F, 0x7E, 0x7F, 0x00,
  0xFC, 0x3E, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0xF1, 0xFC, 0x07, 0xF0, 0xFF,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFF, 0x87, 0xE0, 0x1F, 0xC3, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xF8, 0x7F, 0x01, 0xFC, 0x1F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xC0, 0x7F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F,
  0xCF, 0xE0, 0xFF, 0x00, 0xFE, 0x7F, 0x07, 0xF8, 0x07, 0xF3, 0xF8, 0x3F,
  0xC0, 0x7F, 0x9F, 0xC1, 0xFE, 0x03, 0xFC, 0xFE, 0x0F, 0xE0, 0x1F, 0xE7,
  0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xC7, 0xF8, 0x07, 0xF0, 0xFE, 0x3F, 0xC0,
  0x7F, 0x87, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0x8F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x7F, 0x00, 0xFF, 0x07, 0xF7, 0xF8, 0x07, 0xF8, 0x3F, 0xBF, 0xC0, 0x3F,
  0x81, 0xFD, 0xFE, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xE0, 0x7F, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0x80,
  0x7F, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x1F,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0E, 0x00, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F,
  0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0xE3, 0xF8, 0x07,
  0xF1, 0xFF, 0xC7, 0xF0, 0x0F, 0xE7, 0xFF, 0x9F, 0xC0, 0x1F, 0xCF, 0xFF,
  0x3F, 0x80, 0x3F, 0xBF, 0x7E, 0x7F, 0x00, 0x7F, 0x7E, 0xFC, 0xFC, 0x00,
  0xFE, 0xF9, 0xFB, 0xF8, 0x01, 0xFF, 0xF3, 0xF7, 0xF0, 0x03, 0xF7, 0xE7,
  0xEF, 0xC0, 0x07, 0xFF, 0x87, 0xDF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0x8F, 0xF8,
  0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80,
  0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0xC7, 0xFC, 0x07,
  0xFF, 0x0F, 0xFC, 0x3E, 0xFF, 0x1F, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0x9F, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xF0, 0x0F, 0xF7, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xEF, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0xFC, 0x03, 0xFE, 0x3F, 0xFE, 0x00,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0xFE, 0x7F,
  0x80, 0x1F, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xF0,
  0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0xFF, 0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x3F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x06, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0x1F, 0xF0, 0x07, 0xFF,
  0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F,
  0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x87, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x1F, 0xFE, 0x00,
  0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFE,
  0x03, 0xFD, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xC0,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0xE7, 0xF8, 0x3F, 0xE0, 0x3F, 0x3F, 0xF1, 0xFF,
  0x80, 0xFD, 0xFF, 0xCF, 0xFE, 0x03, 0xF7, 0xFF, 0x7F, 0xFC, 0x0F, 0xF9,
  0xFD, 0x8F, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xC3, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0xFE, 0x03, 0xFC, 0xFF,
  0xFF, 0x80, 0xFF, 0x7F, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0x8F, 0xFF, 0x80, 0x0F, 0xF3, 0xFF, 0xFC,
  0x00, 0xFF, 0x7F, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xE0, 0x03, 0xFE,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xF0, 0x07,
  0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0x80,
  0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0x9F, 0xF0, 0x03, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0x07, 0xFC,
  0x7F, 0xFE, 0x07, 0xFC, 0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFB, 0xF8, 0x02, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x40, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x04, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC,
  0x7F, 0x80, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xFC, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F,
  0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFF, 0x83, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xFF, 0x0F, 0xC0, 0xFC, 0x3E, 0xF8, 0x7E, 0x07, 0xE1,
  0xF7, 0xC7, 0xF0, 0x3F, 0x1F, 0x3E, 0x3F, 0x01, 0xF9, 0xF9, 0xF1, 0xF8,
  0x0F, 0xCF, 0x8F, 0xDF, 0xC0, 0x7E, 0xFC, 0x7E, 0xFC, 0x03, 0xF7, 0xC3,
  0xF7, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x5F, 0xFF, 0xFE, 0x01,
  0xEF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x1F, 0xFF, 0xFE, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph LiberationMono_BoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 17, 41, 37, 11, -41 },
  { 89, 25, 19, 37, 10, -45 },
  { 149, 37, 41, 37, 1, -41 },
  { 339, 36, 51, 37, 1, -46 },
  { 569, 41, 43, 37, -1, -42 },
  { 790, 36, 42, 37, -1, -41 },
  { 979, 11, 19, 37, 17, -45 },
  { 1006, 24, 58, 37, 9, -45 },
  { 1180, 24, 58, 37, 4, -45 },
  { 1354, 24, 23, 37, 10, -45 },
  { 1423, 31, 31, 37, 3, -36 },
  { 1544, 19, 20, 37, 2, -9 },
  { 1592, 19, 7, 37, 9, -20 },
  { 1609, 11, 9, 37, 11, -9 },
  { 1622, 41, 46, 37, -1, -45 },
  { 1858, 32, 43, 37, 3, -42 },
  { 2030, 32, 41, 37, 1, -41 },
  { 2194, 35, 42, 37, 1, -42 },
  { 2378, 34, 43, 37, 2, -42 },
  { 2561, 34, 41, 37, 1, -41 },
  { 2736, 34, 42, 37, 2, -41 },
  { 2915, 32, 43, 37, 4, -42 },
  { 3087, 31, 41, 37, 7, -41 },
  { 3246, 34, 43, 37, 2, -42 },
  { 3429, 32, 43, 37, 3, -42 },
  { 3601, 15, 33, 37, 11, -33 },
  { 3663, 21, 44, 37, 5, -33 },
  { 3779, 31, 33, 37, 3, -37 },
  { 3907, 31, 24, 37, 3, -32 },
  { 4000, 31, 33, 37, 3, -37 },
  { 4128, 32, 42, 37, 5, -42 },
  { 4296, 38, 54, 37, 0, -45 },
  { 4553, 37, 41, 37, -3, -41 },
  { 4743, 35, 41, 37, 1, -41 },
  { 4923, 34, 43, 37, 3, -42 },
  { 5106, 35, 41, 37, 1, -41 },
  { 5286, 37, 41, 37, 1, -41 },
  { 5476, 36, 41, 37, 2, -41 },
  { 5661, 33, 43, 37, 3, -42 },
  { 5839, 37, 41, 37, 1, -41 },
  { 6029, 35, 41, 37, 2, -41 },
  { 6209, 34, 42, 37, 2, -41 },
  { 6388, 40, 41, 37, 1, -41 },
  { 6593, 29, 41, 37, 3, -41 },
  { 6742, 39, 41, 37, 0, -41 },
  { 6942, 37, 41, 37, 1, -41 },
  { 7132, 35, 43, 37, 2, -42 },
  { 7321, 36, 41, 37, 1, -41 },
  { 7506, 35, 54, 37, 2, -42 },
  { 7743, 37, 41, 37, 1, -41 },
  { 7933, 37, 43, 37, 0, -42 },
  { 8132, 35, 41, 37, 5, -41 },
  { 8312, 35, 42, 37, 3, -41 },
  { 8496, 37, 41, 37, 5, -41 },
  { 8686, 39, 41, 37, 3, -41 },
  { 8886, 44, 41, 37, -3, -41 },
  { 9112, 37, 41, 37, 5, -41 },
  { 9302, 39, 41, 37, -1, -41 },
  { 9502, 29, 58, 37, 6, -45 },
  { 9713, 23, 46, 37, 8, -45 },
  { 9846, 29, 58, 37, 2, -45 },
  { 10057, 34, 27, 37, 1, -43 },
  { 10172, 38, 3, 37, -5, 4 },
  { 10187, 14, 8, 37, 16, -44 },
  { 10201, 31, 35, 37, 2, -34 },
  { 10337, 34, 46, 37, 1, -45 },
  { 10533, 32, 35, 37, 3, -34 },
  { 10673, 36, 46, 37, 2, -45 },
  { 10880, 32, 35, 37, 3, -34 },
  { 11020, 34, 46, 37, 6, -46 },
  { 11216, 36, 47, 37, 1, -34 },
  { 11428, 34, 45, 37, 1, -45 },
  { 11620, 33, 45, 37, 0, -45 },
  { 11806, 34, 58, 37, -2, -45 },
  { 12053, 36, 45, 37, 2, -45 },
  { 12256, 33, 45, 37, 0, -45 },
  { 12442, 38, 34, 37, -1, -34 },
  { 12604, 34, 34, 37, 1, -34 },
  { 12749, 33, 35, 37, 2, -34 },
  { 12894, 36, 47, 37, -1, -34 },
  { 13106, 34, 47, 37, 2, -34 },
  { 13306, 32, 34, 37, 4, -34 },
  { 13442, 32, 35, 37, 2, -34 },
  { 13582, 26, 43, 37, 7, -42 },
  { 13722, 33, 34, 37, 3, -33 },
  { 13863, 35, 33, 37, 4, -33 },
  { 14008, 37, 33, 37, 3, -33 },
  { 14161, 40, 33, 37, -2, -33 },
  { 14326, 40, 46, 37, -1, -33 },
  { 14556, 33, 33, 37, 1, -33 },
  { 14693, 32, 58, 37, 5, -45 },
  { 14925, 8, 59, 37, 15, -45 },
  { 14984, 32, 58, 37, 0, -45 },
  { 15216, 33, 10, 37, 3, -25 },
};

const GFXfont LiberationMono_BoldItalic62pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic62pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic62pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _LIBERATIONMONO_BOLDITALIC62PT7B_H_
