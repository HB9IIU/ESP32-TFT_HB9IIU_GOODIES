#ifndef _LIBERATIONMONO_BOLDITALIC37PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x3E, 0x78, 0x7D, 0xF0,
  0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xE0, 0xF3, 0xC1, 0xC7, 0x83, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x30,
  0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x07,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC1,
  0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x70, 0x30,
  0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0C, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7E, 0x67, 0xE3, 0xE3, 0x1F,
  0x1E, 0x18, 0xF0, 0xF8, 0xC0, 0x07, 0xCC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x67, 0xE0,
  0x03, 0x1F, 0x0E, 0x18, 0x79, 0xF0, 0xC7, 0xCF, 0x8C, 0x3E, 0x7E, 0x67,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x07, 0x83,
  0xFC, 0x07, 0x83, 0xFE, 0x03, 0x83, 0xC7, 0x03, 0x81, 0xC3, 0x83, 0x80,
  0xE1, 0xC3, 0x80, 0x70, 0xE3, 0x80, 0x78, 0xF3, 0x80, 0x3C, 0x73, 0x80,
  0x0F, 0xFB, 0x80, 0x07, 0xFB, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xCF,
  0x80, 0x01, 0xDF, 0xE0, 0x01, 0xDF, 0xF8, 0x01, 0xCF, 0x3C, 0x01, 0xCF,
  0x1E, 0x01, 0xC7, 0x0F, 0x01, 0xC3, 0x87, 0x01, 0xC1, 0xC3, 0x81, 0xE0,
  0xE3, 0xC1, 0xE0, 0x7F, 0xC0, 0xE0, 0x1F, 0xC0, 0xE0, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xDF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xF1, 0xFF, 0x0F, 0x1F, 0x78, 0x79,
  0xF3, 0xE7, 0x9F, 0x0F, 0x3C, 0xF0, 0x7F, 0xC7, 0x81, 0xFC, 0x3C, 0x0F,
  0xE1, 0xE0, 0x3F, 0x0F, 0x87, 0xFC, 0x7F, 0xFF, 0xFD, 0xFF, 0xCF, 0xC3,
  0xF8, 0x1E, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xC7,
  0x80, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x08, 0xF1, 0x7B, 0xBD, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F,
  0xC0, 0x7F, 0x87, 0xDE, 0x3E, 0x7C, 0x70, 0xE0, 0x82, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x7F, 0xF7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x7F, 0xFF, 0xBE, 0xFB, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF3, 0xCF, 0xBE, 0x79, 0xFF, 0xCF, 0x7D,
  0xF3, 0xCF, 0xBE, 0x79, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x7C, 0x7E, 0x1F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xF3, 0xE0, 0x70, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0x7C,
  0x3E, 0x03, 0xE0, 0x10, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x7E, 0xFC, 0x07, 0xCF, 0xE1,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F,
  0x1F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF0, 0x1F, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x3F, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x3E, 0x3F, 0x03, 0xF1, 0xFC, 0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFC, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x7E, 0x0F, 0xBF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF0, 0xFD,
  0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF1,
  0xF0, 0x7E, 0x3F, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF1,
  0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x87, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xF0, 0x7C, 0x7E, 0x07,
  0xE7, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xE1,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x7E,
  0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF8,
  0x1F, 0xBF, 0x8F, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFD, 0xF0, 0x7E,
  0x7C, 0x00, 0x0F, 0x81, 0x03, 0xF3, 0xE0, 0x7C, 0x7E, 0x3F, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x8F, 0x87, 0xC3,
  0xE1, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x38,
  0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF0,
  0xFE, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xC1, 0xE0, 0x0F, 0x01, 0xE0, 0x38, 0x01,
  0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x07, 0x0F, 0x37, 0x0C, 0x3F, 0x6E,
  0x38, 0xE7, 0xDC, 0x63, 0x87, 0x39, 0xCE, 0x0E, 0x73, 0x9C, 0x3C, 0xC6,
  0x70, 0x71, 0x9C, 0xE0, 0xE3, 0x3B, 0x81, 0x8E, 0x67, 0x07, 0x18, 0xCE,
  0x0E, 0x31, 0x9C, 0x18, 0xE7, 0x30, 0x71, 0x8E, 0x60, 0xE3, 0x1C, 0xC2,
  0x8C, 0x39, 0xCF, 0x38, 0x73, 0xF7, 0xE0, 0xE3, 0x87, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x08, 0x03, 0x80, 0x78, 0x07, 0x83, 0xC0,
  0x07, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F,
  0x00, 0x78, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF0, 0x07, 0xCF, 0xC0,
  0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xF8,
  0x3F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1,
  0xF8, 0x1F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F,
  0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFE, 0x3F, 0x8F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1C,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF3,
  0xE0, 0x1F, 0x1F, 0x81, 0xF0, 0xFE, 0x1F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7C, 0x07,
  0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C,
  0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF1, 0xF8, 0x7F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xF8, 0x7E, 0x7E, 0x07, 0xCF,
  0x80, 0xFB, 0xF0, 0x18, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x1F, 0x7F, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x1F, 0x07, 0xE3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80,
  0x1F, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x80, 0x7C, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xE0,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1D, 0xC1, 0xDC, 0x3F, 0x87,
  0xB8, 0xFF, 0x0F, 0x71, 0xDE, 0x1E, 0xF7, 0xBC, 0x3D, 0xEE, 0xF0, 0x7B,
  0xFD, 0xE1, 0xE7, 0xF3, 0xC3, 0xCF, 0xE7, 0x87, 0x9F, 0xCF, 0x0F, 0x3F,
  0x3C, 0x1E, 0x7E, 0x78, 0x78, 0xF8, 0xF0, 0xF1, 0xF1, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0x0F, 0xC0, 0x7C, 0x3F, 0x81, 0xE0, 0xFE, 0x0F, 0x83,
  0xF8, 0x3E, 0x1F, 0xE0, 0xF8, 0x7F, 0x83, 0xE1, 0xFF, 0x0F, 0x07, 0xFC,
  0x7C, 0x1E, 0xF1, 0xF0, 0xFB, 0xC7, 0xC3, 0xEF, 0x1F, 0x0F, 0xBE, 0x78,
  0x3C, 0xFB, 0xE0, 0xF1, 0xEF, 0x87, 0xC7, 0xBE, 0x1F, 0x1E, 0xF8, 0x7C,
  0x7B, 0xC1, 0xE1, 0xFF, 0x07, 0x83, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x3F,
  0xC3, 0xE0, 0xFE, 0x0F, 0x83, 0xF8, 0x3C, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0,
  0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0xFC,
  0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xF8,
  0x3F, 0x8F, 0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF9,
  0xF8, 0x0F, 0x8F, 0x81, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x3F,
  0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x03, 0xE7,
  0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0xFC, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01,
  0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0,
  0x3F, 0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xC1, 0xFC, 0x3E, 0x03, 0xF1,
  0xF8, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x08, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x1F,
  0x81, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F,
  0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x87,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x03,
  0xE7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x38, 0x78,
  0xF8, 0xF8, 0xF1, 0xF1, 0xF3, 0xE3, 0xE7, 0xE7, 0x87, 0xCF, 0xCF, 0x0F,
  0xBF, 0xBE, 0x1F, 0x7F, 0x78, 0x3D, 0xEE, 0xF0, 0x7B, 0x9F, 0xE0, 0xFF,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F,
  0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x1F,
  0x1F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x78, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x03,
  0xC1, 0xE0, 0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x07,
  0xE7, 0xC1, 0xFC, 0xFC, 0x7F, 0x9F, 0xFD, 0xFD, 0xFF, 0x3F, 0x9F, 0x83,
  0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF9, 0xF8, 0x1F, 0x3F, 0xC1,
  0xFF, 0xFE, 0x1F, 0xC7, 0xE1, 0xF8, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F,
  0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0x8F, 0xB1,
  0xF8, 0xFB, 0xFF, 0x0F, 0x9F, 0xE0, 0xF8, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xC7, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0xDF,
  0x01, 0xFB, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xFC,
  0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x7C, 0x07, 0xFD, 0xF0, 0x3F, 0xFF,
  0xC1, 0xF8, 0x7F, 0x07, 0xC1, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xC0,
  0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC1, 0xFC,
  0x1F, 0x8F, 0xE0, 0x7F, 0xEF, 0x80, 0xFF, 0x3E, 0x01, 0xF8, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xC7, 0xE3, 0xE0, 0x7C,
  0xFC, 0x07, 0x9F, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0x87,
  0xC0, 0x7C, 0xFC, 0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x3F,
  0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE3, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC1, 0xFF, 0xBE, 0x0F, 0xFB,
  0xE0, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x1F, 0x3F, 0xE1,
  0xF7, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x3F, 0x3F, 0x83, 0xF3, 0xF0, 0x3F,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x1F,
  0x81, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x3F, 0x00, 0x7D, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0x80, 0x7C, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x0F, 0x3C, 0x3C, 0x1E,
  0xFD, 0xFC, 0x3F, 0xFB, 0xF8, 0x7C, 0xFD, 0xF1, 0xF1, 0xF1, 0xE3, 0xE3,
  0xC7, 0xC7, 0x87, 0x8F, 0x8F, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78,
  0x78, 0xF0, 0xF0, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x8F,
  0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0xF8, 0xF0, 0xF1, 0xE1,
  0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x80, 0x1F, 0x0F, 0x81, 0xF3, 0xFE, 0x1F,
  0x7F, 0xE1, 0xFF, 0xFF, 0x1F, 0xC3, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x7E, 0x1F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E,
  0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xEF,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7C, 0xFC, 0x07, 0xC7, 0xC0, 0xF8,
  0x7E, 0x1F, 0x83, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC3,
  0xE0, 0x1F, 0x3F, 0xC0, 0x7D, 0xFF, 0x81, 0xFC, 0x7E, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E,
  0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07,
  0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0xC7, 0xE0, 0xFB, 0xFF, 0x03,
  0xEF, 0xF8, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x3F, 0xEF, 0x83, 0xFF, 0x7C, 0x3F,
  0x1F, 0xE1, 0xF0, 0x7F, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0,
  0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0x83, 0xF8, 0x7E, 0x3F, 0x83,
  0xFF, 0x7C, 0x0F, 0xF3, 0xE0, 0x3F, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0xC7, 0x8F, 0xF3, 0xE7, 0xFC,
  0xFB, 0xFF, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xC1, 0xF1,
  0xF0, 0x1E, 0x3E, 0x03, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x8E,
  0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xF8, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF0, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x01, 0xF7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xDF, 0x81, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x3F, 0x3E, 0x0F, 0xE7, 0xE3, 0xF8, 0xFF, 0xFF, 0x1F, 0xFB, 0xE1, 0xFE,
  0x7C, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x01,
  0xF3, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC3,
  0xC3, 0xCF, 0x0F, 0x0F, 0x3C, 0x7C, 0x78, 0xF1, 0xF1, 0xE3, 0xCF, 0xC7,
  0x0F, 0x3F, 0x3C, 0x3D, 0xDE, 0xF0, 0xE7, 0x7B, 0x83, 0xB8, 0xFE, 0x0E,
  0xE3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x83,
  0xE0, 0x3C, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0xFC, 0x03, 0xE1, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xCF,
  0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03,
  0xF0, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x3E, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0x03, 0xE3,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x2F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F,
  0x00,
};

const GFXglyph LiberationMono_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 24, 22, 7, -24 },
  { 31, 15, 12, 22, 6, -27 },
  { 54, 23, 24, 22, 0, -24 },
  { 123, 21, 29, 22, 1, -26 },
  { 200, 25, 24, 22, -1, -24 },
  { 275, 21, 24, 22, 0, -24 },
  { 338, 7, 12, 22, 10, -27 },
  { 349, 14, 35, 22, 6, -27 },
  { 411, 15, 35, 22, 2, -27 },
  { 477, 14, 14, 22, 6, -27 },
  { 502, 18, 18, 22, 2, -21 },
  { 543, 12, 12, 22, 1, -5 },
  { 561, 12, 4, 22, 5, -12 },
  { 567, 6, 6, 22, 7, -6 },
  { 572, 24, 27, 22, 0, -27 },
  { 653, 19, 24, 22, 2, -24 },
  { 710, 18, 24, 22, 1, -24 },
  { 764, 21, 24, 22, 0, -24 },
  { 827, 20, 24, 22, 1, -24 },
  { 887, 21, 24, 22, 0, -24 },
  { 950, 21, 24, 22, 1, -24 },
  { 1013, 19, 24, 22, 2, -24 },
  { 1070, 19, 24, 22, 4, -24 },
  { 1127, 20, 24, 22, 1, -24 },
  { 1187, 19, 24, 22, 2, -24 },
  { 1244, 9, 20, 22, 7, -20 },
  { 1267, 13, 27, 22, 3, -20 },
  { 1311, 18, 19, 22, 2, -22 },
  { 1354, 18, 14, 22, 2, -19 },
  { 1386, 18, 19, 22, 2, -22 },
  { 1429, 19, 24, 22, 3, -24 },
  { 1486, 23, 32, 22, 0, -27 },
  { 1578, 22, 24, 22, -2, -24 },
  { 1644, 21, 24, 22, 1, -24 },
  { 1707, 21, 24, 22, 1, -24 },
  { 1770, 21, 24, 22, 1, -24 },
  { 1833, 22, 24, 22, 1, -24 },
  { 1899, 22, 24, 22, 1, -24 },
  { 1965, 19, 24, 22, 2, -24 },
  { 2022, 22, 24, 22, 1, -24 },
  { 2088, 21, 24, 22, 1, -24 },
  { 2151, 20, 24, 22, 1, -24 },
  { 2211, 24, 24, 22, 1, -24 },
  { 2283, 17, 24, 22, 2, -24 },
  { 2334, 23, 24, 22, 0, -24 },
  { 2403, 22, 24, 22, 1, -24 },
  { 2469, 21, 24, 22, 1, -24 },
  { 2532, 21, 24, 22, 1, -24 },
  { 2595, 21, 31, 22, 1, -24 },
  { 2677, 22, 24, 22, 1, -24 },
  { 2743, 22, 24, 22, 0, -24 },
  { 2809, 21, 24, 22, 3, -24 },
  { 2872, 21, 24, 22, 2, -24 },
  { 2935, 22, 24, 22, 3, -24 },
  { 3001, 23, 24, 22, 2, -24 },
  { 3070, 26, 24, 22, -2, -24 },
  { 3148, 22, 24, 22, 3, -24 },
  { 3214, 23, 24, 22, 0, -24 },
  { 3283, 18, 35, 22, 3, -27 },
  { 3362, 14, 27, 22, 5, -27 },
  { 3410, 18, 35, 22, 1, -27 },
  { 3489, 20, 16, 22, 1, -25 },
  { 3529, 23, 2, 22, -3, 2 },
  { 3535, 9, 5, 22, 9, -26 },
  { 3541, 19, 20, 22, 1, -20 },
  { 3589, 20, 27, 22, 1, -27 },
  { 3657, 19, 20, 22, 2, -20 },
  { 3705, 22, 27, 22, 1, -27 },
  { 3780, 19, 20, 22, 2, -20 },
  { 3828, 21, 27, 22, 3, -27 },
  { 3899, 21, 28, 22, 1, -20 },
  { 3973, 20, 27, 22, 1, -27 },
  { 4041, 20, 27, 22, 0, -27 },
  { 4109, 20, 35, 22, -1, -27 },
  { 4197, 22, 27, 22, 1, -27 },
  { 4272, 20, 27, 22, 0, -27 },
  { 4340, 23, 20, 22, -1, -20 },
  { 4398, 20, 20, 22, 1, -20 },
  { 4448, 20, 20, 22, 1, -20 },
  { 4498, 22, 28, 22, -1, -20 },
  { 4575, 21, 28, 22, 1, -20 },
  { 4649, 18, 20, 22, 3, -20 },
  { 4694, 19, 20, 22, 1, -20 },
  { 4742, 16, 25, 22, 4, -25 },
  { 4792, 19, 20, 22, 2, -20 },
  { 4840, 21, 20, 22, 2, -20 },
  { 4893, 22, 20, 22, 2, -20 },
  { 4948, 24, 20, 22, -1, -20 },
  { 5008, 24, 28, 22, -1, -20 },
  { 5092, 19, 20, 22, 1, -20 },
  { 5140, 19, 35, 22, 3, -27 },
  { 5224, 4, 35, 22, 9, -27 },
  { 5242, 19, 35, 22, 0, -27 },
  { 5326, 19, 6, 22, 2, -15 },
};

const GFXfont LiberationMono_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic37pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _LIBERATIONMONO_BOLDITALIC37PT7B_H_
