#ifndef _LIBERATIONMONO_BOLDITALIC44PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xE7, 0xE1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xE0, 0x78,
  0x78, 0x3E, 0x3E, 0x0F, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0xF0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x38,
  0x0E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xE6, 0xFF, 0x0F, 0xC7, 0x1F, 0x87, 0xC3, 0x8F, 0xC7,
  0xE1, 0x87, 0xE3, 0xF0, 0xC0, 0x01, 0xF8, 0x60, 0x00, 0xFF, 0x70, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x8F, 0xE0, 0x00, 0xC3,
  0xF0, 0x00, 0x60, 0xF8, 0xF8, 0x30, 0x7C, 0xFC, 0x38, 0x7E, 0x7E, 0x1C,
  0x3F, 0x3F, 0x0C, 0x3F, 0x1F, 0xE6, 0x7F, 0x87, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x78, 0x0F, 0xF8, 0x03, 0xC0, 0x7F, 0xE0, 0x1E, 0x03, 0xE7, 0x80, 0x70,
  0x0F, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0xF0, 0x07,
  0x83, 0x87, 0x80, 0x1E, 0x1E, 0x3C, 0x00, 0x78, 0x79, 0xE0, 0x01, 0xE1,
  0xCF, 0x00, 0x07, 0x8F, 0x38, 0x00, 0x1F, 0xF9, 0xC0, 0x00, 0x3F, 0xCF,
  0x00, 0x00, 0x7E, 0x79, 0xF8, 0x00, 0x03, 0xDF, 0xF0, 0x00, 0x1E, 0xFF,
  0xC0, 0x00, 0xF3, 0xC7, 0x80, 0x07, 0x9E, 0x1E, 0x00, 0x3C, 0x78, 0x78,
  0x00, 0xE3, 0xC1, 0xE0, 0x07, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x1C, 0x01,
  0xE0, 0xF0, 0xF0, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x0F, 0x1E, 0x03, 0xC0,
  0x3F, 0xF0, 0x1E, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x78, 0x3F, 0xF0, 0x3C, 0x3F, 0xF8, 0x3E,
  0x3F, 0x7C, 0x1E, 0x3F, 0x1F, 0x1F, 0x1F, 0x0F, 0xCF, 0x1F, 0x03, 0xEF,
  0x8F, 0x81, 0xFF, 0x87, 0xC0, 0x7F, 0xC3, 0xE0, 0x3F, 0xC1, 0xF0, 0x0F,
  0xE0, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xC7, 0xFF,
  0x8F, 0xE0, 0xFE, 0x01, 0xF0, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x03,
  0x1E, 0x3B, 0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x03, 0xF8,
  0x03, 0xFE, 0x07, 0xDF, 0x07, 0xE7, 0xC7, 0xE3, 0xE0, 0xE1, 0xE0, 0x20,
  0x40, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0x7F,
  0xF8, 0x7E, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF3,
  0xE7, 0xEF, 0xC7, 0x8F, 0xDF, 0x9F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C,
  0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0x7E, 0x03, 0xF3, 0xF8, 0x0E, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x00,
  0xFE, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xE3,
  0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x03, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x30, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x1F, 0xBF, 0xF0, 0x7D, 0xFF, 0xE3,
  0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0x3F, 0x80, 0xFE, 0xFC, 0x03, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x1F,
  0xCF, 0xC0, 0x7E, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF,
  0xF0, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF9, 0xF8, 0x0F,
  0xC7, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0x80, 0x7E, 0x3F, 0x01,
  0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x07, 0x83, 0xCE, 0xE0, 0xE1, 0xFD,
  0xDC, 0x38, 0x7F, 0xB3, 0x87, 0x1E, 0x3E, 0x71, 0xC7, 0x87, 0xCE, 0x38,
  0xE0, 0xF1, 0xC7, 0x3C, 0x1E, 0x39, 0xC7, 0x03, 0xC7, 0x39, 0xE0, 0x71,
  0xC7, 0x38, 0x0E, 0x39, 0xCF, 0x03, 0x87, 0x39, 0xE0, 0x70, 0xE7, 0x38,
  0x1E, 0x38, 0xE7, 0x03, 0x87, 0x18, 0xE0, 0x70, 0xE7, 0x3C, 0x1E, 0x38,
  0xE7, 0x87, 0x87, 0x1C, 0xF0, 0xF1, 0xC3, 0x9E, 0x36, 0x70, 0x71, 0xFE,
  0xFE, 0x0E, 0x3F, 0x9F, 0x81, 0xE3, 0xC3, 0xC0, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x20, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x1F,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81,
  0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03,
  0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x03, 0xF8, 0xFC,
  0x03, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x30,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x78, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xF8, 0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0x0F, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8,
  0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F,
  0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0x7E, 0x3F, 0x80, 0x78, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xFE, 0xFE, 0x1F, 0xFE, 0xFE,
  0x1F, 0xFE, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xF8, 0xFE, 0x01, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0,
  0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x01,
  0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x07,
  0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xC3, 0xFC, 0x00,
  0xFC, 0x7F, 0x80, 0x0F, 0xCF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xBF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0xE0, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7B, 0xC0, 0xFF,
  0xC7, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xF7, 0xCF, 0x7C, 0x1F, 0x7D, 0xF7,
  0xC1, 0xF7, 0xDE, 0x78, 0x1F, 0x3D, 0xEF, 0x81, 0xF3, 0xFC, 0xF8, 0x1E,
  0x3F, 0xCF, 0x83, 0xE3, 0xF8, 0xF8, 0x3E, 0x3F, 0x8F, 0x03, 0xE3, 0xF1,
  0xF0, 0x3E, 0x3F, 0x1F, 0x03, 0xC3, 0xF1, 0xF0, 0x3C, 0x3E, 0x1F, 0x07,
  0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0,
  0xF8, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x0F, 0xC1, 0xFE, 0x03, 0xF0, 0x7F,
  0x80, 0xF8, 0x1F, 0xE0, 0x3E, 0x0F, 0xF8, 0x1F, 0x83, 0xFF, 0x07, 0xE0,
  0xFF, 0xC1, 0xF8, 0x3F, 0xF0, 0x7C, 0x0F, 0xFC, 0x1F, 0x07, 0xFF, 0x07,
  0xC1, 0xFF, 0xC3, 0xF0, 0x7C, 0xF8, 0xFC, 0x1F, 0x3E, 0x3E, 0x07, 0xCF,
  0x8F, 0x83, 0xF3, 0xE3, 0xE0, 0xFC, 0xF9, 0xF8, 0x3F, 0x3F, 0x7E, 0x0F,
  0x87, 0xDF, 0x03, 0xE1, 0xF7, 0xC1, 0xF8, 0x7D, 0xF0, 0x7E, 0x1F, 0x7C,
  0x1F, 0x87, 0xDF, 0x07, 0xC0, 0xFF, 0xC1, 0xF0, 0x3F, 0xE0, 0xFC, 0x0F,
  0xF8, 0x3F, 0x03, 0xFE, 0x0F, 0xC0, 0xFF, 0x83, 0xE0, 0x1F, 0xE0, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC,
  0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xF8, 0x1F, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0,
  0x07, 0xF8, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFC,
  0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x7C,
  0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF1, 0xFE, 0x07, 0xF8,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7E,
  0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x1E, 0x1F,
  0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xE1, 0xF0, 0x7C,
  0x7F, 0x3E, 0x07, 0xCF, 0xF3, 0xE0, 0x7C, 0xFF, 0x3E, 0x07, 0xDF, 0xF7,
  0xC0, 0x7D, 0xEF, 0x7C, 0x07, 0xFE, 0xF7, 0xC0, 0x7F, 0xCF, 0x78, 0x07,
  0xBC, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x03,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0x8F, 0xFF, 0xBF,
  0xEF, 0xFE, 0x7F, 0x9F, 0xF8, 0x7F, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x0F, 0xCF, 0xFC, 0x0F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE,
  0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F,
  0x1F, 0x80, 0x7F, 0x1F, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0xC7, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFD, 0xFF, 0xE0, 0xFC, 0xFF, 0x80, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3,
  0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF9, 0xFC, 0x07,
  0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xFF,
  0x3F, 0x01, 0xFF, 0xDF, 0x81, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0xE1, 0xFC,
  0x0F, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xFE, 0x0F, 0xFF, 0xBF,
  0x03, 0xFF, 0xBF, 0x00, 0xFF, 0x9F, 0x80, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x7C,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x7F,
  0xCF, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F,
  0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3,
  0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xEF, 0xC0, 0x7F, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xE1,
  0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xFC, 0x0F, 0xDF, 0xFE,
  0x0F, 0xDF, 0xFE, 0x0F, 0xBF, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xC0, 0x7F, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x8F, 0x07, 0xC0, 0xF3, 0xF1,
  0xF8, 0x3E, 0xFE, 0x7F, 0x87, 0xFF, 0xDF, 0xF0, 0xFC, 0xFF, 0x3E, 0x1F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0x1F, 0x0F, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0,
  0xF8, 0x7C, 0x7C, 0x1E, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x78, 0x3E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7,
  0xC1, 0xF0, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xFC, 0x0F, 0xCF, 0xFE,
  0x0F, 0xDF, 0xFE, 0x0F, 0xBF, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF,
  0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8, 0x7F,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0xFF, 0xC0, 0x3F, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xDF, 0xFE, 0x03,
  0xF3, 0xFE, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x03, 0xFE, 0x7E, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0x7E,
  0x1F, 0xC3, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xF0,
  0xFF, 0xFB, 0xF0, 0x7F, 0xF7, 0xE0, 0x3F, 0xE7, 0xE0, 0x1F, 0x87, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x0F, 0x81, 0xFC, 0x1F, 0x0F, 0xF8, 0x3E, 0x3F, 0xF0,
  0x7C, 0xFF, 0xE1, 0xFB, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0xFE, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0E, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x78, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x21, 0xFF,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xE7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFC, 0x1F,
  0xE3, 0xF8, 0x7F, 0xC7, 0xFF, 0xDF, 0x8F, 0xFF, 0xBF, 0x0F, 0xFE, 0x7C,
  0x1F, 0xF9, 0xF8, 0x0F, 0x83, 0xF0, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x83, 0xC1, 0xF3, 0xE0, 0xF8, 0x7C, 0xF8,
  0x7E, 0x1E, 0x3E, 0x1F, 0x8F, 0x8F, 0x8F, 0xE3, 0xE3, 0xE3, 0xF8, 0xF0,
  0xF9, 0xFE, 0x7C, 0x3E, 0x77, 0x9F, 0x0F, 0xBC, 0xE7, 0x83, 0xEE, 0x3B,
  0xE0, 0xF7, 0x8F, 0xF8, 0x3D, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xFC, 0x05, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph LiberationMono_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 12, 29, 26, 8, -29 },
  { 45, 18, 14, 26, 7, -32 },
  { 77, 26, 29, 26, 1, -29 },
  { 172, 25, 36, 26, 1, -32 },
  { 285, 30, 29, 26, -1, -29 },
  { 394, 25, 29, 26, 0, -29 },
  { 485, 8, 14, 26, 12, -32 },
  { 499, 17, 41, 26, 7, -32 },
  { 587, 17, 41, 26, 3, -32 },
  { 675, 17, 16, 26, 7, -32 },
  { 709, 22, 23, 26, 2, -26 },
  { 773, 13, 14, 26, 2, -6 },
  { 796, 14, 5, 26, 6, -14 },
  { 805, 7, 7, 26, 8, -7 },
  { 812, 28, 32, 26, 0, -32 },
  { 924, 23, 29, 26, 2, -29 },
  { 1008, 22, 29, 26, 1, -29 },
  { 1088, 25, 29, 26, 0, -29 },
  { 1179, 25, 29, 26, 1, -29 },
  { 1270, 25, 29, 26, 0, -29 },
  { 1361, 25, 29, 26, 1, -29 },
  { 1452, 22, 29, 26, 3, -29 },
  { 1532, 22, 29, 26, 5, -29 },
  { 1612, 24, 29, 26, 1, -29 },
  { 1699, 23, 29, 26, 2, -29 },
  { 1783, 11, 24, 26, 8, -24 },
  { 1816, 16, 32, 26, 3, -24 },
  { 1880, 22, 23, 26, 2, -26 },
  { 1944, 22, 17, 26, 2, -23 },
  { 1991, 22, 23, 26, 2, -26 },
  { 2055, 23, 29, 26, 3, -29 },
  { 2139, 27, 38, 26, 0, -32 },
  { 2268, 26, 29, 26, -2, -29 },
  { 2363, 25, 29, 26, 1, -29 },
  { 2454, 24, 29, 26, 2, -29 },
  { 2541, 25, 29, 26, 1, -29 },
  { 2632, 26, 29, 26, 1, -29 },
  { 2727, 26, 29, 26, 1, -29 },
  { 2822, 24, 29, 26, 2, -29 },
  { 2909, 26, 29, 26, 1, -29 },
  { 3004, 25, 29, 26, 1, -29 },
  { 3095, 23, 29, 26, 2, -29 },
  { 3179, 28, 29, 26, 1, -29 },
  { 3281, 21, 29, 26, 2, -29 },
  { 3358, 28, 29, 26, 0, -29 },
  { 3460, 26, 29, 26, 1, -29 },
  { 3555, 24, 29, 26, 2, -29 },
  { 3642, 25, 29, 26, 1, -29 },
  { 3733, 24, 38, 26, 2, -29 },
  { 3847, 26, 29, 26, 1, -29 },
  { 3942, 26, 29, 26, 0, -29 },
  { 4037, 24, 29, 26, 4, -29 },
  { 4124, 25, 29, 26, 2, -29 },
  { 4215, 27, 29, 26, 3, -29 },
  { 4313, 28, 29, 26, 2, -29 },
  { 4415, 31, 29, 26, -2, -29 },
  { 4528, 27, 29, 26, 3, -29 },
  { 4626, 27, 29, 26, 0, -29 },
  { 4724, 21, 41, 26, 4, -32 },
  { 4832, 16, 32, 26, 6, -32 },
  { 4896, 21, 41, 26, 1, -32 },
  { 5004, 24, 19, 26, 1, -30 },
  { 5061, 27, 2, 26, -3, 3 },
  { 5068, 10, 6, 26, 11, -31 },
  { 5076, 23, 24, 26, 1, -24 },
  { 5145, 24, 32, 26, 1, -32 },
  { 5241, 23, 24, 26, 2, -24 },
  { 5310, 25, 32, 26, 2, -32 },
  { 5410, 23, 24, 26, 2, -24 },
  { 5479, 24, 32, 26, 4, -32 },
  { 5575, 25, 33, 26, 1, -24 },
  { 5679, 24, 32, 26, 1, -32 },
  { 5775, 23, 32, 26, 0, -32 },
  { 5867, 24, 41, 26, -1, -32 },
  { 5990, 26, 32, 26, 1, -32 },
  { 6094, 23, 32, 26, 0, -32 },
  { 6186, 27, 24, 26, -1, -24 },
  { 6267, 24, 24, 26, 1, -24 },
  { 6339, 23, 24, 26, 2, -24 },
  { 6408, 26, 33, 26, -1, -24 },
  { 6516, 24, 33, 26, 2, -24 },
  { 6615, 23, 24, 26, 3, -24 },
  { 6684, 23, 24, 26, 1, -24 },
  { 6753, 19, 30, 26, 5, -30 },
  { 6825, 23, 24, 26, 2, -24 },
  { 6894, 25, 24, 26, 3, -24 },
  { 6969, 26, 24, 26, 2, -24 },
  { 7047, 28, 24, 26, -1, -24 },
  { 7131, 29, 33, 26, -1, -24 },
  { 7251, 23, 24, 26, 1, -24 },
  { 7320, 22, 41, 26, 4, -32 },
  { 7433, 6, 42, 26, 10, -32 },
  { 7465, 23, 41, 26, 0, -32 },
  { 7583, 23, 7, 26, 2, -18 },
};

const GFXfont LiberationMono_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic44pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _LIBERATIONMONO_BOLDITALIC44PT7B_H_
